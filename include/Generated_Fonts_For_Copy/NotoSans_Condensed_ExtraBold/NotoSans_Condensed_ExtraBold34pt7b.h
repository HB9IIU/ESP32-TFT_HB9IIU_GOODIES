#ifndef _NOTOSANS_CONDENSED_EXTRABOLD34PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0x00, 0x02, 0x3E, 0xFB, 0xFF, 0xBE, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF,
  0x9F, 0xF9, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x07, 0x8E, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xC7, 0x07, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0xF3, 0xC0, 0x38, 0xF0,
  0x0E, 0x38, 0x07, 0x8E, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x87,
  0x9E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x7F, 0xC3, 0xFF,
  0xEF, 0xFF, 0x9F, 0xFF, 0x7C, 0xC4, 0xF9, 0x81, 0xF3, 0x01, 0xF6, 0x03,
  0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0x7C, 0x06, 0xFA, 0x0D, 0xF7, 0x9F, 0xEF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8,
  0x07, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x07,
  0xE0, 0x1E, 0x01, 0xFE, 0x03, 0xC0, 0x3F, 0xE0, 0xF0, 0x0F, 0x3C, 0x1E,
  0x01, 0xE7, 0x83, 0x80, 0x3C, 0x78, 0xF0, 0x07, 0x8F, 0x1E, 0x00, 0xF1,
  0xE7, 0x80, 0x1E, 0x3C, 0xF0, 0x03, 0xCF, 0x3C, 0x78, 0x79, 0xE7, 0x9F,
  0xC7, 0xFD, 0xE7, 0xF8, 0xFF, 0x3D, 0xFF, 0x8F, 0xC7, 0x3C, 0xF0, 0x61,
  0xE7, 0x9E, 0x00, 0x3C, 0xF1, 0xE0, 0x0F, 0x1E, 0x3C, 0x01, 0xE3, 0xC7,
  0x80, 0x78, 0x79, 0xF0, 0x0F, 0x0F, 0x3C, 0x03, 0xC1, 0xF7, 0x80, 0x78,
  0x1F, 0xF0, 0x0E, 0x01, 0xFC, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xC0, 0x00,
  0x7F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0x1F, 0xF9, 0xF9, 0xFF, 0xCF,
  0xDF, 0xBF, 0x7C, 0xFC, 0xFF, 0xE7, 0xC3, 0xFE, 0x3E, 0x0F, 0xF1, 0xF8,
  0x7F, 0x0F, 0xE3, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0x7E,
  0x1F, 0xF3, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xF0, 0x07, 0xC3, 0xE0,
  0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0,
  0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F,
  0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0xF0,
  0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x83, 0xC1,
  0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0x87, 0xC0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x0E, 0x79, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF,
  0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0xC1, 0xF7, 0x87, 0xCF, 0x87, 0x8E, 0x02,
  0x10, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x7E, 0xF9, 0xF3, 0xE7,
  0xCF, 0x3E, 0x78, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x23, 0xEF, 0xBF,
  0xFB, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0x01, 0x00,
  0x1F, 0xC0, 0x7F, 0xC1, 0xFF, 0xC7, 0xFF, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E,
  0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x7D, 0xF1, 0xFB, 0xE3, 0xE7,
  0xEF, 0xC7, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x03, 0xE0, 0xFC,
  0x3F, 0x8F, 0xF3, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0x73, 0xE4, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0x00, 0x3F, 0xC1, 0xFF, 0xE7,
  0xFF, 0xCF, 0xFF, 0xCF, 0x1F, 0x8C, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x7F, 0xE3, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xC6, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x7F, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xBF, 0xFE,
  0x7F, 0xF8, 0x7F, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x3C, 0xF8, 0x3C, 0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x3F, 0xFC, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFB, 0x83, 0xFF, 0x8F, 0xFF, 0x3F,
  0xFE, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8,
  0x0F, 0xF8, 0x7E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0x00, 0x38,
  0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0xE0, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF3, 0xE3, 0xEF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDF, 0xDF,
  0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFB, 0xE1, 0xF7,
  0xE7, 0xEF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0xEF, 0xCF, 0x8F, 0x9F, 0x0F, 0xBE, 0x3E, 0x7C, 0x7C, 0xFD,
  0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0x7E,
  0xFC, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xFF, 0xDF,
  0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x01, 0x00, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF,
  0xC7, 0xFF, 0xDF, 0x8F, 0xBE, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x9F, 0xDF, 0x0E,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x8F, 0xFF, 0x1F, 0xFC,
  0x3F, 0xF0, 0x7F, 0x80, 0x73, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x8F, 0xBE, 0xFF, 0xEF, 0x80, 0x38, 0xF9, 0xFB, 0xF7, 0xC7,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x7C, 0xF9, 0xF3,
  0xE7, 0x9F, 0x3E, 0x78, 0x00, 0x02, 0x00, 0x0C, 0x00, 0xF8, 0x07, 0xF0,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0, 0xFE, 0x01, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x3F,
  0x00, 0x78, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE,
  0x7F, 0xF9, 0xC3, 0xF4, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x78,
  0x7F, 0x9E, 0x78, 0x7F, 0xCF, 0x3C, 0x7F, 0xE3, 0x9E, 0x78, 0xF1, 0xCE,
  0x3C, 0x78, 0xEF, 0x1E, 0x3C, 0x7F, 0x9E, 0x1E, 0x3F, 0xCF, 0x0F, 0x1D,
  0xE7, 0x87, 0x8E, 0xF1, 0xC3, 0xCF, 0x78, 0xF3, 0xE7, 0x9C, 0x7F, 0xFF,
  0x8F, 0x1F, 0xDF, 0x87, 0x87, 0xC7, 0x81, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x60, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xDE, 0x00, 0xF9,
  0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0xC0, 0x0F, 0xF8, 0x7F, 0xF9, 0xFF,
  0xF3, 0xFF, 0xEF, 0xE1, 0x9F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x17, 0xF1, 0xE7, 0xFF, 0xCF, 0xFF,
  0x8F, 0xFF, 0x07, 0xFC, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF,
  0xF8, 0xFC, 0x7F, 0x3F, 0x0F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F,
  0xBF, 0x03, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xEF,
  0xC0, 0xFB, 0xF0, 0x3E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0x20,
  0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF3, 0xF8, 0x19, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xEF, 0xC1, 0xF7, 0xF0, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFF, 0x07, 0xFE, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F,
  0xBF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF9, 0xFB, 0xFE, 0xFF, 0xBF, 0xCF, 0xE0, 0xFC, 0x1F, 0xFF, 0x07, 0xEF,
  0xC3, 0xF3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF7,
  0xE0, 0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x07, 0xEF, 0xC1, 0xFB, 0xF0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFB, 0xC3, 0xFF, 0xFB, 0xC3, 0xDF, 0xFB, 0xE3,
  0xDF, 0xF9, 0xE3, 0xDF, 0xF9, 0xE7, 0x9F, 0xF9, 0xE7, 0x9F, 0xF9, 0xF7,
  0x9F, 0xF8, 0xFF, 0x9F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFF,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x3C, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFB,
  0xE3, 0xFF, 0x7C, 0x7F, 0xE7, 0xCF, 0xFC, 0xF9, 0xFF, 0x8F, 0xBF, 0xF1,
  0xF7, 0xFE, 0x3F, 0x7F, 0xC3, 0xEF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF,
  0xF8, 0xFC, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x3F, 0x07,
  0xE7, 0xF3, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7F, 0xC0, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xE0,
  0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x3F,
  0xBF, 0x03, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x3F, 0x07, 0xE7, 0xF3, 0xFC,
  0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xC7, 0xE7, 0xE1,
  0xF3, 0xF0, 0xF9, 0xF8, 0x7C, 0xFC, 0x3E, 0x7E, 0x3F, 0x3F, 0x7F, 0x9F,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFB, 0xF0, 0xFC, 0xF8,
  0x7E, 0x7E, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0,
  0x7F, 0xF8, 0x3F, 0x01, 0x80, 0x7F, 0xE3, 0xFF, 0xDF, 0xFF, 0x7F, 0xF9,
  0xF0, 0xEF, 0xC0, 0xBF, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xF0, 0x3F, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x07,
  0xEF, 0xE7, 0xF7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xF0, 0xFC,
  0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xE0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x7E, 0x0F, 0x8F, 0x81, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x07, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xFF,
  0xC0, 0x7C, 0x0F, 0xBF, 0x07, 0xE0, 0x7C, 0xF8, 0x3F, 0x03, 0xE7, 0xC1,
  0xFC, 0x1F, 0x3E, 0x0F, 0xE1, 0xF9, 0xF0, 0x7F, 0x0F, 0x87, 0xC7, 0xF8,
  0x7C, 0x3E, 0x3D, 0xC3, 0xE1, 0xF1, 0xEF, 0x1F, 0x0F, 0x8F, 0x79, 0xF0,
  0x7C, 0xFB, 0xCF, 0x81, 0xF7, 0xDE, 0x7C, 0x0F, 0xBC, 0xF3, 0xE0, 0x7D,
  0xE3, 0xDF, 0x03, 0xEF, 0x1F, 0xF0, 0x1F, 0x78, 0xFF, 0x80, 0x7F, 0xC7,
  0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0xFC,
  0x0F, 0xCF, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x8F, 0x81, 0xF3, 0xF0, 0x3F,
  0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xBE, 0x03, 0xF7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0xC3, 0xE1,
  0xF8, 0xFC, 0x1F, 0x9F, 0x03, 0xF7, 0xE0, 0x3F, 0xFC, 0x0F, 0xDF, 0x03,
  0xF7, 0xE0, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xE0,
  0x7E, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x3C, 0xF0, 0x0F, 0x3E, 0x07, 0xC7, 0x81, 0xE1, 0xF0, 0xF8, 0x3C,
  0x3C, 0x0F, 0x9F, 0x01, 0xEF, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x78, 0x0F, 0xE0, 0x7F, 0xF0, 0xFF,
  0xF1, 0xFF, 0xE1, 0x87, 0xC0, 0x0F, 0xC0, 0x1F, 0x81, 0xFF, 0x3F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFF,
  0xFF, 0x7F, 0xFE, 0xFF, 0x7C, 0xFC, 0x78, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xF8, 0xFB, 0xF9,
  0xFF, 0xFB, 0xFF, 0xF7, 0xF7, 0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x8F,
  0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xF9, 0xE3, 0xE0, 0x07, 0xF0, 0xFF, 0xCF,
  0xFE, 0x7F, 0xF7, 0xF3, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x05, 0xF8, 0x6F, 0xFF, 0x3F, 0xF8,
  0xFF, 0xC3, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x0F, 0x1F, 0x1F, 0xDF, 0x3F, 0xDF, 0x7F,
  0xFF, 0x7E, 0x7F, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7E, 0x3F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xE1, 0xFF, 0xE7, 0xC7, 0xEF, 0x87, 0xDF, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x81, 0x3F,
  0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x03, 0xF8, 0x7F, 0x87, 0xFC,
  0x3F, 0xE1, 0xF1, 0x0F, 0x80, 0x7C, 0x07, 0xFC, 0x7F, 0xE7, 0xFF, 0x3F,
  0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x00, 0x0F, 0x9F, 0x1F, 0xDF, 0x3F, 0xDF, 0x7F, 0xFF, 0x7E, 0x7F,
  0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7E, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1F, 0x00, 0x3F, 0x40, 0x3E, 0x70, 0x7E,
  0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F, 0xE0, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xF8, 0xFB,
  0xF9, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0x87, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7C, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xBF, 0xFF, 0xFE, 0xFE, 0xF8,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x3E, 0xF8, 0x3E, 0x7C, 0x3F, 0x3E, 0x3F, 0x1F,
  0x1F, 0x0F, 0x9F, 0x87, 0xDF, 0x83, 0xEF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xBF, 0x0F, 0x8F, 0x87, 0xC7, 0xE3, 0xE1,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3F, 0x7C, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF1, 0xF0, 0x7C, 0xF3, 0xF9, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xBF, 0xFC, 0x7E, 0x1F, 0xFC, 0x7E, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF1, 0xF1,
  0xE7, 0xF3, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xF8, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3F, 0x7C, 0x3F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F,
  0x7C, 0x3F, 0x7E, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0,
  0xF1, 0xF1, 0xF7, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xE7, 0xFF, 0x8F, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x87, 0xFF, 0x1F, 0xFF, 0xFE, 0xFF, 0xFD, 0xF7, 0xF3, 0xE7, 0xC7,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x0F, 0x9F, 0x1F, 0xDF, 0x3F, 0xDF, 0x7F, 0xFF, 0x7E,
  0x7F, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7E, 0x7F, 0x7F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xF1, 0xFE, 0x7F,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFE, 0xF8, 0x6F, 0x80, 0xFC, 0x0F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x01, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x11, 0xFF, 0x1F,
  0xF1, 0xFF, 0x07, 0xF0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xBC, 0xFC, 0x78, 0xF8, 0x0F, 0xFE, 0x0F, 0xDF, 0x07, 0xCF, 0x83,
  0xE7, 0xC1, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x1E, 0x3E, 0x0F,
  0xBE, 0x07, 0xDF, 0x01, 0xEF, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0x0F,
  0xDF, 0x0F, 0xC3, 0xE7, 0xC3, 0xF0, 0xF9, 0xF1, 0xFC, 0x3E, 0x7C, 0x7F,
  0x8F, 0x9F, 0x1F, 0xE7, 0xC3, 0xE7, 0xF9, 0xF0, 0xF9, 0xDE, 0x7C, 0x3E,
  0xF3, 0x9F, 0x0F, 0xBC, 0xF7, 0x81, 0xEF, 0x3F, 0xE0, 0x7B, 0xCF, 0xF8,
  0x1E, 0xE3, 0xFE, 0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x3F, 0x1F, 0x9F, 0x8F, 0x87, 0xCF, 0xC3, 0xF7, 0xC0, 0xFF, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFD, 0xF0, 0x7C, 0xFC, 0x7E, 0x3E, 0x3E,
  0x1F, 0xBF, 0x07, 0xE0, 0xFC, 0x0F, 0xFE, 0x0F, 0xDF, 0x07, 0xCF, 0x83,
  0xE7, 0xE1, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x1F, 0x3E, 0x0F,
  0xBE, 0x07, 0xDF, 0x01, 0xEF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x01, 0x3F, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07,
  0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x7F, 0x0F, 0xF0,
  0xFF, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x7F, 0x8F, 0xF0, 0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFE, 0x0F, 0xF0,
  0x7F, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC3,
  0xF8, 0x7F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C,
  0x0F, 0x81, 0xFE, 0x1F, 0xC0, 0xF8, 0x7F, 0x1F, 0xE3, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xC1, 0x00, 0x00, 0x3E, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF0, 0x1F, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraBold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 24, 9, 2, -24 },
  { 19, 12, 9, 16, 2, -24 },
  { 33, 18, 24, 19, 1, -24 },
  { 87, 15, 28, 17, 1, -26 },
  { 140, 27, 25, 29, 1, -25 },
  { 225, 21, 25, 22, 1, -25 },
  { 291, 5, 9, 9, 2, -24 },
  { 297, 10, 30, 11, 1, -25 },
  { 335, 9, 30, 11, 1, -25 },
  { 369, 15, 15, 16, 1, -26 },
  { 398, 15, 16, 17, 1, -20 },
  { 428, 7, 9, 9, 1, -4 },
  { 436, 9, 4, 11, 1, -11 },
  { 441, 6, 6, 9, 2, -6 },
  { 446, 14, 25, 14, 0, -25 },
  { 490, 15, 25, 17, 1, -25 },
  { 537, 11, 24, 17, 2, -24 },
  { 570, 15, 25, 17, 1, -25 },
  { 617, 15, 25, 17, 1, -25 },
  { 664, 16, 24, 17, 1, -24 },
  { 712, 14, 24, 17, 2, -24 },
  { 754, 15, 25, 17, 1, -25 },
  { 801, 15, 24, 17, 1, -24 },
  { 846, 15, 25, 17, 1, -25 },
  { 893, 15, 25, 17, 1, -25 },
  { 940, 6, 19, 9, 2, -19 },
  { 955, 7, 24, 9, 1, -19 },
  { 976, 15, 17, 17, 1, -21 },
  { 1008, 15, 11, 17, 1, -17 },
  { 1029, 15, 17, 17, 1, -21 },
  { 1061, 14, 25, 14, 0, -25 },
  { 1105, 25, 28, 27, 1, -25 },
  { 1193, 20, 24, 20, 0, -24 },
  { 1253, 16, 24, 20, 2, -24 },
  { 1301, 15, 25, 18, 2, -25 },
  { 1348, 18, 24, 21, 2, -24 },
  { 1402, 12, 24, 16, 2, -24 },
  { 1438, 12, 24, 16, 2, -24 },
  { 1474, 17, 25, 21, 2, -25 },
  { 1528, 18, 24, 22, 2, -24 },
  { 1582, 10, 24, 12, 1, -24 },
  { 1612, 10, 31, 10, -2, -24 },
  { 1651, 18, 24, 20, 2, -24 },
  { 1705, 13, 24, 16, 2, -24 },
  { 1744, 24, 24, 28, 2, -24 },
  { 1816, 19, 24, 24, 2, -24 },
  { 1873, 19, 25, 23, 2, -25 },
  { 1933, 15, 24, 18, 2, -24 },
  { 1978, 19, 31, 23, 2, -25 },
  { 2052, 17, 24, 19, 2, -24 },
  { 2103, 14, 25, 16, 1, -25 },
  { 2147, 15, 24, 16, 1, -24 },
  { 2192, 17, 24, 21, 2, -24 },
  { 2243, 19, 24, 19, 0, -24 },
  { 2300, 29, 24, 29, 0, -24 },
  { 2387, 19, 24, 19, 0, -24 },
  { 2444, 18, 24, 18, 0, -24 },
  { 2498, 15, 24, 16, 1, -24 },
  { 2543, 8, 31, 11, 2, -25 },
  { 2574, 14, 25, 14, 0, -25 },
  { 2618, 8, 31, 11, 1, -25 },
  { 2649, 18, 15, 18, 0, -24 },
  { 2683, 15, 3, 15, 0, 3 },
  { 2689, 9, 5, 12, 1, -26 },
  { 2695, 15, 19, 18, 1, -19 },
  { 2731, 15, 26, 19, 2, -26 },
  { 2780, 13, 19, 15, 1, -19 },
  { 2811, 16, 26, 19, 1, -26 },
  { 2863, 15, 19, 17, 1, -19 },
  { 2899, 13, 26, 11, 0, -26 },
  { 2942, 16, 27, 19, 1, -19 },
  { 2996, 15, 26, 19, 2, -26 },
  { 3045, 5, 26, 9, 2, -26 },
  { 3062, 8, 34, 9, -1, -26 },
  { 3096, 17, 26, 18, 2, -26 },
  { 3152, 5, 26, 9, 2, -26 },
  { 3169, 24, 19, 28, 2, -19 },
  { 3226, 15, 19, 19, 2, -19 },
  { 3262, 16, 19, 18, 1, -19 },
  { 3300, 15, 27, 19, 2, -19 },
  { 3351, 16, 27, 19, 1, -19 },
  { 3405, 11, 19, 13, 2, -19 },
  { 3432, 12, 19, 14, 1, -19 },
  { 3461, 12, 23, 13, 0, -23 },
  { 3496, 15, 19, 19, 2, -19 },
  { 3532, 17, 19, 17, 0, -19 },
  { 3573, 26, 19, 26, 0, -19 },
  { 3635, 17, 19, 17, 0, -19 },
  { 3676, 17, 27, 17, 0, -19 },
  { 3734, 12, 19, 14, 1, -19 },
  { 3763, 12, 30, 13, 0, -24 },
  { 3808, 4, 34, 16, 6, -26 },
  { 3825, 11, 30, 13, 1, -24 },
  { 3867, 15, 6, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_ExtraBold34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD34PT7B_H_
