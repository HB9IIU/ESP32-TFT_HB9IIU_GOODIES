#ifndef _NOTOSANS_CONDENSED_EXTRABOLD43PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0x10, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C,
  0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xC1, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3E, 0x0F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x83, 0xC7,
  0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF,
  0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x30, 0xCF, 0xCC, 0x03, 0xF3, 0x00,
  0xFC, 0xC0, 0x3F, 0xB0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x37, 0xF0, 0x0C,
  0xFC, 0x03, 0x3F, 0x80, 0xCF, 0xFC, 0x33, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xF8,
  0x01, 0xF0, 0x03, 0xFF, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x3E, 0x00, 0x7D,
  0xF8, 0x1F, 0x00, 0x1F, 0x3E, 0x07, 0xC0, 0x0F, 0x8F, 0x81, 0xF0, 0x03,
  0xE1, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x1F, 0x00,
  0x0F, 0x87, 0xC7, 0xC0, 0x03, 0xE1, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0xF8,
  0x78, 0x1F, 0x3E, 0x7C, 0x7F, 0x87, 0xCF, 0x9F, 0x3F, 0xF1, 0xFF, 0xE7,
  0xCF, 0xFE, 0x3F, 0xF3, 0xE7, 0xFF, 0x87, 0xF8, 0xF9, 0xF3, 0xE0, 0xFC,
  0x7C, 0x7C, 0x7C, 0x00, 0x1F, 0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0x87, 0xC0,
  0x03, 0xE3, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x1F,
  0x00, 0x1F, 0x07, 0xC7, 0xC0, 0x0F, 0x81, 0xF3, 0xF0, 0x03, 0xE0, 0x7C,
  0xF8, 0x01, 0xF0, 0x1F, 0xFE, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x3E, 0x00,
  0x7F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xF0, 0xFF, 0xE0, 0xFE,
  0x3F, 0xFE, 0x1F, 0x87, 0xFF, 0xE7, 0xF1, 0xFD, 0xFE, 0xFE, 0x3F, 0x9F,
  0xDF, 0x8F, 0xE1, 0xFF, 0xF1, 0xFC, 0x3F, 0xFE, 0x3F, 0x83, 0xFF, 0x87,
  0xF0, 0x3F, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xF1, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7F, 0x81,
  0xFF, 0x87, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF0, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x0F,
  0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0xC3, 0xE1, 0x9F, 0x7D, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC,
  0x07, 0xEF, 0xC1, 0xF8, 0xFC, 0x3F, 0x1F, 0x01, 0xC1, 0xC0, 0x18, 0x20,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF9, 0xF8, 0xFC,
  0x7E, 0x3E, 0x1F, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3C, 0x7E, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0x10, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xC7, 0xF3, 0xF8,
  0x7E, 0x7F, 0x0F, 0xEF, 0xC1, 0xFD, 0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0xFE, 0xFC, 0x1F, 0xDF, 0xC3,
  0xFB, 0xF8, 0x7F, 0x3F, 0x0F, 0xC7, 0xF3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x7F,
  0xFF, 0xFD, 0xFD, 0xF3, 0xF9, 0xC7, 0xF1, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0x07, 0xF0,
  0xC0, 0x7E, 0x10, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x07,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x86,
  0x07, 0xF0, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3D, 0xF8,
  0x07, 0xDF, 0x80, 0xFD, 0xF8, 0x0F, 0x9F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F,
  0x83, 0xE1, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0x81,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xFE, 0x3F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xF1, 0x8F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x3F, 0x07, 0xEF, 0xF8, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF8, 0x3F,
  0x7F, 0x0F, 0xE7, 0xF3, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x3F, 0x9F, 0xC3, 0xFB,
  0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xE1, 0xF8, 0xFE, 0x7F, 0x1F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFE, 0xFF, 0x3F, 0x8F, 0xF7, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xEF, 0xE1, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F,
  0xC7, 0xF3, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xDF, 0xC7, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xDF, 0x87, 0xF3, 0xF0, 0x38, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x88, 0x1F, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x3C,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x10,
  0x1E, 0x1F, 0x9F, 0xCF, 0xF7, 0xFB, 0xF8, 0xFC, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xF3, 0xF1,
  0xF8, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC7, 0xE0, 0x00, 0x00,
  0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xFB, 0xFF, 0xFC, 0xC0, 0xFE, 0x40, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x02, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x3E, 0x0F, 0xF8, 0xF9, 0xF0, 0x7F, 0xF1,
  0xE7, 0xC3, 0xFF, 0xC7, 0xDE, 0x1F, 0xFF, 0x1F, 0xF8, 0xFC, 0x7C, 0x7F,
  0xE3, 0xE1, 0xF0, 0xFF, 0x8F, 0x87, 0xC3, 0xFE, 0x3C, 0x1F, 0x0F, 0xF1,
  0xF0, 0x7C, 0x3F, 0xC7, 0xC1, 0xF0, 0xFF, 0x1F, 0x07, 0xC7, 0xFC, 0x7C,
  0x1F, 0x1F, 0xF0, 0xF8, 0xFC, 0x7F, 0xE3, 0xE3, 0xF3, 0xEF, 0x8F, 0xFF,
  0xFF, 0xBE, 0x1F, 0xF7, 0xFC, 0x78, 0x3F, 0xCF, 0xE1, 0xF0, 0x7C, 0x1F,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x01, 0x00,
  0x7F, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0,
  0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xE3,
  0xF8, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC,
  0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFC,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0,
  0x7E, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFE, 0x0F, 0xEF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xC0, 0xC7,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x23, 0xFF, 0x3E, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xE1, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x07,
  0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F,
  0xEF, 0xE0, 0x7F, 0xBF, 0x81, 0xFC, 0xFE, 0x1F, 0xF3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFE, 0x03, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFD, 0xFC, 0x03,
  0xF7, 0xF0, 0x0F, 0xDF, 0xE0, 0x3F, 0x3F, 0xC0, 0xFC, 0xFF, 0xCF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x3F, 0xB7, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0x81, 0xFC, 0xFE,
  0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F,
  0x83, 0xF9, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xDF, 0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0x8F,
  0xE0, 0xFF, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0,
  0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xDF, 0x03, 0xEF, 0xFF, 0x7C, 0x0F,
  0xBF, 0xFD, 0xF8, 0x7E, 0xFF, 0xF7, 0xE1, 0xF3, 0xFF, 0xCF, 0x87, 0xCF,
  0xFF, 0x3E, 0x1F, 0x3F, 0xFC, 0xFC, 0xFC, 0xFF, 0xF3, 0xF3, 0xE3, 0xFF,
  0xC7, 0xCF, 0x8F, 0xFF, 0x1F, 0x7E, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xF1,
  0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0x0F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xE0, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0x07, 0xF0,
  0x3F, 0xFC, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF8,
  0x3F, 0xFD, 0xFC, 0x3F, 0xFC, 0xFC, 0x3F, 0xFC, 0xFE, 0x3F, 0xFC, 0x7E,
  0x3F, 0xFC, 0x7F, 0x3F, 0xFC, 0x3F, 0x3F, 0xFC, 0x3F, 0xBF, 0xFC, 0x3F,
  0xBF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x7F,
  0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF,
  0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xFC, 0xFF, 0x01,
  0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0x87, 0xF7, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xBF, 0x9F, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0xFF,
  0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xBF, 0x80, 0x1F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x03,
  0xFC, 0xFF, 0x01, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE3,
  0xF8, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x9F, 0x80, 0xFE, 0x7F, 0x03, 0xF8, 0xFE,
  0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F,
  0xE0, 0xFE, 0x3F, 0x83, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xEF, 0xE0,
  0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xF0, 0x79, 0xFC, 0x04, 0x7E, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFB, 0xFE, 0xFF, 0xDF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE7, 0xF0, 0x07, 0xE3, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F,
  0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01,
  0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0xC0, 0x7F, 0x7E, 0x03, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0xC0, 0x7E, 0x7F, 0x03, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xE0,
  0xFE, 0x3F, 0x07, 0xFE, 0x0F, 0xE3, 0xF0, 0x7F, 0xE0, 0xFC, 0x3F, 0x07,
  0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0xE1, 0xFC, 0x3F, 0x87, 0xFF, 0x1F, 0xC1,
  0xF8, 0xFD, 0xF1, 0xFC, 0x1F, 0x8F, 0x9F, 0x1F, 0x81, 0xF8, 0xF9, 0xF1,
  0xF8, 0x1F, 0xCF, 0x9F, 0x1F, 0x80, 0xFC, 0xF9, 0xFB, 0xF8, 0x0F, 0xDF,
  0x8F, 0xBF, 0x80, 0xFD, 0xF8, 0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF, 0x00,
  0xFD, 0xF0, 0xFB, 0xF0, 0x07, 0xDF, 0x0F, 0xBF, 0x00, 0x7F, 0xF0, 0x7B,
  0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFE,
  0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC3, 0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xEF, 0xE0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC7, 0xF0,
  0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFE,
  0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFD,
  0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x07,
  0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F,
  0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x7E, 0x00, 0xF8, 0xF8, 0x07,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80,
  0xFC, 0x7E, 0x03, 0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0xBE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x03, 0xFC, 0x03, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1C, 0x3F, 0xC2, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0x1F, 0xDF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xEF,
  0xCF, 0xF8, 0xF8, 0xFE, 0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE3, 0xE0, 0xFE, 0xFF, 0x8F, 0xEF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xDF, 0xEF, 0xF0, 0xFE, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F,
  0xEF, 0xF8, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xCF,
  0xF8, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFE, 0x7F, 0xDE, 0xFF, 0x02, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x07, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF,
  0x1F, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0xFC, 0x7F, 0x9F, 0x9F, 0xFB, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFD, 0xF8, 0xFF, 0xBF, 0x0F, 0xE3, 0xE0, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xC7,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x19, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0xF1,
  0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xC7, 0xE3, 0xFC, 0xFC,
  0xFF, 0xDF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0x7F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x7F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xEF, 0xC7,
  0xFD, 0xF8, 0x7E, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xA0,
  0x07, 0xF7, 0x83, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE3, 0xF0, 0xFE, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCE, 0x00, 0x00, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0x03, 0xC0, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x0F, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xF3, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0xFC, 0x0F, 0xEF,
  0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xC3, 0xF8, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0,
  0xFC, 0xFE, 0x0F, 0xDF, 0xC0, 0xFD, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x7F, 0x0F, 0xC7,
  0xF0, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC,
  0x0F, 0xEF, 0xC0, 0xFF, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFC, 0x3F, 0x03, 0xF1, 0xF9, 0xFF, 0x1F, 0xF3, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFC, 0x3F, 0xFF, 0x87, 0xF8, 0x7F, 0xFE, 0x07, 0xF0, 0x7F, 0xFC,
  0x0F, 0xC0, 0xFF, 0xF8, 0x1F, 0x81, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xE0,
  0x7E, 0x07, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x81, 0xF8, 0x1F, 0xFF, 0x03,
  0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF8, 0x1F,
  0x81, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0xC0, 0xFC,
  0x0F, 0xFF, 0x81, 0xF8, 0x1F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x3F, 0x0F,
  0xCF, 0xF8, 0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0x0F, 0xEF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF9, 0xFC,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0,
  0x7E, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0x7F, 0x1F, 0xC7, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0xFC, 0x3E, 0x0F,
  0xCF, 0xF8, 0xFC, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF9, 0xFE,
  0xFF, 0x0F, 0xEF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFE, 0xFF, 0x8F, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0xFF, 0x8F, 0xE7, 0xF0, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC7,
  0xE3, 0xFC, 0xFC, 0xFF, 0xDF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0x7F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0x7F, 0xEF, 0xC7, 0xF9, 0xF8, 0x7E, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0xF8, 0x7F, 0xC7, 0xFE, 0x7F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF0,
  0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFE, 0x1C, 0xFE, 0x04,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE1, 0x3F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x07,
  0xF8, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC, 0x7F, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0x7F, 0xF7, 0xCF, 0xFC, 0xF8, 0x7F, 0x1F, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF0,
  0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E,
  0x3F, 0x81, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x7F,
  0x00, 0xFD, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x7E, 0x0F, 0xF0, 0x3F,
  0x7E, 0x0F, 0xF0, 0x7F, 0x7E, 0x0F, 0xF8, 0x7F, 0x7F, 0x0F, 0xF8, 0x7E,
  0x7F, 0x0F, 0xF8, 0x7E, 0x3F, 0x1F, 0xF8, 0x7E, 0x3F, 0x1F, 0x78, 0xFE,
  0x3F, 0x1F, 0x7C, 0xFC, 0x3F, 0x9F, 0x7C, 0xFC, 0x1F, 0x9E, 0x7C, 0xFC,
  0x1F, 0xBE, 0x7C, 0xFC, 0x1F, 0xBE, 0x3D, 0xF8, 0x1F, 0xBE, 0x3D, 0xF8,
  0x0F, 0xBE, 0x3D, 0xF8, 0x0F, 0xBE, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFB, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC,
  0x7F, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7E, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F,
  0x83, 0xF9, 0xFC, 0x1F, 0xDF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x81, 0xFC,
  0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x7F, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x27, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x0F, 0xFC, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0xFF, 0xC3, 0xFE,
  0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x83, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x03, 0xFC,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x07, 0xFC, 0x3F, 0xF0,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x17, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0xC0, 0x3F, 0xC8, 0x00, 0x30,
};

const GFXglyph NotoSans_Condensed_ExtraBold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 32, 12, 2, -31 },
  { 33, 16, 11, 20, 2, -31 },
  { 55, 22, 31, 24, 1, -31 },
  { 141, 18, 36, 22, 2, -33 },
  { 222, 34, 31, 36, 1, -31 },
  { 354, 27, 31, 28, 1, -31 },
  { 459, 7, 11, 11, 2, -31 },
  { 469, 12, 38, 14, 2, -31 },
  { 526, 11, 38, 14, 1, -31 },
  { 579, 19, 19, 21, 1, -33 },
  { 625, 19, 21, 22, 1, -26 },
  { 675, 9, 12, 12, 1, -6 },
  { 689, 11, 5, 14, 1, -14 },
  { 696, 8, 8, 12, 2, -7 },
  { 704, 18, 31, 18, 0, -31 },
  { 774, 19, 31, 22, 1, -31 },
  { 848, 15, 31, 22, 2, -31 },
  { 907, 19, 31, 22, 1, -31 },
  { 981, 19, 31, 22, 1, -31 },
  { 1055, 20, 31, 22, 1, -31 },
  { 1133, 18, 31, 22, 2, -31 },
  { 1203, 19, 31, 22, 1, -31 },
  { 1277, 19, 31, 22, 1, -31 },
  { 1351, 19, 31, 22, 1, -31 },
  { 1425, 19, 31, 22, 1, -31 },
  { 1499, 8, 25, 12, 2, -24 },
  { 1524, 9, 30, 12, 1, -24 },
  { 1558, 19, 21, 22, 1, -26 },
  { 1608, 19, 14, 22, 1, -22 },
  { 1642, 20, 21, 22, 1, -26 },
  { 1695, 17, 32, 18, 0, -31 },
  { 1763, 30, 34, 34, 2, -31 },
  { 1891, 26, 31, 26, 0, -31 },
  { 1992, 20, 31, 25, 3, -31 },
  { 2070, 20, 31, 23, 2, -31 },
  { 2148, 22, 31, 27, 3, -31 },
  { 2234, 15, 31, 20, 3, -31 },
  { 2293, 15, 31, 20, 3, -31 },
  { 2352, 22, 31, 27, 2, -31 },
  { 2438, 22, 31, 28, 3, -31 },
  { 2524, 13, 31, 15, 1, -31 },
  { 2575, 13, 40, 13, -3, -31 },
  { 2640, 22, 31, 25, 3, -31 },
  { 2726, 16, 31, 20, 3, -31 },
  { 2788, 30, 31, 36, 3, -31 },
  { 2905, 24, 31, 30, 3, -31 },
  { 2998, 25, 31, 28, 2, -31 },
  { 3095, 19, 31, 23, 3, -31 },
  { 3169, 25, 38, 28, 2, -31 },
  { 3288, 22, 31, 24, 3, -31 },
  { 3374, 18, 31, 20, 1, -31 },
  { 3444, 19, 31, 21, 1, -31 },
  { 3518, 21, 31, 27, 3, -31 },
  { 3600, 25, 31, 25, 0, -31 },
  { 3697, 36, 31, 36, 0, -31 },
  { 3837, 24, 31, 24, 0, -31 },
  { 3930, 23, 31, 23, 0, -31 },
  { 4020, 19, 31, 21, 1, -31 },
  { 4094, 11, 38, 14, 2, -31 },
  { 4147, 18, 31, 18, 0, -31 },
  { 4217, 10, 38, 14, 1, -31 },
  { 4265, 22, 20, 23, 1, -31 },
  { 4320, 19, 4, 19, 0, 3 },
  { 4330, 11, 7, 15, 2, -33 },
  { 4340, 19, 24, 22, 1, -24 },
  { 4397, 20, 33, 24, 2, -33 },
  { 4480, 16, 24, 19, 2, -24 },
  { 4528, 19, 33, 24, 2, -33 },
  { 4607, 18, 24, 22, 2, -24 },
  { 4661, 15, 33, 15, 1, -33 },
  { 4723, 19, 34, 24, 2, -24 },
  { 4804, 20, 33, 24, 2, -33 },
  { 4887, 7, 33, 12, 2, -33 },
  { 4916, 11, 43, 12, -2, -33 },
  { 4976, 20, 33, 23, 3, -33 },
  { 5059, 7, 33, 12, 2, -33 },
  { 5088, 31, 24, 36, 2, -24 },
  { 5181, 20, 24, 24, 2, -24 },
  { 5241, 20, 24, 23, 2, -24 },
  { 5301, 20, 34, 24, 2, -24 },
  { 5386, 19, 34, 24, 2, -24 },
  { 5467, 13, 24, 17, 3, -24 },
  { 5506, 16, 24, 18, 1, -24 },
  { 5554, 14, 29, 16, 1, -29 },
  { 5605, 19, 24, 24, 2, -24 },
  { 5662, 22, 24, 22, 0, -24 },
  { 5728, 32, 24, 33, 0, -24 },
  { 5824, 21, 24, 21, 0, -24 },
  { 5887, 22, 34, 22, 0, -24 },
  { 5981, 16, 24, 18, 1, -24 },
  { 6029, 14, 38, 16, 1, -31 },
  { 6096, 6, 43, 20, 7, -33 },
  { 6129, 14, 38, 16, 1, -31 },
  { 6196, 20, 8, 22, 1, -19 },
};

const GFXfont NotoSans_Condensed_ExtraBold43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD43PT7B_H_
