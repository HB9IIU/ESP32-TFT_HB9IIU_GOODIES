#ifndef _NOTOSANS_CONDENSED_EXTRABOLD18PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0xEF, 0xDF, 0xB6, 0x6C, 0xC0, 0x19,
  0x86, 0x41, 0xB0, 0x6C, 0x7F, 0xDF, 0xF1, 0x30, 0xCC, 0xFF, 0x8D, 0x83,
  0x60, 0xD8, 0x36, 0x00, 0x10, 0x21, 0xFF, 0xFD, 0x1A, 0x3C, 0x3E, 0x1E,
  0x2E, 0x5F, 0xFF, 0xC2, 0x04, 0x00, 0x38, 0x60, 0xF8, 0xC1, 0xB3, 0x07,
  0x66, 0x0E, 0xD8, 0x0D, 0xB7, 0x1F, 0x7F, 0x1D, 0xB6, 0x03, 0x6E, 0x0C,
  0xDC, 0x19, 0xB0, 0x63, 0xE0, 0xC3, 0xC0, 0x1E, 0x03, 0xF0, 0x33, 0x03,
  0x30, 0x3F, 0x03, 0xE0, 0x3C, 0xE7, 0xEE, 0x67, 0xEE, 0x3C, 0x73, 0xC7,
  0xFC, 0x3E, 0xF0, 0xFF, 0xEC, 0x3B, 0x99, 0xCE, 0x63, 0x18, 0xC6, 0x39,
  0xC6, 0x31, 0xC7, 0xE3, 0x8C, 0x63, 0x9C, 0x63, 0x18, 0xCE, 0x73, 0x19,
  0xDC, 0x1C, 0x18, 0x59, 0x7F, 0xFF, 0x3C, 0x77, 0x26, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0xFF, 0x60, 0xFF, 0xC0, 0xFF, 0x80,
  0x06, 0x1C, 0x38, 0x61, 0xC3, 0x06, 0x1C, 0x30, 0xE1, 0xC3, 0x0E, 0x00,
  0x38, 0x7C, 0xEE, 0xEE, 0xC6, 0xC6, 0xC7, 0xC6, 0xC6, 0xE6, 0xEE, 0x7E,
  0x7C, 0x1C, 0xF7, 0xFF, 0xDD, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x3E,
  0xFF, 0x67, 0x47, 0x07, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x7F, 0x7F,
  0x7D, 0xFF, 0x38, 0x70, 0xEF, 0x9F, 0x3F, 0x0E, 0x1E, 0x3F, 0xFF, 0xC0,
  0x07, 0x07, 0x83, 0xC3, 0xE3, 0xF1, 0xB9, 0xDC, 0xCE, 0xFF, 0xFF, 0xC1,
  0xC0, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0x0E, 0x1F, 0xBF, 0x87, 0x06, 0x1E,
  0x3F, 0xFF, 0xC0, 0x1E, 0x7E, 0x70, 0xE0, 0xC0, 0xDE, 0xFE, 0xE6, 0xC7,
  0xC7, 0xEE, 0x7E, 0x7C, 0xFF, 0xFF, 0xFE, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C,
  0x38, 0x38, 0x30, 0x70, 0x70, 0x7C, 0xFE, 0xEE, 0xE6, 0xEE, 0x7C, 0x7C,
  0xFE, 0xC6, 0xC7, 0xC6, 0xFE, 0x7C, 0x78, 0xFC, 0xEE, 0xC6, 0xC6, 0xC7,
  0xFF, 0xFE, 0x26, 0x0E, 0x1E, 0xFC, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0xFF,
  0x80, 0x00, 0xFF, 0x60, 0x01, 0x0F, 0x3E, 0xF8, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0x3E, 0x0F,
  0x3E, 0xF8, 0xE0, 0x80, 0x7D, 0xFD, 0x38, 0x30, 0xE3, 0x8E, 0x18, 0x30,
  0x00, 0xC1, 0xC3, 0x80, 0x0F, 0x81, 0xFF, 0x1C, 0x18, 0xCE, 0x6C, 0xFB,
  0x6C, 0xCB, 0x66, 0x7B, 0x32, 0xD9, 0xB6, 0xFF, 0xB3, 0xB8, 0xC0, 0x07,
  0x8C, 0x0F, 0xE0, 0x1E, 0x03, 0xE0, 0x7C, 0x0D, 0x83, 0xB0, 0x77, 0x0E,
  0xE3, 0x9C, 0x7F, 0x8F, 0xF9, 0xC7, 0x70, 0xEE, 0x0E, 0xFC, 0x7F, 0xB9,
  0xDC, 0x6E, 0x77, 0xFB, 0xF9, 0xCE, 0xE3, 0xF1, 0xF9, 0xDF, 0xEF, 0xE0,
  0x1F, 0x7F, 0x73, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x71, 0x7F,
  0x3F, 0xFC, 0x7F, 0xBF, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xFB, 0xDF, 0xEF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1F, 0xBF, 0x7E, 0xE1,
  0xC3, 0x87, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x3F, 0x7E, 0xE1,
  0xC3, 0x87, 0x0E, 0x00, 0x1F, 0x1F, 0xDE, 0x5E, 0x0E, 0x07, 0x03, 0x9F,
  0xCF, 0xE3, 0xF1, 0xDC, 0xEF, 0xF3, 0xF8, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x18, 0xFF, 0xF3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xBF, 0xFC, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xFE, 0xE0, 0xE3, 0xF1, 0xF9, 0xDD, 0xCE,
  0xE7, 0xE3, 0xF1, 0xFC, 0xEE, 0x73, 0xB9, 0xDC, 0x7E, 0x38, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xF0, 0x7F,
  0x83, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0xFF, 0xB6, 0xFD, 0xB7, 0xED,
  0xBF, 0x7D, 0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0x80, 0xF0, 0xFC, 0x3F, 0x8F,
  0xE3, 0xFC, 0xFF, 0x3E, 0xEF, 0xBB, 0xE7, 0xF9, 0xFE, 0x3F, 0x8F, 0xE1,
  0xC0, 0x3E, 0x1F, 0xE7, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x77, 0x39, 0xFE, 0x3F, 0x00, 0xFC, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7,
  0xFF, 0xFE, 0xF8, 0xE0, 0xE0, 0xE0, 0xE0, 0x3E, 0x1F, 0xE7, 0x3B, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x77, 0x39, 0xFE, 0x3F, 0x01,
  0xC0, 0x38, 0x0F, 0xFC, 0x7F, 0xBB, 0xDC, 0xEE, 0x77, 0x3B, 0xF9, 0xF8,
  0xEE, 0x77, 0x39, 0xDC, 0xFE, 0x38, 0x7D, 0xFF, 0xB7, 0x0E, 0x1E, 0x1F,
  0x1F, 0x0E, 0x1F, 0x3F, 0xEF, 0x80, 0xFF, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFC, 0xEF, 0xE3, 0xE0, 0xE1, 0xF8,
  0x76, 0x1D, 0xC6, 0x73, 0x9C, 0xE3, 0x38, 0xEC, 0x3F, 0x07, 0xC1, 0xE0,
  0x78, 0x1E, 0x00, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3B, 0x1C, 0x77, 0x7C,
  0xCE, 0xDB, 0x9D, 0xB7, 0x1B, 0x6E, 0x36, 0xD8, 0x6C, 0xF0, 0xF1, 0xE1,
  0xE3, 0xC1, 0xC7, 0x80, 0xE3, 0xDC, 0xE7, 0x38, 0xFC, 0x3F, 0x07, 0x81,
  0xE0, 0x78, 0x3F, 0x0F, 0xC7, 0x39, 0xCE, 0xE1, 0xC0, 0xE1, 0xDC, 0xE7,
  0x39, 0xDC, 0x3F, 0x0F, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0x06, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70,
  0x70, 0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xE0,
  0xC1, 0x83, 0x83, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x70, 0x60, 0xFF,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xFF, 0x0C, 0x0E, 0x07,
  0x83, 0xC3, 0x71, 0x99, 0x8F, 0xC3, 0xFF, 0xFF, 0xE7, 0x30, 0xFC, 0xFD,
  0x38, 0x37, 0xFE, 0xF1, 0xE7, 0xFF, 0xEC, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE,
  0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xDE, 0x3E, 0xFB, 0x97,
  0x0C, 0x18, 0x38, 0x71, 0xFC, 0xF8, 0x07, 0x07, 0x07, 0x07, 0x77, 0xFF,
  0xE7, 0xE7, 0xC7, 0xC7, 0xE7, 0xE7, 0xFF, 0x7F, 0x3C, 0x7E, 0xE6, 0xC7,
  0xFF, 0xFF, 0xC0, 0xE2, 0xFE, 0x7E, 0x1E, 0x79, 0xF3, 0x87, 0xDF, 0x9C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x77, 0xFF, 0xE7, 0xE7, 0xC7,
  0xC7, 0xE7, 0xE7, 0xFF, 0x7F, 0x07, 0x87, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x39, 0xCE, 0x03, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0xFF, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x7F, 0x3B,
  0xB9, 0xF8, 0xFC, 0x7E, 0x3B, 0x9D, 0xCE, 0x77, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xDE, 0xF7, 0xFF, 0xF9, 0xEF, 0xCE, 0x7E, 0x73, 0xF3,
  0x9F, 0x9C, 0xFC, 0xE7, 0xE7, 0x3F, 0x39, 0xC0, 0xDE, 0xFF, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x3C, 0x7E, 0xE7, 0xE7, 0xC7, 0xC7,
  0xE7, 0xE7, 0x7E, 0x3C, 0xDE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xFF, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0x77, 0xFF, 0xE7, 0xE7, 0xC7, 0xC7,
  0xE7, 0xE7, 0xFF, 0x7F, 0x07, 0x07, 0x07, 0x07, 0xCF, 0x7F, 0xF8, 0xE3,
  0x8E, 0x38, 0xE3, 0x80, 0x7B, 0xFC, 0x78, 0xF9, 0xF1, 0xE7, 0xFF, 0xE0,
  0x30, 0xC7, 0xFF, 0x71, 0xC7, 0x1C, 0x71, 0xC3, 0xCF, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7B, 0xE3, 0xF1, 0xD8, 0xCE, 0xE7,
  0x71, 0xB0, 0xD8, 0x7C, 0x1C, 0x0E, 0x00, 0xE7, 0x1F, 0x9E, 0x66, 0x7B,
  0x9D, 0xEE, 0x7D, 0xB1, 0xF6, 0xC3, 0xCB, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3,
  0x80, 0xE3, 0xBB, 0x9D, 0x87, 0xC3, 0xC1, 0xE0, 0xF8, 0xEE, 0x77, 0x71,
  0xC0, 0xE3, 0xF1, 0xDC, 0xCE, 0xE7, 0x71, 0xB0, 0xF8, 0x7C, 0x1C, 0x0E,
  0x07, 0x03, 0x07, 0x83, 0x80, 0x7E, 0xFC, 0x38, 0xE1, 0x87, 0x1C, 0x38,
  0xFF, 0xFC, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0xBC, 0xF0, 0xE3, 0x8E, 0x38,
  0xE3, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC7, 0x18, 0xC6, 0x31, 0xC7,
  0x3B, 0x98, 0xC6, 0x33, 0x98, 0xF1, 0xFF, 0x9E,
};

const GFXglyph NotoSans_Condensed_ExtraBold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 7, 5, 9, 1, -13 },
  { 11, 10, 13, 10, 0, -13 },
  { 28, 7, 15, 9, 1, -14 },
  { 42, 15, 13, 15, 0, -13 },
  { 67, 12, 13, 12, 0, -13 },
  { 87, 3, 5, 5, 1, -13 },
  { 89, 5, 16, 6, 1, -13 },
  { 99, 5, 16, 6, 0, -13 },
  { 109, 8, 8, 9, 0, -14 },
  { 117, 8, 9, 9, 1, -11 },
  { 126, 3, 4, 5, 1, -2 },
  { 128, 5, 2, 6, 0, -6 },
  { 130, 3, 3, 5, 1, -3 },
  { 132, 7, 13, 8, 0, -13 },
  { 144, 8, 13, 9, 1, -13 },
  { 157, 6, 13, 9, 1, -13 },
  { 167, 8, 13, 9, 0, -13 },
  { 180, 7, 13, 9, 1, -13 },
  { 192, 9, 13, 9, 0, -13 },
  { 207, 7, 13, 9, 1, -13 },
  { 219, 8, 13, 9, 1, -13 },
  { 232, 8, 13, 9, 1, -13 },
  { 245, 8, 13, 9, 1, -13 },
  { 258, 8, 13, 9, 1, -13 },
  { 271, 3, 10, 5, 1, -10 },
  { 275, 3, 12, 5, 1, -10 },
  { 280, 8, 9, 9, 1, -11 },
  { 289, 8, 6, 9, 1, -9 },
  { 295, 8, 9, 9, 1, -11 },
  { 304, 7, 13, 7, 0, -13 },
  { 316, 13, 14, 14, 1, -13 },
  { 339, 11, 13, 11, 0, -13 },
  { 357, 9, 13, 10, 1, -13 },
  { 372, 8, 13, 10, 1, -13 },
  { 385, 9, 13, 11, 1, -13 },
  { 400, 7, 13, 9, 1, -13 },
  { 412, 7, 13, 8, 1, -13 },
  { 424, 9, 13, 11, 1, -13 },
  { 439, 9, 13, 12, 1, -13 },
  { 454, 6, 13, 6, 0, -13 },
  { 464, 5, 17, 5, -1, -13 },
  { 475, 9, 13, 10, 1, -13 },
  { 490, 7, 13, 8, 1, -13 },
  { 502, 13, 13, 15, 1, -13 },
  { 524, 10, 13, 13, 1, -13 },
  { 541, 10, 13, 12, 1, -13 },
  { 558, 8, 13, 10, 1, -13 },
  { 571, 10, 16, 12, 1, -13 },
  { 591, 9, 13, 10, 1, -13 },
  { 606, 7, 13, 9, 1, -13 },
  { 618, 8, 13, 9, 0, -13 },
  { 631, 9, 13, 11, 1, -13 },
  { 646, 10, 13, 10, 0, -13 },
  { 663, 15, 13, 15, 0, -13 },
  { 688, 10, 13, 10, 0, -13 },
  { 705, 10, 13, 10, 0, -13 },
  { 722, 8, 13, 9, 0, -13 },
  { 735, 4, 16, 6, 1, -13 },
  { 743, 7, 13, 8, 0, -13 },
  { 755, 5, 16, 6, 0, -13 },
  { 765, 9, 8, 10, 0, -13 },
  { 774, 8, 2, 8, 0, 1 },
  { 776, 4, 3, 6, 1, -14 },
  { 778, 7, 10, 9, 1, -10 },
  { 787, 8, 14, 10, 1, -14 },
  { 801, 7, 10, 8, 1, -10 },
  { 810, 8, 14, 10, 1, -14 },
  { 824, 8, 10, 9, 1, -10 },
  { 834, 7, 14, 6, 0, -14 },
  { 847, 8, 14, 10, 1, -10 },
  { 861, 8, 14, 10, 1, -14 },
  { 875, 3, 14, 5, 1, -14 },
  { 881, 5, 18, 5, -1, -14 },
  { 893, 9, 14, 10, 1, -14 },
  { 909, 3, 14, 5, 1, -14 },
  { 915, 13, 10, 15, 1, -10 },
  { 932, 8, 10, 10, 1, -10 },
  { 942, 8, 10, 10, 1, -10 },
  { 952, 8, 14, 10, 1, -10 },
  { 966, 8, 14, 10, 1, -10 },
  { 980, 6, 10, 7, 1, -10 },
  { 988, 6, 10, 8, 1, -10 },
  { 996, 6, 12, 7, 0, -12 },
  { 1005, 8, 10, 10, 1, -10 },
  { 1015, 9, 10, 9, 0, -10 },
  { 1027, 14, 10, 14, 0, -10 },
  { 1045, 9, 10, 9, 0, -10 },
  { 1057, 9, 14, 9, 0, -10 },
  { 1073, 7, 10, 7, 0, -10 },
  { 1082, 6, 16, 7, 0, -13 },
  { 1094, 2, 18, 8, 3, -14 },
  { 1099, 5, 16, 7, 1, -13 },
  { 1109, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_ExtraBold18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD18PT7B_H_
