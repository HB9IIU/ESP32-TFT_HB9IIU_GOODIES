#ifndef _NOTOSANS_CONDENSED_EXTRABOLD15PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x3C, 0xDE, 0xF7, 0xB0, 0x1A, 0x16, 0x16, 0x7F, 0x7F,
  0x34, 0xFF, 0xFF, 0x2C, 0x6C, 0x6C, 0x23, 0xFF, 0xB8, 0xE1, 0xE3, 0xCB,
  0xAF, 0xE2, 0x08, 0x30, 0xC7, 0x98, 0xD9, 0x8D, 0xB0, 0xDB, 0x47, 0xEF,
  0x36, 0xB0, 0x5B, 0x0D, 0xB0, 0x8F, 0x18, 0xE0, 0x1C, 0x0F, 0x86, 0x61,
  0xF8, 0x3C, 0x0E, 0x67, 0xDB, 0xBE, 0xE7, 0x1F, 0xE7, 0xDC, 0xFF, 0x76,
  0xCC, 0xCC, 0xCC, 0xCC, 0xC6, 0x70, 0xC6, 0x63, 0x33, 0x33, 0x33, 0x36,
  0xE0, 0x18, 0xAF, 0xF9, 0xC6, 0xC5, 0x80, 0x30, 0xC3, 0x3F, 0xFC, 0xC3,
  0x00, 0x6D, 0xE0, 0xFF, 0xF0, 0x0C, 0x31, 0x86, 0x18, 0xC3, 0x18, 0x61,
  0x8C, 0x00, 0x73, 0xED, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xE7, 0x80, 0x19,
  0xDF, 0xB9, 0x8C, 0x63, 0x18, 0xC6, 0x39, 0xF9, 0x38, 0x70, 0xE1, 0x86,
  0x18, 0x71, 0xFF, 0xF8, 0x39, 0xF9, 0x38, 0x71, 0xC7, 0x07, 0x83, 0x0F,
  0xFF, 0xF0, 0x0C, 0x38, 0x71, 0xE3, 0xCD, 0x93, 0x7F, 0xFE, 0x18, 0x30,
  0xFB, 0xEC, 0x30, 0xFB, 0xF1, 0xC3, 0x1F, 0xFF, 0x80, 0x1E, 0x7D, 0xC3,
  0x07, 0xCF, 0xF9, 0xB3, 0x66, 0xFC, 0xF0, 0xFF, 0xFC, 0x18, 0x70, 0xC3,
  0x86, 0x0C, 0x38, 0x61, 0xC0, 0x3C, 0xFD, 0x9B, 0x37, 0xC7, 0x1F, 0xB3,
  0xE6, 0xFD, 0xF0, 0x38, 0xF9, 0xBF, 0x3E, 0x6F, 0xDF, 0x83, 0x0E, 0xF9,
  0xE0, 0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x78, 0x02, 0x1C, 0xF7, 0x07, 0x83,
  0xC1, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x87, 0x87, 0x3F, 0x88, 0x00,
  0x7B, 0xF4, 0xC3, 0x1C, 0xE3, 0x00, 0x01, 0xC3, 0x00, 0x1E, 0x0F, 0xE6,
  0x0F, 0x7B, 0x9A, 0x6C, 0x9B, 0x26, 0xDB, 0xDF, 0xB0, 0x06, 0x10, 0xFC,
  0x1C, 0x0E, 0x0D, 0x86, 0xC3, 0x63, 0xB1, 0xDC, 0xFE, 0x7F, 0x71, 0xF8,
  0xE0, 0xF9, 0xFB, 0x3E, 0x7C, 0xDF, 0xB3, 0xE3, 0xCF, 0xFF, 0xF0, 0x3C,
  0xFF, 0x96, 0x0C, 0x18, 0x30, 0x60, 0xE0, 0xF8, 0xF0, 0xF8, 0xFC, 0xCE,
  0xC6, 0xC7, 0xC7, 0xC7, 0xC6, 0xCE, 0xFC, 0xF8, 0xFF, 0xF1, 0x8F, 0xFF,
  0x18, 0xC7, 0xFE, 0xFF, 0xF1, 0x8C, 0x7F, 0xF8, 0xC6, 0x30, 0x3E, 0xFF,
  0x8F, 0x0C, 0x19, 0xF3, 0xE3, 0xE6, 0xFC, 0xF8, 0xC7, 0xC7, 0xC7, 0xC7,
  0xFF, 0xFF, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xFF, 0xDC, 0xE7, 0x39, 0xCE,
  0x73, 0xFE, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC7, 0xCE, 0xCC,
  0xDC, 0xD8, 0xF8, 0xFC, 0xDC, 0xCC, 0xCE, 0xC7, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xE1, 0xFE, 0x3F, 0xC7, 0xF9, 0xFD, 0x3F,
  0xB7, 0xF6, 0xBE, 0xF7, 0xCE, 0xF9, 0xDF, 0x33, 0x80, 0xE3, 0xE3, 0xF3,
  0xF3, 0xDB, 0xDB, 0xDF, 0xCF, 0xCF, 0xC7, 0xC7, 0x3C, 0x7E, 0xE7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7E, 0x3C, 0xF9, 0xFB, 0x3E, 0x7C, 0xFF,
  0xBF, 0x60, 0xC1, 0x83, 0x00, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE7, 0x7E, 0x3C, 0x0E, 0x06, 0x07, 0xF8, 0xFC, 0xCE, 0xCE, 0xCE,
  0xFC, 0xF8, 0xDC, 0xCC, 0xCE, 0xC7, 0x7B, 0xFC, 0xB0, 0xE1, 0xE3, 0x87,
  0x9F, 0xEF, 0x00, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE0, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xE7, 0xFD, 0xF0, 0xC3,
  0xF1, 0x98, 0xCC, 0xE6, 0x63, 0xB0, 0xD8, 0x7C, 0x3C, 0x0E, 0x07, 0x00,
  0xC6, 0x3E, 0x39, 0xB9, 0xCC, 0xCE, 0x66, 0xF3, 0x36, 0xB9, 0xB7, 0x8F,
  0xBC, 0x39, 0xE1, 0xCF, 0x0E, 0x38, 0xE7, 0x66, 0x76, 0x3C, 0x3C, 0x1C,
  0x3C, 0x3C, 0x76, 0x67, 0xE7, 0xE3, 0x67, 0x66, 0x7E, 0x3C, 0x3C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0xFC, 0x38, 0x61, 0x87, 0x0C, 0x38, 0x61,
  0xFF, 0xF8, 0xFF, 0x6D, 0xB6, 0xDB, 0x6E, 0xC1, 0x86, 0x18, 0x30, 0xC3,
  0x06, 0x18, 0x30, 0xC0, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x18,
  0x18, 0x3C, 0x3C, 0x66, 0x66, 0xC3, 0xFF, 0xFC, 0xE7, 0x7C, 0x5C, 0x1B,
  0xF6, 0x7C, 0xDF, 0xBB, 0xC1, 0x83, 0x07, 0xEF, 0xD9, 0xF3, 0xE7, 0xCF,
  0xFB, 0xF0, 0x7F, 0xF1, 0x8C, 0x63, 0xEF, 0x0C, 0x30, 0xFF, 0xFF, 0x3C,
  0xF3, 0xCF, 0xF7, 0xC0, 0x7B, 0x3C, 0xFF, 0xFF, 0x0F, 0xDF, 0x3D, 0xE6,
  0x3E, 0xF9, 0x86, 0x18, 0x61, 0x86, 0x00, 0xFF, 0xFC, 0xF3, 0xCF, 0x3F,
  0xDF, 0x0E, 0x7F, 0xDC, 0xC1, 0x83, 0x07, 0xEF, 0xD9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x38, 0x7C, 0xFF, 0xFF, 0x13, 0x30, 0x33, 0x33, 0x33, 0x33, 0x33,
  0xF4, 0xC1, 0x83, 0x06, 0x7D, 0xDB, 0x3E, 0x7C, 0xDD, 0x9B, 0x38, 0xFF,
  0xFF, 0xFC, 0xFF, 0xDF, 0xFF, 0x3B, 0xE6, 0x7C, 0xCF, 0x99, 0xF3, 0x3E,
  0x67, 0xFD, 0xFB, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x79, 0xFB, 0x36, 0x7C,
  0xF9, 0xBF, 0x3C, 0xFD, 0xFB, 0x3E, 0x7C, 0xF9, 0xFF, 0x6E, 0xC1, 0x83,
  0x06, 0x00, 0xFF, 0xFC, 0xF3, 0xCF, 0x3F, 0xDF, 0x0C, 0x30, 0xC3, 0xFF,
  0xF9, 0x8C, 0x63, 0x18, 0x7F, 0xA6, 0x1E, 0x3C, 0x3F, 0xFE, 0x23, 0x3F,
  0xF6, 0x31, 0x8C, 0x79, 0xC0, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xDD, 0xE7,
  0x66, 0x6E, 0x6C, 0x7C, 0x3C, 0x38, 0x38, 0xEE, 0x6D, 0xCD, 0xBF, 0xB5,
  0xE6, 0xBC, 0xF7, 0x8E, 0x71, 0xCC, 0xEE, 0xD8, 0xF1, 0xC3, 0xCF, 0x9B,
  0xF3, 0xE7, 0x66, 0x6E, 0x6C, 0x3C, 0x3C, 0x38, 0x18, 0x18, 0x30, 0x70,
  0x40, 0xFF, 0xF1, 0x8C, 0x31, 0x8F, 0xFF, 0x19, 0xCC, 0x63, 0x1B, 0x9E,
  0x31, 0x8C, 0x63, 0x80, 0xFF, 0xFC, 0xE7, 0x8C, 0x63, 0x18, 0xE7, 0x31,
  0x8C, 0xEE, 0x00, 0x23, 0xFE, 0x78,
};

const GFXglyph NotoSans_Condensed_ExtraBold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 8, 11, 8, 0, -11 },
  { 18, 6, 12, 8, 1, -11 },
  { 27, 12, 11, 13, 0, -11 },
  { 44, 10, 11, 10, 0, -11 },
  { 58, 2, 4, 4, 1, -11 },
  { 59, 4, 13, 5, 1, -11 },
  { 66, 4, 13, 5, 0, -11 },
  { 73, 7, 6, 7, 0, -11 },
  { 79, 6, 7, 8, 1, -9 },
  { 85, 3, 4, 4, 0, -2 },
  { 87, 4, 2, 5, 0, -5 },
  { 88, 2, 2, 4, 1, -2 },
  { 89, 6, 11, 6, 0, -11 },
  { 98, 6, 11, 8, 1, -11 },
  { 107, 5, 11, 8, 1, -11 },
  { 114, 7, 11, 8, 0, -11 },
  { 124, 7, 11, 8, 0, -11 },
  { 134, 7, 11, 8, 0, -11 },
  { 144, 6, 11, 8, 1, -11 },
  { 153, 7, 11, 8, 0, -11 },
  { 163, 7, 11, 8, 0, -11 },
  { 173, 7, 11, 8, 0, -11 },
  { 183, 7, 11, 8, 0, -11 },
  { 193, 2, 8, 4, 1, -8 },
  { 195, 3, 10, 4, 0, -8 },
  { 199, 7, 7, 8, 0, -9 },
  { 206, 6, 5, 8, 1, -8 },
  { 210, 6, 7, 8, 1, -9 },
  { 216, 6, 11, 6, 0, -11 },
  { 225, 10, 12, 12, 1, -11 },
  { 240, 9, 11, 9, 0, -11 },
  { 253, 7, 11, 9, 1, -11 },
  { 263, 7, 11, 8, 1, -11 },
  { 273, 8, 11, 9, 1, -11 },
  { 284, 5, 11, 7, 1, -11 },
  { 291, 5, 11, 7, 1, -11 },
  { 298, 7, 11, 9, 1, -11 },
  { 308, 8, 11, 10, 1, -11 },
  { 319, 5, 11, 5, 0, -11 },
  { 326, 4, 14, 4, -1, -11 },
  { 333, 8, 11, 9, 1, -11 },
  { 344, 6, 11, 7, 1, -11 },
  { 353, 11, 11, 13, 1, -11 },
  { 369, 8, 11, 10, 1, -11 },
  { 380, 8, 11, 10, 1, -11 },
  { 391, 7, 11, 8, 1, -11 },
  { 401, 8, 14, 10, 1, -11 },
  { 415, 8, 11, 9, 1, -11 },
  { 426, 6, 11, 7, 1, -11 },
  { 435, 7, 11, 7, 0, -11 },
  { 445, 7, 11, 9, 1, -11 },
  { 455, 9, 11, 9, 0, -11 },
  { 468, 13, 11, 13, 0, -11 },
  { 486, 8, 11, 8, 0, -11 },
  { 497, 8, 11, 8, 0, -11 },
  { 508, 7, 11, 7, 0, -11 },
  { 518, 3, 13, 5, 1, -11 },
  { 523, 6, 11, 6, 0, -11 },
  { 532, 4, 13, 5, 0, -11 },
  { 539, 8, 7, 8, 0, -11 },
  { 546, 7, 2, 7, 0, 1 },
  { 548, 4, 2, 5, 1, -11 },
  { 549, 7, 8, 8, 0, -8 },
  { 556, 7, 11, 8, 1, -11 },
  { 566, 5, 8, 7, 1, -8 },
  { 571, 6, 11, 8, 1, -11 },
  { 580, 6, 8, 8, 1, -8 },
  { 586, 6, 11, 5, 0, -11 },
  { 595, 6, 12, 8, 1, -8 },
  { 604, 7, 11, 8, 1, -11 },
  { 614, 2, 12, 4, 1, -12 },
  { 617, 4, 16, 4, -1, -12 },
  { 625, 7, 11, 8, 1, -11 },
  { 635, 2, 11, 4, 1, -11 },
  { 638, 11, 8, 12, 1, -8 },
  { 649, 7, 8, 8, 1, -8 },
  { 656, 7, 8, 8, 1, -8 },
  { 663, 7, 12, 8, 1, -8 },
  { 674, 6, 12, 8, 1, -8 },
  { 683, 5, 8, 6, 1, -8 },
  { 688, 6, 8, 6, 0, -8 },
  { 694, 5, 10, 6, 0, -10 },
  { 701, 6, 8, 8, 1, -8 },
  { 707, 8, 8, 8, 0, -8 },
  { 715, 11, 8, 11, 0, -8 },
  { 726, 7, 8, 7, 0, -8 },
  { 733, 8, 12, 8, 0, -8 },
  { 745, 6, 8, 6, 0, -8 },
  { 751, 5, 13, 6, 0, -11 },
  { 760, 1, 14, 7, 3, -11 },
  { 762, 5, 13, 6, 0, -11 },
  { 771, 7, 3, 8, 0, -7 },
};

const GFXfont NotoSans_Condensed_ExtraBold15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD15PT7B_H_
