#ifndef _NOTOSANS_CONDENSED_EXTRABOLD58PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0x03, 0x80, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xBF, 0xE1, 0xFE, 0xFF, 0x87, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0,
  0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xF9, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F,
  0x9F, 0xC1, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x80,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x80,
  0x01, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x3F, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x8F, 0xFB, 0xCF, 0xC7, 0xF9, 0xE0, 0xE7, 0xF8, 0xF0, 0x03, 0xFC,
  0x78, 0x01, 0xFE, 0x3C, 0x00, 0x7F, 0x9E, 0x00, 0x3F, 0xEF, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xEF, 0xF8, 0x00, 0xF3,
  0xFC, 0x00, 0x79, 0xFE, 0x00, 0x3C, 0xFF, 0x40, 0x1E, 0x7F, 0xBC, 0x0F,
  0x3F, 0xDF, 0x87, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x20, 0x00,
  0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x83, 0xF8,
  0x00, 0x0F, 0xC1, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE1, 0xFC, 0x00,
  0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0xFE, 0x00, 0x00,
  0xFE, 0x1F, 0xC7, 0xF0, 0x10, 0x07, 0xF0, 0xFC, 0x3F, 0x07, 0xF8, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFF, 0xE1, 0xFE, 0x7F, 0x1F, 0x8F, 0xFF, 0x87, 0xFF,
  0xF9, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xC7, 0xF3, 0xFC, 0xFE, 0x0F, 0xFC, 0x7F,
  0x1F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0x87,
  0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC1, 0xFC,
  0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC3, 0xF8,
  0x00, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xC1, 0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0x87, 0xFC, 0xFF, 0xDF, 0xF8,
  0xFF, 0xCF, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xDF, 0xFC, 0x0F, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFD, 0xFE, 0xFF, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x00, 0xFF,
  0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x03, 0xF0, 0x31, 0xF0, 0xFC, 0x3E,
  0x7F, 0xBF, 0x7F, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0xCF, 0xF0, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0x7C, 0x0F,
  0x80, 0x0F, 0x03, 0xC0, 0x00, 0x80, 0x40, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F,
  0xE3, 0xFC, 0x7F, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x8F,
  0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x1F, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xE3, 0xFF, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0,
  0x7F, 0xCF, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFC, 0x07,
  0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0x81, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0,
  0xFF, 0x8F, 0xF8, 0xFF, 0xC7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x9F, 0xF7, 0xF1, 0xFF, 0x3E, 0x1F, 0xF1, 0xC1, 0xFF, 0x08, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0x1F, 0x00, 0xFF, 0x87, 0x00, 0x7F, 0xC1,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x1E, 0x03, 0xFF, 0x0C, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x0A, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFD,
  0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0x9F, 0xE0,
  0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE,
  0x1F, 0xE0, 0x1F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0x81, 0xFE,
  0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xBE,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x10, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0xF8, 0x1F, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x78,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0xFF, 0x1F, 0xF8, 0x3F, 0xCF, 0xFF, 0x0F, 0xF7, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFE, 0x1F,
  0xFB, 0xFF, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0x1F, 0xEF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xF9, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F,
  0xE3, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF1, 0xFF, 0x87, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x0F, 0xF9, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFE, 0x3F, 0xF0, 0xFF, 0xDF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x1F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80,
  0xFF, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFF, 0xDF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x02, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x7F, 0xC3, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0x7F, 0x8F, 0xFF, 0x3F, 0xC1, 0xFF, 0x1F, 0xE0,
  0x3E, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0x87, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFC, 0x0C, 0x00, 0x1F, 0x87, 0xF9, 0xFF,
  0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xF9, 0xFE, 0x3F, 0xC1, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC,
  0x7F, 0x9F, 0xF3, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x8F, 0xF1, 0xFE,
  0x3F, 0x87, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3E, 0x03, 0xFE, 0x30, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x7F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0xFF, 0xC1, 0xFC, 0x1F, 0x80,
  0xFF, 0xFE, 0x3F, 0x0F, 0xE0, 0x7F, 0xFF, 0x8F, 0xE3, 0xF0, 0x3F, 0xFF,
  0xE3, 0xF8, 0xFC, 0x1F, 0xFF, 0xF8, 0x7E, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F,
  0x9F, 0x83, 0xF8, 0x3F, 0x87, 0xE7, 0xE1, 0xFC, 0x0F, 0xC1, 0xF9, 0xF8,
  0x7F, 0x03, 0xF0, 0x7F, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xFF, 0x87, 0xE0,
  0x3F, 0x07, 0xFF, 0xE1, 0xF8, 0x0F, 0xC1, 0xFF, 0xF8, 0x7E, 0x03, 0xF0,
  0x7E, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0xBF, 0x87, 0xE0, 0x7F, 0x07, 0xEF,
  0xE1, 0xF8, 0x1F, 0xC1, 0xFB, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0xFE, 0x1F,
  0xC1, 0xFC, 0x3F, 0x1F, 0x87, 0xF8, 0xFF, 0x9F, 0xC7, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE1, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0x9F, 0xFC,
  0x1F, 0xC0, 0xFF, 0xC7, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0E,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFC, 0x0F, 0xFE,
  0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0,
  0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x3F, 0xE7,
  0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFC, 0x0F, 0xFE, 0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0x87, 0xFF,
  0x00, 0x21, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x47, 0xFF, 0x00, 0x30, 0xFF,
  0xF8, 0x3E, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0xFC, 0xFF,
  0x80, 0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0x00,
  0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xEF,
  0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xFB, 0xFE, 0x01, 0xFF, 0xDF, 0xF0,
  0x1F, 0xFC, 0xFF, 0x81, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xE0, 0xFF, 0xE0, 0x00,
  0x83, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFD,
  0xFF, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x01, 0xFF, 0x7F,
  0xF0, 0x07, 0xFC, 0xFF, 0xE0, 0x1F, 0xF3, 0xFF, 0xE0, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x00,
  0x60, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x03,
  0xFF, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x03, 0xFF,
  0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x03,
  0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE3, 0xFF, 0x80, 0xFF,
  0x8F, 0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xEF,
  0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xBF, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF,
  0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x0F,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x00, 0xFF,
  0xCF, 0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xFC,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFB, 0xF8, 0x07, 0xF7, 0xFF, 0xFD, 0xFE, 0x03, 0xFB, 0xFF, 0xFE, 0xFF,
  0x01, 0xFD, 0xFF, 0xFF, 0x3F, 0x81, 0xFE, 0xFF, 0xFF, 0x9F, 0xC0, 0xFE,
  0x7F, 0xFF, 0xCF, 0xF0, 0x7F, 0x3F, 0xFF, 0xE7, 0xF8, 0x3F, 0x9F, 0xFF,
  0xF1, 0xFC, 0x3F, 0x8F, 0xFF, 0xF8, 0xFE, 0x1F, 0xC7, 0xFF, 0xFC, 0x7F,
  0x8F, 0xE3, 0xFF, 0xFE, 0x1F, 0xCF, 0xF1, 0xFF, 0xFF, 0x0F, 0xE7, 0xF0,
  0xFF, 0xFF, 0x87, 0xFB, 0xF8, 0x7F, 0xFF, 0xC3, 0xFD, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0x7F, 0xC0, 0xFF,
  0xFF, 0x3F, 0xE0, 0xFF, 0xFF, 0x3F, 0xE0, 0xFF, 0xFF, 0x3F, 0xE0, 0xFF,
  0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF,
  0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0x07, 0xFC, 0xFF,
  0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x07,
  0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE7, 0xFC, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xF0, 0x07, 0xFE,
  0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFE, 0x1F, 0xFE, 0xFF, 0x81, 0xFF, 0xBF,
  0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80,
  0xFF, 0xBF, 0xE0, 0x7F, 0xEF, 0xF8, 0x7F, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x07,
  0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE7, 0xFC, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xF0, 0x07, 0xFE,
  0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xBF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0xF0,
  0xFF, 0x81, 0xFF, 0xC7, 0xFC, 0x07, 0xFE, 0x3F, 0xE0, 0x3F, 0xF1, 0xFF,
  0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xE3, 0xFE, 0x03,
  0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x1F, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0,
  0x3F, 0xF1, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x3F,
  0xF3, 0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x7F, 0xE0, 0xFC, 0xFF, 0xC0, 0x18, 0xFF, 0xC0, 0x04, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFE, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF,
  0xC7, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x0F,
  0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF9, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xF8, 0x07, 0xFC, 0x3F,
  0xC0, 0x1F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x0F,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xC1,
  0xFE, 0x03, 0xF7, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFB, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFD, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFE, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xBF, 0x83, 0xFC,
  0x03, 0xFC, 0x3F, 0xDF, 0xC3, 0xFE, 0x01, 0xFF, 0x1F, 0xCF, 0xF1, 0xFF,
  0x00, 0xFF, 0x8F, 0xE3, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x80, 0x1F, 0xE3, 0xF8, 0xFE, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x7F, 0x3F,
  0xE0, 0x07, 0xF9, 0xFC, 0x3F, 0x9F, 0xF0, 0x03, 0xFE, 0xFE, 0x0F, 0xEF,
  0xF8, 0x00, 0xFF, 0x7F, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0x83, 0xFB,
  0xFC, 0x00, 0x3F, 0xDF, 0xC1, 0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0xFE,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFE,
  0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0,
  0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x80,
  0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF,
  0x80, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F,
  0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x8F,
  0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0,
  0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0xFF,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0x9F, 0xFC, 0x1E, 0x03, 0xFE, 0x04, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xF7, 0xF9, 0xFF, 0xF3, 0xFC, 0x7F, 0xF0, 0xFE, 0x1F, 0xF0,
  0x7F, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F,
  0x81, 0xFF, 0x3F, 0xF8, 0x3F, 0xEF, 0xFF, 0x87, 0xFD, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0xFF,
  0xEF, 0xFE, 0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0xBF, 0xF0, 0x1F, 0xF7, 0xFC,
  0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF8, 0x0F, 0xFB,
  0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFE, 0x0F, 0xFD, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F,
  0xE7, 0xFF, 0xC3, 0xFC, 0x7F, 0xF0, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF8, 0x1C,
  0x7F, 0xE0, 0x08, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x06, 0x7F, 0xF0,
  0x3C, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x16, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0xCF, 0xF0, 0xFF, 0xFB,
  0xFC, 0x7F, 0xFE, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFD, 0xFF, 0xC7, 0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xF0, 0x1F, 0xF7,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xDF,
  0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xEF, 0xF0, 0x7F, 0xF1, 0xFC, 0x0F, 0xF8, 0x7F, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0x9F, 0xE0, 0x1F, 0xE7,
  0xF8, 0x07, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x04, 0x7F, 0xE0, 0x03,
  0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x82, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC1, 0xFF, 0xC7, 0xF0,
  0xFF, 0xFB, 0xFC, 0x7F, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xC7, 0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xF0,
  0x1F, 0xF7, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x7F,
  0xE0, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xBF, 0xC3, 0xFF, 0xEF, 0xF0, 0x7F, 0xF3, 0xFC, 0x0F, 0xF0,
  0xFF, 0x00, 0x70, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x20, 0x00, 0x7F, 0xCE, 0x00, 0x3F, 0xE3, 0xFE, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x3F, 0xE7, 0xFF, 0x8F, 0xFB, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x08, 0x1F,
  0xC7, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x7F, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF,
  0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE,
  0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0x80, 0x00, 0x40, 0x07, 0xF0, 0x0F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xEF, 0xF0, 0x07, 0xFC, 0xFF,
  0x00, 0xFF, 0x8F, 0xF0, 0x1F, 0xF8, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF1, 0xFF, 0x00, 0xFF, 0x3F, 0xF0, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x7F,
  0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF,
  0x01, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0xCF, 0xF0, 0x07,
  0xFC, 0xFF, 0x00, 0x7F, 0xEF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xC7, 0xFF, 0x87, 0xFF, 0x8F, 0xF3, 0xFF, 0xF3,
  0xFF, 0xF3, 0xFD, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC7, 0xFF, 0x8F, 0xF3, 0xFF, 0xF3, 0xFD, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xFE, 0x7F, 0xC0, 0x7F,
  0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x1F, 0xF3,
  0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x1F, 0xE3, 0xFF, 0x83, 0xFC, 0xFF, 0xF8, 0x7F, 0xDF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0x07,
  0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xF8, 0x0F, 0xFB, 0xFF, 0x01, 0xFF, 0x7F,
  0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x80, 0xFF,
  0xBF, 0xF0, 0x1F, 0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xE1, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1,
  0xFF, 0x7F, 0xFC, 0x3F, 0xE7, 0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x80,
  0x80, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x1F, 0xC1, 0xFF, 0xC7, 0xF0, 0xFF, 0xFB, 0xFC, 0x7F, 0xFE, 0xFF, 0x1F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xC7, 0xFF,
  0x7F, 0xE0, 0xFF, 0xDF, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xF7, 0xFC, 0x07,
  0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0xC3, 0xFF, 0xEF, 0xF0,
  0x7F, 0xF3, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0x70, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x9F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0x1F, 0x9F, 0xE0, 0x18, 0xFF, 0x00, 0x47, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x08, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x0E, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0x7F, 0xE1, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xBF, 0xC7, 0xFF, 0xEF, 0xF0, 0xFF, 0xF1,
  0xFC, 0x1F, 0xF0, 0x7F, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFB,
  0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC,
  0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07,
  0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x1F,
  0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF7, 0xF8, 0x07,
  0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFF,
  0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xFF, 0x03,
  0xFC, 0x3F, 0xC0, 0xFF, 0xF0, 0x3F, 0xC3, 0xFE, 0x0F, 0xFF, 0x07, 0xFC,
  0x3F, 0xE1, 0xFF, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xFF, 0x87, 0xF8, 0x1F,
  0xE1, 0xFB, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0x9F, 0x87, 0xF8, 0x1F, 0xF1,
  0xF9, 0xF8, 0xFF, 0x80, 0xFF, 0x3F, 0x9F, 0xCF, 0xF0, 0x0F, 0xF3, 0xF9,
  0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0x1F, 0xCF, 0xF0, 0x0F, 0xF3, 0xF0, 0xFC,
  0xFF, 0x00, 0xFF, 0x3F, 0x0F, 0xDF, 0xE0, 0x07, 0xFB, 0xF0, 0xFD, 0xFE,
  0x00, 0x7F, 0xFF, 0x0F, 0xDF, 0xE0, 0x07, 0xFF, 0xF0, 0xFD, 0xFE, 0x00,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xF7, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xE3, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF,
  0x80, 0xFF, 0xDF, 0xF0, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0xF0,
  0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF,
  0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF,
  0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80,
  0xFF, 0x87, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0xFF,
  0x1F, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0x7F,
  0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x07, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x4F, 0xFC, 0x00, 0x17, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xA0, 0x01, 0xFF, 0x88, 0x00, 0x03,
  0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBold58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 42, 16, 3, -41 },
  { 54, 22, 15, 27, 3, -41 },
  { 96, 31, 41, 33, 1, -41 },
  { 255, 25, 47, 29, 2, -44 },
  { 402, 45, 42, 49, 2, -42 },
  { 639, 36, 43, 38, 2, -42 },
  { 833, 9, 15, 15, 3, -41 },
  { 850, 16, 51, 19, 2, -42 },
  { 952, 16, 51, 19, 1, -42 },
  { 1054, 26, 25, 28, 1, -44 },
  { 1136, 26, 29, 30, 2, -35 },
  { 1231, 11, 16, 16, 2, -8 },
  { 1253, 15, 8, 18, 2, -20 },
  { 1268, 10, 10, 16, 3, -9 },
  { 1281, 24, 42, 24, 0, -42 },
  { 1407, 25, 43, 29, 2, -42 },
  { 1542, 20, 41, 29, 3, -41 },
  { 1645, 25, 42, 29, 2, -42 },
  { 1777, 25, 43, 29, 2, -42 },
  { 1912, 28, 41, 29, 1, -41 },
  { 2056, 24, 42, 29, 3, -41 },
  { 2182, 26, 43, 29, 2, -42 },
  { 2322, 25, 41, 29, 2, -41 },
  { 2451, 26, 43, 29, 2, -42 },
  { 2591, 25, 43, 29, 2, -42 },
  { 2726, 10, 33, 16, 3, -32 },
  { 2768, 11, 40, 16, 2, -32 },
  { 2823, 26, 29, 30, 2, -35 },
  { 2918, 26, 19, 30, 2, -30 },
  { 2980, 26, 29, 30, 2, -35 },
  { 3075, 23, 43, 24, 0, -42 },
  { 3199, 42, 46, 46, 2, -42 },
  { 3441, 35, 41, 35, 0, -41 },
  { 3621, 27, 41, 34, 4, -41 },
  { 3760, 27, 43, 31, 3, -42 },
  { 3906, 29, 41, 36, 4, -41 },
  { 4055, 21, 41, 27, 4, -41 },
  { 4163, 21, 41, 27, 4, -41 },
  { 4271, 30, 43, 36, 3, -42 },
  { 4433, 30, 41, 38, 4, -41 },
  { 4587, 17, 41, 21, 2, -41 },
  { 4675, 17, 54, 17, -4, -41 },
  { 4790, 30, 41, 33, 4, -41 },
  { 4944, 22, 41, 27, 4, -41 },
  { 5057, 41, 41, 49, 4, -41 },
  { 5268, 32, 41, 40, 4, -41 },
  { 5432, 33, 43, 38, 3, -42 },
  { 5610, 26, 41, 31, 4, -41 },
  { 5744, 33, 52, 38, 3, -42 },
  { 5959, 29, 41, 33, 4, -41 },
  { 6108, 24, 43, 28, 2, -42 },
  { 6237, 26, 41, 28, 1, -41 },
  { 6371, 29, 42, 37, 4, -41 },
  { 6524, 33, 41, 33, 0, -41 },
  { 6694, 49, 41, 49, 0, -41 },
  { 6946, 32, 41, 32, 0, -41 },
  { 7110, 31, 41, 31, 0, -41 },
  { 7269, 26, 41, 28, 1, -41 },
  { 7403, 14, 51, 18, 3, -42 },
  { 7493, 24, 42, 24, 0, -42 },
  { 7619, 14, 51, 18, 1, -42 },
  { 7709, 30, 26, 31, 1, -41 },
  { 7807, 26, 6, 26, 0, 4 },
  { 7827, 16, 9, 20, 2, -44 },
  { 7845, 25, 33, 30, 2, -32 },
  { 7949, 27, 45, 32, 3, -44 },
  { 8101, 23, 33, 26, 2, -32 },
  { 8196, 26, 45, 32, 2, -44 },
  { 8343, 26, 33, 30, 2, -32 },
  { 8451, 20, 44, 20, 1, -44 },
  { 8561, 26, 46, 32, 2, -32 },
  { 8711, 26, 44, 32, 3, -44 },
  { 8854, 10, 45, 16, 3, -45 },
  { 8911, 15, 59, 16, -2, -45 },
  { 9022, 28, 44, 31, 4, -44 },
  { 9176, 9, 44, 16, 3, -44 },
  { 9226, 42, 32, 48, 3, -32 },
  { 9394, 26, 32, 32, 3, -32 },
  { 9498, 27, 33, 31, 2, -32 },
  { 9610, 27, 46, 32, 3, -32 },
  { 9766, 26, 46, 32, 2, -32 },
  { 9916, 19, 32, 23, 3, -32 },
  { 9992, 21, 33, 24, 2, -32 },
  { 10079, 19, 39, 22, 1, -38 },
  { 10172, 26, 33, 32, 3, -32 },
  { 10280, 29, 32, 29, 0, -32 },
  { 10396, 44, 32, 44, 0, -32 },
  { 10572, 28, 32, 29, 0, -32 },
  { 10684, 29, 46, 29, 0, -32 },
  { 10851, 22, 32, 24, 1, -32 },
  { 10939, 19, 51, 22, 1, -42 },
  { 11061, 7, 57, 27, 10, -44 },
  { 11111, 19, 51, 22, 2, -42 },
  { 11233, 26, 11, 30, 2, -26 },
};

const GFXfont NotoSans_Condensed_ExtraBold58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD58PT7B_H_
