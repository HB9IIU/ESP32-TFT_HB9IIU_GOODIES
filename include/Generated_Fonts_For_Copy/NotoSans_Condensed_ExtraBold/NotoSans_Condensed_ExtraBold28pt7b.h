#ifndef _NOTOSANS_CONDENSED_EXTRABOLD28PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x04, 0x7F,
  0xFE, 0xF0, 0xFB, 0xFF, 0x3D, 0xE7, 0xB8, 0xF7, 0x1E, 0xE3, 0xDC, 0x70,
  0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x73, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCE, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x1C, 0xF0, 0x06,
  0x00, 0x60, 0x1F, 0xE7, 0xFF, 0x7F, 0xEF, 0xE6, 0xF6, 0x0F, 0x60, 0xFE,
  0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x6F, 0x06, 0xF8, 0x6F, 0xF7,
  0xFF, 0xFE, 0xFF, 0xC3, 0xF8, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3E, 0x07,
  0x81, 0xF8, 0x1C, 0x0F, 0xF0, 0xF0, 0x39, 0xC3, 0x80, 0xE7, 0x0E, 0x03,
  0x9E, 0x70, 0x0E, 0x79, 0xC0, 0x39, 0xCE, 0x00, 0xE7, 0x39, 0xF3, 0xFD,
  0xEF, 0xE7, 0xF7, 0x7F, 0x8F, 0xBD, 0xCE, 0x00, 0xE7, 0x3C, 0x03, 0x9C,
  0xF0, 0x1C, 0x73, 0xC0, 0x71, 0xCF, 0x03, 0x87, 0x38, 0x0E, 0x0F, 0xE0,
  0x78, 0x3F, 0x81, 0xC0, 0x7C, 0x0F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0x9E, 0x07, 0x8F, 0x03, 0xE7, 0x80, 0xF7, 0x80, 0x7F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC7, 0xDF, 0xE3, 0xDF, 0xFB, 0xEF, 0xBF, 0xF7, 0x8F, 0xF3, 0xC3,
  0xF9, 0xF1, 0xF8, 0xFD, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xF9, 0xF0,
  0xFF, 0xDE, 0xE7, 0x39, 0xC0, 0x0F, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x78,
  0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78,
  0x78, 0x3C, 0x3C, 0x1E, 0x1F, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E,
  0x1E, 0x3C, 0x3C, 0x38, 0xF8, 0x0F, 0x00, 0xE0, 0x0E, 0x0E, 0xE6, 0xFF,
  0xFF, 0xFF, 0x3F, 0x81, 0xF8, 0x3F, 0xC7, 0xBE, 0x39, 0xC1, 0x10, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7B, 0xDE, 0xFF, 0x7B,
  0xDC, 0xFF, 0xFF, 0xF8, 0x23, 0xFF, 0xF7, 0x80, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0xFE, 0x79, 0xFF, 0x8F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8,
  0xF7, 0x9F, 0x7F, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0x03, 0xC1, 0xF0, 0xFC,
  0x7F, 0x3F, 0xFE, 0xF7, 0xBC, 0xCF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x3F, 0x87, 0xFC,
  0xFF, 0xEF, 0xFE, 0x61, 0xF4, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xFE, 0xFF, 0xE7, 0x3F, 0x41, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x3F, 0xC3, 0xF0, 0x3F, 0xC3, 0xFE, 0x01, 0xF0, 0x1F,
  0x01, 0xF8, 0x1F, 0xE3, 0xFF, 0xFE, 0xFF, 0xCF, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xEF, 0x07, 0xBC, 0x1D,
  0xF0, 0xF7, 0xC3, 0x9F, 0x1E, 0x7C, 0x71, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x7F, 0xE7, 0xFE, 0x7F,
  0xE7, 0xFE, 0x78, 0x07, 0x80, 0x78, 0x07, 0xF8, 0x7F, 0xC7, 0xFE, 0x7F,
  0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0xF7, 0xEF, 0xFE, 0xFF,
  0xC7, 0xF8, 0x07, 0xE1, 0xFE, 0x3F, 0xE7, 0xF2, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x7C, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x8F, 0x7D, 0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x1F, 0xC7, 0xFE, 0x7F, 0xEF, 0x9F, 0xF0, 0xFF, 0x8F, 0x79,
  0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0x3F, 0xC7, 0xFE, 0xF9, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF9, 0xFF, 0xFF, 0x7F, 0xE3, 0xFC, 0x1F, 0x83, 0xFC, 0x7F,
  0xEF, 0xFE, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xBF, 0x7F,
  0xF7, 0xFF, 0x3E, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x4F, 0xE7, 0xFC, 0x7F,
  0x87, 0xE0, 0x23, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x67, 0xFF, 0xEF,
  0x33, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x07, 0xBD, 0xEF, 0xF7, 0xBD,
  0xC0, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x3F,
  0x0F, 0xF3, 0xF8, 0xFE, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x3F, 0x9F, 0xF9,
  0xFF, 0xBD, 0xF4, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0x8F, 0x81, 0xE0, 0x3C, 0x38,
  0x01, 0xE7, 0x8F, 0xCE, 0x71, 0xFE, 0xF7, 0x3D, 0xE7, 0xE3, 0x8E, 0x7E,
  0x79, 0xE7, 0xE7, 0x1E, 0x7E, 0x71, 0xE7, 0xE7, 0x1E, 0x7E, 0x79, 0xEE,
  0xE3, 0xFF, 0xE7, 0x3F, 0x7C, 0x70, 0xE3, 0x87, 0x80, 0x00, 0x3C, 0x01,
  0x01, 0xF9, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xF7, 0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x3E,
  0xF0, 0x1E, 0x7C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xFF, 0xE1,
  0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7C, 0x1F, 0x3C, 0x0F, 0xBE, 0x03,
  0xDF, 0x01, 0xF0, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xDE, 0x3E, 0xFF, 0xE7, 0xFE, 0x3F, 0xFD, 0xE3, 0xEF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xF9, 0xFF, 0x80,
  0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0x7F, 0xF7, 0xC1, 0x3E, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x0F, 0x81, 0x3F, 0xF9, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0xFF, 0x83, 0xFF,
  0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0xFB, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xBC,
  0x3E, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xEF, 0xFB, 0xFE,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x07, 0xFC,
  0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE7, 0xE0, 0x4F, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x83, 0xEF, 0x07,
  0xDF, 0x0F, 0xBE, 0x1F, 0x3F, 0x7E, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFE, 0xFE, 0xF8, 0xF0, 0x7F, 0xC1,
  0xEF, 0x0F, 0xBC, 0x7C, 0xF1, 0xF3, 0xCF, 0x8F, 0x7C, 0x3D, 0xF0, 0xF7,
  0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFB, 0xE3, 0xCF, 0x8F, 0x1F, 0x3C,
  0x7C, 0xF0, 0xFB, 0xC3, 0xEF, 0x07, 0xBC, 0x1F, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xF7, 0x1F, 0xFF, 0x79, 0xDF, 0xF7, 0x9D,
  0xFF, 0x7B, 0xDF, 0xF3, 0xB9, 0xFF, 0x3F, 0x9F, 0xF3, 0xF9, 0xFF, 0x1F,
  0x9F, 0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0xF1, 0xF1, 0xFF, 0x0E, 0x1F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x9F, 0xF7, 0x9F, 0xF7, 0xDF, 0xF3, 0xCF, 0xF3, 0xEF, 0xF1,
  0xEF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C,
  0x3E, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x3F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF,
  0xFF, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFC, 0xFF, 0x8F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x7C,
  0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x3F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0xF1, 0xF3,
  0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0,
  0xF3, 0xC3, 0xCF, 0x8F, 0x1E, 0x3C, 0x7C, 0xF1, 0xF3, 0xC3, 0xEF, 0x0F,
  0xBC, 0x1F, 0x1F, 0xC7, 0xFD, 0xFF, 0xFF, 0xFF, 0x85, 0xE0, 0x3E, 0x07,
  0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x03, 0xC0, 0x7E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF,
  0x07, 0xF8, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E,
  0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xF0, 0x3C, 0x1F, 0xF8, 0x3C, 0x1E,
  0xF8, 0x7C, 0x1E, 0x78, 0x7C, 0x1E, 0x78, 0x7E, 0x3E, 0x78, 0x7E, 0x3E,
  0x78, 0xFE, 0x3C, 0x3C, 0xFE, 0x3C, 0x3C, 0xEE, 0x3C, 0x3C, 0xEF, 0x7C,
  0x3C, 0xEF, 0x78, 0x3D, 0xE7, 0x78, 0x1F, 0xE7, 0x78, 0x1F, 0xE7, 0x78,
  0x1F, 0xC7, 0x78, 0x1F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x7C, 0x3C, 0x3C, 0x7C,
  0x3E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8,
  0x3E, 0x78, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x3E, 0xF8, 0x3F, 0xF8, 0x3E,
  0xF0, 0x7D, 0xF0, 0xF1, 0xE3, 0xE3, 0xC7, 0x87, 0xDF, 0x07, 0xBC, 0x0F,
  0x78, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xFF,
  0xFC, 0xF0, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x01,
  0xDC, 0x07, 0xBC, 0x0E, 0x38, 0x3C, 0x78, 0x78, 0x71, 0xE0, 0xF3, 0xC1,
  0xEF, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0x03, 0xFC, 0x7F, 0xE3, 0xFF, 0x21, 0xF0, 0x0F, 0x0F, 0xF3, 0xFF,
  0x7F, 0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xF1, 0xFF, 0xFF, 0x7F, 0xF7, 0xE7,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x38, 0xF7, 0xCF, 0xFE,
  0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x9F, 0xFF, 0xEF, 0xFE, 0xE7, 0xC0, 0x07, 0x83, 0xFC, 0xFF,
  0xBF, 0xE7, 0x85, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C,
  0x17, 0xCE, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x86, 0x7C, 0xFD, 0xEF, 0xEF, 0x7F, 0xFF, 0xC7, 0xFE, 0x3F,
  0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x1F, 0xF8, 0xFB, 0xEF, 0xDF,
  0xFE, 0x7E, 0xF3, 0xE7, 0x80, 0x07, 0x01, 0xFC, 0x3F, 0xE7, 0xFF, 0x78,
  0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C,
  0x37, 0xFF, 0x3F, 0xF1, 0xFE, 0x0F, 0xC7, 0xF3, 0xFC, 0xF8, 0x3C, 0x0F,
  0x07, 0xFB, 0xFE, 0xFF, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x0C, 0x01, 0xFB, 0xDF,
  0xDE, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFE, 0x3F, 0xF1, 0xF7, 0xDF, 0xBF, 0xFC, 0xFD, 0xE7, 0xDF, 0x00, 0xF8,
  0x07, 0xD0, 0x3C, 0xFF, 0xE7, 0xFE, 0x3F, 0xE0, 0x7C, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x38, 0xF7, 0xEF, 0xFE, 0xFF, 0xFF,
  0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x4F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x08, 0x3C, 0xF8, 0xF1, 0xC0, 0x00, 0x0F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x3F, 0xFF, 0xF7, 0xEF, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC3, 0xDE, 0x3E, 0xF3, 0xE7, 0x9E, 0x3D,
  0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0x78, 0xF3, 0xE7, 0x8F,
  0x3C, 0x7D, 0xE1, 0xEF, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x83, 0x0E, 0xFE, 0xFC, 0xEF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xF9, 0xF9, 0xFF, 0x1F, 0x1F, 0xF0, 0xF1, 0xFF, 0x0F,
  0x1F, 0xF0, 0xF1, 0xFF, 0x0F, 0x1F, 0xF0, 0xF1, 0xFF, 0x0F, 0x1F, 0xF0,
  0xF1, 0xFF, 0x0F, 0x1F, 0xF0, 0xF1, 0xFF, 0x0F, 0x1F, 0x03, 0x8E, 0xFE,
  0xEF, 0xEF, 0xFF, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x07, 0x00, 0xFE,
  0x0F, 0xF8, 0xFF, 0xE7, 0x8F, 0x7C, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFE, 0x1F, 0xF1, 0xF7, 0xCF, 0x3F, 0xF8, 0xFF, 0x83, 0xF8, 0x03,
  0x8E, 0x7C, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFB, 0xFF, 0xFE, 0xFF, 0xEF, 0x7C, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x0C, 0x01,
  0xFB, 0xDF, 0xDE, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFE, 0x3F, 0xF1, 0xF7, 0xDF, 0xBF, 0xFC, 0xFD, 0xE7, 0xDF,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x01, 0xF3, 0xFB, 0xDF, 0xEF, 0xF7, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x0E, 0x1F, 0xFF, 0xFB, 0xFE, 0xF0,
  0xBE, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7C, 0x0F, 0xC7, 0xFF, 0xFF,
  0xFB, 0xFC, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF9, 0x3F, 0xC7,
  0xF0, 0xFC, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0x7E,
  0x70, 0xF8, 0x7D, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3,
  0xCF, 0x0F, 0x3C, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x78, 0x00, 0xF8, 0xF8, 0x7B, 0xC7, 0xC7, 0xDE, 0x3F, 0x3C,
  0xF3, 0xF9, 0xE7, 0x9D, 0xCF, 0x1E, 0xEE, 0x78, 0xF7, 0x77, 0x87, 0xBB,
  0xBC, 0x3D, 0xCF, 0xE1, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xFD, 0xF3, 0xE3,
  0xCF, 0x0F, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x83, 0xFE, 0x0F, 0x7C, 0x7C, 0xF1, 0xE3, 0xEF, 0x87, 0xC0, 0xF8,
  0x7D, 0xE1, 0xE7, 0x87, 0x9F, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3, 0xCF, 0x07,
  0xBC, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF8,
  0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC3, 0xF0,
  0xFC, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x87, 0xE3, 0xF0,
  0xF8, 0x3F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x03,
  0xF0, 0xFC, 0x1F, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0xE3, 0xF0, 0xF8, 0xFC, 0xF8, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC7, 0xE3, 0xF1, 0xF0, 0x80, 0x00, 0x7E, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7F, 0x80, 0x40,
};

const GFXglyph NotoSans_Condensed_ExtraBold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 20, 8, 1, -20 },
  { 14, 11, 7, 13, 1, -20 },
  { 24, 14, 20, 16, 1, -20 },
  { 59, 12, 23, 14, 1, -21 },
  { 94, 22, 20, 23, 1, -20 },
  { 149, 17, 20, 18, 1, -20 },
  { 192, 5, 7, 7, 1, -20 },
  { 197, 8, 24, 9, 1, -20 },
  { 221, 8, 24, 9, 0, -20 },
  { 245, 12, 12, 14, 1, -21 },
  { 263, 12, 14, 14, 1, -17 },
  { 284, 5, 8, 8, 1, -4 },
  { 289, 7, 3, 9, 1, -9 },
  { 292, 5, 5, 8, 1, -5 },
  { 296, 12, 20, 12, 0, -20 },
  { 326, 12, 20, 14, 1, -20 },
  { 356, 10, 20, 14, 1, -20 },
  { 381, 12, 20, 14, 1, -20 },
  { 411, 12, 20, 14, 1, -20 },
  { 441, 14, 20, 14, 0, -20 },
  { 476, 12, 20, 14, 1, -20 },
  { 506, 12, 20, 14, 1, -20 },
  { 536, 12, 20, 14, 1, -20 },
  { 566, 12, 20, 14, 1, -20 },
  { 596, 12, 20, 14, 1, -20 },
  { 626, 5, 16, 8, 1, -16 },
  { 636, 5, 20, 8, 1, -16 },
  { 649, 12, 14, 14, 1, -17 },
  { 670, 12, 9, 14, 1, -14 },
  { 684, 12, 14, 14, 1, -17 },
  { 705, 11, 20, 12, 0, -20 },
  { 733, 20, 22, 22, 1, -20 },
  { 788, 17, 20, 17, 0, -20 },
  { 831, 13, 20, 16, 2, -20 },
  { 864, 13, 20, 15, 1, -20 },
  { 897, 14, 20, 17, 2, -20 },
  { 932, 10, 20, 13, 2, -20 },
  { 957, 10, 20, 13, 2, -20 },
  { 982, 15, 20, 17, 1, -20 },
  { 1020, 14, 20, 18, 2, -20 },
  { 1055, 8, 20, 10, 1, -20 },
  { 1075, 8, 26, 8, -2, -20 },
  { 1101, 14, 20, 16, 2, -20 },
  { 1136, 10, 20, 13, 2, -20 },
  { 1161, 20, 20, 23, 2, -20 },
  { 1211, 16, 20, 19, 2, -20 },
  { 1251, 16, 20, 19, 1, -20 },
  { 1291, 12, 20, 15, 2, -20 },
  { 1321, 16, 25, 19, 1, -20 },
  { 1371, 14, 20, 16, 2, -20 },
  { 1406, 11, 20, 13, 1, -20 },
  { 1434, 13, 20, 14, 0, -20 },
  { 1467, 14, 20, 18, 2, -20 },
  { 1502, 16, 20, 16, 0, -20 },
  { 1542, 24, 20, 24, 0, -20 },
  { 1602, 16, 20, 16, 0, -20 },
  { 1642, 15, 20, 15, 0, -20 },
  { 1680, 12, 20, 14, 1, -20 },
  { 1710, 6, 25, 9, 2, -20 },
  { 1729, 12, 20, 12, 0, -20 },
  { 1759, 6, 25, 9, 1, -20 },
  { 1778, 15, 13, 15, 0, -20 },
  { 1803, 13, 3, 13, 0, 2 },
  { 1808, 8, 4, 10, 1, -21 },
  { 1812, 12, 16, 14, 1, -16 },
  { 1836, 12, 21, 15, 2, -21 },
  { 1868, 11, 16, 13, 1, -16 },
  { 1890, 13, 21, 15, 1, -21 },
  { 1925, 12, 16, 14, 1, -16 },
  { 1949, 10, 21, 9, 0, -21 },
  { 1976, 13, 23, 15, 1, -16 },
  { 2014, 12, 21, 16, 2, -21 },
  { 2046, 4, 22, 8, 2, -22 },
  { 2057, 7, 29, 8, -1, -22 },
  { 2083, 13, 21, 15, 2, -21 },
  { 2118, 4, 21, 8, 2, -21 },
  { 2129, 20, 16, 23, 2, -16 },
  { 2169, 12, 16, 16, 2, -16 },
  { 2193, 13, 16, 15, 1, -16 },
  { 2219, 12, 23, 15, 2, -16 },
  { 2254, 13, 23, 15, 1, -16 },
  { 2292, 9, 16, 11, 2, -16 },
  { 2310, 10, 16, 12, 1, -16 },
  { 2330, 10, 19, 10, 0, -19 },
  { 2354, 12, 15, 16, 2, -15 },
  { 2377, 14, 15, 14, 0, -15 },
  { 2404, 21, 15, 21, 0, -15 },
  { 2444, 14, 15, 14, 0, -15 },
  { 2471, 14, 22, 14, 0, -15 },
  { 2510, 10, 15, 12, 1, -15 },
  { 2529, 10, 25, 10, 0, -20 },
  { 2561, 3, 27, 13, 5, -21 },
  { 2572, 9, 25, 10, 1, -20 },
  { 2601, 12, 5, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_ExtraBold28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD28PT7B_H_
