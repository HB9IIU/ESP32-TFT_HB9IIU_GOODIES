#ifndef _NOTOSANS_CONDENSED_EXTRABOLD38PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xDF, 0x7D, 0xF0, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0xC0, 0xFC, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7D, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x03, 0xCF, 0x80, 0x7C, 0xF0, 0x07, 0x8F, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x79, 0xF0, 0x0F, 0x9E,
  0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xF8, 0x3F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xF9, 0x84, 0xF9, 0x80, 0xF9, 0x80, 0xFD, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFE,
  0x01, 0xFF, 0x01, 0xBF, 0x01, 0x9F, 0x81, 0x9F, 0xE1, 0xBE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x04, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xFC, 0x03,
  0xC0, 0x1F, 0xF8, 0x0F, 0x00, 0x7F, 0xE0, 0x78, 0x03, 0xE7, 0xC1, 0xE0,
  0x0F, 0x9F, 0x0F, 0x80, 0x3E, 0x7C, 0x3C, 0x00, 0xF1, 0xF1, 0xF0, 0x03,
  0xC7, 0xC7, 0x80, 0x0F, 0x9F, 0x3E, 0x00, 0x3E, 0x7C, 0xF0, 0xE0, 0xF9,
  0xF3, 0xCF, 0xE1, 0xFF, 0x9E, 0x7F, 0xC7, 0xFE, 0x79, 0xFF, 0x8F, 0xF3,
  0xEF, 0x9E, 0x1F, 0x8F, 0x3E, 0x78, 0x18, 0x7C, 0xF9, 0xF0, 0x01, 0xE3,
  0xC7, 0xC0, 0x0F, 0x8F, 0x1F, 0x00, 0x3C, 0x3C, 0x7C, 0x00, 0xF0, 0xF1,
  0xF0, 0x07, 0xC3, 0xE7, 0xC0, 0x1E, 0x0F, 0x9E, 0x00, 0xF8, 0x1F, 0xF8,
  0x03, 0xC0, 0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0x00, 0x78, 0x01, 0xF8, 0x07,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF0, 0x7E, 0x1F, 0xF0, 0xFE, 0x3F, 0xF8, 0xFC, 0x7F, 0xFC, 0xFC, 0x7E,
  0xFF, 0xFC, 0xFC, 0x7F, 0xF8, 0xFC, 0x3F, 0xF8, 0xFC, 0x1F, 0xF0, 0xFC,
  0x1F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xEF, 0xBE, 0xF9, 0xE0, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F,
  0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F,
  0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F,
  0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x04, 0x3C, 0x37, 0xDE, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x83, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xF7, 0xC3, 0xF3, 0xF0,
  0xF8, 0xF0, 0x18, 0x70, 0x04, 0x20, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x7D, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0xF9, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x00, 0x80, 0x03, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x1F, 0x3E, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xEF, 0x83, 0xF7, 0xE1, 0xF3,
  0xF1, 0xF9, 0xF8, 0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x9F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xCF, 0xCC, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00,
  0x80, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8,
  0xE0, 0xFC, 0x60, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x80, 0x0F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8,
  0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x3F,
  0xC0, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x07, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xDF, 0x81, 0xF7, 0xE0,
  0x79, 0xF8, 0x3E, 0x7E, 0x0F, 0x1F, 0x87, 0xC7, 0xE1, 0xE1, 0xF8, 0xF8,
  0x7E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0x7B, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0xC0, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0xC3, 0xFF, 0xE3, 0xFF, 0x31, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x3C, 0x1F, 0x7F, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xEF, 0x83,
  0xF7, 0xE1, 0xFB, 0xF1, 0xFD, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x07,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3,
  0xF3, 0xF0, 0xF9, 0xF0, 0x7C, 0xFC, 0x3E, 0x7E, 0x3F, 0x1F, 0xBF, 0x8F,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE,
  0x7E, 0x3F, 0x7E, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF8, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1,
  0xFB, 0xF0, 0x7D, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xE3, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xDF,
  0x83, 0x8F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0xFF,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x7B, 0xFF,
  0xFF, 0xFD, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0x7C, 0x3C, 0x7E, 0x7E, 0x7F, 0x7E, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0xF8, 0xF8, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x07, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x01, 0xFC, 0x00, 0xF8,
  0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x3F, 0xE1, 0xFF, 0xE7,
  0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xC8, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x03,
  0xF0, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1E, 0x01, 0x03, 0xC3,
  0xE1, 0xFF, 0x3E, 0x3C, 0x3F, 0xF1, 0xE7, 0xC7, 0xFF, 0x1E, 0x78, 0xF8,
  0xF1, 0xE7, 0x8F, 0x0F, 0x1E, 0x78, 0xF0, 0xF1, 0xF7, 0x9F, 0x0F, 0x1F,
  0xF9, 0xF0, 0xF1, 0xEF, 0x9F, 0x0F, 0x1E, 0xF9, 0xF0, 0xF1, 0xE7, 0x9F,
  0x1F, 0x1E, 0x78, 0xF1, 0xF3, 0xE7, 0x8F, 0xFF, 0xFC, 0x78, 0x7F, 0xBF,
  0x87, 0xC7, 0xF3, 0xF0, 0x3C, 0x0C, 0x0E, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0x9F,
  0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xE0, 0x3F, 0x1F,
  0xC0, 0x7E, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8,
  0x03, 0xF8, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xBF,
  0x3F, 0xDF, 0xFF, 0xCF, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFD, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xF0, 0x11, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x18, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF9, 0xF8, 0x7F, 0x3F, 0x07, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F,
  0xDF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x3F,
  0x7E, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x18, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0xE0, 0x33, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xF7,
  0xE0, 0x7E, 0xFE, 0x0F, 0xDF, 0xC1, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x8F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0xBF, 0xF7,
  0xFE, 0xFF, 0x9F, 0xE3, 0xF8, 0x00, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0,
  0x7F, 0x7E, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F, 0x3F, 0x87, 0xE7,
  0xE0, 0xFD, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x1F, 0x9F,
  0x83, 0xF3, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xF7, 0xFE, 0xF0, 0x7D, 0xFF, 0xBE, 0x1F, 0x7F, 0xEF,
  0x87, 0x9F, 0xFB, 0xE3, 0xE7, 0xFE, 0x7C, 0xF9, 0xFF, 0x9F, 0x3E, 0x7F,
  0xE7, 0xCF, 0x1F, 0xF9, 0xF7, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xF8,
  0x7F, 0xE3, 0xFE, 0x1F, 0xF8, 0x7F, 0x87, 0xFE, 0x1F, 0xE1, 0xFF, 0x87,
  0xF0, 0x7F, 0xE1, 0xFC, 0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xFF,
  0x83, 0xE0, 0x7C, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFE, 0xFC, 0x7F, 0xF7, 0xE3, 0xFF, 0x9F,
  0x9F, 0xFC, 0xFC, 0xFF, 0xE3, 0xF7, 0xFF, 0x1F, 0xBF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xF7, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFE, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFC, 0x1F, 0xCF, 0xC0, 0x7E, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x01, 0xF9,
  0xFC, 0x1F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF0, 0xFF, 0x80, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF9, 0xFC, 0x1F, 0xCF, 0xC0, 0x7E, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x01, 0xF9, 0xFC, 0x1F, 0xC7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xFC, 0xFC,
  0x3F, 0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0x9F, 0x83, 0xF3,
  0xF0, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1,
  0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xFB, 0xF0, 0x3F, 0x80, 0x00, 0xC0, 0x0F,
  0xFC, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x0C, 0x7E,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xEF, 0xC0, 0xFD, 0xFC, 0x3F, 0xBF, 0xFF, 0xF3, 0xFF, 0xFC,
  0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF8, 0xF8, 0x0F,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0x7C, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xFC,
  0xFC, 0x03, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF8,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0x7C,
  0x07, 0xE0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E,
  0x0F, 0xF0, 0x7E, 0x3E, 0x0F, 0xF0, 0x7E, 0x3E, 0x0F, 0xF0, 0x7C, 0x3F,
  0x1F, 0xF8, 0xFC, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0x1F, 0xF8, 0xFC, 0x1F,
  0x1E, 0x78, 0xF8, 0x1F, 0x3E, 0x78, 0xF8, 0x1F, 0x3E, 0x7D, 0xF8, 0x1F,
  0xBE, 0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F,
  0xBC, 0x3D, 0xF0, 0x0F, 0xFC, 0x3D, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0xFE,
  0x03, 0xF3, 0xF8, 0x3F, 0x8F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC1, 0xF8, 0xFC,
  0x0F, 0xCF, 0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x01, 0xF9, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x87,
  0xE0, 0xFC, 0x7F, 0x07, 0xF3, 0xF0, 0x1F, 0xBF, 0x80, 0xFE, 0xFE, 0x03,
  0xFB, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F,
  0x87, 0xE0, 0x7E, 0x3F, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x81, 0xF0,
  0xF8, 0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0xFC,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x0F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0xE1, 0xE3, 0xF0, 0x81, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x0F, 0xFF,
  0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFB, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x7F, 0xFE, 0x7F, 0xBF, 0xFF, 0xDF, 0xFF, 0xE7, 0xF9, 0xF1,
  0xF8, 0xF8, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0xFC, 0x7E, 0xFF, 0x3F,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF,
  0x3F, 0xCF, 0x8F, 0xC0, 0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE3,
  0xFF, 0xCF, 0xE0, 0x9F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x01, 0x7F, 0xFE,
  0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x0F, 0xCF, 0xC7, 0xFB, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0x87, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD,
  0xF8, 0x7F, 0x7F, 0xBF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xBF, 0x0F,
  0xC7, 0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xF3,
  0xF3, 0xF0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x02,
  0x7F, 0x07, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x03,
  0xF8, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0xF9, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x0F, 0xC7, 0xC7, 0xFB, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0x87, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x03, 0xF7, 0xE0, 0xFD,
  0xF8, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xBF, 0x0F,
  0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x60, 0x1F, 0x9F, 0xFF,
  0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x07, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0xFC, 0x7E, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xF8,
  0x7B, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x0F,
  0xC7, 0xE3, 0xF1, 0xF8, 0x38, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF,
  0xFF, 0xDF, 0xEF, 0xE7, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xDF, 0x83, 0xF3, 0xF0, 0xFE, 0x7E, 0x1F, 0x8F, 0xC7, 0xE1,
  0xF9, 0xFC, 0x3F, 0x3F, 0x07, 0xEF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFD, 0xFC, 0x3F, 0x1F, 0x87,
  0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x07, 0xEF,
  0xC0, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0xFC, 0x3F, 0x9F, 0x3F, 0xCF, 0xFB, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0x87, 0xE1, 0xFF,
  0xE0, 0xFC, 0x1F, 0xFC, 0x1F, 0x83, 0xFF, 0x83, 0xF0, 0x7F, 0xF0, 0x7E,
  0x0F, 0xFE, 0x0F, 0xC1, 0xFF, 0xC1, 0xF8, 0x3F, 0xF8, 0x3F, 0x07, 0xFF,
  0x07, 0xE0, 0xFF, 0xE0, 0xFC, 0x1F, 0xFC, 0x1F, 0x83, 0xFF, 0x83, 0xF0,
  0x7F, 0xF0, 0x7E, 0x0F, 0xFE, 0x0F, 0xC1, 0xFF, 0xC1, 0xF8, 0x3E, 0xF8,
  0xFC, 0x7C, 0xFF, 0x3E, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xF8, 0x07, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xBF, 0x9F, 0x87, 0xE7, 0xE0, 0xFD,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7C,
  0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x7E, 0x3F, 0x3F, 0x8F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xF8, 0xFC, 0x7C, 0xFF,
  0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xDF, 0xBF, 0xCF, 0xCF, 0xC7, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x0F, 0xC7, 0xC7, 0xFB, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF,
  0x87, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x03, 0xF7, 0xE0, 0xFD, 0xF8, 0x7F,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xBF, 0x0F, 0xCF, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0xFF, 0x9F, 0xFB,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xF7, 0xFF, 0x9F, 0xFE, 0xFC,
  0x7B, 0xF0, 0x4F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xF9, 0xFF, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFC, 0x7F, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFB, 0xE7,
  0xFD, 0xF1, 0xFC, 0xF8, 0xFC, 0x07, 0xEF, 0x80, 0xFD, 0xF8, 0x3F, 0x3F,
  0x07, 0xE7, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x1F,
  0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x1F, 0xC1, 0xFB, 0xE0, 0xFE,
  0x0F, 0x9F, 0x07, 0xF0, 0xFC, 0xFC, 0x7F, 0x87, 0xE7, 0xE3, 0xFE, 0x3F,
  0x1F, 0x1F, 0xF1, 0xF0, 0xF8, 0xF7, 0x8F, 0x87, 0xE7, 0xBC, 0xFC, 0x3F,
  0x7D, 0xE7, 0xE1, 0xFB, 0xEF, 0x3E, 0x07, 0xDE, 0x7D, 0xF0, 0x3E, 0xF1,
  0xEF, 0x81, 0xF7, 0x8F, 0xFC, 0x0F, 0xBC, 0x7F, 0xC0, 0x3D, 0xE3, 0xFE,
  0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x83, 0xF8, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xCF, 0xC3, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC1, 0xFB, 0xF0, 0x3F,
  0x7E, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFD,
  0xF8, 0x3F, 0x3F, 0x07, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x07, 0xEF, 0xE0,
  0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x3F, 0x3F, 0x07, 0xE3, 0xE0,
  0xFC, 0x7E, 0x1F, 0x0F, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xF3,
  0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x83, 0xF8, 0xFF,
  0x0F, 0xE0, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xF8, 0x3F, 0xC3, 0xFE, 0x3F,
  0x81, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFC, 0x00, 0x1C, 0x00,
  0xBF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x00,
  0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraBold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 27, 10, 2, -27 },
  { 22, 14, 10, 18, 2, -27 },
  { 40, 20, 27, 21, 1, -27 },
  { 108, 16, 31, 19, 2, -29 },
  { 170, 30, 28, 32, 1, -28 },
  { 275, 24, 27, 25, 1, -27 },
  { 356, 6, 10, 10, 2, -27 },
  { 364, 10, 34, 13, 2, -28 },
  { 407, 10, 34, 13, 1, -28 },
  { 450, 17, 17, 18, 1, -29 },
  { 487, 17, 19, 19, 1, -23 },
  { 528, 7, 10, 10, 1, -5 },
  { 537, 10, 5, 12, 1, -13 },
  { 544, 6, 6, 10, 2, -6 },
  { 549, 16, 27, 16, 0, -27 },
  { 603, 17, 28, 19, 1, -28 },
  { 663, 13, 27, 19, 2, -27 },
  { 707, 17, 28, 19, 1, -28 },
  { 767, 17, 28, 19, 1, -28 },
  { 827, 18, 27, 19, 1, -27 },
  { 888, 16, 27, 19, 2, -27 },
  { 942, 17, 27, 19, 1, -27 },
  { 1000, 17, 27, 19, 1, -27 },
  { 1058, 17, 27, 19, 1, -27 },
  { 1116, 17, 27, 19, 1, -27 },
  { 1174, 6, 21, 10, 2, -21 },
  { 1190, 8, 26, 10, 1, -21 },
  { 1216, 17, 19, 19, 1, -23 },
  { 1257, 17, 13, 19, 1, -20 },
  { 1285, 17, 19, 19, 1, -23 },
  { 1326, 15, 28, 16, 0, -28 },
  { 1379, 28, 30, 30, 1, -27 },
  { 1484, 23, 27, 23, 0, -27 },
  { 1562, 17, 27, 22, 3, -27 },
  { 1620, 18, 28, 21, 2, -28 },
  { 1683, 19, 27, 24, 3, -27 },
  { 1748, 13, 27, 18, 3, -27 },
  { 1792, 13, 27, 18, 3, -27 },
  { 1836, 19, 28, 24, 2, -28 },
  { 1903, 19, 27, 25, 3, -27 },
  { 1968, 12, 27, 14, 1, -27 },
  { 2009, 11, 35, 11, -2, -27 },
  { 2058, 19, 27, 22, 3, -27 },
  { 2123, 14, 27, 18, 3, -27 },
  { 2171, 26, 27, 32, 3, -27 },
  { 2259, 21, 27, 26, 3, -27 },
  { 2330, 21, 28, 25, 2, -28 },
  { 2404, 16, 27, 21, 3, -27 },
  { 2458, 21, 34, 25, 2, -28 },
  { 2548, 19, 27, 22, 3, -27 },
  { 2613, 16, 28, 18, 1, -28 },
  { 2669, 17, 27, 18, 1, -27 },
  { 2727, 19, 27, 24, 3, -27 },
  { 2792, 22, 27, 22, 0, -27 },
  { 2867, 32, 27, 32, 0, -27 },
  { 2975, 21, 27, 21, 0, -27 },
  { 3046, 21, 27, 21, 0, -27 },
  { 3117, 17, 27, 18, 1, -27 },
  { 3175, 9, 34, 12, 2, -28 },
  { 3214, 16, 27, 16, 0, -27 },
  { 3268, 9, 34, 12, 1, -28 },
  { 3307, 20, 17, 21, 0, -27 },
  { 3350, 17, 3, 17, 0, 3 },
  { 3357, 10, 6, 13, 2, -29 },
  { 3365, 17, 21, 20, 1, -21 },
  { 3410, 17, 29, 21, 2, -29 },
  { 3472, 15, 21, 17, 1, -21 },
  { 3512, 18, 29, 21, 1, -29 },
  { 3578, 17, 21, 19, 1, -21 },
  { 3623, 14, 29, 13, 0, -29 },
  { 3674, 18, 30, 21, 1, -21 },
  { 3742, 17, 29, 21, 2, -29 },
  { 3804, 6, 29, 10, 2, -29 },
  { 3826, 9, 38, 10, -1, -29 },
  { 3869, 19, 29, 21, 2, -29 },
  { 3938, 6, 29, 10, 2, -29 },
  { 3960, 27, 21, 32, 2, -21 },
  { 4031, 17, 21, 21, 2, -21 },
  { 4076, 18, 21, 21, 1, -21 },
  { 4124, 17, 30, 21, 2, -21 },
  { 4188, 18, 30, 21, 1, -21 },
  { 4256, 12, 21, 15, 2, -21 },
  { 4288, 14, 21, 16, 1, -21 },
  { 4325, 12, 25, 14, 1, -25 },
  { 4363, 17, 21, 21, 2, -21 },
  { 4408, 19, 21, 19, 0, -21 },
  { 4458, 29, 21, 29, 0, -21 },
  { 4535, 19, 21, 19, 0, -21 },
  { 4585, 19, 30, 19, 0, -21 },
  { 4657, 14, 21, 16, 1, -21 },
  { 4694, 12, 33, 14, 1, -27 },
  { 4744, 5, 38, 17, 6, -29 },
  { 4768, 13, 33, 14, 1, -27 },
  { 4822, 17, 7, 19, 1, -17 },
};

const GFXfont NotoSans_Condensed_ExtraBold38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD38PT7B_H_
