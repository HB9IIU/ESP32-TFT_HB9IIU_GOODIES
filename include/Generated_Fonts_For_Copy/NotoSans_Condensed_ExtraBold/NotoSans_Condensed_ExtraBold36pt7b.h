#ifndef _NOTOSANS_CONDENSED_EXTRABOLD36PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF,
  0xBE, 0x78, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xC0, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x87, 0x8F, 0x00, 0xF1, 0xC0, 0x1E, 0x78, 0x03,
  0xCF, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x0F,
  0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x9E, 0x00, 0x03, 0x00, 0x06, 0x00, 0x1F, 0x81, 0xFF, 0xE7,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7D, 0x84, 0xF3, 0x01, 0xF6, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x06, 0xFC, 0x0C, 0xFC, 0x19, 0xFC, 0x33, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFC, 0x7F, 0xE0, 0x1F, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x1F,
  0x00, 0x3C, 0x03, 0xF8, 0x07, 0x80, 0x7F, 0xC0, 0x78, 0x07, 0xFE, 0x0F,
  0x00, 0xF9, 0xE0, 0xF0, 0x0F, 0x1E, 0x1F, 0x00, 0xF1, 0xE1, 0xE0, 0x0F,
  0x1E, 0x3E, 0x00, 0xF1, 0xE3, 0xC0, 0x0F, 0x1E, 0x3C, 0x00, 0xF1, 0xE7,
  0x87, 0x0F, 0x9E, 0x79, 0xFC, 0x7F, 0xEF, 0x3F, 0xE7, 0xFC, 0xF3, 0xFE,
  0x3F, 0x9F, 0x7D, 0xF1, 0xF1, 0xE7, 0x8F, 0x00, 0x3E, 0x78, 0xF0, 0x03,
  0xC7, 0x8F, 0x00, 0x3C, 0x78, 0xF0, 0x07, 0x87, 0x8F, 0x00, 0x78, 0x78,
  0xF0, 0x0F, 0x07, 0x8F, 0x00, 0xF0, 0x3D, 0xF0, 0x1F, 0x03, 0xFE, 0x01,
  0xE0, 0x1F, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0xFC, 0xFF, 0xC7, 0xE7, 0xFF, 0x9F, 0x9F,
  0xFF, 0x7E, 0xFC, 0xFF, 0xF3, 0xF1, 0xFF, 0xCF, 0xC3, 0xFE, 0x3F, 0x0F,
  0xF8, 0xFC, 0x1F, 0xC3, 0xFD, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFD, 0xF8, 0x3F, 0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E,
  0x1F, 0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x83, 0xC2, 0xF3, 0xDE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3E,
  0xF8, 0x7E, 0x7C, 0x3C, 0x78, 0x0C, 0x30, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x3C,
  0xF9, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7B, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE,
  0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7E, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF,
  0x1F, 0xF3, 0xFF, 0x7F, 0xFF, 0xDF, 0xF9, 0xF7, 0x1F, 0x21, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xE0, 0x3F,
  0xF8, 0x7F, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x78, 0x7E, 0x30, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x30,
  0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0xF8, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0x7C,
  0x07, 0xBE, 0x07, 0x9F, 0x07, 0xCF, 0x83, 0xC7, 0xC3, 0xE3, 0xE1, 0xE1,
  0xF1, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF3, 0x03, 0xFF, 0xC7, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFF, 0x88, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x0F, 0xDF, 0x7F, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF0,
  0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE,
  0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0xF0, 0xFB, 0xFC,
  0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x3F, 0x7E, 0x3F, 0x7F, 0x7E, 0x3F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xF0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7E, 0x3E, 0x3F, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC,
  0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE,
  0xFC, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFE, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x43, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDE, 0x3C, 0xFD, 0xFB,
  0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7E,
  0xFD, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xF8, 0x00, 0x01, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x0F, 0xE1, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x7F, 0xFC, 0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xC3, 0xF8, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x03,
  0xC3, 0xE0, 0x00, 0xF8, 0xF0, 0xFF, 0x9E, 0x3C, 0x7F, 0xE7, 0x9E, 0x3F,
  0xF8, 0xF7, 0x8F, 0x1E, 0x3D, 0xE7, 0xC7, 0x8F, 0x79, 0xE1, 0xE3, 0xFC,
  0x78, 0x78, 0xFF, 0x1E, 0x1E, 0x3F, 0xC7, 0x87, 0x8F, 0xF1, 0xE1, 0xE3,
  0xDC, 0x78, 0xF9, 0xE7, 0x9F, 0x7F, 0x79, 0xE3, 0xFF, 0xFC, 0x78, 0x7E,
  0x7E, 0x1F, 0x0F, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x18, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xFC, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F,
  0xC0, 0xFF, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xBF, 0xFF,
  0xDF, 0xFF, 0xCF, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFD, 0xF8, 0x7F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x03, 0xFC, 0x07,
  0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x7F, 0x06, 0x7E, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x01, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF9, 0xF8, 0x7F, 0x3F, 0x07, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x80,
  0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F,
  0xEF, 0xC3, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x01, 0xFE, 0x01,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xE0, 0x67, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF1, 0xFF,
  0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7D, 0xF8, 0x1F, 0x7F, 0x07, 0xDF, 0xF7, 0xF3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xC0, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xEF, 0xFB, 0xFC, 0xFE,
  0x3E, 0x00, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x83, 0xFB, 0xE0, 0xFC, 0xF8,
  0x7E, 0x3E, 0x1F, 0x8F, 0x8F, 0xC3, 0xE7, 0xF0, 0xF9, 0xF8, 0x3E, 0xFC,
  0x0F, 0xBF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFD, 0xF8, 0x3E, 0x3F, 0x0F, 0x8F, 0xC3, 0xE1, 0xF8, 0xF8,
  0x7E, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0xFE, 0xF8, 0x1F, 0xBE, 0x07,
  0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x78, 0x7B,
  0xFF, 0xBE, 0x7D, 0xFF, 0xDF, 0x3E, 0xFF, 0xEF, 0x9E, 0x7F, 0xF3, 0xCF,
  0x3F, 0xF9, 0xFF, 0x9F, 0xFC, 0xFF, 0xCF, 0xFE, 0x3F, 0xC7, 0xFF, 0x1F,
  0xE3, 0xFF, 0x8F, 0xF1, 0xFF, 0xC7, 0xF0, 0xFF, 0xE1, 0xF8, 0x7F, 0xF0,
  0xFC, 0x3F, 0xF8, 0x7E, 0x1F, 0xFC, 0x3E, 0x0F, 0xC0, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xF7, 0xC3, 0xFF, 0x7E, 0x3F, 0xFB, 0xE3,
  0xFF, 0xBF, 0x3F, 0xFB, 0xF3, 0xFF, 0x9F, 0xBF, 0xF9, 0xFB, 0xFF, 0x8F,
  0xBF, 0xF8, 0xFD, 0xFF, 0x87, 0xDF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7E, 0x7F, 0x0F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xF0, 0xFE, 0x7E, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0,
  0x7E, 0x7F, 0x0F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7,
  0xE0, 0xFC, 0xFC, 0x1F, 0x1F, 0x83, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFC, 0xFC, 0x1F,
  0x9F, 0x83, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F,
  0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0xF8, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xC3, 0xBF, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xFE, 0x07,
  0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x3F, 0x7E,
  0x0F, 0xDF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFF,
  0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xFC, 0x07, 0xE7,
  0xE0, 0x3E, 0x3F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x81, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x07,
  0xC0, 0x7F, 0xF0, 0x1F, 0x01, 0xFF, 0xC0, 0xFC, 0x0F, 0xDF, 0x03, 0xF0,
  0x3F, 0x7C, 0x0F, 0xC0, 0xFD, 0xF0, 0x3F, 0x83, 0xE7, 0xE1, 0xFE, 0x0F,
  0x9F, 0x87, 0xF8, 0x7E, 0x3E, 0x1F, 0xE1, 0xF8, 0xF8, 0x7F, 0xC7, 0xC3,
  0xE1, 0xFF, 0x1F, 0x0F, 0xCF, 0xBC, 0x7C, 0x3F, 0x3E, 0xF3, 0xF0, 0x7C,
  0xF3, 0xCF, 0xC1, 0xF3, 0xCF, 0xBE, 0x07, 0xCF, 0x3E, 0xF8, 0x1F, 0x7C,
  0x7B, 0xE0, 0x3F, 0xF1, 0xEF, 0x80, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC,
  0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00,
  0xFE, 0x07, 0xE7, 0xE0, 0x7E, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F,
  0x81, 0xF9, 0xF8, 0x1F, 0x9F, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01,
  0xF9, 0xF8, 0x1F, 0x9F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E,
  0x7E, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xF7, 0xC0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF9,
  0xF0, 0x0F, 0xBF, 0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0xBE, 0x01, 0xE3, 0xC0, 0x7C,
  0x7C, 0x0F, 0x87, 0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x0F, 0x01, 0xF3, 0xE0,
  0x1E, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE,
  0x3F, 0xFE, 0x1C, 0x7E, 0x10, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x1F, 0xFF,
  0x3F, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xDF, 0x3F, 0x9F, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0xF8, 0xFB, 0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFB, 0xFC, 0xF9, 0xF8, 0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x7F,
  0xF9, 0xF8, 0x27, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x5F, 0xC7, 0x3F, 0xFC, 0xFF, 0xF1,
  0xFF, 0xC1, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x1F, 0x3F, 0x1F, 0xDF, 0x9F, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE3, 0xFB, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xF7, 0xC1, 0xFB,
  0xF0, 0xFD, 0xF8, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xF7, 0xC3, 0xF3,
  0xE0, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C,
  0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x06, 0x3F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x80, 0x3F, 0xC3, 0xFE, 0x3F, 0xF1,
  0xFF, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0xF3, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0x0F, 0x8F, 0x8F, 0xE7, 0xCF, 0xFB, 0xE7, 0xFF, 0xF7,
  0xF7, 0xFB, 0xF1, 0xFD, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFB, 0xE0, 0xFD, 0xF8, 0x7E, 0xFE,
  0x7F, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xF7, 0xE1, 0xFB, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0xE0, 0x7E, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF,
  0x07, 0xFF, 0x00, 0x38, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFD, 0xF8, 0xFB, 0xFC, 0xFB,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x33,
  0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0F, 0x87, 0xE3,
  0xF1, 0xF8, 0x78, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E, 0xFF, 0x7F, 0xBF, 0x9F,
  0x87, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0xFC, 0x3F, 0x3F, 0x0F,
  0xCF, 0xC7, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x7E, 0x0F, 0xFF, 0x03,
  0xEF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFB, 0xE0, 0xFC,
  0xFC, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x07,
  0xEF, 0xC1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF1, 0xF8, 0x7E, 0x3E, 0xFF, 0x3F, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0,
  0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF,
  0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0,
  0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3,
  0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xF1, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x07, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xF3, 0xF3, 0xF0, 0xF9, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFB, 0xE0, 0xFD, 0xF8, 0x7C, 0xFC, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0xF8, 0xF8, 0xFB, 0xFC, 0xFB, 0xFE, 0xFF, 0xFE,
  0xFF, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFB, 0xFC, 0xFD, 0xF8, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x0F, 0x8F, 0x8F, 0xE7, 0xCF, 0xFB, 0xE7, 0xFF, 0xF7, 0xF7,
  0xFB, 0xF1, 0xFD, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFB, 0xE0, 0xFD, 0xF8, 0x7E, 0xFE, 0x7F,
  0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xF7, 0xE1, 0xF3, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0xF0, 0xFF, 0x9F, 0xFB, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x1F, 0xE1,
  0xFF, 0xDF, 0xFD, 0xFF, 0xEF, 0xC7, 0x7C, 0x03, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0x80, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xFF, 0x3F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3F, 0x31, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFE, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF,
  0x1F, 0x8F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xF9, 0xF8, 0x7E, 0x7E,
  0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0xFC, 0x1F, 0x3E, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFC,
  0x1F, 0x83, 0xEF, 0x87, 0xF0, 0xFD, 0xF0, 0xFE, 0x1F, 0xBE, 0x1F, 0xC3,
  0xE7, 0xE3, 0xFC, 0x7C, 0xFC, 0x77, 0x8F, 0x8F, 0x9E, 0xF3, 0xF1, 0xF3,
  0xDE, 0x7C, 0x3E, 0x7B, 0xCF, 0x87, 0xEF, 0x39, 0xF0, 0x7D, 0xE7, 0xBE,
  0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC,
  0x7F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x1F, 0x9F, 0x87, 0xE3,
  0xE3, 0xF0, 0xFC, 0xFC, 0x1F, 0x3E, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0xF8, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE1, 0xFB, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xF9, 0xF8,
  0x3E, 0x7E, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0xFC, 0x1F, 0x3F,
  0x07, 0xCF, 0x81, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x3F, 0x07, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x81, 0xF8, 0xFF, 0x8F, 0xE0, 0xFE, 0x0F, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0x7F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x1F, 0xC1, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xF0,
  0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0x00, 0x1E, 0x01, 0x7F, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0x80, 0xFE, 0x80, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 13, 10, 17, 2, -26 },
  { 38, 19, 26, 20, 1, -26 },
  { 100, 15, 29, 18, 2, -27 },
  { 155, 28, 26, 30, 1, -26 },
  { 246, 22, 26, 23, 1, -26 },
  { 318, 5, 10, 9, 2, -26 },
  { 325, 9, 32, 12, 2, -26 },
  { 361, 9, 32, 12, 1, -26 },
  { 397, 16, 15, 17, 1, -27 },
  { 427, 16, 17, 18, 1, -21 },
  { 461, 7, 10, 10, 1, -5 },
  { 470, 9, 5, 11, 1, -12 },
  { 476, 6, 6, 10, 2, -6 },
  { 481, 15, 26, 15, 0, -26 },
  { 530, 16, 26, 18, 1, -26 },
  { 582, 12, 26, 18, 2, -26 },
  { 621, 16, 26, 18, 1, -26 },
  { 673, 16, 26, 18, 1, -26 },
  { 725, 17, 26, 18, 1, -26 },
  { 781, 15, 26, 18, 2, -26 },
  { 830, 16, 26, 18, 1, -26 },
  { 882, 16, 26, 18, 1, -26 },
  { 934, 16, 26, 18, 1, -26 },
  { 986, 16, 26, 18, 1, -26 },
  { 1038, 6, 20, 10, 2, -20 },
  { 1053, 7, 25, 10, 1, -20 },
  { 1075, 16, 18, 18, 1, -22 },
  { 1111, 16, 12, 18, 1, -19 },
  { 1135, 16, 18, 18, 1, -22 },
  { 1171, 14, 26, 15, 0, -26 },
  { 1217, 26, 29, 28, 1, -26 },
  { 1312, 21, 26, 21, 0, -26 },
  { 1381, 17, 26, 21, 2, -26 },
  { 1437, 16, 26, 19, 2, -26 },
  { 1489, 19, 26, 22, 2, -26 },
  { 1551, 12, 26, 17, 3, -26 },
  { 1590, 12, 26, 17, 3, -26 },
  { 1629, 18, 26, 22, 2, -26 },
  { 1688, 18, 26, 23, 3, -26 },
  { 1747, 11, 26, 13, 1, -26 },
  { 1783, 10, 34, 11, -2, -26 },
  { 1826, 18, 26, 21, 3, -26 },
  { 1885, 14, 26, 17, 2, -26 },
  { 1931, 25, 26, 30, 3, -26 },
  { 2013, 20, 26, 25, 3, -26 },
  { 2078, 20, 26, 24, 2, -26 },
  { 2143, 16, 26, 19, 2, -26 },
  { 2195, 20, 32, 24, 2, -26 },
  { 2275, 19, 26, 20, 2, -26 },
  { 2337, 15, 26, 17, 1, -26 },
  { 2386, 16, 26, 17, 1, -26 },
  { 2438, 18, 26, 23, 2, -26 },
  { 2497, 21, 26, 21, 0, -26 },
  { 2566, 30, 26, 30, 0, -26 },
  { 2664, 20, 26, 20, 0, -26 },
  { 2729, 20, 26, 20, 0, -26 },
  { 2794, 16, 26, 17, 1, -26 },
  { 2846, 9, 32, 11, 2, -26 },
  { 2882, 15, 26, 15, 0, -26 },
  { 2931, 8, 32, 11, 1, -26 },
  { 2963, 19, 17, 19, 0, -26 },
  { 3004, 16, 3, 16, 0, 3 },
  { 3010, 10, 6, 12, 1, -28 },
  { 3018, 16, 20, 19, 1, -20 },
  { 3058, 16, 27, 20, 2, -27 },
  { 3112, 14, 20, 16, 1, -20 },
  { 3147, 17, 27, 20, 1, -27 },
  { 3205, 16, 20, 18, 1, -20 },
  { 3245, 13, 28, 12, 0, -28 },
  { 3291, 17, 29, 20, 1, -20 },
  { 3353, 16, 27, 20, 2, -27 },
  { 3407, 6, 28, 10, 2, -28 },
  { 3428, 9, 37, 10, -1, -28 },
  { 3470, 18, 27, 20, 2, -27 },
  { 3531, 6, 27, 10, 2, -27 },
  { 3552, 26, 20, 30, 2, -20 },
  { 3617, 16, 20, 20, 2, -20 },
  { 3657, 17, 20, 19, 1, -20 },
  { 3700, 16, 29, 20, 2, -20 },
  { 3758, 17, 29, 20, 1, -20 },
  { 3820, 12, 20, 14, 2, -20 },
  { 3850, 13, 20, 15, 1, -20 },
  { 3883, 13, 24, 13, 0, -24 },
  { 3922, 16, 20, 20, 2, -20 },
  { 3962, 18, 20, 18, 0, -20 },
  { 4007, 27, 20, 27, 0, -20 },
  { 4075, 18, 20, 18, 0, -20 },
  { 4120, 18, 29, 18, 0, -20 },
  { 4186, 13, 20, 15, 1, -20 },
  { 4219, 12, 32, 13, 0, -26 },
  { 4267, 5, 36, 17, 6, -28 },
  { 4290, 12, 32, 13, 1, -26 },
  { 4338, 16, 7, 18, 1, -16 },
};

const GFXfont NotoSans_Condensed_ExtraBold36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD36PT7B_H_
