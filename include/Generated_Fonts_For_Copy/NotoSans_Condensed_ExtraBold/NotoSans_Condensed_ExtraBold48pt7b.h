#ifndef _NOTOSANS_CONDENSED_EXTRABOLD48PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0x0F, 0xE7, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0x3F, 0x06, 0x00, 0xFF, 0x1F, 0xFF, 0xC7, 0xF7, 0xF1, 0xFD,
  0xFC, 0x7F, 0x7E, 0x1F, 0xDF, 0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F, 0x7E,
  0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x00, 0xFC, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80,
  0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFC, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3,
  0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xE7, 0x1C, 0xFE, 0x70, 0x4F, 0xE7,
  0x00, 0xFE, 0x70, 0x0F, 0xE7, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0x7F, 0x00, 0x73, 0xF0, 0x07, 0x3F,
  0xC0, 0x73, 0xFF, 0x07, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x0F,
  0xFF, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x03, 0xF0, 0x01, 0xF9, 0xF8, 0x0F,
  0x80, 0x07, 0xC7, 0xE0, 0x7E, 0x00, 0x1F, 0x1F, 0x81, 0xF0, 0x00, 0xFC,
  0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0xF8,
  0x00, 0x3F, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x3E, 0x1F, 0x00, 0x03, 0xF0,
  0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xE3, 0xE1, 0xF8, 0x1F, 0x1F, 0x9F, 0x8F,
  0xF8, 0x7E, 0x7E, 0x7C, 0x7F, 0xF0, 0xFF, 0xF3, 0xF3, 0xFF, 0xC3, 0xFF,
  0xCF, 0xCF, 0xFF, 0x87, 0xFE, 0x3E, 0x7E, 0x7E, 0x0F, 0xF1, 0xF9, 0xF8,
  0xFC, 0x0F, 0x07, 0xC7, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x8F, 0xC0, 0x00,
  0xF8, 0x7E, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0xFC, 0x00, 0x1F, 0x07, 0xE3,
  0xF0, 0x00, 0xFC, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0x7E, 0x3F, 0x00, 0x0F,
  0x81, 0xF8, 0xFC, 0x00, 0x7E, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0x0F, 0xFF,
  0x80, 0x0F, 0xC0, 0x3F, 0xFE, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x01, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x07, 0xF8,
  0x3F, 0xFC, 0x1F, 0xE1, 0xFF, 0xF0, 0x7F, 0x8F, 0xFF, 0xE1, 0xFC, 0x7F,
  0xFF, 0xCF, 0xF1, 0xFE, 0xFF, 0xBF, 0xC7, 0xF1, 0xFF, 0xFE, 0x3F, 0xC3,
  0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0xC3, 0xFC, 0x0F, 0xFF, 0x0F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0x3F, 0xE0, 0x7F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x01, 0xF8, 0x1F, 0x81,
  0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8,
  0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x20, 0x7C, 0x09, 0xC3, 0xE1, 0xCF, 0xDF,
  0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFB, 0xF0, 0x1F, 0xDF,
  0xC1, 0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x1E, 0x0F, 0x00, 0x30, 0x70, 0x00,
  0x82, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xC3, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF,
  0xFD, 0xFC, 0xFE, 0x1C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xF1, 0xFC, 0x7F, 0x0F, 0xF7, 0xF8, 0x3F, 0xBF,
  0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE,
  0xFE, 0x07, 0xF7, 0xF8, 0x3F, 0xBF, 0xC1, 0xFC, 0xFE, 0x1F, 0xE7, 0xF8,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xDF, 0xE7, 0xCF, 0xF1, 0xC7, 0xF8, 0x43, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC7, 0xC1, 0xFE, 0x1C, 0x07, 0xF8, 0x40, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0x81, 0xFF, 0x20, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xF3,
  0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC1, 0xF8, 0x3F,
  0x83, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x18, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0,
  0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0xF3, 0x87, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x80, 0x7F, 0x3F, 0xC3, 0xFB, 0xFF,
  0x1F, 0xBF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFE,
  0x0F, 0xEF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xE7, 0xF8,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x9F, 0xE0,
  0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFE,
  0x3F, 0xCF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFF, 0x3F, 0xE7, 0xF8, 0x7F, 0x9F, 0xC0, 0xFE, 0x7F, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x7F, 0x03, 0xFD, 0xFF,
  0x1F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F,
  0xE1, 0xFE, 0x7F, 0x07, 0xF9, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF,
  0x7F, 0x87, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F,
  0xFD, 0xF8, 0x3F, 0xE7, 0xE0, 0x7F, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x00, 0x1C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD,
  0xFC, 0xFE, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC7, 0xF3, 0xFB, 0xFF, 0xFF, 0xFF, 0xBF, 0x8F, 0xC1,
  0x00, 0x0E, 0x0F, 0xE3, 0xF8, 0xFF, 0x7F, 0xCF, 0xF3, 0xF8, 0x7E, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC,
  0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x78,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xC1,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF9,
  0xC0, 0xFF, 0x20, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x0F,
  0xC0, 0x7F, 0x07, 0xE3, 0xF0, 0x7F, 0xF9, 0xF8, 0xF8, 0x3F, 0xFE, 0x3E,
  0x7E, 0x1F, 0xFF, 0x8F, 0x9F, 0x0F, 0xF7, 0xE3, 0xF7, 0xC3, 0xF0, 0xF8,
  0x7F, 0xF1, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0x87, 0xFE, 0x1F, 0x07,
  0xE1, 0xFF, 0x87, 0xC1, 0xF8, 0x7F, 0xE3, 0xF0, 0x7E, 0x1F, 0xF8, 0xFC,
  0x1F, 0x87, 0xFE, 0x3F, 0x07, 0xE1, 0xFF, 0x87, 0xC1, 0xF8, 0xFB, 0xE1,
  0xF0, 0x7E, 0x3E, 0xF8, 0x7E, 0x3F, 0x9F, 0xBF, 0x1F, 0xFF, 0xFF, 0xCF,
  0xC3, 0xFF, 0xFF, 0xF1, 0xF0, 0x7F, 0xCF, 0xF8, 0x7E, 0x0F, 0xE1, 0xFC,
  0x1F, 0x80, 0x40, 0x18, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x20, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xF8,
  0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x3F,
  0xC7, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xCF,
  0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xC1, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03,
  0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x7F,
  0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xF8, 0x3F, 0xEF, 0xF0, 0x3F, 0xDF,
  0xE0, 0x3F, 0xBF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xF8, 0x1C,
  0x3F, 0xE0, 0x08, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x43, 0xFF, 0x03,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE3, 0xFC, 0x3F, 0xF9, 0xFE, 0x07, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80,
  0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7,
  0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0x7F, 0x81, 0xFF, 0x3F, 0xC1, 0xFF, 0x9F, 0xE7, 0xFF, 0x8F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xF0, 0x1C, 0x3F, 0xE0, 0x02, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFD, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x80,
  0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xF0, 0x0F, 0xE7, 0xFC, 0x07, 0xF3, 0xFF,
  0x03, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xC1, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x01, 0xFF, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3,
  0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xBF,
  0xC0, 0x7F, 0x9F, 0xE0, 0x7F, 0xCF, 0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xF0,
  0x3F, 0xCF, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFC,
  0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x8F, 0xF0, 0x3F, 0xC7,
  0xF8, 0x1F, 0xF3, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFE, 0xFF, 0x00, 0xFF,
  0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D, 0xFF, 0xFB, 0xF0, 0x3F, 0x7F,
  0xFE, 0xFC, 0x0F, 0xDF, 0xFF, 0xBF, 0x03, 0xF7, 0xFF, 0xE7, 0xE1, 0xF9,
  0xFF, 0xF9, 0xF8, 0x7E, 0x7F, 0xFE, 0x7E, 0x1F, 0x9F, 0xFF, 0x9F, 0x87,
  0xC7, 0xFF, 0xE3, 0xF3, 0xF1, 0xFF, 0xF8, 0xFC, 0xFC, 0x7F, 0xFE, 0x3F,
  0x3F, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xF8, 0x7F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF8, 0x1F,
  0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0,
  0x7F, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x07, 0xF0, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0x7F, 0x07, 0xFF, 0xEF, 0xE0, 0xFF, 0xFD, 0xFE, 0x1F, 0xFF, 0x9F, 0xC3,
  0xFF, 0xF3, 0xFC, 0x7F, 0xFE, 0x3F, 0x8F, 0xFF, 0xC7, 0xF9, 0xFF, 0xF8,
  0x7F, 0x3F, 0xFF, 0x0F, 0xF7, 0xFF, 0xE0, 0xFE, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F,
  0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE,
  0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xFC, 0x03,
  0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xEF,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xE7, 0xF8,
  0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x3F,
  0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x03, 0xFC,
  0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xFC,
  0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFC, 0x1E, 0xFF, 0x00,
  0x9F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x7F, 0x00,
  0x1F, 0xE7, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xFC,
  0x3F, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x81, 0xFC,
  0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xFB, 0xF8, 0x00,
  0x1F, 0xBF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x80, 0x3F,
  0xBF, 0xC0, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xE0, 0x1F, 0xE7, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xFE,
  0x03, 0xF8, 0x7F, 0x03, 0xFF, 0x01, 0xFC, 0x3F, 0x81, 0xFF, 0x81, 0xFE,
  0x1F, 0xC0, 0xFF, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x7C, 0x1F, 0xC0, 0xFE, 0x1F, 0xBE,
  0x1F, 0xE0, 0x7F, 0x0F, 0xDF, 0x8F, 0xE0, 0x3F, 0x87, 0xCF, 0xC7, 0xF0,
  0x1F, 0xC7, 0xE7, 0xE3, 0xF8, 0x07, 0xF3, 0xF3, 0xF1, 0xFC, 0x03, 0xF9,
  0xF9, 0xF9, 0xFE, 0x01, 0xFC, 0xFC, 0x7E, 0xFE, 0x00, 0xFE, 0x7E, 0x3F,
  0x7F, 0x00, 0x7F, 0x7E, 0x1F, 0xBF, 0x80, 0x1F, 0xBF, 0x0F, 0xDF, 0xC0,
  0x0F, 0xFF, 0x87, 0xEF, 0xE0, 0x07, 0xFF, 0xC1, 0xF7, 0xE0, 0x03, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F,
  0xCF, 0xF0, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x9F, 0xE0,
  0x07, 0xF3, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0x7F,
  0x80, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0xDF, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x1F, 0xE7, 0xF8,
  0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x07,
  0xE7, 0xE0, 0x0F, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F,
  0x81, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x38, 0x1F, 0xE1, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x07, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC7, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFD, 0xF8, 0xFF, 0xCF, 0xC3, 0xF8, 0x3E, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x78, 0x0F, 0xE7, 0xF8, 0x3F, 0xBF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xE3, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xEF,
  0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F,
  0xBF, 0xC0, 0xFE, 0xFF, 0x07, 0xFB, 0xFE, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xCF, 0xFC, 0x3F, 0x1F,
  0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFC, 0x79, 0xFE, 0x02, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0x7F, 0x81,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0,
  0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0x0F, 0xF0, 0xFF, 0x3F, 0xC7, 0xFE, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xF7, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFD, 0xFE, 0x1F,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xF7, 0xF1,
  0xFF, 0x9F, 0xC3, 0xFC, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFE, 0x1F, 0xCF,
  0xE0, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03,
  0x3F, 0xE0, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0x88, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9,
  0xFF, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xC7, 0xF1, 0xFF, 0x9F, 0xCF, 0xFF, 0x7F, 0x3F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFC, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0x87, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xEF, 0xF0, 0xFF,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE4, 0x00, 0x3F,
  0x9C, 0x01, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0xF8, 0x3F, 0x9F, 0xF1, 0xFD, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xF0, 0x7D, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0x08, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC1,
  0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x3F, 0xC1, 0xFC, 0xFF,
  0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFE, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F,
  0x83, 0xFC, 0x7F, 0x03, 0xFC, 0xFE, 0x07, 0xF9, 0xFC, 0x07, 0xFB, 0xF8,
  0x0F, 0xF7, 0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x3F, 0x1F, 0xF0, 0xFF, 0x8F, 0xCF, 0xFE,
  0x7F, 0xF3, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF,
  0x07, 0xF8, 0x1F, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF,
  0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8,
  0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F,
  0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF,
  0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0x07, 0xE3,
  0xFE, 0x3F, 0x3F, 0xF9, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7,
  0xF8, 0x7F, 0x9F, 0xC0, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xDF,
  0xC0, 0xFE, 0x7F, 0x87, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0x03, 0xF1, 0xFE, 0x0F, 0xCF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xF8, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF,
  0xF0, 0x3F, 0xBF, 0xC1, 0xFE, 0xFF, 0x87, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFE, 0xFF, 0xE3, 0xFB, 0xFF, 0x0F, 0xE3, 0xF8,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0xC7, 0xF1, 0xFF, 0x9F, 0xCF, 0xFF, 0x7F, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFC, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0x87, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xEF, 0xF0, 0xFF, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xF3, 0xF8, 0x39, 0xFC, 0x04, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFE, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x03, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0x3F, 0xF9, 0xF8, 0xFF, 0x0F, 0xC0,
  0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFE,
  0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xFC,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE7, 0xF0,
  0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF7, 0xF0,
  0x3F, 0xE0, 0x7F, 0x7F, 0x03, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0xE0, 0xFE,
  0x7F, 0x87, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0xE0, 0xFE, 0x3F, 0x87, 0xFF,
  0x1F, 0xC3, 0xF8, 0x7F, 0xF1, 0xFC, 0x3F, 0x8F, 0xDF, 0x1F, 0xC1, 0xFC,
  0xF9, 0xF1, 0xFC, 0x1F, 0xCF, 0x9F, 0x1F, 0x81, 0xFC, 0xF9, 0xFB, 0xF8,
  0x1F, 0xCF, 0x9F, 0xBF, 0x80, 0xFD, 0xF8, 0xFB, 0xF8, 0x0F, 0xDF, 0x8F,
  0xBF, 0x80, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F, 0xFF, 0x0F, 0xBF, 0x00, 0xFF,
  0xF0, 0xFB, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF1,
  0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0x81, 0xFC, 0xFE, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0xC0, 0x7F, 0x3F,
  0x81, 0xFE, 0x7F, 0x83, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x3F, 0xC1, 0xFE,
  0x7F, 0x81, 0xFF, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE,
  0x7F, 0x80, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC,
  0x3F, 0xC1, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xF0,
  0x07, 0xF7, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x02, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x87, 0xFF,
  0x0F, 0xFC, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xC1, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0xC0,
  0x05, 0xFF, 0xC0, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xA0, 0x03, 0xFC,
};

const GFXglyph NotoSans_Condensed_ExtraBold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 35, 13, 2, -34 },
  { 41, 18, 12, 23, 2, -34 },
  { 68, 25, 34, 27, 1, -34 },
  { 175, 20, 39, 24, 2, -36 },
  { 273, 38, 35, 40, 1, -35 },
  { 440, 30, 35, 31, 1, -35 },
  { 572, 8, 12, 12, 2, -34 },
  { 584, 13, 43, 16, 2, -35 },
  { 654, 13, 43, 16, 1, -35 },
  { 724, 21, 22, 23, 1, -37 },
  { 782, 21, 24, 24, 2, -29 },
  { 845, 10, 12, 13, 1, -6 },
  { 860, 13, 6, 15, 1, -16 },
  { 870, 9, 9, 13, 2, -8 },
  { 881, 20, 35, 20, 0, -35 },
  { 969, 21, 35, 24, 2, -35 },
  { 1061, 17, 34, 24, 2, -34 },
  { 1134, 21, 35, 24, 1, -35 },
  { 1226, 20, 35, 24, 2, -35 },
  { 1314, 23, 34, 24, 1, -34 },
  { 1412, 20, 34, 24, 2, -34 },
  { 1497, 21, 35, 24, 2, -35 },
  { 1589, 22, 34, 24, 1, -34 },
  { 1683, 22, 35, 24, 1, -35 },
  { 1780, 22, 35, 24, 1, -35 },
  { 1877, 9, 28, 13, 2, -27 },
  { 1909, 10, 33, 13, 1, -27 },
  { 1951, 21, 24, 24, 2, -29 },
  { 2014, 21, 16, 24, 2, -25 },
  { 2056, 21, 24, 24, 2, -29 },
  { 2119, 19, 36, 20, 0, -35 },
  { 2205, 34, 39, 38, 2, -35 },
  { 2371, 29, 34, 29, 0, -34 },
  { 2495, 23, 34, 28, 3, -34 },
  { 2593, 23, 35, 26, 2, -35 },
  { 2694, 25, 34, 30, 3, -34 },
  { 2801, 17, 34, 23, 3, -34 },
  { 2874, 17, 34, 22, 3, -34 },
  { 2947, 25, 35, 30, 2, -35 },
  { 3057, 25, 34, 31, 3, -34 },
  { 3164, 15, 34, 17, 1, -34 },
  { 3228, 14, 44, 14, -3, -34 },
  { 3305, 25, 34, 28, 3, -34 },
  { 3412, 18, 34, 22, 3, -34 },
  { 3489, 34, 34, 40, 3, -34 },
  { 3634, 27, 34, 33, 3, -34 },
  { 3749, 28, 35, 32, 2, -35 },
  { 3872, 21, 34, 26, 3, -34 },
  { 3962, 28, 43, 32, 2, -35 },
  { 4113, 24, 34, 27, 3, -34 },
  { 4215, 19, 35, 23, 2, -35 },
  { 4299, 21, 34, 23, 1, -34 },
  { 4389, 24, 34, 30, 3, -34 },
  { 4491, 28, 34, 28, 0, -34 },
  { 4610, 41, 34, 40, 0, -34 },
  { 4785, 27, 34, 27, 0, -34 },
  { 4900, 26, 34, 26, 0, -34 },
  { 5011, 21, 34, 23, 1, -34 },
  { 5101, 11, 43, 15, 3, -35 },
  { 5161, 20, 35, 20, 0, -35 },
  { 5249, 11, 43, 15, 1, -35 },
  { 5309, 24, 22, 26, 1, -34 },
  { 5375, 22, 4, 22, 0, 4 },
  { 5386, 13, 8, 17, 2, -37 },
  { 5399, 21, 27, 25, 1, -27 },
  { 5470, 22, 36, 26, 3, -36 },
  { 5569, 18, 27, 22, 2, -27 },
  { 5630, 22, 36, 26, 2, -36 },
  { 5729, 21, 27, 24, 2, -27 },
  { 5800, 17, 37, 16, 1, -37 },
  { 5879, 22, 39, 26, 2, -27 },
  { 5987, 21, 36, 27, 3, -36 },
  { 6082, 7, 37, 13, 3, -37 },
  { 6115, 12, 49, 13, -2, -37 },
  { 6189, 23, 36, 26, 3, -36 },
  { 6293, 7, 36, 13, 3, -36 },
  { 6325, 34, 27, 40, 3, -27 },
  { 6440, 21, 27, 27, 3, -27 },
  { 6511, 22, 27, 26, 2, -27 },
  { 6586, 22, 39, 26, 3, -27 },
  { 6694, 22, 39, 26, 2, -27 },
  { 6802, 15, 27, 19, 3, -27 },
  { 6853, 17, 27, 20, 2, -27 },
  { 6911, 16, 32, 18, 1, -32 },
  { 6975, 21, 26, 27, 3, -26 },
  { 7044, 24, 26, 24, 0, -26 },
  { 7122, 36, 26, 36, 0, -26 },
  { 7239, 23, 26, 24, 0, -26 },
  { 7314, 24, 38, 24, 0, -26 },
  { 7428, 18, 26, 20, 1, -26 },
  { 7487, 15, 43, 18, 1, -35 },
  { 7568, 6, 48, 22, 8, -37 },
  { 7604, 16, 43, 18, 1, -35 },
  { 7690, 22, 8, 24, 1, -21 },
};

const GFXfont NotoSans_Condensed_ExtraBold48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD48PT7B_H_
