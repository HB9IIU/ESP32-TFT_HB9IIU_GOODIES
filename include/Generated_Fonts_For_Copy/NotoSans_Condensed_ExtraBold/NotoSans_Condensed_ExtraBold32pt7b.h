#ifndef _NOTOSANS_CONDENSED_EXTRABOLD32PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3D, 0xFF, 0xFF, 0xC0, 0xF9, 0xFF, 0x1F, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF,
  0x1E, 0xF1, 0xEF, 0x1E, 0x07, 0x9C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0,
  0x39, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0xFE, 0x0F, 0xFF, 0x7F, 0xF9, 0xFF,
  0xEF, 0xB1, 0xBE, 0xC0, 0xFB, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xDF, 0x03, 0x3E, 0x0C, 0xFE, 0x37, 0xFF,
  0xFE, 0xFF, 0xF9, 0xFF, 0xC0, 0xF8, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x3E, 0x01, 0xE0, 0x3F, 0x80, 0xF0, 0x1F, 0xE0, 0x70, 0x1E, 0x70, 0x78,
  0x0F, 0x3C, 0x38, 0x07, 0x9E, 0x3C, 0x03, 0xCF, 0x1C, 0x01, 0xE7, 0x9E,
  0x00, 0xF3, 0xCF, 0x00, 0x79, 0xEF, 0x1E, 0x3C, 0xE7, 0xBF, 0x8F, 0xF3,
  0x9F, 0xE7, 0xF3, 0xDE, 0x71, 0xF1, 0xCF, 0x3C, 0x01, 0xE7, 0x9E, 0x00,
  0xE3, 0xCF, 0x00, 0xF1, 0xE7, 0x80, 0x78, 0xF3, 0xC0, 0x78, 0x79, 0xE0,
  0x3C, 0x3C, 0xF0, 0x1C, 0x0F, 0xF0, 0x1E, 0x07, 0xF8, 0x1E, 0x01, 0xF8,
  0x07, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3C, 0x7C,
  0x03, 0xC7, 0xC0, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x3E, 0x7F, 0xE7, 0xE7, 0xFF, 0x7C, 0xF9,
  0xFF, 0xCF, 0x8F, 0xF8, 0xF8, 0x7F, 0x8F, 0x87, 0xF0, 0xFC, 0x7F, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xE7, 0xF0, 0xFF, 0xBD,
  0xEF, 0x7B, 0xDE, 0x0F, 0x87, 0x87, 0x83, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8,
  0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E,
  0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0xF8,
  0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78,
  0x7C, 0x3C, 0x3E, 0x1E, 0x1F, 0x1F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x31, 0xC6, 0xFF, 0x7B, 0xFF, 0xEF, 0xFF, 0xC3, 0xF0, 0x1F, 0xC0, 0xFF,
  0x83, 0xDF, 0x1F, 0x3E, 0x18, 0xE0, 0x21, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x7D,
  0xF7, 0xDE, 0x7B, 0xEF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x7C,
  0xF9, 0xF1, 0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7D, 0xF1, 0xF7,
  0xCF, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3F,
  0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF, 0xFD, 0xF7, 0x9F, 0x31, 0xF1, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0xC7,
  0xFF, 0x3F, 0xFE, 0x78, 0xF8, 0x83, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x70, 0xF8, 0x83, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x7F, 0xC1, 0xFC, 0x07, 0xF8, 0x1F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xFC, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFB, 0xFF, 0xC7, 0xFC, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0x78, 0x1E, 0xF0, 0x79,
  0xE0, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x1E, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7F, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xFF, 0xE6, 0x7F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xE0, 0x7D, 0xFF, 0xEF, 0xFF,
  0x7F, 0xF3, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x8F, 0xFE, 0x3E,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF9, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF,
  0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7D, 0xE1, 0xF7,
  0xC7, 0xDF, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x7C, 0x7D, 0xE1,
  0xF7, 0x87, 0xDF, 0x3E, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x07, 0xF8, 0x3F,
  0xF1, 0xFF, 0xEF, 0xCF, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFF,
  0xFF, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0x87, 0xFF,
  0x1F, 0xFE, 0xFC, 0xFB, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x8F, 0xFF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF1, 0xF7, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0x9F, 0xFC, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0x00,
  0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xC0,
  0x39, 0xF7, 0xDF, 0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF,
  0x7D, 0xE7, 0x9E, 0xFB, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3F,
  0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC0, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x7C, 0x07, 0xF0, 0xFF, 0x8F, 0xF8,
  0xFF, 0x83, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x1F, 0xC3, 0xFF, 0x3F, 0xFC,
  0xFF, 0xE7, 0x1F, 0xA0, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7C, 0x07, 0x81, 0xE0, 0x07, 0x87,
  0x80, 0x07, 0x8E, 0x1F, 0xE7, 0x3C, 0x7F, 0xCF, 0x79, 0xFF, 0x9E, 0xE3,
  0xCF, 0x3F, 0xCF, 0x1E, 0x3F, 0x9E, 0x3C, 0x7F, 0x3C, 0x78, 0xFE, 0x78,
  0xF3, 0xFC, 0xF1, 0xE7, 0xF9, 0xE3, 0xCE, 0xF1, 0xFF, 0xFC, 0xE3, 0xFB,
  0xF1, 0xE3, 0xE7, 0xC3, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x08,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03,
  0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xE3, 0xC0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x1E, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7D, 0xF8,
  0x0F, 0xFF, 0x00, 0xF8, 0xFF, 0xC1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF,
  0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7D, 0xFF, 0xFB, 0xFF,
  0xC7, 0xFF, 0xCF, 0xFF, 0xDF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0x00,
  0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF3, 0xF0, 0xCF, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x19,
  0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xF9, 0xFE, 0xF8, 0x7E, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7E, 0xF9, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE,
  0xFF, 0xEF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xEF, 0xFE, 0xFF,
  0xEF, 0xFE, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0xE3, 0xF8, 0x71, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x1F, 0xFF, 0x8F, 0xF7, 0xC7, 0xFB, 0xE3, 0xFD, 0xF0, 0x3E,
  0xF8, 0x1F, 0x7C, 0x0F, 0xBF, 0x07, 0xCF, 0xC3, 0xE7, 0xFF, 0xF1, 0xFF,
  0xF8, 0x7F, 0xFC, 0x0F, 0xF8, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0xCF, 0xFF, 0xFF, 0xEF, 0xE7, 0xC0, 0xF8, 0x1F, 0xFC,
  0x1F, 0xBE, 0x0F, 0x9F, 0x0F, 0xCF, 0x8F, 0xC7, 0xC7, 0xC3, 0xE7, 0xE1,
  0xF3, 0xE0, 0xFB, 0xF0, 0x7D, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x83, 0xF7, 0xC1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E,
  0x1F, 0x1F, 0x0F, 0xCF, 0x83, 0xE7, 0xC1, 0xFB, 0xE0, 0x7E, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xBF, 0xF7,
  0x8F, 0x7F, 0xEF, 0x1E, 0xFF, 0xDE, 0x39, 0xFF, 0xBC, 0xF3, 0xFF, 0x3D,
  0xE7, 0xFE, 0x7B, 0xCF, 0xFC, 0xFF, 0x1F, 0xF9, 0xFE, 0x3F, 0xF1, 0xFC,
  0x7F, 0xE3, 0xF8, 0xFF, 0xC7, 0xE1, 0xFF, 0x8F, 0xC3, 0xFF, 0x0F, 0x87,
  0xFE, 0x1E, 0x0F, 0x80, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFE, 0xF9, 0xFF, 0xBE, 0x7F, 0xE7, 0xDF, 0xF9, 0xF7, 0xFE, 0x3E, 0xFF,
  0x8F, 0xBF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFC, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0xFC, 0x1F, 0x9F, 0x01,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xEF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C, 0x07,
  0xCF, 0xC1, 0xF8, 0xFC, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xFF, 0xFE,
  0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0xFC, 0x1F, 0x9F, 0x01,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xEF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C, 0x07,
  0xCF, 0xC1, 0xF8, 0xFC, 0x7F, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF9,
  0xFC, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8,
  0x3F, 0x0F, 0xE1, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xC7, 0x7C, 0x0B, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF1, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C, 0x3F, 0x7F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0,
  0x7D, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C,
  0x3E, 0x1F, 0x07, 0x87, 0xC1, 0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x03,
  0xCF, 0x80, 0xFB, 0xC0, 0x3E, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x1F,
  0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xBC, 0x0F, 0x83, 0xE7,
  0xC3, 0xF8, 0x7C, 0xF8, 0x7F, 0x0F, 0x9F, 0x0F, 0xE1, 0xF3, 0xE1, 0xDC,
  0x3E, 0x3C, 0x3B, 0x8F, 0x87, 0xCF, 0x79, 0xF0, 0xF9, 0xEF, 0x3E, 0x1F,
  0x3D, 0xE7, 0xC1, 0xE7, 0xBC, 0xF0, 0x3D, 0xE7, 0x9E, 0x07, 0xBC, 0x7F,
  0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x9F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8,
  0xFC, 0x1F, 0x3E, 0x07, 0xDF, 0x81, 0xF7, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0x7C, 0x07, 0xCF, 0x83, 0xF3, 0xE0, 0xF8,
  0x7C, 0x7E, 0x1F, 0x1F, 0x07, 0xEF, 0xC0, 0xFC, 0xF8, 0x0F, 0xBE, 0x07,
  0xDF, 0x07, 0xCF, 0xC3, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0x7C, 0xF8, 0x3E,
  0xF8, 0x0F, 0x7C, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3D, 0xE0, 0x1E, 0xF0, 0x1E,
  0x3C, 0x0F, 0x1E, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0xC0, 0xF3, 0xC0, 0x7B,
  0xE0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x3E, 0x0F, 0x83,
  0xE0, 0xF0, 0x3C, 0x0F, 0xC1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x10, 0xFC,
  0x01, 0xF0, 0x07, 0xC3, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0xC7, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE3, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xBC, 0xFC, 0xF0, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x9E, 0x3E,
  0xFC, 0xFF, 0xFB, 0xFF, 0xEF, 0xCF, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xEF, 0x7F, 0x3C, 0xF8, 0x07, 0xE0, 0xFF, 0xCF, 0xFC, 0xFF, 0xE7,
  0xE2, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x09, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC3, 0xCF,
  0x9F, 0xDF, 0x3F, 0xFE, 0xFF, 0xFD, 0xF9, 0xFB, 0xE3, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFB, 0xE3,
  0xF7, 0xFF, 0xEF, 0xFF, 0xCF, 0xEF, 0x8F, 0x8F, 0x07, 0xC0, 0x7F, 0xC3,
  0xFF, 0x9F, 0xFE, 0x7C, 0x7D, 0xE1, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x17, 0xF7, 0x8F, 0xFE,
  0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1E, 0x03,
  0xE0, 0x3F, 0xE7, 0xFE, 0xFF, 0xEF, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x3E, 0x7F, 0x7C, 0xFF, 0xFB, 0xFF, 0xF7,
  0xE7, 0xEF, 0x8F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x8F, 0xDF, 0xFF, 0xBF, 0xFF, 0x3F, 0xBE,
  0x3E, 0x7C, 0x00, 0xF8, 0x01, 0xF4, 0x07, 0xCF, 0x3F, 0x9F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF0, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x9E, 0x3F, 0xFC, 0xF7, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x27,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x04, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xBF, 0xFE, 0xFE, 0xFC, 0xF0,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x0F, 0xFC, 0x3E, 0xF8, 0xFD, 0xF1, 0xF3, 0xE7, 0xC7, 0xDF, 0x8F, 0xBE,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFB, 0xE3, 0xE7, 0xC7,
  0xC7, 0xCF, 0x8F, 0x9F, 0x0F, 0xBE, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xE0, 0xF1, 0xEF, 0xE7, 0xF3, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xCF, 0xE7, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8,
  0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87,
  0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C,
  0x3F, 0xF0, 0xF8, 0x7C, 0xF1, 0xE3, 0xDF, 0xCF, 0x7F, 0xBF, 0xFF, 0xFC,
  0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xF0,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x87, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0xC3,
  0xEF, 0x8F, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xC0, 0xF1, 0xE3,
  0xCF, 0xCF, 0x7F, 0xBF, 0xFE, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF3, 0xEF, 0x8F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x3E, 0x7F, 0x7C,
  0xFF, 0xFB, 0xFF, 0xF7, 0xC7, 0xEF, 0x8F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x8F, 0xDF, 0xFF,
  0xBF, 0xFF, 0x3F, 0xBE, 0x3E, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xF1, 0xFC, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xFE, 0x7F,
  0xEF, 0xFE, 0xF8, 0x4F, 0x80, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F,
  0xE0, 0x3E, 0x01, 0xF8, 0x1E, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0xF7, 0xFF, 0xFF, 0xFF, 0xF9, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFC,
  0x7F, 0x8F, 0xF0, 0xFE, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBC, 0xFC, 0xF0,
  0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x3C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0x78, 0x7E, 0x1F, 0x7C, 0x7E, 0x1E,
  0x7C, 0x7F, 0x3E, 0x7C, 0xFF, 0x3E, 0x3C, 0xFF, 0x3E, 0x3C, 0xF7, 0x3C,
  0x3E, 0xE7, 0x3C, 0x3E, 0xE7, 0xFC, 0x1E, 0xE7, 0xFC, 0x1F, 0xE7, 0xF8,
  0x1F, 0xE3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x7C, 0x3E, 0x7E, 0x7C,
  0x3E, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0x7C,
  0x7E, 0x7C, 0x7C, 0x3E, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C,
  0x1F, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x81,
  0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x8F, 0xF1, 0xFC, 0x3F, 0x07, 0xF8, 0x1F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0xE1,
  0xFC, 0x1F, 0x81, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x3F, 0x0F, 0xE3,
  0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F,
  0xC3, 0xF0, 0x7C, 0x7F, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xE0, 0x7E, 0x07, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraBold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 23, 9, 2, -23 },
  { 16, 12, 8, 15, 2, -23 },
  { 28, 16, 23, 18, 1, -23 },
  { 74, 14, 26, 16, 1, -24 },
  { 120, 25, 23, 27, 1, -23 },
  { 192, 20, 23, 21, 1, -23 },
  { 250, 5, 8, 8, 2, -23 },
  { 255, 9, 28, 11, 1, -23 },
  { 287, 9, 28, 11, 0, -23 },
  { 319, 14, 14, 15, 1, -24 },
  { 344, 14, 15, 16, 1, -19 },
  { 371, 6, 8, 9, 1, -4 },
  { 377, 8, 5, 10, 1, -11 },
  { 382, 5, 5, 9, 2, -5 },
  { 386, 13, 23, 13, 0, -23 },
  { 424, 14, 23, 16, 1, -23 },
  { 465, 12, 23, 16, 1, -23 },
  { 500, 14, 23, 16, 1, -23 },
  { 541, 14, 23, 16, 1, -23 },
  { 582, 15, 23, 16, 1, -23 },
  { 626, 13, 23, 16, 2, -23 },
  { 664, 14, 23, 16, 1, -23 },
  { 705, 14, 23, 16, 1, -23 },
  { 746, 14, 23, 16, 1, -23 },
  { 787, 14, 23, 16, 1, -23 },
  { 828, 5, 18, 9, 2, -18 },
  { 840, 6, 22, 9, 1, -18 },
  { 857, 14, 16, 16, 1, -20 },
  { 885, 14, 10, 16, 1, -16 },
  { 903, 14, 16, 16, 1, -20 },
  { 931, 13, 23, 13, 0, -23 },
  { 969, 23, 25, 25, 1, -23 },
  { 1041, 19, 23, 19, 0, -23 },
  { 1096, 15, 23, 19, 2, -23 },
  { 1140, 15, 23, 17, 1, -23 },
  { 1184, 16, 23, 20, 2, -23 },
  { 1230, 12, 23, 15, 2, -23 },
  { 1265, 12, 23, 15, 2, -23 },
  { 1300, 17, 23, 20, 1, -23 },
  { 1349, 17, 23, 21, 2, -23 },
  { 1398, 10, 23, 11, 1, -23 },
  { 1427, 9, 30, 10, -2, -23 },
  { 1461, 17, 23, 18, 2, -23 },
  { 1510, 12, 23, 15, 2, -23 },
  { 1545, 23, 23, 27, 2, -23 },
  { 1612, 18, 23, 22, 2, -23 },
  { 1664, 19, 23, 21, 1, -23 },
  { 1719, 14, 23, 17, 2, -23 },
  { 1760, 19, 28, 21, 1, -23 },
  { 1827, 16, 23, 18, 2, -23 },
  { 1873, 13, 23, 15, 1, -23 },
  { 1911, 14, 23, 16, 1, -23 },
  { 1952, 16, 23, 20, 2, -23 },
  { 1998, 18, 23, 18, 0, -23 },
  { 2050, 27, 23, 27, 0, -23 },
  { 2128, 18, 23, 18, 0, -23 },
  { 2180, 17, 23, 17, 0, -23 },
  { 2229, 14, 23, 16, 1, -23 },
  { 2270, 7, 28, 10, 2, -23 },
  { 2295, 13, 23, 13, 0, -23 },
  { 2333, 7, 28, 10, 1, -23 },
  { 2358, 17, 15, 17, 0, -23 },
  { 2390, 15, 3, 14, 0, 2 },
  { 2396, 9, 6, 11, 1, -25 },
  { 2403, 14, 18, 17, 1, -18 },
  { 2435, 14, 24, 18, 2, -24 },
  { 2477, 13, 18, 14, 1, -18 },
  { 2507, 15, 24, 18, 1, -24 },
  { 2552, 14, 18, 16, 1, -18 },
  { 2584, 12, 24, 11, 0, -24 },
  { 2620, 15, 26, 18, 1, -18 },
  { 2669, 14, 24, 18, 2, -24 },
  { 2711, 5, 25, 9, 2, -25 },
  { 2727, 8, 33, 9, -1, -25 },
  { 2760, 15, 24, 17, 2, -24 },
  { 2805, 5, 24, 9, 2, -24 },
  { 2820, 23, 18, 27, 2, -18 },
  { 2872, 14, 18, 18, 2, -18 },
  { 2904, 15, 18, 17, 1, -18 },
  { 2938, 14, 26, 18, 2, -18 },
  { 2984, 15, 26, 18, 1, -18 },
  { 3033, 10, 18, 12, 2, -18 },
  { 3056, 12, 18, 14, 1, -18 },
  { 3083, 11, 21, 12, 0, -21 },
  { 3112, 14, 18, 18, 2, -18 },
  { 3144, 16, 18, 16, 0, -18 },
  { 3180, 24, 18, 24, 0, -18 },
  { 3234, 16, 18, 16, 0, -18 },
  { 3270, 16, 26, 16, 0, -18 },
  { 3322, 12, 18, 13, 1, -18 },
  { 3349, 11, 28, 12, 0, -23 },
  { 3388, 4, 31, 15, 5, -24 },
  { 3404, 10, 28, 12, 1, -23 },
  { 3439, 14, 6, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_ExtraBold32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD32PT7B_H_
