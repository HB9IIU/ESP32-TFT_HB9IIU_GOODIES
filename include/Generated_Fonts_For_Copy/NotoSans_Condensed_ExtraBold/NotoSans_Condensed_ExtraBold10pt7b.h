#ifndef _NOTOSANS_CONDENSED_EXTRABOLD10PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x5C, 0xD5, 0x29, 0xFE, 0xAF, 0xA9, 0x40, 0x23, 0xFC, 0xC7,
  0x1F, 0xEC, 0x20, 0x64, 0xAC, 0xA8, 0x6F, 0x15, 0x15, 0x27, 0x70, 0xB1,
  0xC3, 0xAD, 0xDB, 0x1F, 0x80, 0xD0, 0x69, 0x6C, 0x93, 0x20, 0xC9, 0xB6,
  0xDA, 0xC0, 0x25, 0x7E, 0xE5, 0x00, 0x21, 0x3E, 0x42, 0x00, 0x70, 0xE0,
  0x70, 0x12, 0x26, 0x44, 0xC0, 0x72, 0xF7, 0xBD, 0xA9, 0xC0, 0x3F, 0x73,
  0x33, 0x30, 0xF2, 0xC4, 0x66, 0x23, 0xE0, 0xF4, 0xC4, 0xE1, 0xCF, 0xC0,
  0x31, 0x94, 0xAF, 0xFC, 0x40, 0x72, 0x18, 0xE1, 0xCF, 0xC0, 0x72, 0x3D,
  0xFD, 0xAD, 0xC0, 0xF8, 0xC4, 0x62, 0x31, 0x80, 0x76, 0xD4, 0xED, 0xED,
  0xC0, 0x76, 0xF7, 0xF5, 0x89, 0xC0, 0x70, 0x70, 0x50, 0x1C, 0x0B, 0xB0,
  0x60, 0x80, 0xF8, 0x3E, 0xC3, 0x86, 0xC8, 0x00, 0xF9, 0x36, 0x44, 0x60,
  0x3C, 0x42, 0x5E, 0xEF, 0xEE, 0x5E, 0x64, 0x3C, 0x31, 0xC7, 0x96, 0x7B,
  0x3C, 0xC0, 0xF9, 0xBF, 0x9B, 0xF0, 0x7B, 0x51, 0x84, 0x35, 0xE0, 0xF4,
  0xA7, 0x39, 0xDB, 0x80, 0xF2, 0x79, 0x38, 0xF2, 0x79, 0x20, 0x3D, 0x84,
  0x37, 0x4D, 0xB3, 0xC0, 0x9C, 0xE7, 0xF9, 0xCE, 0x60, 0xED, 0xB6, 0xF8,
  0x24, 0x92, 0x49, 0xE0, 0x9D, 0xA9, 0xCB, 0x5A, 0x60, 0x92, 0x49, 0x38,
  0xCF, 0x9F, 0xBD, 0x7B, 0x76, 0xED, 0x80, 0xCE, 0x7B, 0x5B, 0xCE, 0x60,
  0x79, 0xB4, 0xF1, 0x4D, 0xB3, 0x80, 0xFB, 0xBF, 0xC8, 0x80, 0x79, 0xB4,
  0xF1, 0x4D, 0xB3, 0x82, 0x0C, 0xF5, 0xAD, 0xEA, 0x5A, 0x60, 0x7D, 0xC7,
  0x19, 0xF0, 0xF9, 0x08, 0x42, 0x10, 0x80, 0x9C, 0xE7, 0x39, 0xEF, 0xC0,
  0xCF, 0x25, 0x96, 0x70, 0xC3, 0x00, 0xD9, 0xD9, 0x5B, 0x5F, 0x56, 0x76,
  0x66, 0xD9, 0xE7, 0x0C, 0x71, 0x6C, 0xC0, 0xCA, 0xDC, 0x63, 0x18, 0xC0,
  0xF8, 0x8C, 0x46, 0x63, 0xE0, 0xEA, 0xAA, 0xC0, 0xC4, 0x46, 0x23, 0x10,
  0xED, 0xB6, 0xDB, 0xE0, 0x21, 0x95, 0x90, 0xF8, 0xCC, 0x23, 0x87, 0xFD,
  0xBC, 0x88, 0xAF, 0x99, 0xBF, 0x37, 0xCC, 0x57, 0x18, 0xCE, 0xFD, 0xED,
  0x6F, 0x23, 0xB7, 0xF4, 0xB8, 0x36, 0x4E, 0x44, 0x44, 0x2B, 0xF7, 0xBD,
  0xBC, 0x6E, 0x88, 0xAF, 0xBB, 0xBB, 0xFF, 0x55, 0x55, 0x70, 0x88, 0x8B,
  0xEE, 0xB9, 0xFF, 0xA5, 0xFE, 0xDD, 0xBB, 0x76, 0xC0, 0xAF, 0xBB, 0xBB,
  0x23, 0xF7, 0xB5, 0xB8, 0xAF, 0x99, 0xBF, 0x88, 0x2B, 0xF7, 0xBD, 0xBC,
  0x63, 0xBE, 0x49, 0x00, 0x6F, 0xC7, 0xBF, 0x4B, 0xA4, 0x98, 0xBB, 0xBB,
  0xBD, 0xDE, 0xD4, 0xA7, 0x10, 0xDB, 0x5A, 0x6E, 0x6E, 0x6C, 0xDB, 0x9C,
  0xAD, 0x80, 0xDE, 0xD4, 0xA7, 0x10, 0x9C, 0xFF, 0x26, 0x4F, 0x6D, 0xBC,
  0xDB, 0x20, 0xFF, 0xC0, 0xC4, 0x46, 0x74, 0x4C, 0xC0, 0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraBold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 3, 0, -7 },
  { 3, 4, 2, 5, 0, -7 },
  { 4, 5, 7, 6, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 8, 7, 8, 0, -7 },
  { 22, 7, 7, 6, 0, -7 },
  { 29, 2, 2, 3, 0, -7 },
  { 30, 3, 9, 3, 0, -7 },
  { 34, 3, 9, 3, 0, -7 },
  { 38, 5, 5, 5, 0, -8 },
  { 42, 5, 5, 5, 0, -6 },
  { 46, 2, 2, 3, 0, -1 },
  { 47, 3, 1, 3, 0, -3 },
  { 48, 2, 2, 3, 0, -2 },
  { 49, 4, 7, 4, 0, -7 },
  { 53, 5, 7, 5, 0, -7 },
  { 58, 4, 7, 5, 0, -7 },
  { 62, 5, 7, 5, 0, -7 },
  { 67, 5, 7, 5, 0, -7 },
  { 72, 5, 7, 5, 0, -7 },
  { 77, 5, 7, 5, 0, -7 },
  { 82, 5, 7, 5, 0, -7 },
  { 87, 5, 7, 5, 0, -7 },
  { 92, 5, 7, 5, 0, -7 },
  { 97, 5, 7, 5, 0, -7 },
  { 102, 2, 6, 3, 0, -6 },
  { 104, 2, 7, 3, 0, -6 },
  { 106, 5, 5, 5, 0, -6 },
  { 110, 5, 3, 5, 0, -5 },
  { 112, 5, 5, 5, 0, -6 },
  { 116, 4, 7, 4, 0, -7 },
  { 120, 8, 8, 8, 0, -7 },
  { 128, 6, 7, 6, 0, -7 },
  { 134, 4, 7, 6, 1, -7 },
  { 138, 5, 7, 5, 0, -7 },
  { 143, 5, 7, 6, 1, -7 },
  { 148, 3, 7, 5, 1, -7 },
  { 151, 3, 7, 5, 1, -7 },
  { 154, 6, 7, 6, 0, -7 },
  { 160, 5, 7, 6, 1, -7 },
  { 165, 3, 7, 4, 0, -7 },
  { 168, 3, 9, 3, -1, -7 },
  { 172, 5, 7, 6, 1, -7 },
  { 177, 3, 7, 5, 1, -7 },
  { 180, 7, 7, 8, 1, -7 },
  { 187, 5, 7, 7, 1, -7 },
  { 192, 6, 7, 7, 0, -7 },
  { 198, 4, 7, 5, 1, -7 },
  { 202, 6, 9, 7, 0, -7 },
  { 209, 5, 7, 6, 1, -7 },
  { 214, 4, 7, 5, 0, -7 },
  { 218, 5, 7, 5, 0, -7 },
  { 223, 5, 7, 6, 1, -7 },
  { 228, 6, 7, 6, 0, -7 },
  { 234, 8, 7, 8, 0, -7 },
  { 241, 6, 7, 6, 0, -7 },
  { 247, 5, 7, 5, 0, -7 },
  { 252, 5, 7, 5, 0, -7 },
  { 257, 2, 9, 3, 1, -7 },
  { 260, 4, 7, 4, 0, -7 },
  { 264, 3, 9, 3, 0, -7 },
  { 268, 5, 4, 5, 0, -7 },
  { 271, 5, 1, 5, 0, 1 },
  { 272, 3, 2, 3, 0, -8 },
  { 273, 5, 6, 5, 0, -6 },
  { 277, 4, 8, 5, 1, -8 },
  { 281, 4, 6, 4, 0, -6 },
  { 284, 5, 8, 5, 0, -8 },
  { 289, 5, 6, 5, 0, -6 },
  { 293, 4, 8, 3, 0, -8 },
  { 297, 5, 8, 5, 0, -6 },
  { 302, 4, 8, 6, 1, -8 },
  { 306, 1, 8, 3, 1, -8 },
  { 307, 2, 10, 3, 0, -8 },
  { 310, 4, 8, 5, 1, -8 },
  { 314, 1, 8, 3, 1, -8 },
  { 315, 7, 6, 8, 1, -6 },
  { 321, 4, 6, 6, 1, -6 },
  { 324, 5, 6, 5, 0, -6 },
  { 328, 4, 8, 5, 1, -6 },
  { 332, 5, 8, 5, 0, -6 },
  { 337, 3, 6, 4, 1, -6 },
  { 340, 4, 6, 4, 0, -6 },
  { 343, 3, 7, 4, 0, -7 },
  { 346, 4, 6, 6, 1, -6 },
  { 349, 5, 6, 5, 0, -6 },
  { 353, 8, 5, 8, 0, -5 },
  { 358, 5, 5, 5, 0, -5 },
  { 362, 5, 8, 5, 0, -6 },
  { 367, 4, 6, 4, 0, -6 },
  { 370, 3, 9, 4, 0, -7 },
  { 374, 1, 10, 5, 2, -8 },
  { 376, 4, 9, 4, 0, -7 },
  { 381, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_ExtraBold10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD10PT7B_H_
