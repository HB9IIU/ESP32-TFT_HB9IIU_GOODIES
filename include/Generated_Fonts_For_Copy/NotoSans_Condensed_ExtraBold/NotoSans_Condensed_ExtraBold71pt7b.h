#ifndef _NOTOSANS_CONDENSED_EXTRABOLD71PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF,
  0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF9, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x1F, 0xC1, 0xFF, 0x9F, 0xFC, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x8F, 0xF8,
  0x1F, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFD, 0xFF, 0x83, 0xFF,
  0xBF, 0xF0, 0x7F, 0xF7, 0xFE, 0x0F, 0xFE, 0xFF, 0xC1, 0xFF, 0xDF, 0xF8,
  0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFD,
  0xFF, 0x81, 0xFF, 0x3F, 0xF0, 0x3F, 0xE7, 0xFE, 0x07, 0xFC, 0xFF, 0xC0,
  0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7,
  0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFE, 0x7C, 0x3E, 0x3F, 0xF1, 0xF0, 0x18, 0xFF, 0xC7,
  0xC0, 0x03, 0xFF, 0x1F, 0x00, 0x0F, 0xFC, 0x7C, 0x00, 0x3F, 0xF1, 0xF0,
  0x00, 0xFF, 0xE7, 0xC0, 0x03, 0xFF, 0xDF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xF7,
  0xFF, 0x00, 0x07, 0xCF, 0xFC, 0x00, 0x1F, 0x1F, 0xF0, 0x00, 0x7C, 0x7F,
  0xF0, 0x01, 0xF1, 0xFF, 0xE0, 0x07, 0xCF, 0xFF, 0xF0, 0x1F, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x83,
  0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x3F,
  0xC0, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x7F, 0xC3, 0xFF, 0xC0, 0x7F, 0x87,
  0xF8, 0x7F, 0x87, 0xFF, 0xE0, 0x7F, 0xCF, 0xF8, 0x7F, 0x8F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xFE, 0x3F, 0xE3, 0xFC, 0x0F, 0xFF, 0xC3, 0xFE, 0x3F, 0xE3, 0xFE, 0x07,
  0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x87, 0xFF, 0x1F, 0xFF, 0x7F, 0xF0,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE7, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F,
  0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x3F,
  0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x20, 0x0F, 0xF0, 0x04, 0x3C,
  0x0F, 0xF0, 0x1C, 0x3F, 0x8F, 0xF0, 0xFC, 0x3F, 0xF7, 0xF7, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x07,
  0xFE, 0x7F, 0xE0, 0x0F, 0xFE, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0xFE, 0x0F,
  0xFC, 0xFF, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF,
  0x9F, 0xFC, 0x7F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F,
  0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F,
  0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0x3F, 0xE3, 0xFF,
  0x8F, 0xE1, 0xFF, 0xC3, 0xE0, 0xFF, 0xE1, 0xE0, 0x7F, 0xF0, 0x60, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xE1,
  0xFF, 0xF8, 0x7F, 0x00, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0xE0, 0xE0, 0x01,
  0xFF, 0xC0, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0xFF, 0xF8, 0x3C, 0x00, 0xFF, 0xF0,
  0x60, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xBF, 0xF8, 0x00, 0x1F, 0xEF, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x80,
  0x03, 0xFC, 0xFF, 0xE0, 0x01, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0x8F, 0xFE,
  0x00, 0x3F, 0xC3, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xE0, 0x07, 0xF8, 0x3F,
  0xF8, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xF3, 0xFF,
  0xFE, 0x08, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xE0, 0x00,
  0x7F, 0xFB, 0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x7F,
  0xE3, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0xE0, 0x7F, 0xEF, 0xFF, 0xF0, 0x7F,
  0xDF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x1F, 0xFE, 0xFF,
  0xF8, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F,
  0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F,
  0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F,
  0xF8, 0x0F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xFE, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x7F,
  0xF8, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0B, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF0, 0x3F, 0xFC, 0x7F,
  0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x7F,
  0xF8, 0x3F, 0xFF, 0x7F, 0xFC, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF7, 0xFE, 0x0F, 0xFF, 0xE7, 0xFE, 0x07, 0xFF, 0xE7, 0xFE, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x3E, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x1E, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x04, 0x03, 0xFC, 0x7F, 0xEF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE7,
  0xFC, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x03, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE3, 0xFC, 0x1F, 0x00, 0x01, 0x00, 0x3F,
  0xC1, 0xFF, 0x8F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F,
  0xFC, 0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0xFE,
  0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFC, 0x0F, 0xFF, 0x1E, 0x00, 0x7F, 0xF1, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xC1, 0xFE,
  0x00, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xE1, 0xFE, 0x3F,
  0xC0, 0x7F, 0xFF, 0xF8, 0x7F, 0x8F, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xE7,
  0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFD, 0xFE, 0x07, 0xFE, 0x1F, 0xE0, 0xFF,
  0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xDF, 0xC0, 0xFF, 0x01, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0,
  0x7F, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0xC1, 0xFE, 0x01, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFF, 0xFC, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFE, 0x03,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xBF, 0xC1, 0xFE,
  0x03, 0xFC, 0x0F, 0xEF, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xFB, 0xFC, 0x1F,
  0xF0, 0x7F, 0xE1, 0xFC, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF8, 0x1F, 0xFF, 0xEF, 0xFF, 0xE1, 0xFE,
  0x07, 0xFF, 0xF3, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00,
  0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x7F, 0xF1,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xF0, 0x3F, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xDF, 0xFC,
  0x01, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x1F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F,
  0xF0, 0x07, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0x01, 0xFF, 0xFB, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xC0, 0x0F,
  0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0x07, 0xFF, 0xE0, 0x07, 0x83, 0xFF, 0xE0, 0x00, 0x83, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x02, 0x1F, 0xFF, 0x00, 0x07, 0x0F, 0xFF, 0xE0,
  0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0x8F, 0xFE, 0x00, 0xFF,
  0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xE0,
  0x03, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xEF,
  0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xE0,
  0x07, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x70, 0x3F, 0xFF, 0x00, 0x01,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFD,
  0xFF, 0xC0, 0x7F, 0xFF, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00,
  0x3F, 0xFB, 0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF,
  0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x1F,
  0xFC, 0xFF, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFF,
  0x00, 0x3F, 0xF8, 0xFF, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x83, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x3F,
  0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xE0,
  0x0F, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE1,
  0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F,
  0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF8,
  0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F,
  0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xFC, 0xFF, 0xE0,
  0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xEF,
  0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xDF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0x00, 0x7F, 0xDF, 0xFF, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFF,
  0xFF, 0xCF, 0xF8, 0x07, 0xF9, 0xFF, 0xFF, 0xF3, 0xFE, 0x03, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0xE7,
  0xFF, 0xFF, 0xC7, 0xFC, 0x0F, 0xF1, 0xFF, 0xFF, 0xF1, 0xFF, 0x07, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xF8, 0x7F,
  0x87, 0xFF, 0xFF, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0x8F,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFC,
  0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xDF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF7, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xFC, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0xFE,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0xFF, 0xF9, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0xFF,
  0xC3, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F, 0xFF, 0xFC, 0x0F, 0xFE, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFC, 0xFF, 0xFF, 0xF0, 0x1F, 0xFD, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF9, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC3, 0xFF, 0xC0, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xF1, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x01, 0xFF,
  0xCF, 0xFE, 0x00, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x81, 0xFF, 0xF7, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFA,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xC0,
  0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x01, 0xFF,
  0xE7, 0xFF, 0x80, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F,
  0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xE0,
  0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xCF,
  0xFE, 0x00, 0x3F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0x87, 0xFF,
  0x80, 0x3E, 0x1F, 0xFC, 0x00, 0x38, 0x7F, 0xF0, 0x00, 0x21, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xEC, 0x00, 0x03, 0xFF, 0xBC,
  0x00, 0x0F, 0xFE, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0x87, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xA0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xCF,
  0xFF, 0xC0, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x9F, 0xFC,
  0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00,
  0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x8F, 0xFC, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0xBF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xBF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xF9, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x9F, 0xF0, 0xFF, 0xE0, 0x07, 0xFE,
  0x0F, 0xF9, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0x9F, 0xF0, 0xFF,
  0xE0, 0x07, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF1, 0xFF,
  0x0F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC, 0x00,
  0x3F, 0xF1, 0xFF, 0x0F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF0, 0xFF,
  0x9F, 0xFC, 0x00, 0x3F, 0xF1, 0xFE, 0x0F, 0xF9, 0xFF, 0x80, 0x01, 0xFF,
  0xBF, 0xE0, 0x7F, 0x9F, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x07, 0xF9, 0xFF,
  0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x7F, 0x9F, 0xF8, 0x00, 0x1F, 0xFB, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFB, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xE1,
  0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF0,
  0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x7F,
  0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0xFF, 0xE0, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x1F, 0xFE,
  0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x1F, 0xFD, 0xFF,
  0xC0, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x1F,
  0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF,
  0xC7, 0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F,
  0xC7, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xC0, 0x7F, 0xF8, 0x0C, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xC3, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0x7F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xE3, 0xFF, 0xFC, 0x7F, 0xC3, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x1C, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xE3, 0xFF,
  0xC0, 0xFF, 0xE7, 0xFF, 0xE0, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F,
  0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFE, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xFE, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xDF, 0xFF, 0xF0, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0x87, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xE3, 0xF1, 0xFF, 0xF0, 0x0C, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x02, 0xFF,
  0xF0, 0x00, 0x9F, 0xFF, 0x00, 0xF3, 0xFF, 0xF9, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x3C, 0x07, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC7, 0xFF,
  0x0F, 0xFF, 0xE7, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF,
  0x7F, 0xF8, 0x1F, 0xFF, 0x7F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF3, 0xFF, 0x07, 0xFF, 0xF3, 0xFF, 0x03, 0xFF, 0xE1, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0xF1, 0xFF,
  0xC0, 0x7F, 0xF3, 0xFF, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0xFF, 0xDF, 0xFC,
  0x00, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0x1F, 0xFE, 0x00, 0x06, 0x1F, 0xFE, 0x00, 0x7C,
  0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xE3, 0xFF,
  0x07, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFE, 0x7F, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF,
  0x7F, 0xF8, 0x1F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF7, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xC7, 0xFF,
  0x01, 0xFF, 0x87, 0xFF, 0x00, 0x3C, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x40, 0x00, 0x0F, 0xFE, 0x78, 0x00, 0x1F, 0xFE, 0x7F, 0x00, 0x7F, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x7C, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0xE0, 0xFF, 0xEF, 0xFF, 0xF0,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFC, 0x1F, 0xFE, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0x04, 0x07, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFC, 0xFF, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF,
  0x9F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xF0, 0x0F,
  0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xC0,
  0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x87,
  0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFC, 0x01, 0xFF,
  0xE3, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xCF, 0xFE, 0x00,
  0x3F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x83, 0xFE,
  0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F,
  0xF9, 0xFF, 0xFF, 0x9F, 0xFF, 0xF9, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0x87, 0xFF,
  0xE0, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xF8, 0x0F,
  0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFE,
  0x07, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0x7F, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xE0, 0x7F,
  0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF,
  0xCF, 0xFF, 0xF0, 0xFF, 0xDF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0xFF,
  0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF,
  0xE7, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x80, 0xFF,
  0xE0, 0x3C, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0xF3, 0xFF, 0x0F,
  0xFF, 0xF3, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x7F, 0xFF, 0x7F,
  0xF8, 0x1F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0x7F,
  0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x0F,
  0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x00,
  0x38, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3D, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0x6F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xF8, 0x07, 0x8F, 0xFE,
  0x00, 0x63, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0x0F, 0xFF,
  0xDF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF8, 0xFF, 0xFF, 0x9F, 0xF1,
  0xFF, 0xFF, 0x3F, 0xE0, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xE0, 0x7F, 0x80,
  0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x0F, 0xFE,
  0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x1F,
  0xF9, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFB, 0xFF, 0x00,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xDF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xF3, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xBF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC3, 0xFC, 0xFE, 0x0F,
  0xFC, 0x07, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0x3F,
  0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xF9, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F,
  0x8F, 0xF1, 0xFF, 0x80, 0x3F, 0xF3, 0xFC, 0x7F, 0x8F, 0xFC, 0x01, 0xFF,
  0x9F, 0xE1, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0x0F, 0xF3, 0xFF, 0x00,
  0x7F, 0xE7, 0xF8, 0x7F, 0x9F, 0xF0, 0x03, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF,
  0x80, 0x0F, 0xF9, 0xFC, 0x1F, 0xEF, 0xFC, 0x00, 0x7F, 0xCF, 0xE0, 0x7F,
  0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x03, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x1F, 0xDF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0xFE, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x0F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8,
  0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00,
  0xFF, 0xF7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC,
  0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x1F,
  0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x10, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x05, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x34, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0x1F, 0xFF, 0x00, 0x03, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0xC0, 0x00, 0xFF, 0xFC, 0x80, 0x00, 0x1F, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraBold71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 13, 52, 19, 3, -51 },
  { 86, 27, 19, 34, 3, -51 },
  { 151, 38, 51, 40, 1, -51 },
  { 394, 30, 58, 36, 3, -54 },
  { 612, 56, 52, 60, 2, -51 },
  { 976, 44, 52, 46, 2, -51 },
  { 1262, 12, 19, 18, 3, -51 },
  { 1291, 19, 62, 23, 3, -51 },
  { 1439, 19, 62, 23, 1, -51 },
  { 1587, 32, 31, 34, 1, -54 },
  { 1711, 32, 34, 36, 2, -42 },
  { 1847, 14, 19, 19, 2, -9 },
  { 1881, 18, 10, 22, 2, -24 },
  { 1904, 13, 13, 19, 3, -12 },
  { 1926, 29, 52, 30, 0, -51 },
  { 2115, 32, 52, 36, 2, -51 },
  { 2323, 25, 51, 36, 3, -51 },
  { 2483, 31, 51, 36, 2, -51 },
  { 2681, 31, 52, 36, 2, -51 },
  { 2883, 34, 51, 36, 1, -51 },
  { 3100, 30, 52, 36, 3, -51 },
  { 3295, 32, 52, 36, 2, -51 },
  { 3503, 32, 51, 36, 2, -51 },
  { 3707, 32, 52, 36, 2, -51 },
  { 3915, 32, 52, 36, 2, -51 },
  { 4123, 12, 41, 19, 4, -40 },
  { 4185, 14, 50, 20, 2, -40 },
  { 4273, 32, 35, 36, 2, -43 },
  { 4413, 32, 24, 36, 2, -37 },
  { 4509, 32, 35, 36, 2, -43 },
  { 4649, 28, 52, 30, 0, -51 },
  { 4831, 50, 56, 56, 3, -51 },
  { 5181, 42, 51, 42, 0, -51 },
  { 5449, 33, 51, 41, 5, -51 },
  { 5660, 33, 52, 38, 3, -51 },
  { 5875, 36, 51, 44, 5, -51 },
  { 6105, 25, 51, 34, 5, -51 },
  { 6265, 25, 51, 33, 5, -51 },
  { 6425, 37, 52, 44, 3, -51 },
  { 6666, 36, 51, 46, 5, -51 },
  { 6896, 21, 51, 25, 2, -51 },
  { 7030, 20, 66, 21, -4, -51 },
  { 7195, 36, 51, 41, 5, -51 },
  { 7425, 26, 51, 33, 5, -51 },
  { 7591, 50, 51, 60, 5, -51 },
  { 7910, 39, 51, 49, 5, -51 },
  { 8159, 41, 52, 47, 3, -51 },
  { 8426, 31, 51, 38, 5, -51 },
  { 8624, 41, 63, 47, 3, -51 },
  { 8947, 36, 51, 40, 5, -51 },
  { 9177, 30, 52, 34, 2, -51 },
  { 9372, 32, 51, 34, 1, -51 },
  { 9576, 35, 52, 45, 5, -51 },
  { 9804, 41, 51, 41, 0, -51 },
  { 10066, 60, 51, 60, 0, -51 },
  { 10449, 39, 51, 39, 0, -51 },
  { 10698, 38, 51, 38, 0, -51 },
  { 10941, 32, 51, 34, 1, -51 },
  { 11145, 17, 63, 22, 4, -51 },
  { 11279, 29, 52, 30, 0, -51 },
  { 11468, 16, 63, 22, 2, -51 },
  { 11594, 36, 33, 38, 1, -51 },
  { 11743, 32, 7, 32, 0, 5 },
  { 11771, 19, 11, 24, 3, -54 },
  { 11798, 31, 41, 37, 2, -40 },
  { 11957, 32, 55, 39, 4, -54 },
  { 12177, 27, 41, 32, 3, -40 },
  { 12316, 32, 55, 39, 3, -54 },
  { 12536, 31, 41, 36, 3, -40 },
  { 12695, 25, 54, 24, 1, -54 },
  { 12864, 32, 57, 39, 3, -40 },
  { 13092, 32, 54, 40, 4, -54 },
  { 13308, 11, 55, 19, 4, -55 },
  { 13384, 18, 72, 19, -3, -55 },
  { 13546, 35, 54, 38, 4, -54 },
  { 13783, 11, 54, 19, 4, -54 },
  { 13858, 51, 40, 59, 4, -40 },
  { 14113, 32, 40, 40, 4, -40 },
  { 14273, 33, 41, 38, 3, -40 },
  { 14443, 32, 57, 39, 4, -40 },
  { 14671, 32, 57, 39, 3, -40 },
  { 14899, 23, 40, 28, 4, -40 },
  { 15014, 26, 41, 30, 2, -40 },
  { 15148, 24, 48, 26, 1, -47 },
  { 15292, 31, 40, 40, 4, -39 },
  { 15447, 36, 39, 36, 0, -39 },
  { 15623, 53, 39, 54, 0, -39 },
  { 15882, 35, 39, 35, 0, -39 },
  { 16053, 36, 56, 36, 0, -39 },
  { 16305, 27, 39, 29, 1, -39 },
  { 16437, 23, 63, 26, 1, -51 },
  { 16619, 9, 70, 33, 12, -54 },
  { 16698, 23, 63, 26, 2, -51 },
  { 16880, 32, 12, 36, 2, -31 },
};

const GFXfont NotoSans_Condensed_ExtraBold71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold71pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD71PT7B_H_
