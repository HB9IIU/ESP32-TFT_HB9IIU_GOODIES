#ifndef _NOTOSANS_CONDENSED_EXTRABOLD9PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x30, 0xF5, 0x37, 0xD5, 0xF5, 0x30, 0x27, 0xE6, 0x3B, 0x62,
  0x45, 0x52, 0xA5, 0xB5, 0x67, 0xC9, 0x80, 0x21, 0xC5, 0x1B, 0xFB, 0x67,
  0xC0, 0xD0, 0x29, 0x6D, 0x93, 0x89, 0x36, 0x96, 0x2F, 0x67, 0x2F, 0x22,
  0x70, 0xE0, 0xC0, 0x12, 0x26, 0x44, 0x80, 0x27, 0xDD, 0xDD, 0x70, 0x7F,
  0x33, 0x33, 0x2F, 0x13, 0x64, 0xF0, 0x2F, 0x16, 0x19, 0xF0, 0x37, 0x7B,
  0xF3, 0x74, 0x71, 0x9F, 0x17, 0xCF, 0xDD, 0x70, 0xF1, 0x32, 0x64, 0x27,
  0xD6, 0xDD, 0x70, 0x27, 0xDD, 0x71, 0x60, 0xD0, 0xC0, 0xD0, 0x70, 0x13,
  0xC6, 0x10, 0xF0, 0xF0, 0x8C, 0x37, 0x80, 0x4F, 0x36, 0x40, 0x40, 0x10,
  0xD9, 0x6D, 0x5A, 0xBF, 0x91, 0x1C, 0x73, 0x94, 0xFF, 0xE4, 0xFB, 0xEB,
  0xBE, 0x13, 0xD1, 0x8C, 0x25, 0xC0, 0xF9, 0x99, 0xBE, 0xF3, 0xC9, 0xC0,
  0xF3, 0xC9, 0x00, 0x13, 0xD1, 0xBD, 0xA5, 0xE0, 0x99, 0xF9, 0x99, 0xE9,
  0x25, 0xC0, 0x24, 0x92, 0x5F, 0xBA, 0xEE, 0xAB, 0x92, 0x49, 0xC0, 0xCF,
  0x7D, 0x7D, 0xB6, 0x90, 0xDE, 0xFF, 0x7B, 0xCC, 0x21, 0xE4, 0xB3, 0xCD,
  0x27, 0x80, 0xEB, 0xAE, 0x88, 0x21, 0xE4, 0xB3, 0xCD, 0x27, 0x86, 0x0C,
  0xEB, 0xEE, 0xAB, 0x27, 0xC6, 0x39, 0xE0, 0xF6, 0x66, 0x66, 0x99, 0x99,
  0x9F, 0xDA, 0xD4, 0xA7, 0x18, 0xDB, 0xDA, 0x5A, 0x6E, 0x6E, 0x64, 0xDB,
  0x88, 0xE5, 0x6C, 0xDA, 0x9C, 0x42, 0x10, 0xF3, 0x24, 0xCF, 0xFB, 0x6D,
  0xB7, 0x8C, 0x44, 0x22, 0x30, 0xD5, 0x57, 0x22, 0x95, 0x30, 0xF0, 0xC4,
  0x71, 0x7D, 0x70, 0x88, 0xEB, 0xBB, 0xE0, 0x7C, 0xCC, 0x70, 0x11, 0x7D,
  0xDD, 0x70, 0x7D, 0xFC, 0x70, 0x6B, 0xA4, 0x90, 0x7D, 0xDD, 0x71, 0x70,
  0x88, 0xEB, 0xBB, 0xB0, 0xD5, 0x54, 0xD5, 0x55, 0xC0, 0x88, 0xBE, 0xEA,
  0xB0, 0xFE, 0xFE, 0xDA, 0x69, 0xA4, 0xEB, 0xBB, 0xB0, 0x76, 0xB7, 0xA7,
  0x00, 0xEB, 0xBB, 0xE8, 0x80, 0x7D, 0xDD, 0x71, 0x10, 0xEA, 0x80, 0x6C,
  0x63, 0xE0, 0x5D, 0x24, 0xC0, 0xB6, 0xDE, 0xDE, 0x9C, 0xC6, 0x00, 0x97,
  0xE9, 0xB3, 0x66, 0xC0, 0xD7, 0x67, 0xD0, 0xDE, 0x9C, 0xC6, 0x33, 0x00,
  0xE2, 0x64, 0xF0, 0x69, 0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF9,
};

const GFXglyph NotoSans_Condensed_ExtraBold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 4, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 5, 0, -7 },
  { 12, 7, 7, 8, 0, -7 },
  { 19, 6, 7, 6, 0, -7 },
  { 25, 2, 2, 2, 0, -6 },
  { 26, 3, 8, 3, 0, -7 },
  { 29, 3, 8, 3, 0, -7 },
  { 32, 4, 4, 4, 0, -7 },
  { 34, 4, 4, 5, 0, -5 },
  { 36, 2, 2, 2, 0, -1 },
  { 37, 3, 1, 3, 0, -3 },
  { 38, 2, 1, 2, 0, -1 },
  { 39, 4, 7, 4, 0, -7 },
  { 43, 4, 7, 5, 0, -7 },
  { 47, 4, 6, 5, 0, -6 },
  { 50, 4, 7, 5, 0, -7 },
  { 54, 4, 7, 5, 0, -7 },
  { 58, 4, 6, 5, 0, -6 },
  { 61, 4, 6, 5, 0, -6 },
  { 64, 4, 7, 5, 0, -7 },
  { 68, 4, 6, 5, 0, -6 },
  { 71, 4, 7, 5, 0, -7 },
  { 75, 4, 7, 5, 0, -7 },
  { 79, 2, 5, 2, 0, -5 },
  { 81, 2, 6, 2, 0, -5 },
  { 83, 4, 5, 5, 0, -6 },
  { 86, 4, 3, 5, 0, -5 },
  { 88, 4, 5, 5, 0, -6 },
  { 91, 4, 7, 4, 0, -7 },
  { 95, 7, 8, 7, 0, -7 },
  { 102, 5, 6, 5, 0, -6 },
  { 106, 4, 6, 5, 1, -6 },
  { 109, 5, 7, 5, 0, -7 },
  { 114, 4, 6, 6, 1, -6 },
  { 117, 3, 6, 4, 1, -6 },
  { 120, 3, 6, 4, 1, -6 },
  { 123, 5, 7, 6, 0, -7 },
  { 128, 4, 6, 6, 1, -6 },
  { 131, 3, 6, 3, 0, -6 },
  { 134, 3, 8, 3, -1, -6 },
  { 137, 4, 6, 5, 1, -6 },
  { 140, 3, 6, 4, 1, -6 },
  { 143, 6, 6, 8, 1, -6 },
  { 148, 5, 6, 6, 1, -6 },
  { 152, 6, 7, 6, 0, -7 },
  { 158, 4, 6, 5, 1, -6 },
  { 161, 6, 9, 6, 0, -7 },
  { 168, 4, 6, 5, 1, -6 },
  { 171, 4, 7, 4, 0, -7 },
  { 175, 4, 6, 4, 0, -6 },
  { 178, 4, 6, 6, 1, -6 },
  { 181, 5, 6, 5, 0, -6 },
  { 185, 8, 6, 8, 0, -6 },
  { 191, 5, 6, 5, 0, -6 },
  { 195, 5, 6, 5, 0, -6 },
  { 199, 4, 6, 4, 0, -6 },
  { 202, 3, 8, 3, 0, -7 },
  { 205, 4, 7, 4, 0, -7 },
  { 209, 2, 8, 3, 0, -7 },
  { 211, 5, 4, 5, 0, -6 },
  { 214, 4, 1, 4, 0, 1 },
  { 215, 3, 2, 3, 0, -7 },
  { 216, 4, 5, 5, 0, -5 },
  { 219, 4, 7, 5, 1, -7 },
  { 223, 4, 5, 4, 0, -5 },
  { 226, 4, 7, 5, 0, -7 },
  { 230, 4, 5, 5, 0, -5 },
  { 233, 3, 7, 3, 0, -7 },
  { 236, 4, 7, 5, 0, -5 },
  { 240, 4, 7, 5, 1, -7 },
  { 244, 2, 7, 2, 0, -7 },
  { 246, 2, 9, 2, 0, -7 },
  { 249, 4, 7, 5, 1, -7 },
  { 253, 1, 7, 2, 1, -7 },
  { 254, 6, 5, 7, 1, -5 },
  { 258, 4, 5, 5, 1, -5 },
  { 261, 5, 5, 5, 0, -5 },
  { 265, 4, 7, 5, 1, -5 },
  { 269, 4, 7, 5, 0, -5 },
  { 273, 2, 5, 4, 1, -5 },
  { 275, 4, 5, 4, 0, -5 },
  { 278, 3, 6, 3, 0, -6 },
  { 281, 3, 5, 5, 1, -5 },
  { 283, 5, 5, 5, 0, -5 },
  { 287, 7, 5, 7, 0, -5 },
  { 292, 4, 5, 4, 0, -5 },
  { 295, 5, 7, 5, 0, -5 },
  { 300, 4, 5, 4, 0, -5 },
  { 303, 3, 7, 3, 0, -6 },
  { 306, 1, 9, 4, 2, -7 },
  { 308, 3, 7, 3, 0, -6 },
  { 311, 4, 2, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_ExtraBold9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD9PT7B_H_
