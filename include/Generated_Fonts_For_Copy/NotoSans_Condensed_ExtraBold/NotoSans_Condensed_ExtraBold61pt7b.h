#ifndef _NOTOSANS_CONDENSED_EXTRABOLD61PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE,
  0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x3F, 0xCF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xF9, 0xFF,
  0x1F, 0xC0, 0xE0, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x7F,
  0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC,
  0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xC0, 0xFF, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x7F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xF9,
  0xE0, 0xE7, 0xF8, 0xF0, 0x13, 0xFC, 0x78, 0x01, 0xFE, 0x3C, 0x00, 0xFF,
  0x1E, 0x00, 0x7F, 0xCF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xF7, 0xFC, 0x00, 0x79, 0xFE, 0x00, 0x3C,
  0xFF, 0x00, 0x1E, 0x7F, 0xC0, 0x0F, 0x3F, 0xF8, 0x07, 0x9F, 0xFF, 0x03,
  0xDF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x3F,
  0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xE3, 0xF8, 0x1F, 0x00, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0xE0, 0xFF, 0x1F, 0xC7, 0xF0, 0xFF, 0xF0, 0x7F, 0x3F,
  0xC7, 0xF1, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF,
  0x8F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF,
  0x1F, 0xC7, 0xF1, 0xFE, 0x0F, 0xFC, 0x1F, 0xC7, 0xF0, 0xFE, 0x03, 0xF8,
  0x3F, 0x87, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0xFE, 0x00, 0x00,
  0x7F, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0xFE, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0xFF, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0xFE, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x07,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x3F, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0xF1,
  0xFF, 0x87, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF,
  0xF8, 0x3F, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xFD, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC7, 0xFF, 0x80, 0x7F,
  0xFC, 0x0F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFB,
  0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF1, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x0C, 0x0F, 0xE0, 0x31, 0xF0, 0xFC, 0x3E, 0x7F, 0x9F, 0xBF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x03, 0xFD, 0xFF, 0x00,
  0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x03,
  0xE0, 0x01, 0xC0, 0x78, 0x00, 0x18, 0x04, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF3,
  0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC7, 0xFC, 0x7F, 0xC7,
  0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xCF, 0xE0, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0x83,
  0xFE, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xBF,
  0xF0, 0x1F, 0xF7, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFD, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE,
  0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF9, 0xFF, 0x83, 0xFE, 0x1F, 0xF0,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFD, 0xFE, 0x3F, 0xE7,
  0xE1, 0xFF, 0x1E, 0x1F, 0xF8, 0x60, 0xFF, 0xC2, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xC3, 0xFF, 0x8F, 0xC0, 0x7F,
  0xE1, 0xC0, 0x0F, 0xF8, 0x20, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0x03, 0xFF, 0x87, 0x00, 0x7F, 0xE1,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xF4, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0x7F, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xBF, 0xF0, 0x01, 0xFD, 0xFF, 0x80, 0x1F, 0xCF, 0xFC, 0x01,
  0xFE, 0x7F, 0xE0, 0x0F, 0xE3, 0xFF, 0x00, 0xFF, 0x1F, 0xF8, 0x07, 0xF0,
  0xFF, 0xC0, 0x7F, 0x87, 0xFE, 0x03, 0xF8, 0x3F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x83, 0xFC, 0x0F, 0xFC, 0x1F, 0xC0, 0x7F, 0xE1, 0xFE, 0x03, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x18, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x0F,
  0x00, 0x7F, 0x8F, 0xF8, 0x1F, 0xF3, 0xFF, 0xC3, 0xFE, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0x87, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xEF, 0xF8,
  0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0xBF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x7F,
  0xE0, 0xFF, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F,
  0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x3F, 0xE1, 0xFF,
  0x8F, 0xFC, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1,
  0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0xE7, 0xFC, 0x0F, 0xFD, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x9F, 0xF8,
  0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xF7, 0xFC, 0x7F, 0xFC, 0xFF, 0x03,
  0xFF, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x83, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7A, 0x00, 0x00,
  0x1F, 0x0F, 0xF1, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xC7, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0xF1,
  0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC7, 0xF0, 0x38,
  0x00, 0x0F, 0x83, 0xFC, 0x3F, 0xE7, 0xFE, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFE, 0x3F, 0xE1, 0xFC, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x8F,
  0xF0, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0x03, 0xFF,
  0x1C, 0x01, 0xFF, 0x10, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0x1F, 0xC1,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFE, 0x3F, 0x81, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFE, 0x3F, 0x07, 0xFF, 0xFF, 0x07, 0xE7, 0xF0, 0x7F,
  0x87, 0xF0, 0x7F, 0x7F, 0x0F, 0xF0, 0x7F, 0x07, 0xF7, 0xF0, 0xFE, 0x07,
  0xF0, 0x7F, 0x7E, 0x0F, 0xE0, 0x7F, 0x07, 0xF7, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0xE1, 0xFC, 0x07, 0xF0, 0x7F,
  0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0xFE,
  0x1F, 0xC0, 0x7F, 0x07, 0xEF, 0xE1, 0xFC, 0x07, 0xF0, 0x7E, 0xFE, 0x0F,
  0xE0, 0xFF, 0x0F, 0xE7, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x7E, 0x0F, 0xE0,
  0xFF, 0x0F, 0xC7, 0xF0, 0xFF, 0xBF, 0xFB, 0xFC, 0x7F, 0x07, 0xFF, 0xFF,
  0xFF, 0x87, 0xF0, 0x7F, 0xFE, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xCF, 0xFF,
  0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xE0,
  0x00, 0x0E, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x07, 0xFD, 0xFE, 0x00,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xF7, 0xFE, 0x03, 0xFF,
  0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0x7F,
  0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0,
  0x7F, 0xE7, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x07, 0xFF, 0x3F, 0xF0,
  0x1F, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x07, 0xC3,
  0xFF, 0xC0, 0x0C, 0x3F, 0xF8, 0x00, 0x47, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x63, 0xFF, 0xE0, 0x1E, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0x00, 0xFF,
  0xE7, 0xFE, 0x00, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xDF, 0xF8, 0x01, 0xFF,
  0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8,
  0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0,
  0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0xC7, 0xFE, 0x1F,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xF8, 0x7F, 0xFC,
  0x00, 0x20, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0xFF, 0xBF,
  0xF0, 0x01, 0xFF, 0x7F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF,
  0xE0, 0x0F, 0xF9, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xF8, 0x7F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE,
  0x83, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0xFF,
  0xEF, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFC,
  0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x00, 0xFF,
  0xDF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xBF, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x1F, 0xF8, 0x07, 0xFE,
  0x3F, 0xF0, 0x0F, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFD,
  0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xF0,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xEF, 0xFF, 0xFD, 0xFC, 0x01, 0xFD, 0xFF, 0xFF, 0xBF, 0xC0,
  0x7F, 0xBF, 0xFF, 0xF7, 0xF8, 0x0F, 0xF7, 0xFF, 0xFE, 0xFF, 0x01, 0xFC,
  0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0x9F, 0xFF, 0xF9, 0xFE, 0x0F, 0xF3, 0xFF,
  0xFF, 0x3F, 0xC1, 0xFC, 0x7F, 0xFF, 0xE3, 0xF8, 0x3F, 0x8F, 0xFF, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFF, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xFF, 0xF1, 0xFE,
  0x3F, 0x87, 0xFF, 0xFE, 0x1F, 0xCF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFD, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xBF, 0x83, 0xFF, 0xFF, 0x0F, 0xF7, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xEF, 0xFC, 0x1F, 0xFF, 0xF9, 0xFF, 0x07,
  0xFF, 0xFE, 0x7F, 0xE1, 0xFF, 0xFF, 0x8F, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF,
  0x1F, 0xFF, 0xF8, 0x7F, 0xC7, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0x83,
  0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xF8, 0x1F, 0xF3, 0xFF, 0xFE,
  0x07, 0xFE, 0xFF, 0xFF, 0x81, 0xFF, 0xBF, 0xFF, 0xE0, 0x3F, 0xEF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F,
  0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF,
  0xBF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0x8F,
  0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xEF,
  0xFC, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF8, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF8,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF4, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x01, 0xFF,
  0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1,
  0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8,
  0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07,
  0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFC, 0x7F, 0xE0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F,
  0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xF8,
  0xFE, 0x3F, 0xF0, 0x0F, 0x1F, 0xF0, 0x01, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x0B, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFD,
  0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x80, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x34, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0x03, 0xFB, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xBF,
  0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFB, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xBF, 0xC1, 0xFF, 0x00, 0xFF, 0x87, 0xFB, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8,
  0x7F, 0x9F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xF9, 0xFC, 0x3F, 0xE0, 0x07,
  0xF8, 0x7F, 0x1F, 0xC3, 0xFE, 0x00, 0x7F, 0xC7, 0xF1, 0xFE, 0x3F, 0xE0,
  0x07, 0xFC, 0xFF, 0x1F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0xFE, 0x7F,
  0xC0, 0x07, 0xFC, 0xFF, 0x0F, 0xE7, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0xFE,
  0x7F, 0xC0, 0x03, 0xFC, 0xFE, 0x0F, 0xE7, 0xFC, 0x00, 0x3F, 0xCF, 0xE0,
  0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFE, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0xFF,
  0x80, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x3F,
  0xFB, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0x07,
  0xFF, 0x06, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFB, 0xFC, 0xFF, 0xFC, 0x7F, 0x1F, 0xFE, 0x1F, 0xC3, 0xFF,
  0x07, 0xF0, 0x0C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F,
  0x01, 0xFF, 0x1F, 0xF8, 0x3F, 0xEF, 0xFF, 0x87, 0xFD, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFE, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0x81,
  0xFF, 0xBF, 0xFC, 0x7F, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0x9F, 0xFF, 0x0F, 0xF1, 0xFF,
  0xC1, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xF8, 0x1C, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x02, 0x7F,
  0xF0, 0x06, 0x3F, 0xF8, 0x3E, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x01,
  0xFC, 0x1F, 0xF0, 0x3F, 0xF1, 0xFF, 0x07, 0xFF, 0x9F, 0xF0, 0xFF, 0xFD,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0,
  0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F,
  0xE0, 0x3F, 0xF7, 0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0xF0,
  0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0x8F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x07, 0xF9,
  0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x10, 0xFF, 0xC0, 0x0E, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x2E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFC,
  0x10, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF,
  0x07, 0xFF, 0x8F, 0xF0, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F,
  0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0,
  0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFE, 0x07, 0xFF,
  0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0xF0, 0xFF, 0xF9, 0xFF, 0x07, 0xFF, 0x9F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x00, 0x30, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x40, 0x00, 0x3F, 0xE3, 0x00, 0x07,
  0xFE, 0x3F, 0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x7F, 0x01, 0xFF, 0x3F, 0xF8, 0x3F, 0xEF, 0xFF, 0x87,
  0xFB, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFE, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xBF,
  0xF0, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0x1F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0x83, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF,
  0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD,
  0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFC, 0x00, 0xF8, 0x07, 0xF8,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x03,
  0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF1,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF,
  0x0F, 0xFC, 0x03, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x01, 0xFF, 0x9F,
  0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC7, 0xFE,
  0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x07,
  0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0x81,
  0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE,
  0x07, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x03,
  0xFF, 0x3F, 0xE0, 0x1F, 0xF9, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFF,
  0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xF8, 0x03,
  0xFC, 0x1F, 0xC3, 0xFF, 0x81, 0xFF, 0xE3, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE,
  0x7F, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0xFE,
  0x07, 0xF0, 0x1F, 0xC3, 0xFF, 0x83, 0xF8, 0xFF, 0xFC, 0x7F, 0xBF, 0xFF,
  0x8F, 0xF7, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xDF, 0xF8, 0x1F, 0xFB, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0xFC, 0x3F,
  0xF0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0x80,
  0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xFB, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0x3F, 0xE0,
  0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x3F,
  0xF1, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC3, 0xFF, 0x83, 0xFC, 0xFF, 0xF8, 0x7F,
  0x9F, 0xFF, 0x8F, 0xF7, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xDF, 0xF8, 0x1F, 0xFB, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xDF, 0xFC, 0x1F, 0xFB, 0xFF, 0xC7, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFD, 0xFF,
  0xF0, 0xFF, 0x9F, 0xFC, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x07, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0x07, 0xFF, 0x8F, 0xF0, 0xFF, 0xFD,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0,
  0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F,
  0xE0, 0x3F, 0xF7, 0xFE, 0x07, 0xFF, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0xF0,
  0xFF, 0xF9, 0xFF, 0x07, 0xFF, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x00, 0x30,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xCB, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xF0, 0x7C, 0xFF, 0x80,
  0x63, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x30,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0C, 0x00, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x7F, 0xEF, 0xFC, 0x1F, 0xFD,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF7, 0xF8, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF, 0x8F, 0xE0,
  0xFF, 0xC1, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07,
  0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFD, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0x9F, 0xF0, 0x1F, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xF8, 0x0F, 0xF8,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0x0F,
  0xF8, 0x3F, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0x0F, 0xCF, 0xC3, 0xFE, 0x07, 0xFC,
  0x3F, 0x3F, 0x8F, 0xF8, 0x1F, 0xF1, 0xFC, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7,
  0xF3, 0xF8, 0xFF, 0x80, 0xFF, 0x9F, 0xCF, 0xE3, 0xFC, 0x03, 0xFE, 0x7F,
  0x1F, 0x9F, 0xF0, 0x0F, 0xF9, 0xF8, 0x7F, 0x7F, 0xC0, 0x1F, 0xE7, 0xE1,
  0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0x87, 0xF7, 0xF8, 0x01, 0xFE, 0xFE, 0x1F,
  0xDF, 0xE0, 0x07, 0xFB, 0xF8, 0x3F, 0x7F, 0x80, 0x0F, 0xEF, 0xC0, 0xFD,
  0xFE, 0x00, 0x3F, 0xFF, 0x03, 0xF7, 0xF0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFC, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x07, 0xFE,
  0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFE, 0x01,
  0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x07,
  0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x11, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x27, 0xFF, 0x00, 0x05, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xD0, 0x00,
  0x7F, 0xF2, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBold61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 45, 16, 3, -44 },
  { 63, 23, 16, 29, 3, -44 },
  { 109, 32, 44, 34, 1, -44 },
  { 285, 25, 50, 31, 3, -46 },
  { 442, 48, 44, 51, 2, -44 },
  { 706, 38, 45, 40, 2, -44 },
  { 920, 10, 16, 15, 3, -44 },
  { 940, 16, 54, 20, 3, -44 },
  { 1048, 16, 54, 20, 1, -44 },
  { 1156, 27, 26, 29, 1, -46 },
  { 1244, 27, 29, 31, 2, -36 },
  { 1342, 12, 16, 16, 2, -8 },
  { 1366, 16, 9, 19, 2, -21 },
  { 1384, 10, 11, 16, 3, -10 },
  { 1398, 25, 44, 26, 0, -44 },
  { 1536, 27, 45, 31, 2, -44 },
  { 1688, 21, 44, 31, 3, -44 },
  { 1804, 26, 44, 31, 2, -44 },
  { 1947, 26, 45, 31, 2, -44 },
  { 2094, 29, 44, 31, 1, -44 },
  { 2254, 25, 45, 31, 3, -44 },
  { 2395, 27, 45, 31, 2, -44 },
  { 2547, 27, 44, 31, 2, -44 },
  { 2696, 27, 45, 31, 2, -44 },
  { 2848, 27, 45, 31, 2, -44 },
  { 3000, 11, 35, 17, 3, -34 },
  { 3049, 12, 42, 17, 2, -34 },
  { 3112, 27, 30, 31, 2, -37 },
  { 3214, 27, 19, 31, 2, -31 },
  { 3279, 27, 30, 31, 2, -37 },
  { 3381, 24, 45, 25, 0, -44 },
  { 3516, 44, 49, 48, 2, -44 },
  { 3786, 36, 44, 36, 0, -44 },
  { 3984, 29, 44, 35, 4, -44 },
  { 4144, 28, 45, 33, 3, -44 },
  { 4302, 31, 44, 38, 4, -44 },
  { 4473, 22, 44, 29, 4, -44 },
  { 4594, 22, 44, 28, 4, -44 },
  { 4715, 31, 45, 38, 3, -44 },
  { 4890, 31, 44, 40, 4, -44 },
  { 5061, 18, 44, 22, 2, -44 },
  { 5160, 18, 57, 18, -4, -44 },
  { 5289, 31, 44, 35, 4, -44 },
  { 5460, 23, 44, 28, 4, -44 },
  { 5587, 43, 44, 51, 4, -44 },
  { 5824, 34, 44, 42, 4, -44 },
  { 6011, 35, 45, 40, 3, -44 },
  { 6208, 27, 44, 33, 4, -44 },
  { 6357, 35, 54, 40, 3, -44 },
  { 6594, 31, 44, 35, 4, -44 },
  { 6765, 25, 45, 29, 2, -44 },
  { 6906, 28, 44, 30, 1, -44 },
  { 7060, 31, 45, 39, 4, -44 },
  { 7235, 35, 44, 35, 0, -44 },
  { 7428, 52, 44, 51, 0, -44 },
  { 7714, 34, 44, 34, 0, -44 },
  { 7901, 33, 44, 33, 0, -44 },
  { 8083, 27, 44, 30, 1, -44 },
  { 8232, 15, 54, 19, 3, -44 },
  { 8334, 25, 44, 26, 0, -44 },
  { 8472, 15, 54, 19, 1, -44 },
  { 8574, 31, 28, 33, 1, -44 },
  { 8683, 28, 5, 28, 0, 5 },
  { 8701, 17, 10, 21, 2, -47 },
  { 8723, 26, 35, 32, 2, -34 },
  { 8837, 27, 47, 33, 4, -46 },
  { 8996, 24, 35, 27, 2, -34 },
  { 9101, 28, 47, 33, 2, -46 },
  { 9266, 27, 35, 31, 2, -34 },
  { 9385, 21, 47, 21, 1, -47 },
  { 9509, 28, 49, 33, 2, -34 },
  { 9681, 27, 46, 34, 4, -46 },
  { 9837, 10, 47, 17, 3, -47 },
  { 9896, 15, 62, 17, -2, -47 },
  { 10013, 29, 46, 33, 4, -46 },
  { 10180, 9, 46, 16, 4, -46 },
  { 10232, 43, 34, 51, 4, -34 },
  { 10415, 27, 34, 34, 4, -34 },
  { 10530, 29, 35, 33, 2, -34 },
  { 10657, 27, 49, 33, 4, -34 },
  { 10823, 28, 49, 33, 2, -34 },
  { 10995, 19, 34, 24, 4, -34 },
  { 11076, 22, 35, 26, 2, -34 },
  { 11173, 20, 41, 23, 1, -40 },
  { 11276, 27, 35, 34, 3, -34 },
  { 11395, 31, 34, 31, 0, -34 },
  { 11527, 46, 33, 46, 0, -33 },
  { 11717, 30, 33, 30, 0, -33 },
  { 11841, 31, 49, 31, 0, -34 },
  { 12031, 23, 34, 25, 1, -34 },
  { 12129, 20, 54, 23, 1, -44 },
  { 12264, 8, 61, 28, 10, -47 },
  { 12325, 20, 54, 23, 2, -44 },
  { 12460, 27, 11, 31, 2, -27 },
};

const GFXfont NotoSans_Condensed_ExtraBold61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD61PT7B_H_
