#ifndef _NOTOSANS_CONDENSED_EXTRABOLD41PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7,
  0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x0E, 0x3E, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC0, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x8F, 0xFF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7C, 0x01, 0xE3,
  0xE0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01,
  0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x1E,
  0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xE3,
  0xC0, 0x1F, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x7C, 0x03,
  0xE3, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xFF, 0x83,
  0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0xFE, 0xFD, 0xC6, 0x7C, 0xE0,
  0x3E, 0x70, 0x1F, 0xB8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1D, 0xF8,
  0x0E, 0x7E, 0x07, 0x3F, 0x83, 0xBF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0x9F, 0xFF, 0x83, 0xFF, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x3F, 0xE0,
  0x1F, 0x00, 0x7F, 0xF0, 0x1F, 0x00, 0x7F, 0xF0, 0x1E, 0x00, 0x78, 0xF8,
  0x3E, 0x00, 0xF8, 0xF8, 0x3C, 0x00, 0xF8, 0xF8, 0x7C, 0x00, 0xF8, 0xF8,
  0x7C, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF9,
  0xF0, 0x00, 0xF8, 0xF9, 0xF1, 0xF0, 0x78, 0xF9, 0xE3, 0xFC, 0x7D, 0xF3,
  0xE7, 0xFE, 0x7F, 0xF3, 0xCF, 0xFE, 0x3F, 0xE7, 0xCF, 0x9F, 0x1F, 0xC7,
  0xCF, 0x9F, 0x07, 0x0F, 0x8F, 0x1F, 0x00, 0x0F, 0x9F, 0x1F, 0x00, 0x1F,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x1E, 0x1F, 0x1F, 0x00, 0x3E,
  0x0F, 0x1F, 0x00, 0x3C, 0x0F, 0x1F, 0x00, 0x7C, 0x0F, 0x9F, 0x00, 0x7C,
  0x0F, 0xFE, 0x00, 0xF8, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFC, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE7, 0xF0, 0x01, 0xF0, 0xFC,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xFB,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x83, 0xF8, 0x7F, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x1F, 0xFF, 0x9F,
  0xC7, 0xE7, 0xF7, 0xE3, 0xF8, 0xFF, 0xF8, 0xFE, 0x3F, 0xFE, 0x3F, 0x87,
  0xFF, 0x0F, 0xE0, 0xFF, 0xC3, 0xF8, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x7F,
  0x03, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x7D, 0xF0,
  0x07, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81,
  0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F,
  0x03, 0xF0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC0,
  0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x41, 0xE0, 0x9E, 0x79, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xCF, 0x87,
  0xF3, 0xF0, 0x78, 0x78, 0x0E, 0x1C, 0x01, 0x04, 0x00, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0xFC, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00,
  0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE7, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83,
  0xF7, 0xE1, 0xFD, 0xFC, 0x7E, 0x3F, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F,
  0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0xFE, 0xFD, 0xF3,
  0xF3, 0x8F, 0xC4, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3,
  0xC3, 0xF8, 0xE0, 0x7E, 0x10, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x07, 0xFF, 0x07, 0xFF,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0x83, 0xF8, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00,
  0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0x9F, 0x81, 0xF3, 0xF0, 0x7C, 0x7E, 0x0F,
  0x8F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x1F, 0x07, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x0F, 0xFF,
  0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFC, 0x73, 0xFF, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x87, 0xFF,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x3F, 0x07, 0xDF, 0xF0, 0xFB, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFF, 0x1F, 0xDF, 0xC1, 0xFB, 0xF8, 0x3F, 0x7F, 0x07,
  0xFF, 0xE0, 0xFE, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF8, 0x7E, 0x7F, 0x1F,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x80,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFE, 0x7F, 0x9F, 0x87, 0xF3,
  0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF8, 0xFC, 0x7E, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07,
  0xFF, 0xF1, 0xFC, 0xFE, 0x3F, 0x0F, 0xEF, 0xE0, 0xFD, 0xF8, 0x1F, 0xBF,
  0x01, 0xFF, 0xE0, 0x7E, 0xFE, 0x0F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0xC0, 0x03, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xE7, 0xF1, 0xFB, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x87, 0xF7, 0xF3, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1,
  0xFE, 0xFC, 0x3F, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xF8, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00,
  0x1C, 0x3F, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x1E, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0xF8,
  0x7F, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x30, 0x3F, 0x20, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0x7C, 0x3C, 0x0F, 0xF1, 0xF3, 0xE1, 0xFF, 0xCF, 0x9E, 0x1F, 0xFE, 0x3D,
  0xF1, 0xFF, 0xF1, 0xEF, 0x8F, 0x8F, 0x8F, 0xF8, 0xF8, 0x7C, 0x7F, 0xC7,
  0xC3, 0xE3, 0xFE, 0x3E, 0x1F, 0x1F, 0xF1, 0xF0, 0xF8, 0xFF, 0x8F, 0x87,
  0xC7, 0xFC, 0x7C, 0x3E, 0x3D, 0xE3, 0xE1, 0xF1, 0xEF, 0x1F, 0x1F, 0x9F,
  0x78, 0x7D, 0xFE, 0xF3, 0xE3, 0xFF, 0xFF, 0x9F, 0x0F, 0xF7, 0xF8, 0x78,
  0x3F, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xF7, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xE7, 0xE0, 0x07,
  0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x0F, 0xE3, 0xF0, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF8, 0x1F, 0xC1, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0x7E, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8,
  0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0,
  0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFC, 0x7F, 0xDF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE1, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xF0,
  0x73, 0xFC, 0x02, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x02, 0x3F, 0xC3, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7E, 0x1F, 0xF3,
  0xF0, 0x3F, 0x9F, 0x81, 0xFE, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0x00,
  0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F,
  0xEF, 0xC0, 0x7F, 0x7E, 0x07, 0xF3, 0xF0, 0x7F, 0x9F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF,
  0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0x01, 0x8F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xFC, 0x07, 0xEF, 0xF0, 0x3F, 0x3F, 0xC1,
  0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xE1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF,
  0xFC, 0xFF, 0x8F, 0xE0, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x03, 0xF9,
  0xF8, 0x3F, 0xCF, 0xC1, 0xFC, 0x7E, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x8F,
  0xE0, 0xFC, 0xFF, 0x07, 0xE7, 0xF0, 0x3F, 0x7F, 0x01, 0xFB, 0xF8, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0x9F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8, 0x7E,
  0x1F, 0xC3, 0xF0, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F,
  0x3F, 0x03, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x80, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7D, 0xFF,
  0xFE, 0x07, 0xDF, 0xFF, 0xF0, 0x7F, 0xFF, 0xDF, 0x0F, 0xBF, 0xFD, 0xF0,
  0xFB, 0xFF, 0xDF, 0x0F, 0xBF, 0xFD, 0xF8, 0xFB, 0xFF, 0xCF, 0x9F, 0x3F,
  0xFC, 0xF9, 0xF3, 0xFF, 0xCF, 0xDF, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFE, 0x3F, 0xFC, 0x7F, 0xE3, 0xFF, 0xC7, 0xFE, 0x3F, 0xFC, 0x3F, 0xC3,
  0xFF, 0xC3, 0xFC, 0x3F, 0xFC, 0x3F, 0xC3, 0xFF, 0xC3, 0xFC, 0x3F, 0xFC,
  0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xF0, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F,
  0xF7, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xEF, 0xC3, 0xFF, 0xDF, 0xC7, 0xFF,
  0x9F, 0x8F, 0xFF, 0x3F, 0x9F, 0xFE, 0x3F, 0x3F, 0xFC, 0x7F, 0x7F, 0xF8,
  0x7E, 0xFF, 0xF0, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFD,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0,
  0x1F, 0xDF, 0xC0, 0x7F, 0x3F, 0xC0, 0xFE, 0x3F, 0xC7, 0xFC, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0x0F, 0xEF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x1F, 0xE0, 0xFF, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFD, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0xC0,
  0x7F, 0x3F, 0xC0, 0xFE, 0x3F, 0xC7, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xC3, 0xFC, 0xFC, 0x1F, 0xCF,
  0xC1, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC,
  0xFC, 0x7F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFC, 0xFE, 0x0F, 0xC7, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x8F, 0xC1, 0xFC, 0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0xFC,
  0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xF0, 0x01, 0xF0, 0x07, 0xFF, 0x07,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xF9, 0xFC, 0x3C, 0xFC, 0x02,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE,
  0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x01, 0xFC,
  0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x83, 0xF8, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x07, 0xEF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xFF, 0xC0, 0x7E, 0x01, 0xFB, 0xF8, 0x0F, 0xE0, 0x3F, 0x3F, 0x01,
  0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x81, 0xFC, 0xFC, 0x0F, 0xF0, 0x3F, 0x1F,
  0x81, 0xFE, 0x07, 0xE1, 0xF8, 0x3F, 0xE0, 0xFC, 0x3F, 0x07, 0xFC, 0x1F,
  0x87, 0xE1, 0xFF, 0x87, 0xF0, 0xFC, 0x3E, 0xF0, 0xFC, 0x1F, 0x87, 0xDE,
  0x1F, 0x81, 0xF8, 0xFB, 0xE3, 0xF0, 0x3F, 0x1F, 0x7C, 0x7E, 0x07, 0xE7,
  0xCF, 0x9F, 0xC0, 0xFC, 0xF9, 0xF3, 0xF0, 0x1F, 0x9F, 0x3E, 0x7E, 0x01,
  0xF3, 0xE3, 0xEF, 0xC0, 0x3F, 0x7C, 0x7D, 0xF8, 0x07, 0xFF, 0x0F, 0xBF,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0xFE, 0x07, 0xF0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF8, 0xFC, 0x03, 0xF3, 0xF8,
  0x07, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xE3,
  0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F,
  0xEF, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xE7, 0xF0, 0x3F,
  0x8F, 0xC0, 0xFE, 0x3F, 0x83, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x7E, 0x07,
  0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xC7,
  0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xFC, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x8F,
  0x80, 0x7C, 0xFC, 0x03, 0xF7, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0x07, 0xF1, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC1, 0xFF,
  0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF7, 0xFD, 0xFF, 0xFF, 0x7F,
  0xF7, 0xCF, 0xF9, 0xF1, 0xFC, 0x7C, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x3C, 0x1F, 0xDF, 0xE3, 0xF7, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFD, 0xFF, 0x7F, 0xBF, 0xC3, 0xF7, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xDF, 0xE3, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xF9, 0xFB, 0xFE, 0x3F, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xFC,
  0x7F, 0xF9, 0xFF, 0xF7, 0xFF, 0xCF, 0xE3, 0xBF, 0x81, 0x7F, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFE, 0x03, 0xFE, 0x0D, 0xFF, 0xFB, 0xFF, 0xF3, 0xFF, 0xE3,
  0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x0F, 0x8F,
  0xC7, 0xFB, 0xF3, 0xFE, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xE1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F,
  0xFF, 0x87, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xF9, 0xF1,
  0xFC, 0x7C, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x1F, 0x87, 0xEF, 0xC1, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x47, 0xFD, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xE1, 0xFF, 0xC3, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFC, 0x7F,
  0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC3, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0x87, 0xC7, 0xF9, 0xF3, 0xFE, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFB, 0xF1, 0xFC, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF4, 0x01, 0xFD, 0xF1, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF,
  0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x7C, 0x1F, 0x9F, 0xE3, 0xF7, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0x7F, 0xBF, 0xC3, 0xF7, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x7D, 0xFF,
  0xFF, 0xF7, 0xE7, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0xEF, 0xEF, 0xFD, 0xFF, 0xBF, 0xE7, 0xF8, 0x7C, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xFF, 0xE0, 0x7E,
  0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x7F,
  0x0F, 0xEF, 0xE0, 0xFE, 0xFC, 0x0F, 0xFF, 0x80, 0xFD, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE3, 0xF0, 0xFE,
  0x3F, 0x8F, 0xE1, 0xF8, 0xFE, 0x1F, 0xCF, 0xE0, 0xFC, 0xFE, 0x0F, 0xEF,
  0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x7E, 0x07,
  0xC3, 0xF3, 0xFC, 0x7F, 0xCF, 0xDF, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0xFF, 0xEF, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF,
  0x83, 0xF8, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xE0,
  0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0x3F, 0xFE, 0x0F, 0xC0, 0xFF, 0xF8, 0x3F,
  0x03, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0x3F, 0xFE, 0x0F, 0xC0,
  0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0x3F,
  0xFE, 0x0F, 0xC0, 0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xE0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x7C, 0x1F, 0x9F, 0xE3, 0xF7, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0x7F, 0xBF, 0xC3, 0xF7, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x03, 0xF0, 0x01, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFE, 0x7F, 0x3F, 0x87, 0xF7,
  0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFE, 0x0F, 0xCF,
  0xC3, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01,
  0xFE, 0x00, 0xF8, 0x7C, 0x1F, 0x9F, 0xE3, 0xF7, 0xFE, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFD, 0xFF, 0x3F, 0xBF, 0x83, 0xF7, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xDF, 0xF9, 0xF9, 0xFE, 0x3F, 0x9F, 0x87, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x87, 0xC7,
  0xF9, 0xF3, 0xFE, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xE1,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFB, 0xF1, 0xFC,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0xF8, 0x3F, 0xE3, 0xEF, 0xDF, 0xBF, 0x7E, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBF, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0xF8, 0xFF, 0xFB, 0xFF,
  0xE7, 0xFF, 0xDF, 0xC3, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x1F, 0xFC,
  0x00, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0xC4, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0xFF, 0xC1, 0xFE, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xDF,
  0xC7, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xF7, 0xCF, 0xFD, 0xF1, 0xFC,
  0x7C, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x0F, 0xE7,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x3F, 0x00, 0xF9, 0xF8, 0x07,
  0xEF, 0xC0, 0x3F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x7E, 0xFC, 0x1F, 0xC1, 0xFD, 0xF8, 0x3F,
  0x83, 0xF3, 0xF0, 0xFF, 0x87, 0xE7, 0xE1, 0xFF, 0x0F, 0xCF, 0xC3, 0xFE,
  0x1F, 0x8F, 0xC7, 0xBC, 0x7E, 0x1F, 0x8F, 0x78, 0xFC, 0x3F, 0x3E, 0xF9,
  0xF8, 0x7E, 0x7D, 0xF3, 0xF0, 0x7C, 0xFB, 0xE7, 0xC0, 0xFD, 0xE3, 0xDF,
  0x81, 0xFB, 0xC7, 0xBF, 0x03, 0xF7, 0x8F, 0x7E, 0x03, 0xFF, 0x1F, 0xF8,
  0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF7, 0xF0,
  0x7E, 0x7F, 0x0F, 0xE3, 0xF8, 0xFC, 0x3F, 0x9F, 0xC1, 0xF9, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x81, 0xF9, 0xF8, 0x3F, 0x9F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F,
  0xE7, 0xF0, 0x7E, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0x9F,
  0x80, 0xFC, 0xFC, 0x0F, 0xE7, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x87, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x1F,
  0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0,
  0xFF, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x1F, 0xF0, 0xFF, 0x07, 0xE0, 0x3F, 0xC1,
  0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFF, 0x07, 0xF8, 0x3F,
  0xC0, 0xFE, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x03,
  0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x3C, 0x00, 0x3F, 0x00, 0x2F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xA0, 0x0F,
  0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraBold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 29, 11, 2, -29 },
  { 27, 15, 10, 19, 2, -29 },
  { 46, 21, 29, 23, 1, -29 },
  { 123, 17, 33, 21, 2, -31 },
  { 194, 32, 30, 34, 1, -30 },
  { 314, 26, 30, 27, 1, -30 },
  { 412, 6, 10, 10, 2, -29 },
  { 420, 11, 36, 13, 2, -30 },
  { 470, 11, 36, 13, 1, -30 },
  { 520, 18, 18, 20, 1, -31 },
  { 561, 18, 19, 21, 1, -24 },
  { 604, 8, 11, 11, 1, -5 },
  { 615, 11, 6, 13, 1, -14 },
  { 624, 7, 7, 11, 2, -7 },
  { 631, 17, 30, 17, 0, -30 },
  { 695, 18, 30, 21, 1, -30 },
  { 763, 14, 29, 21, 2, -29 },
  { 814, 18, 30, 21, 1, -30 },
  { 882, 18, 30, 21, 1, -30 },
  { 950, 19, 29, 21, 1, -29 },
  { 1019, 17, 29, 21, 2, -29 },
  { 1081, 19, 30, 21, 1, -30 },
  { 1153, 18, 29, 21, 1, -29 },
  { 1219, 19, 30, 21, 1, -30 },
  { 1291, 18, 30, 21, 1, -30 },
  { 1359, 7, 23, 11, 2, -23 },
  { 1380, 8, 29, 11, 1, -23 },
  { 1409, 18, 20, 21, 1, -25 },
  { 1454, 18, 13, 21, 1, -21 },
  { 1484, 19, 20, 21, 1, -25 },
  { 1532, 16, 30, 17, 0, -30 },
  { 1592, 29, 33, 32, 2, -30 },
  { 1712, 24, 29, 24, 0, -29 },
  { 1799, 19, 29, 24, 3, -29 },
  { 1868, 19, 30, 22, 2, -30 },
  { 1940, 21, 29, 25, 3, -29 },
  { 2017, 14, 29, 19, 3, -29 },
  { 2068, 14, 29, 19, 3, -29 },
  { 2119, 21, 30, 26, 2, -30 },
  { 2198, 21, 29, 27, 3, -29 },
  { 2275, 13, 29, 15, 1, -29 },
  { 2323, 12, 38, 12, -3, -29 },
  { 2380, 21, 29, 24, 3, -29 },
  { 2457, 15, 29, 19, 3, -29 },
  { 2512, 28, 29, 34, 3, -29 },
  { 2614, 23, 29, 29, 3, -29 },
  { 2698, 23, 30, 27, 2, -30 },
  { 2785, 18, 29, 22, 3, -29 },
  { 2851, 23, 37, 27, 2, -30 },
  { 2958, 20, 29, 23, 3, -29 },
  { 3031, 17, 30, 19, 1, -30 },
  { 3095, 18, 29, 20, 1, -29 },
  { 3161, 20, 29, 26, 3, -29 },
  { 3234, 24, 29, 24, 0, -29 },
  { 3321, 35, 29, 35, 0, -29 },
  { 3448, 23, 29, 23, 0, -29 },
  { 3532, 22, 29, 22, 0, -29 },
  { 3612, 18, 29, 20, 1, -29 },
  { 3678, 10, 37, 13, 2, -30 },
  { 3725, 17, 30, 17, 0, -30 },
  { 3789, 10, 37, 13, 1, -30 },
  { 3836, 21, 18, 22, 1, -29 },
  { 3884, 19, 4, 18, 0, 3 },
  { 3894, 10, 6, 14, 2, -31 },
  { 3902, 18, 23, 21, 1, -23 },
  { 3954, 19, 31, 23, 2, -31 },
  { 4028, 15, 23, 18, 2, -23 },
  { 4072, 18, 31, 23, 2, -31 },
  { 4142, 18, 23, 21, 2, -23 },
  { 4194, 15, 31, 14, 0, -31 },
  { 4253, 18, 33, 23, 2, -23 },
  { 4328, 19, 31, 23, 2, -31 },
  { 4402, 7, 31, 11, 2, -31 },
  { 4430, 11, 41, 11, -2, -31 },
  { 4487, 20, 31, 22, 2, -31 },
  { 4565, 7, 31, 11, 2, -31 },
  { 4593, 30, 23, 34, 2, -23 },
  { 4680, 19, 23, 23, 2, -23 },
  { 4735, 19, 23, 22, 2, -23 },
  { 4790, 19, 33, 23, 2, -23 },
  { 4869, 18, 33, 23, 2, -23 },
  { 4944, 14, 23, 16, 2, -23 },
  { 4985, 15, 23, 17, 1, -23 },
  { 5029, 13, 27, 15, 1, -27 },
  { 5073, 18, 23, 23, 2, -23 },
  { 5125, 21, 23, 21, 0, -23 },
  { 5186, 31, 23, 31, 0, -23 },
  { 5276, 20, 23, 20, 0, -23 },
  { 5334, 21, 33, 21, 0, -23 },
  { 5421, 15, 23, 17, 1, -23 },
  { 5465, 13, 36, 15, 1, -29 },
  { 5524, 5, 40, 19, 7, -31 },
  { 5549, 14, 36, 15, 1, -29 },
  { 5612, 19, 7, 21, 1, -18 },
};

const GFXfont NotoSans_Condensed_ExtraBold41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD41PT7B_H_
