#ifndef _NOTOSANS_CONDENSED_EXTRABOLD30PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0,
  0x00, 0x39, 0xEF, 0xFF, 0x78, 0xF9, 0xF7, 0x9F, 0x79, 0xF7, 0x9E, 0x79,
  0xE7, 0x8E, 0x78, 0xE0, 0x07, 0x38, 0x1E, 0x70, 0x3C, 0xE0, 0x71, 0xC0,
  0xE7, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0xE0, 0x73,
  0xC0, 0xE7, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9E, 0x70, 0x38, 0xE0,
  0x73, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x00, 0x03, 0x00, 0x18, 0x01,
  0xE0, 0x7F, 0xF7, 0xFF, 0x3F, 0xFB, 0xEC, 0xDE, 0x60, 0xFB, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x6F, 0x03, 0x7E,
  0x1B, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x0F, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x00, 0xFC, 0x07, 0x81, 0xFC, 0x0E, 0x07, 0xBC, 0x3C,
  0x0F, 0x78, 0x70, 0x1C, 0x71, 0xE0, 0x38, 0xE3, 0x80, 0x71, 0xCF, 0x00,
  0xE3, 0x9E, 0x01, 0xEF, 0x39, 0xF3, 0xDE, 0xF7, 0xF3, 0xF9, 0xCF, 0xF3,
  0xF7, 0xBD, 0xE1, 0x0E, 0x79, 0xC0, 0x3C, 0xE3, 0x80, 0x71, 0xC7, 0x01,
  0xE3, 0x8E, 0x03, 0xC7, 0x9C, 0x07, 0x0F, 0x78, 0x1E, 0x0F, 0xF0, 0x38,
  0x1F, 0xC0, 0xF0, 0x1F, 0x00, 0x03, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xCF, 0x80, 0x78, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0x80,
  0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x1F, 0x1F, 0xE3, 0xE7, 0xFE, 0xF9,
  0xF7, 0xDF, 0x3E, 0x7F, 0xE7, 0xC7, 0xF8, 0xF8, 0x7F, 0x1F, 0x0F, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0x9F, 0xC0, 0xFB, 0xDE,
  0xF7, 0xBD, 0xE0, 0x0F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x78,
  0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78,
  0x3C, 0x3C, 0x3E, 0x1E, 0x0F, 0x0F, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3E,
  0x00, 0x0F, 0x00, 0x78, 0x03, 0xC1, 0x0E, 0x2F, 0x77, 0x7F, 0xFF, 0xFF,
  0xE3, 0xF0, 0x1F, 0x81, 0xFE, 0x1F, 0x78, 0xF3, 0xE1, 0x8C, 0x00, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x7D, 0xE7, 0x9E, 0x7B, 0xCF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xEF,
  0xFF, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x07,
  0x00, 0xFE, 0x0F, 0xF8, 0xFF, 0xE7, 0xDF, 0x3C, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFB, 0xC7, 0x9F, 0xFC, 0x7F, 0xE3, 0xFE, 0x0F, 0xE0, 0x03,
  0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFF, 0xFF, 0xDE, 0xF9, 0x9F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x01, 0xFE, 0x1F, 0xF9, 0xFF, 0xE7, 0x9F,
  0x30, 0x78, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x03, 0xFF, 0x3F, 0xFC, 0xFF, 0xE7, 0x1F,
  0x20, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0xFF, 0x07, 0xE0, 0x3F, 0xC1,
  0xFF, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFE, 0x3F, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0x7C, 0x1E, 0xF8, 0x39, 0xF0, 0xF3,
  0xE3, 0xC7, 0xC7, 0x8F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0xF3, 0xFF, 0x9F,
  0xFC, 0xFF, 0xE7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xE3, 0xFF,
  0x9F, 0xFC, 0x43, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x81, 0xFF,
  0xFF, 0xBF, 0xFD, 0xFF, 0xC7, 0xF8, 0x00, 0x01, 0xF0, 0x7F, 0x87, 0xFC,
  0x7F, 0xE3, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF3, 0xE7, 0xBF, 0xBF,
  0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7B, 0xC7,
  0xDF, 0xFE, 0x7F, 0xE3, 0xFE, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xFF, 0x1F, 0xFC, 0xFF,
  0xE7, 0x8F, 0xFC, 0x7D, 0xE3, 0xEF, 0x1E, 0x7F, 0xF1, 0xFF, 0x07, 0xF0,
  0x7F, 0xC7, 0xFF, 0x3E, 0xFB, 0xE3, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF,
  0x3E, 0xFF, 0xF7, 0xFF, 0x0F, 0xE0, 0x07, 0x01, 0xFE, 0x1F, 0xF8, 0xFF,
  0xEF, 0xDF, 0x7C, 0x7F, 0xE3, 0xFE, 0x0F, 0xF0, 0x7F, 0xC7, 0xFE, 0x7F,
  0xFF, 0xF7, 0xFF, 0x9F, 0xBC, 0x71, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x9F,
  0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0x80, 0x31, 0xEF, 0xDF, 0x78, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x39, 0xEF, 0xDF, 0x78, 0x31, 0xE7, 0xDF, 0x78, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xDE, 0x79, 0xEF, 0x3C, 0xF0, 0x00,
  0x08, 0x01, 0xC0, 0x7E, 0x0F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x1F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0x80, 0x0C, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xC0, 0x07, 0x80, 0x3F, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x07, 0xE0, 0x1F, 0x07, 0xF8, 0xFF, 0x1F, 0xE1, 0xFC, 0x0F, 0x80,
  0x70, 0x02, 0x00, 0x00, 0x0F, 0x07, 0xFC, 0xFF, 0xE7, 0xFF, 0x71, 0xF4,
  0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xE0, 0xF8,
  0x1E, 0x00, 0xF0, 0xF0, 0x01, 0xC3, 0x87, 0xF7, 0x9E, 0x7F, 0xCE, 0x71,
  0xFF, 0x39, 0xCF, 0x3C, 0xEF, 0x38, 0xF3, 0xFC, 0xE3, 0xCF, 0xE3, 0x8F,
  0x3B, 0x8E, 0x3C, 0xEE, 0x38, 0xF3, 0xBC, 0xF7, 0xDE, 0x73, 0xFB, 0xF1,
  0xC7, 0xEF, 0x87, 0x82, 0x0C, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x7F,
  0x7E, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x78, 0x78, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7C, 0x0F, 0x9F, 0x03, 0xE7,
  0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xC0, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF,
  0xBE, 0x7F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xBE, 0x3E, 0xFF, 0xF3, 0xFF,
  0x8F, 0xFF, 0x3F, 0xFE, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC0, 0x01, 0xE0, 0x1F, 0xF1,
  0xFF, 0xCF, 0xFF, 0x3F, 0x39, 0xF8, 0x17, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x13, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0xFF,
  0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x0F, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x3E, 0xF8, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFB, 0xFF, 0x7F,
  0xEF, 0xFD, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0x00, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x8E, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0x78, 0xFF, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E,
  0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3F, 0xFE, 0xFF, 0x7F, 0x3F, 0x04, 0x00, 0xF8, 0x3F, 0xF0,
  0xFB, 0xE3, 0xF7, 0xC7, 0xCF, 0x9F, 0x1F, 0x3E, 0x3E, 0xF8, 0x7D, 0xF0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x3E, 0x3E,
  0x7C, 0x7C, 0x7C, 0xF8, 0xF9, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3, 0xFF, 0x83,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xDC, 0x1D,
  0xFE, 0xF1, 0xEF, 0xF7, 0x8F, 0x7F, 0xBC, 0x7B, 0xFC, 0xF3, 0x9F, 0xE7,
  0xBC, 0xFF, 0x3D, 0xE7, 0xF9, 0xEE, 0x3F, 0xC7, 0xF1, 0xFE, 0x3F, 0x8F,
  0xF1, 0xFC, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F,
  0x07, 0x80, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xEF, 0x9F, 0xF7, 0xCF, 0xF9, 0xE7, 0xFC,
  0xFB, 0xFE, 0x3C, 0xFF, 0x1F, 0x7F, 0x87, 0xBF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xF8, 0x01,
  0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x3F, 0x1F, 0x87,
  0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C,
  0x0F, 0x9F, 0x87, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0xC7, 0xFF, 0xBF, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xDF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFC, 0x7F, 0x83,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x3F, 0x1F,
  0x87, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x7C, 0x0F, 0x9F, 0x87, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xDF, 0xCF, 0x8F, 0x9F, 0x0F,
  0x3E, 0x1E, 0x7C, 0x7C, 0xF8, 0xF9, 0xFF, 0xE3, 0xFF, 0xC7, 0xFE, 0x0F,
  0xFE, 0x1F, 0x7C, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8, 0xF9, 0xF1, 0xF3, 0xE1,
  0xF7, 0xC3, 0xEF, 0x83, 0xE0, 0x07, 0x03, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF,
  0xEF, 0x82, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xE7, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x00, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x7E, 0xFF, 0xF9, 0xFF,
  0xF1, 0xFF, 0xC1, 0xFE, 0x00, 0xF8, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xCF,
  0x83, 0xE7, 0xC1, 0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0x7C, 0x7C, 0x3E, 0x3E,
  0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xEF, 0x80, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D,
  0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0xF8, 0x3E, 0x07, 0xFC, 0x1F, 0x07, 0xDE, 0x0F, 0x83, 0xEF,
  0x07, 0xC1, 0xF7, 0x83, 0xF0, 0xF3, 0xE3, 0xF8, 0x79, 0xF1, 0xFC, 0x7C,
  0x78, 0xEE, 0x3E, 0x3C, 0x77, 0x9E, 0x1E, 0x7B, 0xCF, 0x0F, 0xBD, 0xE7,
  0x87, 0xDE, 0xF7, 0xC1, 0xEF, 0x3B, 0xE0, 0xF7, 0x1D, 0xE0, 0x7B, 0x8F,
  0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE3, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x3E, 0x1F,
  0x0F, 0x8F, 0x87, 0xCF, 0x81, 0xF7, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3E, 0xF8, 0x3E, 0x7C, 0x1F, 0x1F, 0x1F, 0x0F,
  0x8F, 0x83, 0xEF, 0x81, 0xF8, 0xF8, 0x1F, 0x7C, 0x1E, 0x7C, 0x3E, 0x3C,
  0x3E, 0x3E, 0x7C, 0x1E, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF, 0xF8, 0xF0, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E, 0x78, 0x1C,
  0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x78, 0x1E, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x7C, 0x3E, 0x1E, 0x07, 0x07, 0x83, 0xFF, 0x0F,
  0xFC, 0x7F, 0xE3, 0x0F, 0x80, 0x7C, 0x03, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0xFF, 0xFF, 0xEF, 0xEF, 0x3E, 0x78,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC7, 0x1E,
  0xFC, 0xFF, 0xF7, 0xFF, 0xBE, 0x3F, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0xC7, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB,
  0xDF, 0x80, 0x07, 0xC1, 0xFF, 0x3F, 0xE7, 0xFE, 0x7C, 0x2F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x17, 0xFE, 0x7F,
  0xE3, 0xFE, 0x1F, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0xE7, 0xCF, 0xDF, 0x7F, 0xFD, 0xFF, 0xF7, 0xCF, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xDF, 0xFF, 0x7F, 0xFC, 0xFE, 0xF1, 0xF3, 0xC0, 0x07, 0x80, 0xFF,
  0x0F, 0xFC, 0xFF, 0xE7, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xF0, 0x07, 0x80, 0xBE, 0x19, 0xFF, 0xC7, 0xFE, 0x0F,
  0xF0, 0x07, 0xC3, 0xFC, 0x7F, 0x8F, 0xE3, 0xE0, 0x7C, 0x0F, 0x83, 0xFE,
  0xFF, 0xDF, 0xF8, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x0E, 0x3C, 0xFC,
  0xF7, 0xFF, 0xDF, 0xFF, 0x7C, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7D, 0xFF, 0xF7, 0xFF, 0xCF,
  0xFF, 0x1F, 0x7C, 0x01, 0xF0, 0x07, 0xD0, 0x3E, 0x7F, 0xF9, 0xFF, 0xC7,
  0xFF, 0x0F, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xCF, 0x1E, 0xFC, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xF1, 0xFF, 0x8F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xE0, 0xF7, 0xBF, 0xE6, 0x03, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x1E, 0x1E, 0x1F, 0x1E,
  0x0C, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0xFE, 0xFE,
  0xFC, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x3E, 0xF0, 0xFB, 0xC7, 0xCF, 0x3E, 0x3C, 0xF8, 0xF7,
  0xC3, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xEF, 0x8F, 0x1F, 0x3C,
  0x7C, 0xF0, 0xFB, 0xC1, 0xFF, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xC1, 0xC7, 0xBF, 0xBF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xCF, 0xFC, 0x7C, 0x7F, 0xE3,
  0xE1, 0xFE, 0x1F, 0x0F, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1F,
  0xE1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x7C, 0x3F, 0xC3, 0xE1, 0xFE, 0x1F,
  0x0F, 0xF0, 0xF8, 0x78, 0xE3, 0xC7, 0xBF, 0xBF, 0xFD, 0xFF, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xF8, 0x07, 0x80, 0x7F, 0x83,
  0xFF, 0x1F, 0xFE, 0x7C, 0xFB, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x78, 0x7D, 0xFB, 0xE3, 0xFF, 0x8F, 0xFC,
  0x0F, 0xE0, 0xE3, 0xC7, 0xBF, 0x3F, 0xFD, 0xFF, 0xEF, 0x8F, 0xFC, 0x7F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF1, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xDE, 0xFE, 0xF3, 0xE7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0x0E, 0x3C, 0xFC, 0xF7, 0xFF, 0xDF, 0xFF,
  0x7C, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7D, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xE1,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0xFD, 0xFF, 0x7F,
  0xEF, 0x05, 0xF0, 0x3F, 0x03, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x81, 0xF8,
  0x3F, 0xEF, 0xFF, 0xF7, 0xFE, 0xFF, 0x00, 0x0E, 0x07, 0x81, 0xE0, 0x78,
  0x7F, 0xFF, 0xFF, 0xFC, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3F, 0xC7, 0xF1, 0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xEF, 0xEF, 0x3E, 0x78,
  0xF8, 0x3F, 0xF0, 0x7D, 0xE0, 0xF3, 0xE1, 0xE7, 0xC7, 0xC7, 0x8F, 0x8F,
  0x1E, 0x1F, 0x3C, 0x1E, 0xF8, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x80, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x7C, 0x3E, 0xF1,
  0xF8, 0x79, 0xE3, 0xF9, 0xF3, 0xE7, 0xF3, 0xE7, 0xCE, 0xE7, 0x87, 0x9D,
  0xCF, 0x0F, 0x7B, 0x9E, 0x1E, 0xF7, 0x7C, 0x3D, 0xCF, 0xF0, 0x3F, 0x9F,
  0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x03, 0xF8, 0xFC,
  0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0xFC, 0x7C, 0xF8, 0xF0, 0xFB, 0xE1,
  0xF7, 0x81, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xC1, 0xF7, 0x83, 0xEF, 0x8F, 0x8F, 0x1F, 0x1F, 0x7C, 0x3F,
  0xF8, 0x3F, 0xF0, 0x7D, 0xE0, 0xF3, 0xE1, 0xE7, 0xC7, 0xC7, 0x8F, 0x8F,
  0x1E, 0x1F, 0x3C, 0x1E, 0xF8, 0x3D, 0xE0, 0x7B, 0xC0, 0x7F, 0x80, 0xFE,
  0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x41, 0xF0,
  0xFC, 0x3F, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0xFC,
  0xFE, 0x3E, 0x0F, 0xE1, 0xFC, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3F, 0x0F, 0xC1, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E,
  0x0F, 0xC3, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0,
  0x7C, 0x1F, 0xC1, 0xF1, 0xFC, 0x7E, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC3, 0xF0, 0xFC, 0x3F, 0x0E, 0x00, 0x7E, 0x0F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xF8, 0x1F, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 21, 8, 1, -21 },
  { 17, 12, 7, 14, 1, -21 },
  { 28, 15, 21, 17, 1, -21 },
  { 68, 13, 25, 15, 1, -23 },
  { 109, 23, 22, 25, 1, -22 },
  { 173, 19, 22, 19, 1, -22 },
  { 226, 5, 7, 8, 1, -21 },
  { 231, 8, 27, 10, 1, -22 },
  { 258, 9, 27, 10, 0, -22 },
  { 289, 13, 13, 14, 1, -23 },
  { 311, 13, 15, 15, 1, -18 },
  { 336, 6, 8, 8, 1, -4 },
  { 342, 8, 4, 9, 1, -10 },
  { 346, 6, 5, 8, 1, -5 },
  { 350, 12, 22, 13, 0, -22 },
  { 383, 13, 22, 15, 1, -22 },
  { 419, 11, 21, 15, 1, -21 },
  { 448, 13, 22, 15, 1, -22 },
  { 484, 13, 22, 15, 1, -22 },
  { 520, 15, 21, 15, 0, -21 },
  { 560, 13, 21, 15, 1, -21 },
  { 595, 13, 22, 15, 1, -22 },
  { 631, 13, 21, 15, 1, -21 },
  { 666, 13, 22, 15, 1, -22 },
  { 702, 13, 22, 15, 1, -22 },
  { 738, 6, 17, 8, 1, -17 },
  { 751, 6, 21, 8, 1, -17 },
  { 767, 13, 15, 15, 1, -18 },
  { 792, 13, 9, 15, 1, -15 },
  { 807, 13, 15, 15, 1, -18 },
  { 832, 12, 22, 12, 0, -22 },
  { 865, 22, 24, 24, 1, -22 },
  { 931, 18, 21, 18, 0, -21 },
  { 979, 14, 21, 17, 2, -21 },
  { 1016, 14, 22, 16, 1, -22 },
  { 1055, 15, 21, 19, 2, -21 },
  { 1095, 11, 21, 14, 2, -21 },
  { 1124, 11, 21, 14, 2, -21 },
  { 1153, 16, 22, 19, 1, -22 },
  { 1197, 15, 21, 19, 2, -21 },
  { 1237, 9, 21, 11, 1, -21 },
  { 1261, 9, 28, 9, -2, -21 },
  { 1293, 15, 21, 17, 2, -21 },
  { 1333, 11, 21, 14, 2, -21 },
  { 1362, 21, 21, 25, 2, -21 },
  { 1418, 17, 21, 21, 2, -21 },
  { 1463, 18, 22, 20, 1, -22 },
  { 1513, 13, 21, 16, 2, -21 },
  { 1548, 18, 27, 20, 1, -22 },
  { 1609, 15, 21, 17, 2, -21 },
  { 1649, 12, 22, 14, 1, -22 },
  { 1682, 13, 21, 15, 1, -21 },
  { 1717, 15, 21, 19, 2, -21 },
  { 1757, 17, 21, 17, 0, -21 },
  { 1802, 25, 21, 25, 0, -21 },
  { 1868, 17, 21, 17, 0, -21 },
  { 1913, 16, 21, 16, 0, -21 },
  { 1955, 13, 21, 15, 1, -21 },
  { 1990, 7, 27, 9, 2, -22 },
  { 2014, 12, 22, 13, 0, -22 },
  { 2047, 7, 27, 9, 1, -22 },
  { 2071, 16, 13, 16, 0, -21 },
  { 2097, 14, 3, 14, 0, 2 },
  { 2103, 8, 5, 10, 1, -23 },
  { 2108, 13, 17, 16, 1, -17 },
  { 2136, 13, 23, 16, 2, -23 },
  { 2174, 12, 17, 13, 1, -17 },
  { 2200, 14, 23, 16, 1, -23 },
  { 2241, 13, 17, 15, 1, -17 },
  { 2269, 11, 23, 10, 0, -23 },
  { 2301, 14, 24, 16, 1, -17 },
  { 2343, 13, 23, 17, 2, -23 },
  { 2381, 5, 23, 8, 2, -23 },
  { 2396, 8, 30, 8, -1, -23 },
  { 2426, 14, 23, 16, 2, -23 },
  { 2467, 4, 23, 8, 2, -23 },
  { 2479, 21, 17, 25, 2, -17 },
  { 2524, 13, 17, 17, 2, -17 },
  { 2552, 14, 17, 16, 1, -17 },
  { 2582, 13, 24, 16, 2, -17 },
  { 2621, 14, 24, 16, 1, -17 },
  { 2663, 9, 17, 12, 2, -17 },
  { 2683, 11, 17, 13, 1, -17 },
  { 2707, 10, 20, 11, 0, -20 },
  { 2732, 13, 17, 17, 2, -17 },
  { 2760, 15, 17, 15, 0, -17 },
  { 2792, 23, 16, 23, 0, -16 },
  { 2838, 15, 16, 15, 0, -16 },
  { 2868, 15, 24, 15, 0, -17 },
  { 2913, 11, 17, 12, 1, -17 },
  { 2937, 10, 27, 11, 0, -22 },
  { 2971, 4, 30, 14, 5, -23 },
  { 2986, 10, 27, 11, 1, -22 },
  { 3020, 13, 5, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_ExtraBold30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD30PT7B_H_
