#ifndef _NOTOSANS_CONDENSED_EXTRABOLD42PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF3, 0xE0, 0x00, 0x00, 0x1C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0x84, 0x00, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x01, 0xF1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00,
  0x78, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0,
  0xF0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFC, 0x1F, 0x1E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0x07,
  0x8F, 0x83, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xE0, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0x7C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x78,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0xE0, 0x1F,
  0xFF, 0x0F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xCF, 0x3F, 0x70,
  0x4F, 0x9C, 0x03, 0xF7, 0x00, 0xFD, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xDF, 0x80, 0x73, 0xF0, 0x1C, 0xFE, 0x07, 0x3F, 0xE1, 0xDF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x1F,
  0xF0, 0x07, 0xC0, 0x0F, 0xFC, 0x03, 0xE0, 0x0F, 0xFE, 0x03, 0xE0, 0x07,
  0xCF, 0x81, 0xF0, 0x07, 0xC7, 0xC1, 0xF0, 0x03, 0xE3, 0xE0, 0xF8, 0x01,
  0xF1, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x3C, 0x00,
  0x3E, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x9F, 0x1F,
  0xC3, 0xE7, 0xCF, 0x9F, 0xF1, 0xFF, 0xCF, 0x9F, 0xFC, 0x7F, 0xE7, 0xCF,
  0xFE, 0x3F, 0xE7, 0xCF, 0xDF, 0x8F, 0xE3, 0xE7, 0xC7, 0xC0, 0x01, 0xE3,
  0xE3, 0xE0, 0x01, 0xF1, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8,
  0x7C, 0x7C, 0x00, 0x7C, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x1F, 0x00, 0x3E,
  0x0F, 0x8F, 0x80, 0x3E, 0x07, 0xEF, 0x80, 0x1F, 0x01, 0xFF, 0xC0, 0x0F,
  0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xF8,
  0x7F, 0xF0, 0xFE, 0x3F, 0xFE, 0x3F, 0x9F, 0xFF, 0xCF, 0xC7, 0xF7, 0xFF,
  0xF3, 0xF8, 0xFF, 0xFC, 0xFE, 0x1F, 0xFE, 0x3F, 0x83, 0xFF, 0x8F, 0xE0,
  0xFF, 0xC3, 0xF8, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x7F, 0x81, 0xFF, 0x0F,
  0xF0, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x07,
  0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF8,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03,
  0xE0, 0x3E, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x41, 0xE0, 0x5C, 0x78, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xEF,
  0x83, 0xF3, 0xF0, 0xFC, 0x7E, 0x1E, 0x1E, 0x01, 0x83, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x3F,
  0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x08, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0x3F, 0x1F, 0xC7, 0xF3, 0xF8, 0x7E,
  0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0xBF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFD,
  0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0xC3, 0xF3,
  0xF8, 0xFE, 0x3F, 0x9F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFC,
  0xF3, 0xF8, 0xC7, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF,
  0xFF, 0x9F, 0x8F, 0xF3, 0x81, 0xFC, 0x40, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC,
  0x07, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x78, 0x7F,
  0x84, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFE, 0xF0, 0x3F, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xBF, 0x80, 0xFB, 0xF8, 0x1F, 0x3F, 0x81, 0xF3, 0xF8, 0x3E, 0x3F, 0x83,
  0xE3, 0xF8, 0x7C, 0x3F, 0x87, 0xC3, 0xF8, 0xF8, 0x3F, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0xFF, 0xC7, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF,
  0xFE, 0x30, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xFA, 0x00, 0xFE, 0xF0, 0x7F, 0xBF, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xC0, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x70, 0x3F,
  0x7F, 0x87, 0xDF, 0xF9, 0xFB, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC,
  0x1F, 0xDF, 0x83, 0xFB, 0xF8, 0x7F, 0x3F, 0x9F, 0xC7, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFE, 0x1F, 0x9F,
  0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xE3, 0xF8, 0xFE, 0xFE, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0x87, 0xF7, 0xF1, 0xFC, 0x7F, 0x3F, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xEF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE, 0x3F, 0x9F,
  0x87, 0xF7, 0xF0, 0x7E, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFE, 0xFC, 0x3F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xFE, 0xFC, 0x7F, 0x9F, 0x03, 0xC7, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7D, 0xFF, 0xFF,
  0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x3F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x0C, 0x00,
  0x00, 0x0F, 0xF8, 0x3F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF1,
  0xE3, 0xFC, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0xE0,
  0x7C, 0x7C, 0x1F, 0xFC, 0xF9, 0xF0, 0xFF, 0xF3, 0xE7, 0x87, 0xFF, 0xCF,
  0xBE, 0x3F, 0x1F, 0x1E, 0xF8, 0xF8, 0x7C, 0x7B, 0xE3, 0xE1, 0xF1, 0xEF,
  0x1F, 0x07, 0x87, 0xFC, 0x7C, 0x1E, 0x1F, 0xF1, 0xF0, 0x78, 0x7B, 0xC7,
  0xC3, 0xE1, 0xEF, 0x1F, 0x0F, 0x87, 0xBC, 0x7C, 0x3E, 0x3E, 0xF0, 0xF8,
  0xF8, 0xFB, 0xE3, 0xFF, 0xFF, 0xCF, 0x8F, 0xFF, 0xFE, 0x3E, 0x1F, 0xE7,
  0xF8, 0x7C, 0x3F, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x40, 0x1F, 0xC0, 0x0E, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFC, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC3, 0xFE,
  0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F,
  0xCF, 0xC1, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xCF, 0xC1, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x3F, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE3, 0xFE, 0x3C, 0x7F, 0x80, 0x47, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x06,
  0x3F, 0xE1, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x1F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xF0, 0x7F, 0xDF, 0x80, 0xFE,
  0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0x7E, 0x03,
  0xFB, 0xF0, 0x3F, 0xDF, 0x83, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xC3, 0xC3, 0xFC, 0x01, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xE0, 0x7F, 0x3F, 0xE1,
  0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xCF, 0xFC, 0x7F,
  0xC3, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC,
  0x1F, 0xCF, 0xE1, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFE, 0x7F, 0x07, 0xF7, 0xF8, 0x3F, 0xBF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xDF, 0xC1, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xE7, 0xF0, 0x7F, 0x3F,
  0x83, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0xFF, 0x01, 0xFC, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x1F, 0x7F, 0xFB, 0xE0, 0xFB, 0xFF, 0xDF, 0x07, 0xDF, 0xFE, 0xFC, 0x7E,
  0xFF, 0xF3, 0xE3, 0xE7, 0xFF, 0x9F, 0x1F, 0x3F, 0xFC, 0xF8, 0xF9, 0xFF,
  0xE7, 0xEF, 0xCF, 0xFF, 0x1F, 0x7C, 0x7F, 0xF8, 0xFB, 0xE3, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFE, 0x3F, 0xF0, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0x87, 0xFC,
  0x3F, 0xFC, 0x3F, 0xE1, 0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0x07, 0xF0, 0x7F,
  0xF8, 0x3F, 0x83, 0xFF, 0xC1, 0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0xFC, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xEF, 0xC3, 0xFF, 0xDF, 0xC7,
  0xFF, 0x9F, 0x8F, 0xFF, 0x3F, 0x9F, 0xFE, 0x3F, 0x3F, 0xFC, 0x7F, 0x7F,
  0xF8, 0x7E, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x81, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC3, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x81,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xE7, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7E, 0x7F, 0xE3, 0xF0,
  0x7F, 0x1F, 0x81, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x3F, 0x03, 0xF1,
  0xF8, 0x3F, 0x8F, 0xC1, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xF8, 0xFC, 0x0F,
  0xC7, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x83, 0xF8, 0xFC, 0x1F,
  0xC7, 0xE0, 0x7F, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0xEF, 0xC0, 0x7F, 0x7E,
  0x03, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F,
  0xFF, 0x9F, 0xFF, 0xC7, 0xF0, 0x31, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFE, 0xFF, 0x8F, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E,
  0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F,
  0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07,
  0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F,
  0xBF, 0x01, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x80, 0xFE, 0xFC, 0x07, 0xF8,
  0x1F, 0x9F, 0xC1, 0xFF, 0x03, 0xF3, 0xF8, 0x3F, 0xE0, 0x7E, 0x3F, 0x07,
  0xFC, 0x1F, 0xC7, 0xE0, 0xFF, 0xC3, 0xF8, 0xFC, 0x1F, 0xF8, 0x7E, 0x1F,
  0xC7, 0xDF, 0x0F, 0xC1, 0xF8, 0xFB, 0xE1, 0xF8, 0x3F, 0x1F, 0x7C, 0x7F,
  0x07, 0xE3, 0xEF, 0xCF, 0xC0, 0xFC, 0xFC, 0xF9, 0xF8, 0x1F, 0x9F, 0x9F,
  0x3F, 0x01, 0xFB, 0xE3, 0xE7, 0xE0, 0x3F, 0x7C, 0x7D, 0xFC, 0x07, 0xEF,
  0x8F, 0xBF, 0x00, 0xFD, 0xF0, 0xFF, 0xE0, 0x1F, 0xBE, 0x1F, 0xFC, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F,
  0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xF7, 0xF0, 0x07, 0xEF,
  0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xFD, 0xFC, 0x03, 0xF9, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xDF, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF1, 0xF8,
  0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x07, 0xE1, 0xFC, 0x0F, 0xE3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0xDF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0,
  0x3F, 0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x8F, 0xC0,
  0x7C, 0x7C, 0x03, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x00, 0x20, 0x03, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xEF, 0xF0, 0x81, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFB,
  0xF7, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFD, 0xF3, 0xFE, 0x7C, 0x7F, 0x0F, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xCF, 0xE3, 0xFB,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0x3F,
  0xE7, 0xE3, 0xF0, 0x00, 0x40, 0x07, 0xFE, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F,
  0xFE, 0x7F, 0xFE, 0x7F, 0x04, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFF, 0x06, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x02, 0x0F,
  0xE3, 0xF9, 0xFC, 0xFF, 0xBF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0x7F, 0xEF, 0xCF, 0xF9, 0xF8, 0x7E, 0x3F, 0x07, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0x3F, 0xBF, 0x87, 0xEF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x67,
  0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xE0, 0x01,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC3, 0xF8, 0x87, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0x87, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x03,
  0x00, 0x01, 0xF8, 0xFC, 0xFF, 0x9F, 0x9F, 0xFB, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFB, 0xF8, 0x7E, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x20, 0x0F, 0xE7, 0xC3, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x08, 0x1F, 0xCF, 0xE3, 0xFB, 0xFE, 0x7E, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF9, 0xFF, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF,
  0x9F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x3F, 0x8F, 0xC7,
  0xF0, 0xFC, 0x7F, 0x0F, 0xCF, 0xE0, 0xFD, 0xFC, 0x0F, 0xDF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8,
  0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x08, 0x01, 0x81, 0xF8, 0xFE, 0x1F, 0xE3, 0xF7, 0xFE,
  0x7F, 0xE7, 0xEF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xC7, 0xFC, 0x7F, 0x7F, 0x87, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0,
  0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x07,
  0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x3F,
  0xFF, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF,
  0xF8, 0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0x00,
  0x08, 0x1F, 0x8F, 0xE3, 0xF7, 0xFE, 0x7E, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x00, 0x40, 0x00, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0xBF, 0x87,
  0xF7, 0xF0, 0x7E, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xF9, 0xFC, 0x7F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x08, 0x1F, 0x8F, 0xE3, 0xF3, 0xFE,
  0x7E, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xBF, 0xE7,
  0xF3, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0x00, 0x01, 0xF8, 0xFC, 0xFF, 0x9F, 0x9F, 0xFB, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFB, 0xF8, 0x7E, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x13, 0xE1, 0xFF, 0xCF, 0xFF, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x80, 0x1F, 0xF0, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xDF, 0xEF, 0xBF, 0x83, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE,
  0x3F, 0xF8, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE3, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x4F, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0,
  0xFF, 0xC1, 0xFE, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xEF, 0xE3, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xE7, 0xC3, 0xF8, 0xF8, 0xFE, 0x03,
  0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x1F,
  0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xF1, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E,
  0x07, 0xE3, 0xF0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F,
  0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xF0, 0x7F, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E,
  0x0F, 0xF0, 0x7E, 0x7F, 0x1F, 0xF0, 0xFC, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F,
  0x1F, 0xF8, 0xFC, 0x3F, 0x1E, 0xF8, 0xFC, 0x3F, 0x1E, 0xF9, 0xFC, 0x1F,
  0xBE, 0x79, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F,
  0xBE, 0x7D, 0xF8, 0x1F, 0xBC, 0x7D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F,
  0xBC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF3, 0xF8, 0x3F,
  0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xEF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFE, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0xC7,
  0xF0, 0xFE, 0x3F, 0x83, 0xFB, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xFB, 0xF0,
  0x1F, 0xDF, 0x80, 0xFC, 0xFE, 0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF0,
  0xFE, 0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x03, 0xF3,
  0xF0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x5F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x1F,
  0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x07, 0xF8, 0xFF,
  0x87, 0xF8, 0x3F, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xFC, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xC1, 0xFF,
  0x0F, 0xFC, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x27, 0xF8, 0x07, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0x1F, 0xF4, 0x00,
  0xFC,
};

const GFXglyph NotoSans_Condensed_ExtraBold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 31, 11, 2, -30 },
  { 29, 16, 11, 20, 2, -30 },
  { 51, 22, 30, 24, 1, -30 },
  { 134, 18, 34, 21, 2, -32 },
  { 211, 33, 30, 35, 1, -30 },
  { 335, 26, 30, 27, 1, -30 },
  { 433, 7, 11, 11, 2, -30 },
  { 443, 11, 37, 14, 2, -30 },
  { 494, 11, 37, 14, 1, -30 },
  { 545, 18, 18, 20, 1, -32 },
  { 586, 19, 20, 21, 1, -25 },
  { 634, 8, 11, 11, 1, -5 },
  { 645, 11, 6, 13, 1, -14 },
  { 654, 7, 8, 11, 2, -7 },
  { 661, 17, 30, 18, 0, -30 },
  { 725, 19, 30, 21, 1, -30 },
  { 797, 15, 30, 21, 2, -30 },
  { 854, 18, 30, 21, 1, -30 },
  { 922, 19, 30, 21, 1, -30 },
  { 994, 20, 30, 21, 1, -30 },
  { 1069, 18, 30, 21, 2, -30 },
  { 1137, 19, 30, 21, 1, -30 },
  { 1209, 19, 30, 21, 1, -30 },
  { 1281, 19, 30, 21, 1, -30 },
  { 1353, 19, 30, 21, 1, -30 },
  { 1425, 7, 24, 12, 2, -23 },
  { 1446, 8, 29, 12, 1, -23 },
  { 1475, 19, 21, 21, 1, -26 },
  { 1525, 19, 14, 21, 1, -22 },
  { 1559, 19, 21, 21, 1, -26 },
  { 1609, 17, 31, 17, 0, -30 },
  { 1675, 30, 33, 33, 2, -30 },
  { 1799, 25, 30, 25, 0, -30 },
  { 1893, 20, 30, 24, 3, -30 },
  { 1968, 20, 30, 23, 2, -30 },
  { 2043, 21, 30, 26, 3, -30 },
  { 2122, 15, 30, 20, 3, -30 },
  { 2179, 15, 30, 20, 3, -30 },
  { 2236, 22, 30, 26, 2, -30 },
  { 2319, 21, 30, 27, 3, -30 },
  { 2398, 13, 30, 15, 1, -30 },
  { 2447, 13, 39, 13, -3, -30 },
  { 2511, 21, 30, 24, 3, -30 },
  { 2590, 16, 30, 19, 3, -30 },
  { 2650, 29, 30, 35, 3, -30 },
  { 2759, 23, 30, 29, 3, -30 },
  { 2846, 24, 30, 28, 2, -30 },
  { 2936, 18, 30, 23, 3, -30 },
  { 3004, 24, 37, 28, 2, -30 },
  { 3115, 21, 30, 24, 3, -30 },
  { 3194, 18, 30, 20, 1, -30 },
  { 3262, 19, 30, 20, 1, -30 },
  { 3334, 21, 30, 27, 3, -30 },
  { 3413, 24, 30, 24, 0, -30 },
  { 3503, 35, 30, 35, 0, -30 },
  { 3635, 23, 30, 23, 0, -30 },
  { 3722, 23, 30, 23, 0, -30 },
  { 3809, 19, 30, 20, 1, -30 },
  { 3881, 10, 37, 13, 2, -30 },
  { 3928, 17, 30, 18, 0, -30 },
  { 3992, 10, 37, 13, 1, -30 },
  { 4039, 21, 19, 23, 1, -30 },
  { 4089, 19, 4, 19, 0, 3 },
  { 4099, 11, 7, 14, 2, -32 },
  { 4109, 18, 24, 22, 1, -24 },
  { 4163, 19, 32, 23, 2, -32 },
  { 4239, 16, 24, 19, 2, -24 },
  { 4287, 19, 32, 23, 2, -32 },
  { 4363, 18, 23, 21, 2, -23 },
  { 4415, 15, 32, 14, 0, -32 },
  { 4475, 19, 34, 23, 2, -24 },
  { 4556, 19, 32, 23, 2, -32 },
  { 4632, 7, 32, 11, 2, -32 },
  { 4660, 11, 42, 11, -2, -32 },
  { 4718, 20, 32, 23, 3, -32 },
  { 4798, 7, 32, 11, 2, -32 },
  { 4826, 31, 24, 35, 2, -24 },
  { 4919, 19, 24, 23, 2, -24 },
  { 4976, 19, 24, 23, 2, -24 },
  { 5033, 19, 34, 23, 2, -24 },
  { 5114, 19, 34, 23, 2, -24 },
  { 5195, 14, 24, 16, 2, -24 },
  { 5237, 15, 24, 18, 1, -24 },
  { 5282, 14, 28, 16, 1, -28 },
  { 5331, 19, 23, 23, 2, -23 },
  { 5386, 21, 23, 21, 0, -23 },
  { 5447, 32, 23, 32, 0, -23 },
  { 5539, 21, 23, 21, 0, -23 },
  { 5600, 21, 33, 21, 0, -23 },
  { 5687, 16, 23, 17, 1, -23 },
  { 5733, 13, 37, 16, 1, -30 },
  { 5794, 5, 42, 19, 7, -32 },
  { 5821, 14, 37, 16, 1, -30 },
  { 5886, 19, 8, 21, 1, -19 },
};

const GFXfont NotoSans_Condensed_ExtraBold42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD42PT7B_H_
