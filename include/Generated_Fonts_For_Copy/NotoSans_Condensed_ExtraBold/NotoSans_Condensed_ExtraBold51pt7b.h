#ifndef _NOTOSANS_CONDENSED_EXTRABOLD51PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xCF, 0xE7,
  0xF1, 0xF8, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF3, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xDF, 0xE7, 0xE0, 0xC0, 0xFF, 0x0F, 0xF7, 0xF0, 0xFF,
  0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x07, 0xE7, 0xF0,
  0x7E, 0x7F, 0x07, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF0, 0xFC,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x0F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x1F, 0x87, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xFC, 0x00,
  0x3E, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF0, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7E,
  0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0x9F,
  0x3F, 0x9E, 0x08, 0xFE, 0x78, 0x03, 0xF9, 0xE0, 0x0F, 0xE7, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xEF, 0xF0, 0x07, 0x9F, 0xC0, 0x1E, 0x7F, 0x80,
  0x79, 0xFF, 0x81, 0xE7, 0xFF, 0xC7, 0xBF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0xFC, 0x00, 0x7F, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x3F, 0x01, 0xF8,
  0x00, 0x7E, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x00,
  0x7E, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x1F, 0x87, 0xF0, 0x7E, 0x3F,
  0x3F, 0x1F, 0xF8, 0x7F, 0x7F, 0x3F, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3F,
  0xFE, 0x3F, 0xFE, 0x7E, 0x7F, 0xFE, 0x1F, 0xFC, 0x7E, 0x7E, 0x7F, 0x0F,
  0xF8, 0xFC, 0x7E, 0x3F, 0x03, 0xE0, 0xFC, 0x7E, 0x3F, 0x00, 0x01, 0xF8,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x00, 0x07,
  0xE0, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x3F, 0x00, 0x0F, 0xC0, 0x7E,
  0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0x1F, 0x80, 0x7F, 0xFE, 0x00,
  0x1F, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x81, 0xFE, 0x0F, 0xFF, 0x81, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFC, 0x3F, 0xFF, 0xC3, 0xFC, 0x3F, 0xFF, 0xE3, 0xFC, 0x7F,
  0xDF, 0xF7, 0xF8, 0x7F, 0x8F, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xF8, 0xFF,
  0x87, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE7, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x08, 0x1F, 0x80, 0x9C,
  0x1F, 0x0E, 0x3F, 0x3E, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x1F,
  0xE0, 0xFC, 0x3F, 0x80, 0x78, 0x3C, 0x00, 0x60, 0x70, 0x00, 0x40, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x9F, 0xDF, 0xEF, 0xF7,
  0xFB, 0xF9, 0xFC, 0xFE, 0x7F, 0x7F, 0x3F, 0x9F, 0xCF, 0xC7, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFE, 0x7E, 0x0C, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xE3, 0xFE, 0x7F,
  0x87, 0xF9, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xDF, 0xC0, 0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xE7,
  0xFC, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC,
  0xFF, 0x1E, 0x3F, 0xC7, 0x0F, 0xF0, 0x83, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x1F, 0x83, 0xFE, 0x1E, 0x03, 0xFC, 0x10, 0x07, 0xF8,
  0x20, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x8F, 0x03, 0xFE, 0x10, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xEF, 0x81, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xF7, 0xF0,
  0x03, 0xF7, 0xF0, 0x03, 0xF7, 0xF0, 0x07, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0,
  0x0F, 0xC7, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F, 0x87, 0xF0, 0x3F, 0x07, 0xF0,
  0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x18, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x86, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0xE0, 0x0F, 0xFB, 0xF0,
  0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x7C, 0x0F,
  0xE7, 0xFC, 0x3F, 0xBF, 0xF8, 0xFE, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFD, 0xFE, 0x1F, 0xF7, 0xFC, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE7, 0xFC, 0xFF, 0x9F, 0xC1, 0xFE, 0xFF, 0x03, 0xF9, 0xFC, 0x0F,
  0xE7, 0xF0, 0x3F, 0x9F, 0xC1, 0xFE, 0x7F, 0x87, 0xF8, 0xFF, 0x3F, 0xC3,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF,
  0xBF, 0xC1, 0xFE, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0xE3, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x03, 0xF9, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0,
  0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x83, 0xFE, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF, 0xC3, 0xFF, 0x3F,
  0x83, 0xFC, 0x7F, 0x00, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x08, 0x0F, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x18, 0x3F, 0x3F, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0x7E, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xCF, 0xE7, 0xF3, 0xFB, 0xF9,
  0xFC, 0xFE, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF3, 0xC0, 0xFF, 0x30, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8,
  0x01, 0x00, 0xFC, 0x3F, 0x01, 0xFF, 0xC7, 0xE3, 0xF0, 0x7F, 0xFE, 0x3E,
  0x3E, 0x0F, 0xFF, 0xE3, 0xF7, 0xE1, 0xFF, 0xFE, 0x3F, 0x7E, 0x1F, 0xC7,
  0xE3, 0xF7, 0xC3, 0xF8, 0x7E, 0x1F, 0xFC, 0x3F, 0x07, 0xE1, 0xFF, 0xC3,
  0xE0, 0x7E, 0x1F, 0xFC, 0x7E, 0x07, 0xC1, 0xFF, 0xC7, 0xE0, 0x7C, 0x1F,
  0xFC, 0x7E, 0x07, 0xC1, 0xFF, 0xC7, 0xE0, 0xFC, 0x1F, 0xFC, 0x7E, 0x0F,
  0xC3, 0xFF, 0xC7, 0xE0, 0xFC, 0x3F, 0xFC, 0x7E, 0x0F, 0xC3, 0xEF, 0xC3,
  0xF1, 0xFC, 0x3E, 0xFC, 0x3F, 0xBF, 0xEF, 0xE7, 0xC3, 0xFF, 0xFF, 0xFC,
  0x7E, 0x1F, 0xFD, 0xFF, 0x87, 0xE0, 0xFF, 0x8F, 0xF0, 0x7E, 0x07, 0xF0,
  0x7E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x18, 0x00, 0xFF, 0x80, 0x0F, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0,
  0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFE, 0x7F,
  0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x03, 0xFE, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFF, 0x07, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xF8, 0x1C, 0x3F, 0xF0, 0x04, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x06, 0x1F, 0xFE, 0x7E, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xF3, 0xFC, 0x07, 0xFE, 0xFF, 0x00,
  0xFF, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFB,
  0xFC, 0x07, 0xFC, 0xFF, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3C, 0x3F, 0xF0, 0x01, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xDF, 0xE0, 0xFF, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF,
  0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFE, 0x01,
  0xFE, 0x7F, 0xE0, 0x3F, 0xC7, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x1F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F,
  0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC1,
  0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x1F, 0xF0, 0x3F,
  0xC7, 0xFC, 0x0F, 0xF3, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0xC0,
  0x3F, 0xDF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFC, 0x7F, 0xC0,
  0xFF, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xE3, 0xFC,
  0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xFB,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0xFE, 0x03,
  0xF7, 0xFF, 0xEF, 0xC0, 0x7E, 0xFF, 0xFD, 0xF8, 0x1F, 0xDF, 0xFF, 0xBF,
  0x83, 0xF3, 0xFF, 0xF7, 0xF0, 0x7E, 0x7F, 0xFE, 0x7E, 0x1F, 0xCF, 0xFF,
  0xCF, 0xC3, 0xF1, 0xFF, 0xF9, 0xFC, 0x7E, 0x3F, 0xFF, 0x3F, 0x8F, 0xC7,
  0xFF, 0xE3, 0xF3, 0xF8, 0xFF, 0xFC, 0x7E, 0x7E, 0x1F, 0xFF, 0x8F, 0xEF,
  0xC3, 0xFF, 0xF1, 0xFD, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0x01, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0xF0, 0x7F,
  0xFE, 0xFF, 0x07, 0xFF, 0xE7, 0xF8, 0x7F, 0xFE, 0x7F, 0x87, 0xFF, 0xE3,
  0xFC, 0x7F, 0xFE, 0x3F, 0xC7, 0xFF, 0xE1, 0xFE, 0x7F, 0xFE, 0x1F, 0xE7,
  0xFF, 0xE0, 0xFF, 0x7F, 0xFE, 0x0F, 0xF7, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0,
  0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x1F,
  0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xE3, 0xFE,
  0x01, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x0F, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x87, 0xFE, 0x0F, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFC, 0xFF,
  0x80, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80,
  0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F,
  0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x0F, 0xF0, 0xFF, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE,
  0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFB,
  0xFC, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x9F, 0xF8, 0x7C,
  0xFF, 0x00, 0x67, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x78, 0x07, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xFD, 0xFE, 0x01, 0xFE, 0x7F, 0xC0,
  0xFF, 0x9F, 0xFE, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF,
  0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F,
  0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE,
  0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xF0,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xE0, 0x1F,
  0xE7, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x9F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF1, 0xFC, 0x07, 0xFF, 0x01, 0xFC, 0x3F, 0x80,
  0xFF, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFF,
  0x81, 0xFE, 0x1F, 0xE0, 0xFD, 0xF0, 0x3F, 0xC1, 0xFC, 0x1F, 0xBF, 0x07,
  0xF0, 0x3F, 0x83, 0xF7, 0xE1, 0xFE, 0x07, 0xF8, 0x7E, 0xFC, 0x3F, 0xC0,
  0xFF, 0x0F, 0xDF, 0x87, 0xF8, 0x1F, 0xE3, 0xFB, 0xF0, 0xFF, 0x01, 0xFC,
  0x7F, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC7, 0xE3, 0xF8, 0x07, 0xF1, 0xF8,
  0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0x1F, 0x9F, 0xE0, 0x0F, 0xEF, 0xE3, 0xF3,
  0xFC, 0x01, 0xFD, 0xFC, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x07, 0xEF, 0xE0,
  0x07, 0xF7, 0xE0, 0xFD, 0xFC, 0x00, 0xFE, 0xFC, 0x1F, 0xFF, 0x80, 0x0F,
  0xDF, 0x83, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE3, 0xFC, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xF9, 0xFE,
  0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xE0,
  0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFF,
  0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xF7, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF9,
  0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x38, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFD, 0xFF, 0x83, 0x01,
  0xFE, 0x08, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xF7, 0xF7, 0xFF, 0x9F, 0xCF, 0xFE, 0x7F, 0x1F, 0xE0, 0xFC, 0x0C,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x08, 0x07, 0xF9, 0xFE,
  0x0F, 0xF7, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xBF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFD, 0xFF, 0x8F, 0xFB, 0xFE, 0x0F, 0xF7, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFE, 0xFF, 0xC7,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xEF, 0xFF,
  0x1F, 0xCF, 0xFC, 0x3F, 0x0F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFC, 0x1C, 0x7F, 0x80, 0x47, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x02, 0x7F, 0xC1, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x02, 0x07, 0xF8, 0x3F, 0xCF, 0xF0, 0xFF,
  0xDF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xBF, 0x9F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0x8F, 0xFD, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xBF, 0xC1, 0xFF, 0x7F, 0xC3, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xEF, 0xE1, 0xFF,
  0x9F, 0xC1, 0xFE, 0x1F, 0x80, 0x60, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7,
  0xFE, 0x7F, 0x9F, 0xE0, 0xFE, 0x7F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x27, 0xFC, 0x03, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0x30, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x80,
  0x00, 0x0F, 0xF1, 0xFC, 0x3F, 0xF3, 0xF8, 0xFF, 0xF7, 0xF3, 0xFF, 0xEF,
  0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xE3, 0xFF, 0x7F, 0x83, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xEF, 0xF0,
  0x7F, 0xDF, 0xF1, 0xFF, 0xBF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xEF, 0xF0, 0x7F, 0x9F, 0xE0, 0x10, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0xC0, 0x07, 0xF9,
  0xF8, 0x3F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x08, 0x07, 0xF9, 0xFF, 0x0F, 0xE7, 0xFF, 0x1F, 0xDF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x8F, 0xFB,
  0xFE, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0x80, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0xF9, 0xFF, 0xFF, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xE7,
  0xFE, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0xF3, 0xFC,
  0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F, 0xF8, 0x3F,
  0xC7, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03,
  0xFF, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFD, 0xFE, 0x07, 0xFC, 0xFF,
  0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83,
  0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8,
  0x0F, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x08,
  0x07, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0x1F, 0xFC, 0x7F, 0xF1, 0xFD, 0xFF,
  0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0xE3, 0xFE, 0xFF, 0x83, 0xFE,
  0x0F, 0xF7, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0x81, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0x03,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0x81, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xFF,
  0x03, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0x02, 0x01, 0xF8, 0x7F, 0xC3, 0xF1, 0xFF, 0xC7, 0xF7, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xE3, 0xFE, 0xFF, 0x83,
  0xFD, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xE0, 0x00,
  0x10, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F,
  0x81, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0x7F,
  0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xC3, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x02, 0x01, 0xF8, 0x7F, 0x83, 0xF9,
  0xFF, 0x87, 0xF7, 0xFF, 0x8F, 0xEF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x7F, 0xE3, 0xFE, 0xFF, 0x83, 0xFD, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xBF, 0xF1, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFB,
  0xFF, 0x0F, 0xF3, 0xFC, 0x1F, 0xE0, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xF1, 0xFC, 0x3F, 0xF3, 0xF8,
  0xFF, 0xF7, 0xF3, 0xFF, 0xEF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xE3, 0xFF, 0x7F, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xEF, 0xF0, 0x7F, 0xDF, 0xF1, 0xFF, 0xBF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFD, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xEF, 0xF0,
  0x7F, 0x1F, 0xE0, 0x10, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x06, 0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFB, 0xF3, 0xF8, 0x0C, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x11, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x18, 0x00, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFC, 0xFF, 0xF3, 0xF1, 0xFF, 0xCF,
  0xC3, 0xFC, 0x3F, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x1F,
  0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x07,
  0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xFC,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF7,
  0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFD, 0xFC, 0x07, 0xFC, 0x0F, 0xF7, 0xF8,
  0x3F, 0xF0, 0x3F, 0xDF, 0xE0, 0xFF, 0xC0, 0xFE, 0x7F, 0x83, 0xFF, 0x83,
  0xF8, 0xFE, 0x0F, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0xF8, 0x7F, 0x8F, 0xF0,
  0xFB, 0xE1, 0xFE, 0x3F, 0xC7, 0xEF, 0x87, 0xF0, 0x7F, 0x1F, 0xBF, 0x1F,
  0xC1, 0xFC, 0x7E, 0xFC, 0xFF, 0x07, 0xF1, 0xF3, 0xF3, 0xFC, 0x1F, 0xE7,
  0xCF, 0xCF, 0xE0, 0x3F, 0xBF, 0x1F, 0x3F, 0x80, 0xFE, 0xFC, 0x7C, 0xFE,
  0x03, 0xFB, 0xF1, 0xFB, 0xF8, 0x0F, 0xEF, 0x87, 0xEF, 0xC0, 0x3F, 0xBE,
  0x1F, 0xFF, 0x00, 0x7E, 0xF8, 0x7F, 0xFC, 0x01, 0xFB, 0xE0, 0xFF, 0xF0,
  0x07, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0xBF, 0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0x87,
  0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xDF, 0xE0,
  0x1F, 0xEF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x7F,
  0x8F, 0xF0, 0x3F, 0xC7, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0x9F,
  0xE0, 0x3F, 0xDF, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x1F,
  0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xE1, 0xFE, 0x07,
  0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xF3, 0xFC,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x0D, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07,
  0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFC,
  0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 37, 14, 2, -36 },
  { 43, 20, 13, 24, 2, -36 },
  { 76, 27, 36, 29, 1, -36 },
  { 198, 22, 42, 26, 2, -39 },
  { 314, 40, 37, 43, 1, -37 },
  { 499, 32, 38, 33, 1, -37 },
  { 651, 8, 13, 13, 2, -36 },
  { 664, 14, 45, 17, 2, -37 },
  { 743, 14, 45, 17, 1, -37 },
  { 822, 23, 23, 25, 1, -39 },
  { 889, 22, 24, 26, 2, -30 },
  { 955, 9, 14, 14, 2, -7 },
  { 971, 14, 7, 16, 1, -17 },
  { 984, 9, 9, 14, 2, -8 },
  { 995, 21, 37, 21, 0, -37 },
  { 1093, 22, 38, 26, 2, -37 },
  { 1198, 18, 36, 26, 2, -36 },
  { 1279, 23, 37, 26, 1, -37 },
  { 1386, 22, 38, 26, 2, -37 },
  { 1491, 24, 36, 26, 1, -36 },
  { 1599, 22, 37, 26, 2, -36 },
  { 1701, 22, 38, 26, 2, -37 },
  { 1806, 22, 36, 26, 2, -36 },
  { 1905, 22, 38, 26, 2, -37 },
  { 2010, 23, 38, 26, 1, -37 },
  { 2120, 8, 29, 14, 3, -28 },
  { 2149, 9, 35, 14, 2, -28 },
  { 2189, 22, 25, 26, 2, -31 },
  { 2258, 22, 16, 26, 2, -26 },
  { 2302, 22, 25, 26, 2, -31 },
  { 2371, 20, 38, 21, 0, -37 },
  { 2466, 36, 41, 40, 2, -37 },
  { 2651, 30, 36, 30, 0, -36 },
  { 2786, 24, 36, 30, 3, -36 },
  { 2894, 24, 38, 28, 2, -37 },
  { 3008, 26, 36, 32, 3, -36 },
  { 3125, 18, 36, 24, 4, -36 },
  { 3206, 18, 36, 24, 4, -36 },
  { 3287, 27, 38, 32, 2, -37 },
  { 3416, 25, 36, 33, 4, -36 },
  { 3529, 16, 36, 18, 1, -36 },
  { 3601, 15, 47, 15, -3, -36 },
  { 3690, 26, 36, 29, 4, -36 },
  { 3807, 20, 36, 24, 3, -36 },
  { 3897, 35, 36, 43, 4, -36 },
  { 4055, 28, 36, 36, 4, -36 },
  { 4181, 29, 38, 34, 2, -37 },
  { 4319, 23, 36, 28, 3, -36 },
  { 4423, 29, 46, 34, 2, -37 },
  { 4590, 26, 36, 29, 3, -36 },
  { 4707, 21, 38, 24, 2, -37 },
  { 4807, 23, 36, 25, 1, -36 },
  { 4911, 26, 37, 32, 3, -36 },
  { 5032, 29, 36, 29, 0, -36 },
  { 5163, 43, 36, 43, 0, -36 },
  { 5357, 28, 36, 28, 0, -36 },
  { 5483, 28, 36, 28, 0, -36 },
  { 5609, 23, 36, 25, 1, -36 },
  { 5713, 12, 45, 16, 3, -37 },
  { 5781, 21, 37, 21, 0, -37 },
  { 5879, 12, 45, 16, 1, -37 },
  { 5947, 26, 23, 28, 1, -36 },
  { 6022, 23, 5, 23, 0, 4 },
  { 6037, 14, 8, 18, 2, -39 },
  { 6051, 22, 30, 26, 2, -29 },
  { 6134, 23, 40, 28, 3, -39 },
  { 6249, 20, 30, 23, 2, -29 },
  { 6324, 23, 40, 28, 2, -39 },
  { 6439, 22, 30, 26, 2, -29 },
  { 6522, 18, 39, 17, 1, -39 },
  { 6610, 23, 41, 28, 2, -29 },
  { 6728, 23, 39, 28, 3, -39 },
  { 6841, 8, 39, 14, 3, -39 },
  { 6880, 13, 51, 14, -2, -39 },
  { 6963, 25, 39, 28, 3, -39 },
  { 7085, 8, 39, 14, 3, -39 },
  { 7124, 37, 29, 42, 3, -29 },
  { 7259, 23, 29, 28, 3, -29 },
  { 7343, 24, 30, 28, 2, -29 },
  { 7433, 23, 41, 28, 3, -29 },
  { 7551, 23, 41, 28, 2, -29 },
  { 7669, 16, 29, 20, 3, -29 },
  { 7727, 18, 30, 22, 2, -29 },
  { 7795, 17, 35, 19, 1, -34 },
  { 7870, 22, 29, 28, 3, -28 },
  { 7950, 26, 28, 26, 0, -28 },
  { 8041, 38, 28, 39, 0, -28 },
  { 8174, 25, 28, 25, 0, -28 },
  { 8262, 26, 40, 26, 0, -28 },
  { 8392, 19, 28, 21, 1, -28 },
  { 8459, 16, 45, 19, 1, -37 },
  { 8549, 6, 51, 23, 9, -39 },
  { 8588, 16, 45, 19, 2, -37 },
  { 8678, 22, 9, 26, 2, -22 },
};

const GFXfont NotoSans_Condensed_ExtraBold51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD51PT7B_H_
