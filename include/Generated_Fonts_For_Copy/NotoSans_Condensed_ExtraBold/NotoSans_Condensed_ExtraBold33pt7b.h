#ifndef _NOTOSANS_CONDENSED_EXTRABOLD33PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xE0, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7,
  0x80, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x3C, 0xF0, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC3, 0x8E, 0x01, 0xC7, 0x00, 0xE7, 0x80, 0xF3, 0xC3,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x1C, 0x07, 0x9E,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x71, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x7C, 0x07, 0xFF, 0x3F, 0xFD, 0xFF, 0xF7, 0xFB, 0xBE, 0xE2, 0xFB,
  0x81, 0xEE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x03, 0xBC, 0x0E, 0xFC, 0x3B, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x1E, 0x00, 0xF0,
  0x0F, 0xC0, 0x38, 0x07, 0xF8, 0x1E, 0x03, 0xFF, 0x07, 0x80, 0xF3, 0xC3,
  0xC0, 0x3C, 0xF0, 0xF0, 0x0F, 0x3C, 0x78, 0x03, 0xCF, 0x1E, 0x00, 0xF3,
  0xC7, 0x00, 0x3C, 0xF3, 0xC2, 0x0F, 0x3C, 0xE3, 0xE1, 0xFF, 0x79, 0xFC,
  0x7F, 0x9E, 0xFF, 0x8F, 0xEF, 0x3D, 0xE1, 0xE3, 0xCE, 0x3C, 0x01, 0xE7,
  0x8F, 0x00, 0x79, 0xE3, 0xC0, 0x1C, 0x78, 0xF0, 0x0F, 0x1E, 0x3C, 0x03,
  0x83, 0xCF, 0x01, 0xE0, 0xF7, 0x80, 0x78, 0x3F, 0xE0, 0x3C, 0x07, 0xF0,
  0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x87, 0xE3, 0xFE,
  0x3E, 0x3F, 0xF9, 0xF3, 0xF7, 0xFF, 0x9F, 0x3F, 0xF8, 0xF8, 0xFF, 0xC7,
  0xC3, 0xFC, 0x3E, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF0,
  0x07, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E,
  0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC3,
  0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0xF8, 0x3E, 0x0F,
  0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E,
  0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x21,
  0xE1, 0xF7, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0x83,
  0xFF, 0x1F, 0x3E, 0x3C, 0xF0, 0x61, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x7D, 0xF7, 0xDF, 0x79, 0xEF, 0xBC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x07, 0xC0,
  0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x8F, 0x8F, 0x9F, 0x1F, 0x7C,
  0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3E, 0xF8, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE7, 0xE7,
  0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0xF0, 0x3F, 0x07, 0xF0,
  0xFF, 0x1F, 0xF3, 0xFF, 0x7F, 0xFF, 0xDF, 0x39, 0xF1, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF,
  0xBF, 0xFE, 0x7F, 0xFD, 0xC3, 0xF2, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x7D, 0xFC, 0x83, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE1, 0xFF, 0x07, 0xF0, 0x1F, 0xF0,
  0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x1F, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x1E, 0xF8,
  0x3D, 0xF0, 0xF3, 0xE1, 0xE7, 0xC7, 0x8F, 0x8F, 0x1F, 0x3C, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x7F, 0xF3, 0xFF, 0x9F, 0xFD, 0xFF, 0xEF, 0xFF,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF,
  0xFF, 0xA0, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x83,
  0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0x9F, 0xF0, 0x01, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC3, 0xFC, 0x8F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x41,
  0xF7, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDF, 0x8F, 0xBE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7D, 0xF1, 0xF3, 0xE3, 0xE7, 0xFF, 0xC7, 0xFF,
  0x07, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x8F,
  0x9E, 0x1F, 0x3E, 0x3E, 0x7E, 0xFC, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0x01,
  0xFF, 0x07, 0xFF, 0x1F, 0xBF, 0x7E, 0x3E, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xFF, 0x8F, 0xFE, 0x0F, 0xF0, 0x07, 0x80,
  0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xDF, 0x8F, 0xBE, 0x1F, 0x7C,
  0x3E, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE7, 0xF7, 0xFF, 0xEF, 0xFF,
  0x8F, 0xEF, 0x0F, 0x9E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC7,
  0xFF, 0x0F, 0xFE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7D, 0xF7, 0xDF, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0x7D, 0xF7, 0x9E, 0xFB, 0xC0,
  0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F,
  0xE0, 0x7F, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x07, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x60, 0x00, 0x0F, 0x83, 0xFF,
  0x3F, 0xFC, 0xFF, 0xF7, 0xDF, 0x90, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0x81, 0xFC, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xC1, 0xF8,
  0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x3C, 0x1F, 0x1E, 0x38, 0x7F, 0xDE,
  0x78, 0xFF, 0xCE, 0x79, 0xF3, 0xCF, 0x71, 0xE3, 0x8F, 0xF3, 0xC3, 0x8F,
  0xF3, 0xC3, 0x8F, 0xF3, 0xC3, 0x8F, 0xF3, 0xC7, 0x8F, 0xF3, 0xC7, 0x8E,
  0xF3, 0xC7, 0x9E, 0x71, 0xFF, 0xFE, 0x79, 0xFD, 0xFC, 0x78, 0xF8, 0xF8,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x20, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xBE, 0x00, 0xFB, 0xE0, 0x0F, 0x9E, 0x00, 0xF9, 0xF0, 0x0F, 0x9F,
  0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0x7C, 0x7C,
  0x07, 0xE7, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF,
  0xFE, 0xF8, 0x7E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xF8, 0x07,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x02, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x86, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0x7F,
  0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC3, 0xFB, 0xE0, 0xFD,
  0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x7C, 0x1F, 0xBE,
  0x0F, 0xDF, 0x3F, 0xCF, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x01, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xE3, 0xF0,
  0x13, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xDF, 0x07, 0xEF, 0xE3, 0xF7, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F,
  0xFE, 0x0F, 0xFC, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE9, 0xFB, 0xFE, 0xFF,
  0x3F, 0xCF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xDF, 0x07, 0xCF,
  0x87, 0xE7, 0xC7, 0xE3, 0xE3, 0xF1, 0xF3, 0xF0, 0xF9, 0xF0, 0x7D, 0xF8,
  0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFB,
  0xF0, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x1F, 0x1F, 0x0F, 0xCF, 0x83, 0xE7,
  0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xEF, 0xFF, 0xC3, 0xDF, 0xF7,
  0x87, 0xBF, 0xEF, 0x1F, 0xFF, 0xDE, 0x3D, 0xFF, 0xBE, 0x7B, 0xFF, 0x3C,
  0xF7, 0xFE, 0x7B, 0xCF, 0xFC, 0xF7, 0x9F, 0xF8, 0xFF, 0x3F, 0xF1, 0xFE,
  0x7F, 0xE3, 0xF8, 0xFF, 0xC7, 0xF1, 0xFF, 0x87, 0xE3, 0xFF, 0x0F, 0x87,
  0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0x7C, 0x7F, 0xEF, 0x8F, 0xFC, 0xF9, 0xFF, 0x9F,
  0x3F, 0xF1, 0xF7, 0xFE, 0x3E, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x81, 0xFB, 0xE0, 0x3F, 0x7C, 0x03,
  0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F,
  0x1F, 0x8F, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0,
  0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDF, 0x0F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xF7, 0xDF, 0xEF, 0xFF,
  0xDF, 0xFF, 0x3F, 0xFC, 0x7F, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F,
  0x81, 0xFB, 0xE0, 0x3F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C,
  0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0x1F, 0x8F, 0xE3, 0xFF, 0xF8, 0x3F,
  0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x7F,
  0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC3, 0xF3, 0xE1, 0xF9,
  0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x3F, 0x3E, 0x3F, 0x1F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xF3, 0xE0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E,
  0x3F, 0x1F, 0x0F, 0x8F, 0x87, 0xE7, 0xC1, 0xFB, 0xE0, 0xFD, 0xF0, 0x3F,
  0x07, 0xC0, 0x7F, 0xF3, 0xFF, 0x9F, 0xFE, 0x7F, 0xFB, 0xF0, 0x4F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x7E, 0xFF,
  0xFB, 0xFF, 0xCF, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xCF, 0xC7, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F,
  0xF0, 0x1F, 0xF0, 0xF8, 0x03, 0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0x3E, 0x03,
  0xE7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x87, 0xC3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x1E, 0x7C,
  0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0xF8, 0x0F, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x83, 0xE7, 0xC1,
  0xF8, 0x3E, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x3F, 0x83,
  0xE7, 0xC3, 0xFC, 0x7C, 0x3E, 0x3F, 0xC7, 0xC3, 0xE3, 0xFC, 0x7C, 0x3E,
  0x3F, 0xC7, 0xC3, 0xE7, 0xBC, 0x7C, 0x3E, 0x79, 0xEF, 0x81, 0xE7, 0x9E,
  0xF8, 0x1F, 0x79, 0xEF, 0x81, 0xF7, 0x9E, 0xF8, 0x1F, 0xF1, 0xEF, 0x80,
  0xFF, 0x0E, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xE1, 0xF8, 0xF8, 0x7C, 0x3F, 0x3F, 0x07,
  0xCF, 0x81, 0xFB, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x0F, 0xFC, 0x07, 0xEF, 0x81, 0xF3, 0xE0, 0xFC, 0xFC, 0x3E, 0x1F, 0x1F,
  0x87, 0xE7, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xE7, 0xC0,
  0xF9, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1E, 0xF0, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x87, 0x87, 0xC3, 0xC3,
  0xC0, 0xF3, 0xE0, 0x7B, 0xE0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFC, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF,
  0xBF, 0x10, 0x7C, 0x01, 0xF0, 0x07, 0xC7, 0xFF, 0x7F, 0xFD, 0xFF, 0xFF,
  0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0xDF, 0xFF, 0x7F, 0xBC,
  0xFC, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7D, 0xF8, 0xFF, 0xF9, 0xFF, 0xFB, 0xFF, 0xF7, 0xE3,
  0xEF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC3, 0xFF, 0xC7, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC, 0xF3,
  0xF0, 0x0F, 0xF0, 0xFF, 0xCF, 0xFC, 0xFF, 0xE7, 0xE1, 0x3E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x0D,
  0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x8F, 0xDF, 0x3F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFB, 0xE3, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC7, 0xEF, 0xFF,
  0xCF, 0xFF, 0x9F, 0xEF, 0x1F, 0x9E, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE3,
  0xF7, 0xE7, 0xC3, 0xCF, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x9F, 0xFF, 0x1F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF0, 0x07, 0xF0, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE1, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x9E, 0x7F, 0xBD, 0xFF, 0xFB,
  0xFF, 0xF7, 0xC7, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xEF, 0x8F, 0xDF, 0xFF, 0xBF, 0xFF,
  0x3F, 0xFE, 0x3F, 0x7C, 0x00, 0xF8, 0x01, 0xF4, 0x03, 0xEF, 0x1F, 0xDF,
  0xFF, 0x3F, 0xFC, 0x7F, 0xF0, 0x3F, 0x80, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7D, 0xF8, 0xFF, 0xF9,
  0xFF, 0xFB, 0xFF, 0xF7, 0xE3, 0xEF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7E, 0xFF, 0xFF, 0xF7, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x1F,
  0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0xBF, 0xFF, 0xFE, 0xFC, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0xF8,
  0x7E, 0xF8, 0xFC, 0xF8, 0xF8, 0xF9, 0xF0, 0xFB, 0xF0, 0xFB, 0xE0, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFD, 0xF0, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF3, 0xF1, 0xFC, 0xF7, 0xFB, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFC, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF3, 0xF1, 0xEF, 0xF3, 0xFF,
  0xF7, 0xFF, 0xEF, 0xC7, 0xDF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFC, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFC, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3E, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xF3, 0xF1, 0xEF, 0xF3, 0xFF, 0xF7, 0xFF,
  0xEF, 0xC7, 0xDF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x8F, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF,
  0xF9, 0xF7, 0xE3, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x9E, 0x7F, 0xBD, 0xFF, 0xFB,
  0xFF, 0xF7, 0xC7, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xEF, 0x8F, 0xDF, 0xFF, 0xBF, 0xFF,
  0x3F, 0xFE, 0x3F, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xF3, 0xFE, 0x7B, 0xDF, 0x7F,
  0xEF, 0xFD, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x3F, 0xE7, 0xFF, 0xFF,
  0xEF, 0xDE, 0xF8, 0x2F, 0x80, 0xFE, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xF8, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x3F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xF0, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFE, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF,
  0x7F, 0xBC, 0xFC, 0xF0, 0xF8, 0x1F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x87,
  0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xF8, 0x1E, 0x7C, 0x0F,
  0xBE, 0x07, 0xDE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x3E, 0x0F, 0xBE, 0x3F,
  0x87, 0x9F, 0x1F, 0xC7, 0xCF, 0x8F, 0xE3, 0xE7, 0xC7, 0x71, 0xF1, 0xE3,
  0xB8, 0xF0, 0xFB, 0xDE, 0xF8, 0x7D, 0xEF, 0x7C, 0x3E, 0xF7, 0xBE, 0x1F,
  0x73, 0xDF, 0x07, 0xB8, 0xEF, 0x03, 0xDC, 0x77, 0x81, 0xEE, 0x3B, 0xC0,
  0xFF, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x7E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C,
  0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0x7C, 0x3E, 0x7C, 0x7E, 0x3E,
  0x7C, 0x3E, 0xFC, 0x3F, 0xF8, 0x1F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x87,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x3C, 0xF8, 0x1F, 0x7C, 0x0F,
  0xBE, 0x03, 0xDE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x02, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8,
  0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF1, 0xFE, 0x3F, 0x07,
  0xF0, 0xFF, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xFC, 0x3F, 0x83, 0xF0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x1F, 0x83, 0xF8, 0x7F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF8, 0x3F, 0xC1, 0xF8, 0x7F, 0x1F, 0xE3,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0x80, 0x18, 0x02, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xF0, 0x3F, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraBold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 12, 9, 16, 2, -24 },
  { 30, 17, 24, 19, 1, -24 },
  { 81, 14, 27, 17, 1, -25 },
  { 129, 26, 24, 28, 1, -24 },
  { 207, 21, 24, 21, 1, -24 },
  { 270, 5, 9, 8, 2, -24 },
  { 276, 9, 29, 11, 1, -24 },
  { 309, 9, 29, 11, 0, -24 },
  { 342, 14, 14, 16, 1, -25 },
  { 367, 15, 16, 17, 1, -20 },
  { 397, 6, 8, 9, 1, -4 },
  { 403, 9, 4, 10, 1, -11 },
  { 408, 5, 5, 9, 2, -5 },
  { 412, 14, 24, 14, 0, -24 },
  { 454, 15, 24, 17, 1, -24 },
  { 499, 12, 24, 17, 1, -24 },
  { 535, 14, 24, 17, 1, -24 },
  { 577, 14, 24, 17, 1, -24 },
  { 619, 15, 24, 17, 1, -24 },
  { 664, 13, 24, 17, 2, -24 },
  { 703, 15, 24, 17, 1, -24 },
  { 748, 15, 24, 17, 1, -24 },
  { 793, 15, 24, 17, 1, -24 },
  { 838, 15, 24, 17, 1, -24 },
  { 883, 5, 18, 9, 2, -18 },
  { 895, 6, 22, 9, 1, -18 },
  { 912, 15, 16, 17, 1, -20 },
  { 942, 15, 11, 17, 1, -17 },
  { 963, 15, 16, 17, 1, -20 },
  { 993, 13, 24, 14, 0, -24 },
  { 1032, 24, 27, 26, 1, -24 },
  { 1113, 20, 24, 20, 0, -24 },
  { 1173, 16, 24, 19, 2, -24 },
  { 1221, 16, 24, 18, 1, -24 },
  { 1269, 17, 24, 20, 2, -24 },
  { 1320, 12, 24, 16, 2, -24 },
  { 1356, 12, 24, 15, 2, -24 },
  { 1392, 17, 24, 21, 2, -24 },
  { 1443, 17, 24, 21, 2, -24 },
  { 1494, 10, 24, 12, 1, -24 },
  { 1524, 10, 31, 10, -2, -24 },
  { 1563, 17, 24, 19, 2, -24 },
  { 1614, 13, 24, 15, 2, -24 },
  { 1653, 23, 24, 28, 2, -24 },
  { 1722, 19, 24, 23, 2, -24 },
  { 1779, 19, 24, 22, 1, -24 },
  { 1836, 15, 24, 18, 2, -24 },
  { 1881, 19, 30, 22, 1, -24 },
  { 1953, 17, 24, 19, 2, -24 },
  { 2004, 14, 24, 16, 1, -24 },
  { 2046, 14, 24, 16, 1, -24 },
  { 2088, 17, 24, 21, 2, -24 },
  { 2139, 19, 24, 19, 0, -24 },
  { 2196, 28, 24, 28, 0, -24 },
  { 2280, 18, 24, 18, 0, -24 },
  { 2334, 18, 24, 18, 0, -24 },
  { 2388, 14, 24, 16, 1, -24 },
  { 2430, 8, 29, 10, 2, -24 },
  { 2459, 14, 24, 14, 0, -24 },
  { 2501, 8, 29, 10, 1, -24 },
  { 2530, 17, 15, 18, 0, -24 },
  { 2562, 15, 3, 15, 0, 3 },
  { 2568, 9, 5, 11, 1, -25 },
  { 2574, 14, 18, 17, 1, -18 },
  { 2606, 15, 25, 18, 2, -25 },
  { 2653, 13, 18, 15, 1, -18 },
  { 2683, 15, 25, 18, 1, -25 },
  { 2730, 15, 18, 17, 1, -18 },
  { 2764, 12, 25, 11, 0, -25 },
  { 2802, 15, 26, 18, 1, -18 },
  { 2851, 15, 25, 18, 2, -25 },
  { 2898, 5, 25, 9, 2, -25 },
  { 2914, 8, 33, 9, -1, -25 },
  { 2947, 16, 25, 18, 2, -25 },
  { 2997, 5, 25, 9, 2, -25 },
  { 3013, 24, 18, 27, 2, -18 },
  { 3067, 15, 18, 18, 2, -18 },
  { 3101, 16, 18, 18, 1, -18 },
  { 3137, 15, 26, 18, 2, -18 },
  { 3186, 15, 26, 18, 1, -18 },
  { 3235, 11, 18, 13, 2, -18 },
  { 3260, 12, 18, 14, 1, -18 },
  { 3287, 12, 22, 12, 0, -22 },
  { 3320, 14, 18, 18, 2, -18 },
  { 3352, 17, 18, 17, 0, -18 },
  { 3391, 25, 18, 25, 0, -18 },
  { 3448, 16, 18, 16, 0, -18 },
  { 3484, 17, 26, 17, 0, -18 },
  { 3540, 12, 18, 14, 1, -18 },
  { 3567, 11, 29, 12, 0, -24 },
  { 3607, 4, 33, 15, 6, -25 },
  { 3624, 11, 29, 12, 1, -24 },
  { 3664, 15, 6, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_ExtraBold33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD33PT7B_H_
