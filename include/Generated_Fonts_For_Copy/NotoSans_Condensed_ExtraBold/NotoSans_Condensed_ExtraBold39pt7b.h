#ifndef _NOTOSANS_CONDENSED_EXTRABOLD39PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0x7E, 0xFF, 0xFF,
  0xF3, 0xE0, 0xFC, 0xFF, 0xF8, 0xFB, 0xF1, 0xF7, 0xE3, 0xEF, 0xC7, 0xDF,
  0x8F, 0xBF, 0x1F, 0x7C, 0x3E, 0x78, 0x7C, 0xF0, 0xF8, 0x03, 0xE3, 0xC0,
  0x3E, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x7C, 0xF8, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x07, 0x8F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xF1,
  0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1F,
  0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x07, 0xF0, 0x1F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFD,
  0x8E, 0xF9, 0x80, 0xF9, 0x80, 0xF9, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xBF, 0x01,
  0x9F, 0x01, 0x9F, 0x81, 0x9F, 0xF1, 0xBF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0x7F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x7F, 0x80, 0x3C, 0x01, 0xFF, 0x80, 0xF8, 0x03, 0xFF,
  0x01, 0xE0, 0x0F, 0x9F, 0x07, 0xC0, 0x1F, 0x3E, 0x0F, 0x00, 0x3E, 0x3C,
  0x3E, 0x00, 0x7C, 0x78, 0x78, 0x00, 0xF8, 0xF0, 0xF0, 0x01, 0xF1, 0xE3,
  0xE0, 0x03, 0xE3, 0xC7, 0x80, 0x07, 0xCF, 0x9F, 0x1F, 0x07, 0x9F, 0x3C,
  0xFF, 0x0F, 0xFC, 0xF9, 0xFF, 0x1F, 0xF9, 0xE7, 0xFF, 0x1F, 0xE7, 0xCF,
  0xBE, 0x1F, 0x8F, 0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x7C, 0x00, 0x7C, 0xF8,
  0xF8, 0x00, 0xF1, 0xF1, 0xF0, 0x03, 0xE3, 0xE3, 0xE0, 0x07, 0x87, 0xC7,
  0xC0, 0x1F, 0x07, 0x8F, 0x00, 0x3C, 0x0F, 0x1E, 0x00, 0xF8, 0x1F, 0xFC,
  0x01, 0xE0, 0x1F, 0xF0, 0x03, 0xC0, 0x3F, 0xE0, 0x0F, 0x80, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xBF, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7E, 0x3F, 0xF8, 0x7E, 0x7F, 0xFC, 0x7E,
  0x7F, 0xFE, 0xFC, 0xFE, 0x7F, 0xFC, 0xFC, 0x7F, 0xFC, 0xFC, 0x3F, 0xF8,
  0xFC, 0x1F, 0xF8, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFE, 0xFE, 0x0F, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x79, 0xE0, 0x07, 0xC3, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE1,
  0xF8, 0x7C, 0x3F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x04, 0x3E, 0x13, 0x9E, 0x3B, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0x01,
  0xF7, 0xC1, 0xFB, 0xF1, 0xF8, 0xFC, 0x3C, 0x78, 0x0C, 0x18, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D,
  0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF3,
  0xF9, 0xF9, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD,
  0xFC, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFB, 0xCF, 0xCC, 0x7E, 0x23, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF3, 0xE1, 0xF8,
  0xC0, 0xFE, 0x20, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF1, 0xC1, 0xFC,
  0x80, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x81, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x07, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x03, 0xEF, 0x80, 0xF7, 0xE0,
  0x7D, 0xF8, 0x1E, 0x7E, 0x0F, 0x9F, 0x83, 0xC7, 0xE1, 0xF1, 0xF8, 0xF8,
  0x7E, 0x3E, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x20, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xCF, 0xC1, 0xF7,
  0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x7E, 0xFE, 0x1F,
  0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7E, 0x1F, 0x9F, 0x87, 0xE7,
  0xF1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF,
  0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0xCF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7F, 0x7F, 0x1F, 0x8F, 0xEF, 0xC1, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC1, 0xF9, 0xFC, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF,
  0xC7, 0xFF, 0xF3, 0xF1, 0xFB, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFB, 0xFB, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0x3F, 0xEF, 0x8F, 0xE7, 0xC0, 0x87, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFC, 0x07, 0xF8, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xFB, 0xFF, 0xFF, 0xCF, 0x80,
  0x1C, 0x3E, 0x7F, 0x7F, 0x7F, 0x7E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00,
  0x02, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F,
  0xFE, 0x38, 0x7E, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFC, 0xFF,
  0x81, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF3, 0xE0,
  0xFE, 0x1E, 0x78, 0x3F, 0xF3, 0xCF, 0x0F, 0xFE, 0x7F, 0xE3, 0xF7, 0xC7,
  0xF8, 0xF8, 0xF8, 0xFF, 0x1F, 0x1F, 0x1F, 0xE3, 0xC3, 0xE3, 0xFC, 0x78,
  0x7C, 0x7F, 0x9F, 0x0F, 0x8F, 0xF1, 0xE1, 0xF1, 0xFE, 0x3C, 0x3E, 0x3F,
  0xC7, 0x87, 0xCF, 0xF8, 0xF9, 0xF9, 0xEF, 0x1F, 0xFF, 0xFD, 0xF1, 0xFE,
  0xFF, 0x3E, 0x1F, 0x8F, 0xC3, 0xE0, 0xC0, 0x40, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xCF,
  0x80, 0x1F, 0x9F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC,
  0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F,
  0xC0, 0x7F, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x0F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC,
  0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x3F, 0xBF, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF,
  0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xE0, 0xE7, 0xF0, 0x09,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x18,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0xFF,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF9,
  0xFF, 0xBF, 0x07, 0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFD, 0xF8, 0x3F, 0xBF, 0x1F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xFB, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFC, 0x0C, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x03,
  0xF7, 0xF0, 0x3F, 0x7F, 0x83, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x83, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x1F, 0xC3, 0xF7, 0xFE, 0xFF, 0xDF, 0xF3, 0xFE, 0x7F, 0x00,
  0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x3F,
  0x8F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xCF, 0xE0, 0xFC, 0xFE, 0x0F, 0xDF,
  0xC0, 0xFD, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0, 0xFC, 0xFE, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8,
  0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x7C, 0x1F, 0xFF, 0xEF, 0x83, 0xFF,
  0xFD, 0xF0, 0xFB, 0xFF, 0xBE, 0x1F, 0x7F, 0xF3, 0xE3, 0xEF, 0xFE, 0x7C,
  0x79, 0xFF, 0xCF, 0x9F, 0x3F, 0xF8, 0xFB, 0xE7, 0xFF, 0x1F, 0x7C, 0xFF,
  0xE3, 0xFF, 0x1F, 0xFC, 0x7F, 0xE3, 0xFF, 0x87, 0xFC, 0x7F, 0xF0, 0xFF,
  0x0F, 0xFE, 0x1F, 0xE1, 0xFF, 0xC3, 0xFC, 0x3F, 0xF8, 0x3F, 0x87, 0xFF,
  0x07, 0xE0, 0xFF, 0xE0, 0xFC, 0x1F, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87,
  0xFE, 0xFC, 0x3F, 0xF7, 0xE1, 0xFF, 0x9F, 0x8F, 0xFC, 0xFC, 0x7F, 0xE3,
  0xF3, 0xFF, 0x1F, 0x9F, 0xF8, 0x7E, 0xFF, 0xC3, 0xF7, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xF0,
  0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFE, 0x1F, 0xE7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0xFE, 0x01,
  0xFB, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7E, 0x01, 0xF9, 0xFC, 0x0F,
  0xE7, 0xF8, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xF7, 0xE3, 0xFB, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xF7, 0xFF, 0xFB, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xE7, 0xF0, 0x3F,
  0x9F, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0x7E, 0x01, 0xF9, 0xFC, 0x0F, 0xE7, 0xF8, 0x7F, 0x8F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xF8, 0xFF, 0x3F, 0x0F, 0xE7, 0xE0,
  0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0xFE, 0x7E, 0x1F, 0xCF, 0xCF,
  0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0x9F,
  0x83, 0xF3, 0xF0, 0x7E, 0x7F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x0F,
  0xC7, 0xE1, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xFB, 0xF0, 0x3F, 0xFE, 0x07,
  0xF0, 0x07, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F,
  0x1E, 0x7E, 0x02, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x0F,
  0xDF, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F,
  0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFC, 0x03, 0xE0,
  0x1F, 0xFE, 0x01, 0xF0, 0x0F, 0xFF, 0x01, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE,
  0x07, 0xE7, 0xE0, 0x7F, 0x03, 0xF3, 0xF0, 0x3F, 0x81, 0xF9, 0xF8, 0x3F,
  0xC0, 0xFC, 0xFC, 0x1F, 0xF0, 0xFC, 0x3E, 0x0F, 0xF8, 0x7E, 0x1F, 0x87,
  0xBC, 0x3F, 0x0F, 0xC3, 0xDE, 0x1F, 0x87, 0xE3, 0xEF, 0x0F, 0xC1, 0xF1,
  0xF7, 0xC7, 0xC0, 0xF8, 0xFB, 0xE7, 0xE0, 0x7E, 0x7D, 0xF3, 0xF0, 0x3F,
  0x7C, 0xF9, 0xF8, 0x1F, 0xBE, 0x3C, 0xFC, 0x07, 0xDF, 0x1F, 0x7C, 0x03,
  0xEF, 0x8F, 0xFE, 0x01, 0xF7, 0xC7, 0xFF, 0x00, 0xFB, 0xC3, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xC3, 0xF0,
  0x7F, 0x0F, 0xC1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x00, 0xFC, 0xFC,
  0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xDF, 0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0xFE, 0x0F, 0xE1, 0xF8, 0x3F,
  0x07, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0xFE, 0x01,
  0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0xFC, 0xFE, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F,
  0xC3, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC,
  0x03, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0x7C,
  0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x01, 0xF7, 0xE0,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0xC1, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x87, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF1, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF, 0x3F, 0xDF, 0xFF, 0xEF,
  0xFD, 0xF3, 0xFC, 0xF8, 0xFC, 0x3C, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x78, 0x3F, 0x3F, 0x8F, 0xDF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF,
  0xCF, 0xEF, 0xE1, 0xFB, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFD, 0xFE, 0x3E,
  0x3F, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE,
  0x7F, 0x8C, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x02,
  0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x07, 0x8F, 0xC3, 0xFB, 0xF1, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0xDF, 0xCF, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xDF, 0x83, 0xF7,
  0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x1F, 0xF7, 0xC3, 0xF1, 0xF0, 0x01, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x87, 0xE7, 0xE0, 0xF9, 0xF8, 0x3E,
  0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x8F, 0xE1, 0xC3, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x1F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0x21, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x00, 0x07, 0x80, 0x03, 0xF9, 0xF1, 0xFF, 0x7C, 0xFF, 0xFF, 0x3F, 0xFF,
  0xDF, 0xC7, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8,
  0x3F, 0x7E, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xEF,
  0xC3, 0xF3, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xD8, 0x07, 0xF7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x81, 0xFF, 0x80, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x78, 0x3F, 0x7F, 0x8F, 0xDF, 0xF3,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xCF, 0xEF, 0xE1, 0xFB, 0xF8, 0x7F, 0xFC,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFB, 0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x81, 0xFB, 0xF0, 0x7F, 0x7E, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFC, 0x3F,
  0x3F, 0x87, 0xE7, 0xE0, 0xFD, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0x9F, 0x87, 0xE3, 0xF8, 0xFC,
  0x3F, 0x1F, 0x87, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xEF, 0xC0, 0xFD, 0xF8,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7C, 0x0F, 0x0F, 0x9F, 0xE3, 0xFC, 0xFB, 0xFF, 0x7F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x7F, 0xFE, 0x1F,
  0xC3, 0xFF, 0xE1, 0xFC, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F,
  0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83,
  0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC,
  0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0x00, 0x78, 0x3E, 0x7F, 0x8F, 0xBF,
  0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xCF, 0xEF, 0xE1, 0xFB, 0xF8, 0x7F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFE, 0x3F, 0x9F, 0x83,
  0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xDF, 0xC1, 0xFB, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0xFE, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0xC7, 0xF7, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x00, 0x78, 0x3E, 0x3F, 0x8F, 0xDF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0xBF, 0xCF, 0xEF, 0xE1, 0xFB, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFD, 0xFE,
  0x3F, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0x80, 0x03, 0xF9, 0xF1, 0xFF, 0x7C, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0xC7,
  0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E,
  0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xEF, 0xC3, 0xF3,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xC7,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xFE, 0x3F, 0xC0, 0xFE, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x7F,
  0xE7, 0xFF, 0xDF, 0xFE, 0xFF, 0xFB, 0xF0, 0x6F, 0xC0, 0x3F, 0x80, 0x7F,
  0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0x80,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0xFB, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF1, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xFC,
  0xFF, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0x80, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE7,
  0xFD, 0xF1, 0xFC, 0x78, 0xFC, 0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7,
  0xE0, 0xFC, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x81, 0xF1, 0xF8,
  0x1F, 0x1F, 0x81, 0xF9, 0xF0, 0x1F, 0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xBF,
  0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0xC1,
  0xFB, 0xF0, 0xFF, 0x0F, 0xDF, 0x87, 0xF8, 0x7E, 0xFC, 0x3F, 0xC3, 0xE7,
  0xE3, 0xFE, 0x3F, 0x1F, 0x1F, 0xF1, 0xF8, 0xFC, 0xF7, 0x8F, 0xC7, 0xE7,
  0xBE, 0x7C, 0x3F, 0x3D, 0xF3, 0xE0, 0xF9, 0xE7, 0xBF, 0x07, 0xDF, 0x3D,
  0xF8, 0x3E, 0xF1, 0xEF, 0x81, 0xFF, 0x8F, 0x7C, 0x07, 0xFC, 0x7F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0x7F,
  0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0xFE, 0x0F, 0xEF, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0xCF, 0xC1,
  0xFB, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03,
  0xEF, 0xC0, 0xFD, 0xF8, 0x3F, 0x9F, 0x87, 0xE3, 0xF1, 0xFC, 0x7F, 0x3F,
  0x07, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x81, 0xF1, 0xF8,
  0x1F, 0x9F, 0x81, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x3F, 0x8F, 0xF0, 0xFE, 0x0F, 0xC0, 0xFF,
  0x0F, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xF0, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x81, 0xFF, 0x07, 0xF8, 0x1F,
  0xC3, 0xFE, 0x1F, 0xF1, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x5F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xF0, 0x3F, 0xE8, 0x00, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraBold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 28, 11, 2, -28 },
  { 26, 15, 10, 18, 2, -28 },
  { 45, 20, 28, 22, 1, -28 },
  { 115, 16, 32, 20, 2, -30 },
  { 179, 31, 28, 33, 1, -28 },
  { 288, 24, 28, 25, 1, -28 },
  { 372, 6, 10, 10, 2, -28 },
  { 380, 10, 34, 13, 2, -28 },
  { 423, 10, 34, 13, 1, -28 },
  { 466, 17, 17, 19, 1, -30 },
  { 503, 18, 19, 20, 1, -23 },
  { 546, 8, 10, 11, 1, -5 },
  { 556, 10, 5, 12, 1, -13 },
  { 563, 7, 6, 11, 2, -6 },
  { 569, 16, 28, 16, 0, -28 },
  { 625, 17, 28, 20, 1, -28 },
  { 685, 13, 28, 20, 2, -28 },
  { 731, 17, 28, 20, 1, -28 },
  { 791, 17, 28, 20, 1, -28 },
  { 851, 18, 28, 20, 1, -28 },
  { 914, 16, 28, 20, 2, -28 },
  { 970, 18, 28, 20, 1, -28 },
  { 1033, 17, 28, 20, 1, -28 },
  { 1093, 18, 28, 20, 1, -28 },
  { 1156, 17, 28, 20, 1, -28 },
  { 1216, 7, 22, 11, 2, -22 },
  { 1236, 8, 27, 11, 1, -22 },
  { 1263, 18, 20, 20, 1, -24 },
  { 1308, 18, 13, 20, 1, -20 },
  { 1338, 18, 20, 20, 1, -24 },
  { 1383, 16, 28, 16, 0, -28 },
  { 1439, 27, 31, 31, 2, -28 },
  { 1544, 23, 28, 23, 0, -28 },
  { 1625, 18, 28, 23, 3, -28 },
  { 1688, 18, 28, 21, 2, -28 },
  { 1751, 19, 28, 24, 3, -28 },
  { 1818, 14, 28, 18, 3, -28 },
  { 1867, 14, 28, 18, 3, -28 },
  { 1916, 20, 28, 24, 2, -28 },
  { 1986, 20, 28, 25, 3, -28 },
  { 2056, 12, 28, 14, 1, -28 },
  { 2098, 11, 36, 12, -2, -28 },
  { 2148, 20, 28, 22, 3, -28 },
  { 2218, 14, 28, 18, 3, -28 },
  { 2267, 27, 28, 33, 3, -28 },
  { 2362, 21, 28, 27, 3, -28 },
  { 2436, 22, 28, 26, 2, -28 },
  { 2513, 17, 28, 21, 3, -28 },
  { 2573, 22, 35, 26, 2, -28 },
  { 2670, 19, 28, 22, 3, -28 },
  { 2737, 16, 28, 19, 1, -28 },
  { 2793, 17, 28, 19, 1, -28 },
  { 2853, 19, 28, 25, 3, -28 },
  { 2920, 22, 28, 22, 0, -28 },
  { 2997, 33, 28, 33, 0, -28 },
  { 3113, 22, 28, 22, 0, -28 },
  { 3190, 21, 28, 21, 0, -28 },
  { 3264, 17, 28, 19, 1, -28 },
  { 3324, 9, 34, 12, 2, -28 },
  { 3363, 16, 28, 16, 0, -28 },
  { 3419, 9, 34, 12, 1, -28 },
  { 3458, 21, 18, 21, 0, -28 },
  { 3506, 18, 4, 18, 0, 3 },
  { 3515, 10, 6, 13, 2, -30 },
  { 3523, 17, 22, 20, 1, -22 },
  { 3570, 18, 30, 21, 2, -30 },
  { 3638, 16, 22, 17, 1, -22 },
  { 3682, 18, 30, 21, 1, -30 },
  { 3750, 18, 22, 20, 1, -22 },
  { 3800, 14, 30, 13, 0, -30 },
  { 3853, 18, 31, 21, 1, -22 },
  { 3923, 18, 30, 22, 2, -30 },
  { 3991, 6, 30, 11, 2, -30 },
  { 4014, 9, 39, 11, -1, -30 },
  { 4058, 19, 30, 21, 2, -30 },
  { 4130, 6, 30, 10, 2, -30 },
  { 4153, 28, 22, 32, 2, -22 },
  { 4230, 18, 22, 22, 2, -22 },
  { 4280, 19, 22, 21, 1, -22 },
  { 4333, 18, 31, 21, 2, -22 },
  { 4403, 18, 31, 21, 1, -22 },
  { 4473, 13, 22, 15, 2, -22 },
  { 4509, 14, 22, 16, 1, -22 },
  { 4548, 13, 26, 15, 1, -26 },
  { 4591, 17, 21, 22, 2, -21 },
  { 4636, 20, 21, 20, 0, -21 },
  { 4689, 29, 21, 30, 0, -21 },
  { 4766, 19, 21, 19, 0, -21 },
  { 4816, 20, 30, 20, 0, -21 },
  { 4891, 14, 21, 16, 1, -21 },
  { 4928, 12, 34, 15, 1, -28 },
  { 4979, 4, 39, 18, 7, -30 },
  { 4999, 13, 34, 15, 1, -28 },
  { 5055, 18, 7, 20, 1, -17 },
};

const GFXfont NotoSans_Condensed_ExtraBold39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD39PT7B_H_
