#ifndef _NOTOSANS_CONDENSED_EXTRABOLD23PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x00, 0x6F, 0xFF, 0xF7, 0xFB, 0xFD,
  0xFC, 0xEE, 0x33, 0x18, 0x0E, 0xE0, 0x77, 0x03, 0x38, 0x19, 0x87, 0xFF,
  0xBF, 0xFD, 0xFF, 0xE3, 0xB8, 0x1D, 0xC7, 0xFF, 0xBF, 0xFC, 0x33, 0x03,
  0x98, 0x1D, 0xC0, 0xEE, 0x06, 0x70, 0x0C, 0x07, 0xC7, 0xFF, 0xFE, 0xEC,
  0xBB, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x37, 0x8D, 0xFF, 0xEF,
  0xF9, 0xF8, 0x0C, 0x03, 0x00, 0x30, 0x04, 0x1F, 0x06, 0x0F, 0xC3, 0x83,
  0xB8, 0xC0, 0xCE, 0x70, 0x33, 0x98, 0x0C, 0xEE, 0x03, 0xBB, 0xBC, 0xFD,
  0xDF, 0x9F, 0x77, 0x63, 0x19, 0x9C, 0x0E, 0xE7, 0x03, 0x39, 0xC1, 0xC6,
  0x70, 0x61, 0xD8, 0x38, 0x7E, 0x0E, 0x0F, 0x00, 0x0E, 0x00, 0xFE, 0x07,
  0xF8, 0x1C, 0xE0, 0x73, 0xC1, 0xEE, 0x07, 0xF8, 0x0F, 0xC0, 0x3E, 0x39,
  0xFD, 0xEF, 0xFF, 0xB9, 0xFC, 0xE3, 0xF3, 0xC7, 0x8F, 0xFF, 0x1F, 0xFE,
  0x3F, 0x7C, 0xFF, 0xFE, 0xE6, 0x1C, 0xF3, 0x9E, 0x71, 0xCF, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8F, 0x1C, 0x71, 0xE3, 0x8F, 0x1C, 0xE0, 0xE0, 0xE1,
  0xC3, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x0E, 0x3C,
  0x70, 0xE3, 0x8E, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x37, 0x67, 0xFD, 0xFF,
  0xC7, 0xC0, 0xFC, 0x7B, 0xC7, 0x30, 0x44, 0x00, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x3F, 0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xFE,
  0xEE, 0xFF, 0xFF, 0xC0, 0x6F, 0xFF, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x0F, 0xC7, 0xF9, 0xDE, 0xF3, 0xBC, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xF3, 0xFC, 0xE7, 0xF9, 0xFC,
  0x3E, 0x00, 0x0F, 0x1F, 0x3F, 0x7F, 0xFF, 0x6F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1C, 0x1F, 0xCF, 0xFB, 0xDE, 0x43,
  0x80, 0xE0, 0x38, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x3F, 0xCF, 0xF9, 0x9E, 0x03, 0x80, 0xE0,
  0x78, 0xFC, 0x3E, 0x0F, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0xFF, 0xFB, 0xFE,
  0xFE, 0x00, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x8E, 0xF1,
  0xDE, 0x73, 0xCE, 0x7B, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0xF0, 0x1E,
  0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70, 0x3F, 0x0F, 0xF3, 0xFE, 0x47, 0x80,
  0xF0, 0x3C, 0x0F, 0x83, 0xBF, 0xEF, 0xF3, 0xF8, 0x07, 0x87, 0xE3, 0xF9,
  0xF1, 0x70, 0x38, 0x0E, 0x73, 0xFE, 0xFF, 0xBC, 0xFE, 0x3F, 0x8F, 0xE3,
  0xFC, 0xF7, 0xF9, 0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x03,
  0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03,
  0x81, 0xE0, 0x1C, 0x1F, 0xC7, 0xFB, 0xCE, 0xE3, 0xFC, 0xE7, 0xF9, 0xFC,
  0x3E, 0x1F, 0xEF, 0x7B, 0x8F, 0xE1, 0xF8, 0xFF, 0xFD, 0xFE, 0x3F, 0x00,
  0x1C, 0x1F, 0xC7, 0xFB, 0xDE, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xFF, 0xFF,
  0xF7, 0xDC, 0x0F, 0x03, 0x81, 0xE7, 0xF1, 0xFC, 0x7C, 0x00, 0x6F, 0xF7,
  0x00, 0x00, 0x06, 0xFF, 0xF0, 0x6F, 0xF7, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0xEE, 0x00, 0x40, 0x70, 0x7C, 0x7E, 0x7C, 0x3C, 0x0F, 0x81, 0xFC, 0x0F,
  0xC0, 0xF0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x38, 0x0F, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0xFC, 0xFC, 0xFC,
  0x3C, 0x0C, 0x00, 0x1C, 0x3F, 0xBF, 0xEC, 0xF0, 0x38, 0x1C, 0x1E, 0x1E,
  0x1E, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xC0, 0xF0, 0x78, 0x3C, 0x00, 0x01,
  0xC0, 0x0F, 0xF8, 0x1F, 0x7C, 0x38, 0x0E, 0x70, 0x06, 0x63, 0xF7, 0xE7,
  0xF3, 0xEE, 0x73, 0xEE, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x77, 0xEF,
  0xFE, 0xE7, 0x9E, 0x70, 0x00, 0x70, 0x00, 0x3E, 0x38, 0x1F, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1D, 0xE0, 0x77, 0x81,
  0xCE, 0x0F, 0x38, 0x3C, 0xF0, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x78, 0x79,
  0xE1, 0xEF, 0x07, 0xBC, 0x0F, 0xFF, 0xBF, 0xEE, 0x7F, 0x8F, 0xE3, 0xF8,
  0xFF, 0xFB, 0xFC, 0xFF, 0xF8, 0xFE, 0x1F, 0x87, 0xE3, 0xFF, 0xFF, 0xFB,
  0xFC, 0x07, 0x03, 0xFC, 0xFF, 0x3E, 0x67, 0x81, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x9F, 0xF1, 0xFE, 0x1F,
  0xC0, 0xFF, 0x1F, 0xF3, 0xFF, 0x71, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3D, 0xFF, 0xBF, 0xE7, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE,
  0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x03, 0x81, 0xFF, 0x3F, 0xE7,
  0xEE, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF,
  0x0F, 0x70, 0xF7, 0x8F, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFD, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xBF, 0xFF, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xFF, 0xFE,
  0xF0, 0xE1, 0xFC, 0x7B, 0x8F, 0x73, 0xCE, 0xF1, 0xDE, 0x3F, 0x87, 0xF0,
  0xFF, 0x1F, 0xE3, 0x9E, 0x73, 0xCE, 0x3D, 0xC7, 0xB8, 0x7F, 0x0F, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xEE, 0x6F, 0xEE, 0xEF, 0xEE, 0xEF, 0xE6,
  0xCF, 0xE7, 0xCF, 0xE7, 0xCF, 0xE7, 0xCF, 0xE3, 0x8F, 0xE3, 0x8F, 0xF0,
  0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xFC, 0x7F, 0xE7, 0xEE, 0x7E, 0xF7, 0xE7,
  0x7E, 0x7F, 0xE7, 0xFE, 0x3F, 0xE3, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0x07,
  0x00, 0xFF, 0x0F, 0xFC, 0xFB, 0xE7, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xBC, 0x79, 0xFF, 0xC7,
  0xFC, 0x1F, 0xC0, 0xFF, 0x3F, 0xEF, 0xFB, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0xFE, 0xFF, 0xBF, 0x8E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x07,
  0x00, 0xFF, 0x0F, 0xFC, 0xFB, 0xE7, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7, 0x07, 0xBC, 0x79, 0xFF, 0xC7,
  0xFC, 0x1F, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xFF, 0x1F,
  0xF3, 0xFF, 0x71, 0xEE, 0x3D, 0xC7, 0xB9, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3,
  0x9C, 0x73, 0xCE, 0x79, 0xC7, 0xB8, 0xF7, 0x0F, 0x1C, 0x3F, 0xDF, 0xFF,
  0xFF, 0x0F, 0x83, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF0, 0x3E, 0x3F,
  0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x1F, 0xFF, 0x9F, 0xF1, 0xFC,
  0xF0, 0x7B, 0x83, 0xDC, 0x1C, 0xF0, 0xE7, 0x8F, 0x1C, 0x78, 0xE3, 0x87,
  0x9C, 0x3D, 0xE0, 0xEE, 0x07, 0x70, 0x3B, 0x80, 0xFC, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0xF0, 0xE0, 0xFE, 0x1E, 0x1D, 0xC3, 0xC7, 0xB8, 0xF8, 0xF7,
  0x1F, 0x1C, 0xF3, 0xE3, 0x9E, 0x6E, 0x71, 0xDD, 0xDE, 0x3B, 0xBB, 0xC7,
  0x77, 0x70, 0xEE, 0x6E, 0x1F, 0x8F, 0xC1, 0xF1, 0xF8, 0x3E, 0x3F, 0x07,
  0xC3, 0xC0, 0xF8, 0x78, 0xF8, 0xF3, 0xC7, 0x0E, 0x78, 0x7B, 0x81, 0xFC,
  0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xF0, 0x7B, 0x83,
  0xDE, 0x3C, 0x71, 0xE3, 0xDE, 0x0F, 0xF0, 0xF7, 0x8F, 0x78, 0xE3, 0x9E,
  0x3D, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0xEF, 0xFD, 0xFF, 0x01, 0xE0,
  0x38, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xFC, 0xE0, 0x1C, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0xFC, 0x06, 0x00,
  0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0x9C, 0x39, 0xC3, 0x0E, 0x70, 0xEF,
  0x07, 0xFF, 0xFF, 0xF0, 0xF1, 0xE3, 0x87, 0x1E, 0x1F, 0xE7, 0xF9, 0x0F,
  0x03, 0xCF, 0xF7, 0xFF, 0xCF, 0xE3, 0xF8, 0xFF, 0x7F, 0xF7, 0x79, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x71, 0xFF, 0x3F, 0xF7, 0xCE, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xBF, 0xF7, 0xFE, 0xE7, 0x80,
  0x1F, 0x1F, 0xDF, 0xDE, 0x2F, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x7F,
  0xCF, 0xE3, 0xF0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x39, 0xDF, 0xF7, 0xFF,
  0xCF, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFC, 0xFF, 0xFD, 0xFF, 0x3D,
  0xC0, 0x1E, 0x1F, 0xE7, 0xFB, 0xCF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3C, 0x07, 0xF9, 0xFE, 0x3F, 0x80, 0x06, 0x1F, 0x3F, 0x3D, 0x38, 0x3F,
  0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x39, 0xDF, 0xF7, 0xFF, 0xCF, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFC,
  0xFF, 0xFD, 0xFF, 0x3D, 0xC0, 0x70, 0x1F, 0x9F, 0xFF, 0xBF, 0xC0, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x79, 0xFF, 0xBF, 0xF7, 0xCE, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xE0,
  0x6F, 0xF7, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0xF3, 0xC7,
  0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0xBF, 0xEF, 0x90, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xEF, 0x1E,
  0xF3, 0xCF, 0x78, 0xF7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x3C,
  0xF3, 0xCF, 0x1E, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE7, 0x8E, 0x77, 0xFF, 0xBF, 0xFF, 0xFF, 0x7C, 0xFF, 0x1E,
  0x7F, 0x8E, 0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC,
  0x71, 0xFE, 0x38, 0xFF, 0x1C, 0x78, 0xE7, 0x9D, 0xFB, 0xFF, 0x7C, 0xEF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1E,
  0x1E, 0x07, 0xF1, 0xFF, 0x79, 0xEF, 0x1D, 0xC3, 0xB8, 0x7F, 0x0F, 0xF1,
  0xDE, 0x39, 0xFF, 0x3F, 0xC3, 0xF0, 0xE7, 0x1F, 0xF3, 0xFF, 0x78, 0xEF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3B, 0xFF, 0x7F, 0xEF, 0x79,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x3D, 0xDF, 0xF7,
  0xFF, 0xCF, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFC, 0xFF, 0xFD, 0xFF,
  0x3D, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0xE7, 0xEF, 0xFF,
  0xFE, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x3C, 0xFF,
  0xFE, 0xE2, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0x87, 0xFF, 0xFE, 0xFC, 0x18,
  0x38, 0x3F, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F,
  0x3F, 0x1F, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x77, 0xFD, 0xFF, 0x3C, 0xC0, 0xF0, 0xFF, 0x0E, 0x71, 0xE7,
  0x1E, 0x79, 0xC3, 0x9C, 0x3B, 0xC3, 0xB8, 0x1F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x0F, 0x00, 0xF1, 0xE3, 0xF8, 0xF1, 0xDC, 0xF9, 0xEE, 0x7C, 0xF7,
  0x36, 0x73, 0xDB, 0xB8, 0xED, 0xDC, 0x7E, 0xFE, 0x3F, 0x3E, 0x1F, 0x9F,
  0x07, 0x8F, 0x83, 0xC7, 0xC1, 0xE3, 0xC0, 0xF1, 0xEF, 0x3D, 0xEF, 0x1D,
  0xE3, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x87, 0x71, 0xEF, 0x3C, 0xEF,
  0x1E, 0xF0, 0xFF, 0x0E, 0x71, 0xE7, 0x9E, 0x79, 0xC3, 0x9C, 0x3B, 0xC3,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x07,
  0xE0, 0x7C, 0x07, 0x80, 0x20, 0x00, 0x7F, 0xBF, 0xDF, 0xE0, 0xE0, 0xF0,
  0x70, 0x78, 0x78, 0x3C, 0x3C, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0x0F, 0x1F,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0xFC, 0xF0, 0xF8, 0x3C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1F, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x81, 0xE3, 0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7C,
  0x39, 0xF3, 0x87, 0x0E, 0x1C, 0x38, 0xF3, 0xE7, 0x8E, 0x00, 0xF8, 0x7F,
  0xFF, 0xFE, 0x1E,
};

const GFXglyph NotoSans_Condensed_ExtraBold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 9, 6, 11, 1, -16 },
  { 16, 13, 16, 13, 0, -16 },
  { 42, 10, 18, 12, 1, -17 },
  { 65, 18, 17, 19, 1, -17 },
  { 104, 14, 17, 15, 1, -17 },
  { 134, 4, 6, 6, 1, -16 },
  { 137, 6, 21, 8, 1, -17 },
  { 153, 7, 21, 8, 0, -17 },
  { 172, 11, 11, 11, 0, -18 },
  { 188, 10, 11, 12, 1, -14 },
  { 202, 4, 6, 6, 1, -3 },
  { 205, 6, 3, 7, 1, -8 },
  { 208, 4, 4, 6, 1, -4 },
  { 210, 10, 17, 10, 0, -17 },
  { 232, 10, 17, 12, 1, -17 },
  { 254, 8, 16, 12, 1, -16 },
  { 270, 10, 17, 12, 1, -17 },
  { 292, 10, 17, 12, 1, -17 },
  { 314, 11, 16, 12, 0, -16 },
  { 336, 10, 16, 12, 1, -16 },
  { 356, 10, 17, 12, 1, -17 },
  { 378, 10, 16, 12, 1, -16 },
  { 398, 10, 17, 12, 1, -17 },
  { 420, 10, 17, 12, 1, -17 },
  { 442, 4, 13, 6, 1, -13 },
  { 449, 4, 16, 6, 1, -13 },
  { 457, 10, 11, 12, 1, -14 },
  { 471, 10, 8, 12, 1, -12 },
  { 481, 10, 11, 12, 1, -14 },
  { 495, 9, 17, 10, 0, -17 },
  { 515, 16, 19, 18, 1, -17 },
  { 553, 14, 16, 14, 0, -16 },
  { 581, 10, 16, 13, 2, -16 },
  { 601, 11, 17, 12, 1, -17 },
  { 625, 11, 16, 14, 2, -16 },
  { 647, 8, 16, 11, 2, -16 },
  { 663, 8, 16, 11, 2, -16 },
  { 679, 12, 17, 14, 1, -17 },
  { 705, 11, 16, 15, 2, -16 },
  { 727, 7, 16, 8, 1, -16 },
  { 741, 6, 21, 7, -1, -16 },
  { 757, 11, 16, 13, 2, -16 },
  { 779, 8, 16, 11, 2, -16 },
  { 795, 16, 16, 19, 2, -16 },
  { 827, 12, 16, 16, 2, -16 },
  { 851, 13, 17, 15, 1, -17 },
  { 879, 10, 16, 12, 2, -16 },
  { 899, 13, 21, 15, 1, -17 },
  { 934, 11, 16, 13, 2, -16 },
  { 956, 9, 17, 11, 1, -17 },
  { 976, 11, 16, 11, 0, -16 },
  { 998, 11, 16, 15, 2, -16 },
  { 1020, 13, 16, 13, 0, -16 },
  { 1046, 19, 16, 19, 0, -16 },
  { 1084, 13, 16, 13, 0, -16 },
  { 1110, 12, 16, 12, 0, -16 },
  { 1134, 11, 16, 11, 0, -16 },
  { 1156, 6, 21, 7, 1, -17 },
  { 1172, 10, 17, 10, 0, -17 },
  { 1194, 6, 21, 7, 0, -17 },
  { 1210, 12, 10, 12, 0, -16 },
  { 1225, 10, 2, 10, 0, 2 },
  { 1228, 6, 4, 8, 1, -18 },
  { 1231, 10, 13, 12, 1, -13 },
  { 1248, 11, 17, 13, 1, -17 },
  { 1272, 9, 13, 10, 1, -13 },
  { 1287, 10, 17, 13, 1, -17 },
  { 1309, 10, 13, 12, 1, -13 },
  { 1326, 8, 18, 8, 0, -18 },
  { 1344, 10, 19, 13, 1, -13 },
  { 1368, 11, 17, 13, 1, -17 },
  { 1392, 4, 18, 6, 1, -18 },
  { 1401, 6, 24, 6, -1, -18 },
  { 1419, 12, 17, 12, 1, -17 },
  { 1445, 4, 17, 6, 1, -17 },
  { 1454, 17, 13, 19, 1, -13 },
  { 1482, 11, 13, 13, 1, -13 },
  { 1500, 11, 13, 12, 1, -13 },
  { 1518, 11, 19, 13, 1, -13 },
  { 1545, 10, 19, 13, 1, -13 },
  { 1569, 8, 13, 9, 1, -13 },
  { 1582, 8, 13, 10, 1, -13 },
  { 1595, 8, 15, 9, 0, -15 },
  { 1610, 10, 13, 13, 1, -13 },
  { 1627, 12, 13, 12, 0, -13 },
  { 1647, 17, 13, 17, 0, -13 },
  { 1675, 11, 13, 11, 0, -13 },
  { 1693, 12, 19, 12, 0, -13 },
  { 1722, 9, 13, 10, 0, -13 },
  { 1737, 8, 21, 9, 0, -17 },
  { 1758, 3, 23, 11, 4, -18 },
  { 1767, 7, 21, 9, 1, -17 },
  { 1786, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_ExtraBold23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD23PT7B_H_
