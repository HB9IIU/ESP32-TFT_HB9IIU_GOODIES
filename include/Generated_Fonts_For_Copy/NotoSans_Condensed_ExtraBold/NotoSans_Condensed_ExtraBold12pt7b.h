#ifndef _NOTOSANS_CONDENSED_EXTRABOLD12PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xA3, 0xC0, 0xBB, 0xBB, 0x3C, 0x58, 0xA3, 0xF2, 0x9F, 0xBF,
  0x3C, 0x58, 0x11, 0xED, 0x98, 0x78, 0x69, 0xDE, 0x30, 0x40, 0x63, 0x1C,
  0x8D, 0x63, 0x50, 0x7F, 0x9A, 0xB0, 0xAC, 0x4B, 0x31, 0x80, 0x30, 0x78,
  0x68, 0x78, 0x73, 0x7E, 0xCE, 0xFE, 0x7F, 0xF0, 0x7B, 0x49, 0x24, 0xD9,
  0x80, 0xC9, 0x92, 0x49, 0x6F, 0x00, 0x33, 0xEF, 0xDC, 0x58, 0x30, 0xCF,
  0xCC, 0x30, 0xC0, 0x69, 0x60, 0xFC, 0xF0, 0x18, 0xC4, 0x62, 0x31, 0x88,
  0xC0, 0x31, 0xE4, 0xB3, 0xCF, 0x34, 0xDE, 0x78, 0x37, 0xFB, 0x33, 0x33,
  0x30, 0x33, 0xE4, 0x86, 0x18, 0xC6, 0x1F, 0xFC, 0x33, 0xE0, 0x86, 0x70,
  0x60, 0xF6, 0xF8, 0x18, 0x63, 0x8E, 0x5B, 0x6F, 0xC6, 0x18, 0xF7, 0xB1,
  0x4F, 0x0C, 0x76, 0xF0, 0x19, 0xE6, 0x14, 0xFB, 0x3C, 0xDE, 0x78, 0xFF,
  0xF0, 0x86, 0x18, 0xC3, 0x0C, 0x60, 0x31, 0xE4, 0x9E, 0x31, 0xEC, 0xF3,
  0x78, 0x31, 0xEC, 0xF3, 0xFD, 0xF0, 0xA6, 0x70, 0xB0, 0x3C, 0x4C, 0x00,
  0xD2, 0xC0, 0x0C, 0xEE, 0x1C, 0x1C, 0x10, 0xFC, 0x0F, 0xFF, 0xC1, 0xC1,
  0xCE, 0xE2, 0x00, 0x77, 0xC6, 0x33, 0x30, 0x0C, 0x60, 0x0C, 0x19, 0x98,
  0x6B, 0xD5, 0x6E, 0xB5, 0x5E, 0x96, 0x62, 0x0F, 0x00, 0x38, 0x70, 0xA3,
  0x66, 0xCD, 0x9F, 0x63, 0xC6, 0xE7, 0xF7, 0xBF, 0x6F, 0x7F, 0xF0, 0x37,
  0xF1, 0x8C, 0x63, 0x1F, 0x78, 0xE3, 0xED, 0xF3, 0xCF, 0x3C, 0xFE, 0xF0,
  0xFF, 0xCC, 0xFC, 0xCF, 0xF0, 0xFF, 0xCC, 0xFF, 0xCC, 0xC0, 0x39, 0xFC,
  0x30, 0xDF, 0x7C, 0xFF, 0x7C, 0xCF, 0x3C, 0xF3, 0xFF, 0x3C, 0xF3, 0xCC,
  0xFF, 0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0xEC, 0xCF,
  0x6D, 0xBC, 0xF3, 0xCD, 0xB6, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC3,
  0xE7, 0xE7, 0xE7, 0xF7, 0xFF, 0xDB, 0xDB, 0xDB, 0xC7, 0xCF, 0x9F, 0xBF,
  0x7A, 0xF7, 0xE7, 0xCE, 0x33, 0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0x78, 0xE7,
  0xF7, 0xBF, 0xFB, 0x18, 0xC0, 0x33, 0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0x78,
  0x60, 0xC0, 0xE3, 0xED, 0xB6, 0xFB, 0xCD, 0xB6, 0xCC, 0x33, 0xF2, 0xC7,
  0x1C, 0x7F, 0xF0, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xFF, 0x78, 0xC7, 0x8D, 0x33, 0x66, 0xCD, 0x0A, 0x1C,
  0x38, 0xCC, 0xF3, 0x3C, 0xCD, 0x3A, 0x7F, 0x9F, 0xE7, 0x39, 0xCE, 0x33,
  0x00, 0xCC, 0xD9, 0xA1, 0xC3, 0x07, 0x1E, 0x36, 0xCE, 0xCF, 0x99, 0xB3,
  0xC3, 0x86, 0x0C, 0x18, 0x30, 0xFF, 0xF1, 0x86, 0x31, 0x86, 0x3F, 0xFC,
  0xFE, 0x49, 0x24, 0x93, 0x80, 0xC6, 0x10, 0xC2, 0x18, 0xC2, 0x18, 0xFD,
  0xB6, 0xDB, 0x6F, 0x80, 0x10, 0xC3, 0x9A, 0x4F, 0x10, 0xF8, 0xE3, 0x31,
  0xE0, 0xDF, 0xCF, 0x77, 0xC0, 0xC6, 0x3D, 0xFD, 0xEF, 0x7B, 0xB0, 0x3B,
  0xD1, 0x8C, 0x35, 0xE0, 0x0C, 0x32, 0xDF, 0x4F, 0x3C, 0xDB, 0x7C, 0x31,
  0xE4, 0xFF, 0xC1, 0x97, 0x80, 0x76, 0x7F, 0x66, 0x66, 0x60, 0x2D, 0xF4,
  0xF3, 0xCD, 0xB7, 0xC3, 0x7D, 0xE0, 0xC6, 0x2D, 0xFD, 0xEF, 0x7B, 0xD8,
  0xEF, 0xFF, 0xC0, 0x69, 0xB6, 0xDB, 0x6F, 0x60, 0xC3, 0x0D, 0xB6, 0xF3,
  0xCF, 0x36, 0xDC, 0xFF, 0xFF, 0xC0, 0xB6, 0xFF, 0xDB, 0xDB, 0xDB, 0xDB,
  0xDB, 0xB7, 0xF7, 0xBD, 0xEF, 0x60, 0x31, 0xE4, 0xF3, 0xCD, 0xB7, 0x80,
  0xB7, 0xF7, 0xBD, 0xEE, 0xD8, 0xC6, 0x00, 0x2D, 0xF4, 0xF3, 0xCD, 0xB7,
  0xC3, 0x0C, 0x30, 0xBE, 0xCC, 0xCC, 0xC0, 0x7F, 0xB0, 0xE3, 0xCF, 0xC0,
  0x67, 0xF6, 0x66, 0x77, 0xDE, 0xF7, 0xBD, 0xFF, 0xE0, 0xCF, 0x34, 0x9E,
  0x78, 0xC3, 0x00, 0xCD, 0xEE, 0xD5, 0x6A, 0xA7, 0x73, 0xB8, 0xDC, 0xCD,
  0xE7, 0x8C, 0x79, 0xEC, 0xC0, 0xCF, 0x36, 0x9E, 0x78, 0xC3, 0x0C, 0x61,
  0x80, 0xFF, 0xCC, 0x66, 0x63, 0xE0, 0x13, 0x66, 0x6C, 0x66, 0x63, 0x30,
  0xFF, 0xFF, 0xFF, 0xCE, 0x66, 0x63, 0x76, 0x66, 0xE0, 0xFE, 0x60,
};

const GFXglyph NotoSans_Condensed_ExtraBold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 4, 6, 1, -9 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 6, 10, 6, 0, -9 },
  { 22, 10, 9, 10, 0, -9 },
  { 34, 8, 9, 8, 0, -9 },
  { 43, 1, 4, 3, 1, -9 },
  { 44, 3, 11, 4, 1, -9 },
  { 49, 3, 11, 4, 0, -9 },
  { 54, 6, 5, 6, 0, -9 },
  { 58, 6, 6, 6, 0, -7 },
  { 63, 3, 4, 3, 0, -2 },
  { 65, 3, 2, 4, 0, -4 },
  { 66, 2, 2, 3, 1, -2 },
  { 67, 5, 9, 5, 0, -9 },
  { 73, 6, 9, 6, 0, -9 },
  { 80, 4, 9, 6, 1, -9 },
  { 85, 6, 9, 6, 0, -9 },
  { 92, 6, 9, 6, 0, -9 },
  { 99, 6, 9, 6, 0, -9 },
  { 106, 5, 9, 6, 1, -9 },
  { 112, 6, 9, 6, 0, -9 },
  { 119, 6, 9, 6, 0, -9 },
  { 126, 6, 9, 6, 0, -9 },
  { 133, 6, 9, 6, 0, -9 },
  { 140, 2, 7, 3, 1, -7 },
  { 142, 3, 9, 3, 0, -7 },
  { 146, 6, 6, 6, 0, -7 },
  { 151, 6, 4, 6, 0, -6 },
  { 154, 6, 6, 6, 0, -7 },
  { 159, 5, 9, 5, 0, -9 },
  { 165, 9, 10, 9, 0, -9 },
  { 177, 7, 9, 7, 0, -9 },
  { 185, 5, 9, 7, 1, -9 },
  { 191, 5, 9, 6, 1, -9 },
  { 197, 6, 9, 7, 1, -9 },
  { 204, 4, 9, 6, 1, -9 },
  { 209, 4, 9, 6, 1, -9 },
  { 214, 6, 9, 7, 1, -9 },
  { 221, 6, 9, 8, 1, -9 },
  { 228, 4, 9, 4, 0, -9 },
  { 233, 4, 12, 4, -1, -9 },
  { 239, 6, 9, 7, 1, -9 },
  { 246, 4, 9, 6, 1, -9 },
  { 251, 8, 9, 10, 1, -9 },
  { 260, 7, 9, 8, 1, -9 },
  { 268, 6, 9, 8, 1, -9 },
  { 275, 5, 9, 6, 1, -9 },
  { 281, 6, 11, 8, 1, -9 },
  { 290, 6, 9, 7, 1, -9 },
  { 297, 5, 9, 6, 0, -9 },
  { 303, 6, 9, 6, 0, -9 },
  { 310, 6, 9, 8, 1, -9 },
  { 317, 7, 9, 7, 0, -9 },
  { 325, 10, 9, 10, 0, -9 },
  { 337, 7, 9, 7, 0, -9 },
  { 345, 7, 9, 7, 0, -9 },
  { 353, 6, 9, 6, 0, -9 },
  { 360, 3, 11, 4, 1, -9 },
  { 365, 5, 9, 5, 0, -9 },
  { 371, 3, 11, 4, 0, -9 },
  { 376, 6, 6, 6, 0, -9 },
  { 381, 5, 1, 5, 0, 1 },
  { 382, 4, 2, 4, 0, -9 },
  { 383, 6, 7, 6, 0, -7 },
  { 389, 5, 9, 7, 1, -9 },
  { 395, 5, 7, 5, 0, -7 },
  { 400, 6, 9, 7, 0, -9 },
  { 407, 6, 7, 6, 0, -7 },
  { 413, 4, 9, 4, 0, -9 },
  { 418, 6, 10, 7, 0, -7 },
  { 426, 5, 9, 7, 1, -9 },
  { 432, 2, 9, 3, 1, -9 },
  { 435, 3, 12, 3, 0, -9 },
  { 440, 6, 9, 7, 1, -9 },
  { 447, 2, 9, 3, 1, -9 },
  { 450, 8, 7, 10, 1, -7 },
  { 457, 5, 7, 7, 1, -7 },
  { 462, 6, 7, 6, 0, -7 },
  { 468, 5, 10, 7, 1, -7 },
  { 475, 6, 10, 7, 0, -7 },
  { 483, 4, 7, 5, 1, -7 },
  { 487, 5, 7, 5, 0, -7 },
  { 492, 4, 8, 4, 0, -8 },
  { 496, 5, 7, 7, 1, -7 },
  { 501, 6, 7, 6, 0, -7 },
  { 507, 9, 7, 9, 0, -7 },
  { 515, 6, 7, 6, 0, -7 },
  { 521, 6, 10, 6, 0, -7 },
  { 529, 5, 7, 5, 0, -7 },
  { 534, 4, 11, 4, 0, -9 },
  { 540, 2, 12, 6, 2, -9 },
  { 543, 4, 11, 4, 0, -9 },
  { 549, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_ExtraBold12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD12PT7B_H_
