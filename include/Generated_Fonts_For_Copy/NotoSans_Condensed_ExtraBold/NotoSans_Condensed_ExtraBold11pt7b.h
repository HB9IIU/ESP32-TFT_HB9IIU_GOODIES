#ifndef _NOTOSANS_CONDENSED_EXTRABOLD11PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xBB, 0xB0, 0x28, 0xA7, 0xCA, 0x7B, 0xF5, 0x14, 0x33, 0xF8,
  0xC3, 0x97, 0xE4, 0x20, 0x62, 0x7A, 0x3D, 0x1F, 0x66, 0xB8, 0xF4, 0x4A,
  0x66, 0x30, 0xF1, 0xE3, 0x87, 0x7B, 0xB3, 0x3F, 0xE0, 0x2D, 0x2D, 0x92,
  0x64, 0xC9, 0x92, 0x5B, 0x58, 0x27, 0xCC, 0xB0, 0x21, 0x3F, 0xF2, 0x10,
  0x70, 0xFC, 0xC0, 0x18, 0x8C, 0x46, 0x31, 0x18, 0x73, 0xF7, 0xBD, 0xED,
  0x6E, 0x37, 0xD1, 0x11, 0x11, 0x77, 0xC6, 0x33, 0x31, 0x1F, 0xF2, 0xC6,
  0xE7, 0x8E, 0x7E, 0x19, 0xCE, 0xB5, 0xFC, 0x63, 0xFF, 0x8E, 0xB3, 0xBE,
  0x3B, 0x51, 0xFD, 0xE5, 0x6E, 0xFF, 0xC6, 0x23, 0x18, 0x8C, 0x72, 0xD6,
  0xE7, 0xE7, 0x6F, 0x73, 0xF7, 0xB7, 0x8C, 0x6E, 0xCC, 0x50, 0x1C, 0x08,
  0xD9, 0xC3, 0x84, 0xFF, 0xC1, 0xF0, 0x87, 0x0E, 0x7E, 0x40, 0xFF, 0x13,
  0x60, 0x66, 0x1C, 0x63, 0x5D, 0x55, 0xF5, 0xF5, 0x5A, 0x62, 0x1C, 0x30,
  0x71, 0xE3, 0x46, 0xCF, 0xB3, 0x63, 0xF7, 0xE7, 0xEF, 0xCE, 0x7E, 0x3D,
  0xE6, 0x10, 0xC1, 0x06, 0x8E, 0xF7, 0xE7, 0x18, 0xCE, 0xFE, 0xFF, 0xCF,
  0xFC, 0xCF, 0xFF, 0x8F, 0xF8, 0x88, 0x7F, 0xF1, 0x7B, 0xCF, 0x6F, 0xCE,
  0x73, 0xFF, 0xE7, 0x39, 0xF6, 0x66, 0x66, 0x6F, 0x33, 0x33, 0x33, 0x33,
  0x2E, 0xDE, 0xFD, 0xCF, 0x7B, 0x7B, 0x88, 0x88, 0x88, 0x8F, 0xC7, 0xCF,
  0xBD, 0x5A, 0xB7, 0x6E, 0xC9, 0xCF, 0x3E, 0xEB, 0xBE, 0x79, 0xE3, 0x38,
  0xF9, 0x1A, 0x3C, 0x68, 0xDB, 0x1E, 0xF7, 0xA7, 0x2F, 0x42, 0x10, 0x38,
  0xF9, 0x1A, 0x3C, 0x68, 0xDB, 0x1E, 0x0C, 0x0C, 0xF7, 0xE7, 0x6F, 0x5A,
  0x53, 0x7B, 0xF0, 0xC3, 0x8F, 0x7E, 0xFF, 0xCC, 0x63, 0x18, 0xC6, 0x9C,
  0xE7, 0x39, 0xCF, 0x6E, 0xCF, 0x34, 0xDA, 0x79, 0xE3, 0x8C, 0xC8, 0xE6,
  0xF7, 0x6B, 0xB5, 0x53, 0xA9, 0xDC, 0x66, 0xCD, 0xE7, 0x8C, 0x31, 0xE7,
  0xB3, 0xCD, 0x27, 0x9C, 0x30, 0xC3, 0x0C, 0xFF, 0xC4, 0x62, 0x33, 0x1F,
  0xEA, 0xAA, 0xB0, 0xC2, 0x10, 0xC2, 0x18, 0xC3, 0xED, 0xB6, 0xDB, 0x7C,
  0x30, 0xC7, 0x12, 0xCC, 0xF8, 0xE0, 0x7A, 0xDF, 0xBD, 0xB4, 0x84, 0x3D,
  0xA9, 0xCF, 0x5E, 0x7B, 0x71, 0x86, 0xBC, 0x08, 0x5E, 0xBC, 0xE5, 0x6F,
  0x7A, 0x7F, 0x84, 0xBC, 0x76, 0xF6, 0x66, 0x66, 0x7A, 0xF3, 0x95, 0xBC,
  0x2F, 0x70, 0x84, 0x3D, 0xA9, 0xCE, 0x73, 0xBF, 0x45, 0x55, 0x78, 0x84,
  0x27, 0x6E, 0x7A, 0xD3, 0xFF, 0xFE, 0xDB, 0x93, 0x93, 0x93, 0x93, 0xF6,
  0xA7, 0x39, 0xCC, 0x79, 0x2C, 0xF2, 0x49, 0xE0, 0xF6, 0xA7, 0x3D, 0x7A,
  0x10, 0x80, 0x7A, 0xF3, 0x95, 0xBC, 0x21, 0x08, 0xBE, 0x49, 0x00, 0x7D,
  0x63, 0x9F, 0x4F, 0x44, 0x46, 0x70, 0x99, 0x99, 0xFF, 0xCF, 0x65, 0x9C,
  0x70, 0xC0, 0xD9, 0xDB, 0x5F, 0x56, 0x76, 0x66, 0xDB, 0xDC, 0xE7, 0xEC,
  0xCD, 0x65, 0x9C, 0x30, 0xC3, 0x38, 0xC0, 0xF3, 0x26, 0x4F, 0x36, 0x66,
  0xEE, 0x66, 0x73, 0xFF, 0xE0, 0xC6, 0x66, 0x77, 0x66, 0xEC, 0x6D, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraBold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 4, 3, 5, 1, -8 },
  { 4, 6, 8, 6, 0, -8 },
  { 10, 5, 9, 6, 0, -8 },
  { 16, 9, 8, 9, 0, -8 },
  { 25, 7, 8, 7, 0, -8 },
  { 32, 1, 3, 3, 1, -8 },
  { 33, 3, 10, 4, 0, -8 },
  { 37, 3, 10, 4, 0, -8 },
  { 41, 5, 4, 5, 0, -8 },
  { 44, 5, 6, 6, 0, -7 },
  { 48, 2, 2, 3, 0, -1 },
  { 49, 3, 2, 3, 0, -4 },
  { 50, 1, 2, 3, 1, -2 },
  { 51, 5, 8, 5, 0, -8 },
  { 56, 5, 8, 6, 0, -8 },
  { 61, 4, 8, 6, 0, -8 },
  { 65, 5, 8, 6, 0, -8 },
  { 70, 5, 8, 6, 0, -8 },
  { 75, 5, 8, 6, 0, -8 },
  { 80, 4, 8, 6, 1, -8 },
  { 84, 5, 8, 6, 0, -8 },
  { 89, 5, 8, 6, 0, -8 },
  { 94, 5, 8, 6, 0, -8 },
  { 99, 5, 8, 6, 0, -8 },
  { 104, 1, 6, 3, 1, -6 },
  { 105, 2, 7, 3, 0, -6 },
  { 107, 5, 6, 6, 0, -7 },
  { 111, 5, 4, 6, 0, -6 },
  { 114, 5, 6, 6, 0, -7 },
  { 118, 4, 8, 5, 0, -8 },
  { 122, 8, 9, 9, 0, -8 },
  { 131, 7, 8, 7, 0, -8 },
  { 138, 5, 8, 6, 1, -8 },
  { 143, 6, 8, 6, 0, -8 },
  { 149, 5, 8, 7, 1, -8 },
  { 154, 4, 8, 5, 1, -8 },
  { 158, 4, 8, 5, 1, -8 },
  { 162, 5, 8, 7, 1, -8 },
  { 167, 5, 8, 7, 1, -8 },
  { 172, 4, 8, 4, 0, -8 },
  { 176, 4, 10, 3, -1, -8 },
  { 181, 5, 8, 6, 1, -8 },
  { 186, 4, 8, 5, 1, -8 },
  { 190, 7, 8, 9, 1, -8 },
  { 197, 6, 8, 8, 1, -8 },
  { 203, 7, 8, 7, 0, -8 },
  { 210, 5, 8, 6, 1, -8 },
  { 215, 7, 10, 7, 0, -8 },
  { 224, 5, 8, 6, 1, -8 },
  { 229, 5, 8, 5, 0, -8 },
  { 234, 5, 8, 5, 0, -8 },
  { 239, 5, 8, 7, 1, -8 },
  { 244, 6, 8, 6, 0, -8 },
  { 250, 9, 8, 9, 0, -8 },
  { 259, 6, 8, 6, 0, -8 },
  { 265, 6, 8, 6, 0, -8 },
  { 271, 5, 8, 5, 0, -8 },
  { 276, 2, 10, 3, 1, -8 },
  { 279, 5, 8, 5, 0, -8 },
  { 284, 3, 10, 3, 0, -8 },
  { 288, 6, 5, 6, 0, -8 },
  { 292, 5, 1, 5, 0, 1 },
  { 293, 3, 1, 4, 0, -8 },
  { 294, 5, 6, 6, 0, -6 },
  { 298, 5, 8, 6, 1, -8 },
  { 303, 5, 6, 5, 0, -6 },
  { 307, 5, 8, 6, 0, -8 },
  { 312, 5, 6, 6, 0, -6 },
  { 316, 4, 8, 4, 0, -8 },
  { 320, 5, 9, 6, 0, -6 },
  { 326, 5, 8, 6, 1, -8 },
  { 331, 1, 8, 3, 1, -8 },
  { 332, 2, 11, 3, 0, -8 },
  { 335, 5, 8, 6, 1, -8 },
  { 340, 1, 8, 3, 1, -8 },
  { 341, 8, 6, 9, 1, -6 },
  { 347, 5, 6, 6, 1, -6 },
  { 351, 6, 6, 6, 0, -6 },
  { 356, 5, 9, 6, 1, -6 },
  { 362, 5, 9, 6, 0, -6 },
  { 368, 3, 6, 4, 1, -6 },
  { 371, 4, 6, 5, 0, -6 },
  { 374, 4, 7, 4, 0, -7 },
  { 378, 4, 6, 6, 1, -6 },
  { 381, 6, 6, 6, 0, -6 },
  { 386, 8, 6, 8, 0, -6 },
  { 392, 5, 6, 5, 0, -6 },
  { 396, 6, 9, 6, 0, -6 },
  { 403, 4, 6, 5, 0, -6 },
  { 406, 4, 10, 4, 0, -8 },
  { 411, 1, 11, 5, 2, -8 },
  { 413, 4, 10, 4, 0, -8 },
  { 418, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_ExtraBold11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD11PT7B_H_
