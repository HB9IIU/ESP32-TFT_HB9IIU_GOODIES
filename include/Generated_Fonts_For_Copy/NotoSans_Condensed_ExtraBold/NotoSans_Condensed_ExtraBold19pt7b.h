#ifndef _NOTOSANS_CONDENSED_EXTRABOLD19PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xEF, 0xDF, 0xBF, 0x7E, 0xE0,
  0x0D, 0x83, 0x61, 0x98, 0x66, 0x7F, 0xDF, 0xF1, 0xB0, 0x6C, 0xFF, 0xFF,
  0xF3, 0x30, 0xD8, 0x36, 0x0D, 0x80, 0x18, 0x7F, 0xFE, 0xFA, 0xD8, 0xF8,
  0x7C, 0x3E, 0x1F, 0x1F, 0x9F, 0xFE, 0xFC, 0x18, 0x18, 0x70, 0x63, 0xE3,
  0x8D, 0x8C, 0x36, 0x30, 0xDD, 0x83, 0x66, 0x0D, 0xB7, 0xBE, 0xDF, 0x76,
  0x6C, 0x1B, 0xB0, 0xEE, 0xC3, 0x1B, 0x0C, 0x7C, 0x60, 0xE0, 0x1C, 0x0F,
  0xC1, 0xDC, 0x33, 0x87, 0x70, 0xFC, 0x0F, 0x03, 0xE7, 0xFF, 0xDD, 0xFB,
  0x9F, 0x73, 0xCF, 0xFC, 0xFF, 0xC0, 0xFF, 0xFE, 0x39, 0x9C, 0xCE, 0x73,
  0x98, 0xC6, 0x39, 0xCE, 0x31, 0xCE, 0x38, 0xE3, 0x8C, 0x73, 0x9C, 0x63,
  0x18, 0xC6, 0x33, 0x9C, 0xCE, 0xE0, 0x1C, 0x06, 0x5F, 0xFF, 0xF1, 0xC1,
  0xB1, 0xDC, 0x24, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xEC, 0xFF, 0xFF, 0x80, 0x07, 0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C,
  0x18, 0x38, 0x30, 0x70, 0x70, 0x60, 0xE0, 0x38, 0x7E, 0xFE, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xEE, 0x7E, 0x3C, 0x0C, 0x73, 0xDF,
  0xED, 0x31, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x38, 0xFE, 0xFE, 0x47,
  0x07, 0x0E, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0xFF, 0xFF, 0xFF, 0x38, 0xFE,
  0xFE, 0x87, 0x06, 0x0E, 0x7C, 0x7E, 0x0F, 0x07, 0x07, 0x8F, 0xFE, 0xFC,
  0x07, 0x03, 0x83, 0xC3, 0xE1, 0xF1, 0xF8, 0xDC, 0xEE, 0x67, 0x7F, 0xFF,
  0xE0, 0xE0, 0x70, 0x38, 0x7E, 0xFE, 0xFE, 0xE0, 0xE0, 0xFC, 0xFE, 0xFE,
  0x07, 0x07, 0x07, 0xCF, 0xFE, 0xFC, 0x0E, 0x3E, 0x7E, 0xE0, 0xE0, 0xDC,
  0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0x7E, 0x3C, 0xFF, 0xFF, 0xFF, 0x07,
  0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x38, 0x7E,
  0xFF, 0xE7, 0xE7, 0xFE, 0x7C, 0x7E, 0xEE, 0xE7, 0xC7, 0xE7, 0xFE, 0x7C,
  0x38, 0x7E, 0xFE, 0xE7, 0xC7, 0xC7, 0xE7, 0xFF, 0x7F, 0x07, 0x06, 0x1E,
  0xFC, 0xF8, 0x5F, 0xB0, 0x00, 0xFF, 0x80, 0x5F, 0xB0, 0x00, 0x1F, 0xFD,
  0x80, 0x01, 0x03, 0x0F, 0x3E, 0xF0, 0xF0, 0x7C, 0x1F, 0x07, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0x3E,
  0xF8, 0xE0, 0x80, 0x38, 0xFE, 0x7E, 0x47, 0x06, 0x0E, 0x1C, 0x38, 0x38,
  0x00, 0x00, 0x38, 0x38, 0x38, 0x07, 0x80, 0xFF, 0x0E, 0x1C, 0xC0, 0x6E,
  0x7D, 0xE7, 0xEF, 0x77, 0x7B, 0x3B, 0xD9, 0xDE, 0xEE, 0xF3, 0xFD, 0x8C,
  0xC6, 0x00, 0x3C, 0x60, 0x7F, 0x00, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xB8, 0x77, 0x0E, 0xE1, 0xCE, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x7F, 0x0F,
  0xC1, 0xC0, 0xF8, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F, 0x3F, 0xFD, 0xFE, 0xE3,
  0xF1, 0xF8, 0xFC, 0xFF, 0xF7, 0xF0, 0x0E, 0x1F, 0xDF, 0xCE, 0x2E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x0F, 0x27, 0xF1, 0xF8, 0xF8, 0x3F,
  0xCF, 0xFB, 0x8E, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3B,
  0xFE, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x3F, 0xFF, 0xE1,
  0xC3, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x3F, 0xFF,
  0xFF, 0xC3, 0x87, 0x0E, 0x1C, 0x00, 0x0F, 0x0F, 0xF7, 0xF9, 0xC2, 0xE0,
  0x38, 0x0E, 0x7F, 0x9F, 0xE7, 0xF8, 0x7F, 0x1D, 0xE7, 0x7F, 0xC7, 0xE0,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0xFF, 0xFC, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xEF, 0xFC, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xFF, 0xFF, 0x80, 0xE1, 0xF8, 0xEE, 0x3B, 0x9C, 0xEF, 0x3B, 0x8F, 0xC3,
  0xF8, 0xFE, 0x39, 0xCE, 0x73, 0x8E, 0xE3, 0xB8, 0xF0, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xFF, 0xC0, 0xF0, 0x3F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFF, 0xF3, 0x7E, 0xCD, 0xFB, 0x37,
  0xEF, 0xDF, 0xBE, 0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x1F, 0x9C, 0x70, 0xF0,
  0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0xCF, 0xF9, 0xFB, 0xBF, 0x77, 0xE7, 0xFC,
  0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xC0, 0x1E, 0x07, 0xF1, 0xFF, 0x78,
  0xEE, 0x1D, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0xC7, 0x3D, 0xE7,
  0xF8, 0x3E, 0x00, 0xF8, 0x7F, 0xBF, 0xDC, 0xFE, 0x3F, 0x1F, 0x9D, 0xFE,
  0xFE, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x1E, 0x07, 0xF1, 0xFF, 0x78,
  0xEE, 0x1D, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0xC7, 0x3D, 0xE7,
  0xF8, 0x3E, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0xF8, 0x3F, 0xCF, 0xF3, 0x9E,
  0xE3, 0xB8, 0xEF, 0xF3, 0xF8, 0xFE, 0x3B, 0x8E, 0x73, 0x9E, 0xE3, 0xB8,
  0xF0, 0x3C, 0xFF, 0xFF, 0x1E, 0x1E, 0x3E, 0x3F, 0x1E, 0x1E, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xCE, 0x7F, 0x8F, 0xC0,
  0xE0, 0xFC, 0x1D, 0xC7, 0x38, 0xE7, 0x1C, 0xE3, 0x0E, 0xE1, 0xDC, 0x3B,
  0x87, 0x60, 0x6C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0xE1, 0x87, 0xE1, 0xC7,
  0xE3, 0xC7, 0x63, 0xC6, 0x73, 0xCE, 0x73, 0xCE, 0x77, 0xEE, 0x77, 0xEE,
  0x36, 0x6C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1C, 0x38,
  0xE1, 0xCE, 0x79, 0xCE, 0x1D, 0xC3, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1F,
  0x07, 0xE0, 0xEE, 0x39, 0xC7, 0x1D, 0xC3, 0xC0, 0xE1, 0xFC, 0x77, 0x39,
  0xCE, 0x3B, 0x8F, 0xC1, 0xF0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x38,
  0x1C, 0x1C, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9F, 0xF8, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x38, 0x38,
  0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xF8, 0x0C, 0x03, 0x01, 0xE0, 0x78, 0x3F,
  0x0C, 0xC7, 0x39, 0x86, 0xE1, 0xC0, 0xFF, 0xFF, 0xC0, 0xE3, 0x8E, 0x18,
  0xFE, 0x7F, 0x07, 0x1F, 0xFF, 0xE7, 0xE7, 0xEF, 0xFF, 0xF3, 0xE0, 0x70,
  0x38, 0x1C, 0x8F, 0xF7, 0xFB, 0x9D, 0xC7, 0xE3, 0xF1, 0xF8, 0xFE, 0xEF,
  0xF7, 0x70, 0x1C, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xF2, 0xFD, 0xF8,
  0x07, 0x07, 0x07, 0x37, 0x7B, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xFF, 0x7B, 0x18, 0x7E, 0xFF, 0xE7, 0xE7, 0xFF, 0xFF, 0xE0, 0xE1, 0x7F,
  0x3E, 0x08, 0x7C, 0xF9, 0x87, 0x1F, 0xBF, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x00, 0x30, 0x7B, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xFF, 0x7F, 0x07, 0x87, 0xFF, 0xFE, 0x30, 0xE0, 0x70, 0x38, 0x1D, 0x8F,
  0xF7, 0xFB, 0x9D, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1C, 0x5F,
  0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x11, 0xCE, 0x00, 0x1C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x3F, 0xFC, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x7F,
  0x3B, 0xB9, 0xF8, 0xFC, 0x7F, 0x3B, 0x9C, 0xEE, 0x7F, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x33, 0xFF, 0xEF, 0xFF, 0xF9, 0xE7, 0xE7,
  0x1F, 0x9C, 0x7E, 0x71, 0xF9, 0xC7, 0xE7, 0x1F, 0x9C, 0x7E, 0x71, 0xC0,
  0x0C, 0x7F, 0xBF, 0xDC, 0xEE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xE0, 0x18, 0x3F, 0x3F, 0xDC, 0xEE, 0x37, 0x1F, 0x8F, 0xCE, 0xE7, 0x3F,
  0x8F, 0x80, 0x0C, 0x7F, 0xBF, 0xDC, 0xEE, 0x3F, 0x1F, 0x8F, 0xC7, 0xF7,
  0x7F, 0xBB, 0x9C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x30, 0x7B, 0xFF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0xFF, 0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x33, 0xFF, 0xF0,
  0xF3, 0xE3, 0xC7, 0x9F, 0xFF, 0x80, 0x30, 0x60, 0xC7, 0xFF, 0xEE, 0x1C,
  0x38, 0x70, 0xE1, 0xC9, 0xF3, 0xE0, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE7, 0xE7, 0xFF, 0x7B, 0xE3, 0xDC, 0xE7, 0x39, 0xCC, 0x37, 0x0D, 0xC3,
  0xE0, 0xF8, 0x1E, 0x07, 0x00, 0xE7, 0x9D, 0x9E, 0x77, 0x79, 0xDD, 0xF6,
  0x76, 0xF8, 0xFB, 0xE3, 0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC0, 0xF3,
  0xBB, 0x8F, 0xC7, 0xC1, 0xE1, 0xF0, 0xF8, 0xEE, 0x77, 0xF1, 0xC0, 0xE3,
  0xDC, 0xE7, 0x39, 0xCC, 0x37, 0x0F, 0xC3, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x78, 0x1E, 0x06, 0x00, 0x7E, 0xFC, 0x38, 0xE1, 0xC7, 0x1C,
  0x38, 0xFF, 0xFC, 0x0E, 0x3C, 0xF9, 0xC3, 0x87, 0x0E, 0x3C, 0xF1, 0xF0,
  0xE1, 0xC3, 0x87, 0x0E, 0x0F, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xC3, 0x8F, 0x1C, 0x71, 0xC7, 0x1E, 0x3C, 0xF7, 0x1C, 0x71,
  0xC7, 0x3C, 0xE0, 0xF9, 0xFF, 0x8E,
};

const GFXglyph NotoSans_Condensed_ExtraBold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 7, 5, 9, 1, -14 },
  { 12, 10, 14, 11, 0, -14 },
  { 30, 8, 15, 10, 1, -14 },
  { 45, 14, 14, 16, 1, -14 },
  { 70, 11, 14, 12, 1, -14 },
  { 90, 3, 5, 5, 1, -14 },
  { 92, 5, 17, 6, 1, -14 },
  { 103, 5, 17, 6, 0, -14 },
  { 114, 9, 8, 9, 0, -14 },
  { 123, 8, 9, 10, 1, -11 },
  { 132, 3, 5, 5, 1, -2 },
  { 134, 4, 2, 6, 1, -6 },
  { 135, 3, 3, 5, 1, -3 },
  { 137, 8, 14, 8, 0, -14 },
  { 151, 8, 14, 10, 1, -14 },
  { 165, 6, 14, 10, 1, -14 },
  { 176, 8, 14, 10, 1, -14 },
  { 190, 8, 14, 10, 1, -14 },
  { 204, 9, 14, 10, 0, -14 },
  { 220, 8, 14, 10, 1, -14 },
  { 234, 8, 14, 10, 1, -14 },
  { 248, 8, 14, 10, 1, -14 },
  { 262, 8, 14, 10, 1, -14 },
  { 276, 8, 14, 10, 1, -14 },
  { 290, 3, 11, 5, 1, -11 },
  { 295, 3, 14, 5, 1, -11 },
  { 301, 8, 10, 10, 1, -12 },
  { 311, 8, 6, 10, 1, -10 },
  { 317, 8, 10, 10, 1, -12 },
  { 327, 8, 14, 8, 0, -14 },
  { 341, 13, 15, 15, 1, -14 },
  { 366, 11, 14, 11, 0, -14 },
  { 386, 9, 14, 11, 1, -14 },
  { 402, 9, 14, 10, 1, -14 },
  { 418, 10, 14, 12, 1, -14 },
  { 436, 7, 14, 9, 1, -14 },
  { 449, 7, 14, 9, 1, -14 },
  { 462, 10, 14, 12, 1, -14 },
  { 480, 10, 14, 12, 1, -14 },
  { 498, 5, 14, 7, 1, -14 },
  { 507, 5, 18, 6, -1, -14 },
  { 519, 10, 14, 11, 1, -14 },
  { 537, 7, 14, 9, 1, -14 },
  { 550, 14, 14, 16, 1, -14 },
  { 575, 11, 14, 13, 1, -14 },
  { 595, 11, 14, 13, 1, -14 },
  { 615, 9, 14, 10, 1, -14 },
  { 631, 11, 17, 13, 1, -14 },
  { 655, 10, 14, 11, 1, -14 },
  { 673, 7, 14, 9, 1, -14 },
  { 686, 9, 14, 9, 0, -14 },
  { 702, 10, 14, 12, 1, -14 },
  { 720, 11, 14, 11, 0, -14 },
  { 740, 16, 14, 16, 0, -14 },
  { 768, 11, 14, 11, 0, -14 },
  { 788, 10, 14, 10, 0, -14 },
  { 806, 9, 14, 9, 0, -14 },
  { 822, 5, 17, 6, 1, -14 },
  { 833, 8, 14, 8, 0, -14 },
  { 847, 5, 17, 6, 0, -14 },
  { 858, 10, 9, 10, 0, -14 },
  { 870, 9, 2, 9, 0, 1 },
  { 873, 5, 3, 7, 1, -15 },
  { 875, 8, 11, 10, 1, -11 },
  { 886, 9, 14, 10, 1, -14 },
  { 902, 7, 11, 9, 1, -11 },
  { 912, 8, 14, 10, 1, -14 },
  { 926, 8, 11, 10, 1, -11 },
  { 937, 7, 15, 6, 0, -15 },
  { 951, 8, 16, 10, 1, -11 },
  { 967, 9, 14, 11, 1, -14 },
  { 983, 3, 15, 5, 1, -15 },
  { 989, 5, 20, 5, -1, -15 },
  { 1002, 9, 14, 10, 1, -14 },
  { 1018, 3, 14, 5, 1, -14 },
  { 1024, 14, 11, 16, 1, -11 },
  { 1044, 9, 11, 11, 1, -11 },
  { 1057, 9, 11, 10, 1, -11 },
  { 1070, 9, 16, 10, 1, -11 },
  { 1088, 8, 16, 10, 1, -11 },
  { 1104, 6, 11, 7, 1, -11 },
  { 1113, 6, 11, 8, 1, -11 },
  { 1122, 7, 13, 7, 0, -13 },
  { 1134, 8, 10, 11, 1, -10 },
  { 1144, 10, 10, 10, 0, -10 },
  { 1157, 14, 10, 14, 0, -10 },
  { 1175, 9, 10, 9, 0, -10 },
  { 1187, 10, 15, 10, 0, -10 },
  { 1206, 7, 10, 8, 0, -10 },
  { 1215, 7, 17, 7, 0, -14 },
  { 1230, 3, 19, 9, 3, -15 },
  { 1238, 6, 17, 7, 1, -14 },
  { 1251, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_Condensed_ExtraBold19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD19PT7B_H_
