#ifndef _NOTOSANS_CONDENSED_EXTRABOLD17PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF6, 0x1B, 0xF0, 0xCF, 0x3C, 0xF3, 0x1B, 0x0D, 0x86,
  0xCF, 0xF7, 0xF9, 0xB0, 0xD9, 0xFF, 0xFF, 0x9B, 0x09, 0x8D, 0x80, 0x10,
  0x73, 0xFE, 0xAD, 0x1E, 0x1E, 0x1E, 0x1F, 0x2F, 0xFF, 0xE1, 0x02, 0x00,
  0x78, 0x61, 0xF3, 0x06, 0xCC, 0x33, 0x60, 0x6D, 0x81, 0xFD, 0xE7, 0xB6,
  0xC1, 0xB3, 0x06, 0xCC, 0x19, 0xB0, 0xC7, 0x87, 0x1E, 0x3E, 0x07, 0xE1,
  0xDC, 0x1B, 0x83, 0xE0, 0x79, 0xDF, 0x33, 0x7E, 0xE7, 0xCE, 0x71, 0xFF,
  0x1F, 0xF0, 0xFF, 0x36, 0x6E, 0xCC, 0xCC, 0xCC, 0xEE, 0x67, 0x30, 0xE3,
  0x8C, 0x63, 0x9C, 0xE7, 0x39, 0xCC, 0x67, 0x33, 0x80, 0x18, 0x18, 0x7F,
  0xFF, 0x1C, 0x3E, 0x66, 0x24, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18,
  0xFB, 0x60, 0xFF, 0xFE, 0xDF, 0x80, 0x0E, 0x18, 0x30, 0xE1, 0x83, 0x0C,
  0x18, 0x70, 0xC1, 0x87, 0x00, 0x79, 0xFB, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0xDF, 0xF3, 0xC0, 0x1C, 0xF7, 0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x7E, 0xFE, 0x67, 0x07, 0x06, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x7F,
  0x7F, 0xFD, 0xFA, 0x38, 0x71, 0xCF, 0x1F, 0x07, 0x0F, 0x1F, 0xF7, 0xC0,
  0x0E, 0x0E, 0x1E, 0x1E, 0x36, 0x76, 0x66, 0xFF, 0xFF, 0xFF, 0x06, 0x06,
  0xFD, 0xFB, 0x87, 0x0F, 0x9F, 0x97, 0x87, 0x0F, 0x1F, 0xF7, 0xC0, 0x3C,
  0xFB, 0x86, 0x0D, 0xDF, 0xFB, 0xE7, 0xCF, 0xDF, 0xF3, 0xE0, 0xFF, 0xFC,
  0x38, 0x61, 0xC3, 0x86, 0x1C, 0x38, 0x61, 0xC3, 0x00, 0x7D, 0xFF, 0x3E,
  0x7F, 0xCF, 0x3F, 0x67, 0xC7, 0x9F, 0xFB, 0xE0, 0x3C, 0x7E, 0x67, 0xE7,
  0x67, 0x77, 0x7F, 0x3B, 0x07, 0x0E, 0x7E, 0x7C, 0xFD, 0x00, 0x37, 0xE0,
  0xFD, 0x00, 0x07, 0xDB, 0x00, 0x06, 0x3D, 0xF7, 0x0F, 0x0F, 0x83, 0x81,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81, 0xC1, 0xE0, 0xF1, 0xEF, 0x38,
  0x40, 0xFD, 0xFD, 0x38, 0x71, 0xC7, 0x8C, 0x18, 0x00, 0x60, 0xE1, 0x80,
  0x1F, 0x83, 0x9C, 0x60, 0x6C, 0xFA, 0xDD, 0xBD, 0x9B, 0xD9, 0x3D, 0xB3,
  0xDB, 0xEC, 0xEC, 0xE0, 0x07, 0x08, 0x3F, 0x80, 0x1E, 0x07, 0x81, 0xF0,
  0xFC, 0x3B, 0x0C, 0xC7, 0x39, 0xFE, 0x7F, 0x98, 0x6E, 0x1F, 0x87, 0xFE,
  0xFF, 0xE7, 0xE7, 0xE6, 0xFC, 0xFF, 0xE7, 0xE7, 0xE7, 0xFF, 0xFC, 0x3F,
  0x7E, 0xF2, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF2, 0x7E, 0x3E, 0xFC,
  0x7F, 0xB9, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0x77, 0xBF, 0x9F,
  0x80, 0xFF, 0xFE, 0x38, 0xE3, 0xFF, 0xF8, 0xE3, 0x8F, 0xFF, 0xFF, 0xFE,
  0x38, 0xE3, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0x3F, 0x3F, 0xBC, 0x5C, 0x0E,
  0x07, 0x7F, 0xBF, 0xC7, 0xE3, 0xF9, 0xDF, 0xE7, 0xE0, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0xFD,
  0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC7, 0xFF, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0xFF, 0xDC, 0xE3, 0xF3, 0xBB, 0x9D, 0xCF, 0xC7,
  0xE3, 0xF1, 0xDC, 0xEE, 0x73, 0xB9, 0xDC, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xF0, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF,
  0x9B, 0xF9, 0xBF, 0x9B, 0xFD, 0xBE, 0xF3, 0xEF, 0x3E, 0xF3, 0xE7, 0x3E,
  0x63, 0xF1, 0xFC, 0x7F, 0x9F, 0xE7, 0xFD, 0xFF, 0x7E, 0xFF, 0xBF, 0xE7,
  0xF9, 0xFE, 0x3F, 0x8F, 0x3E, 0x3F, 0xB8, 0xFC, 0x7E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE3, 0xF9, 0xDF, 0xC7, 0xC0, 0xFC, 0xFE, 0xE7, 0xE7, 0xE7, 0xEE,
  0xFE, 0xF8, 0xE0, 0xE0, 0xE0, 0xE0, 0x3E, 0x3F, 0xB8, 0xFC, 0x7E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE3, 0xF9, 0xDF, 0xC7, 0xC0, 0x70, 0x38, 0x0E, 0xFC,
  0x7F, 0x39, 0xDC, 0xEE, 0x77, 0xF3, 0xF1, 0xD8, 0xEE, 0x73, 0x39, 0xDC,
  0x70, 0x7F, 0xFB, 0x16, 0x0E, 0x1F, 0x0F, 0x0E, 0x0F, 0x1B, 0xF7, 0xC0,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0x9F,
  0xC7, 0xC0, 0xE1, 0xF8, 0x66, 0x39, 0xCE, 0x73, 0x0C, 0xC3, 0x70, 0xFC,
  0x3E, 0x07, 0x81, 0xE0, 0x78, 0xE3, 0x0F, 0x8E, 0x76, 0x79, 0xD9, 0xE7,
  0x67, 0x99, 0xDE, 0x67, 0x6F, 0x8F, 0xBE, 0x3C, 0xF8, 0xF3, 0xC3, 0xCF,
  0x0F, 0x1C, 0xE3, 0xB9, 0x8D, 0xC7, 0xC3, 0xE0, 0xE0, 0x78, 0x7C, 0x3F,
  0x3B, 0x9C, 0xFC, 0x70, 0xE3, 0xB1, 0xDD, 0xC6, 0xE3, 0xE1, 0xF0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0x06, 0x0E, 0x0C, 0x1C,
  0x38, 0x38, 0x70, 0x60, 0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCF, 0xF0, 0xE0, 0xC1, 0x83, 0x83, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x30,
  0x70, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x08, 0x0E, 0x07,
  0x06, 0xC3, 0x63, 0x19, 0x8D, 0x83, 0xFF, 0xFF, 0xE7, 0x30, 0x11, 0xF9,
  0xF8, 0x77, 0xFF, 0xF3, 0xE7, 0xFF, 0xEC, 0xE0, 0xE0, 0xE0, 0xE8, 0xFE,
  0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE6, 0xFE, 0xDC, 0x11, 0xFF, 0xF8, 0xC3,
  0x0C, 0x39, 0xFD, 0xF0, 0x06, 0x0C, 0x19, 0x37, 0xFF, 0xF9, 0xE3, 0xC7,
  0x8F, 0xBF, 0xF7, 0x60, 0x10, 0xFB, 0xBE, 0x3F, 0xFF, 0xF0, 0x71, 0xFE,
  0xFC, 0x3C, 0xF7, 0x1C, 0xFF, 0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x20,
  0xFF, 0xFF, 0x3C, 0x78, 0xF1, 0xF7, 0xFE, 0xEC, 0x1C, 0x7F, 0xFF, 0x80,
  0xE0, 0xE0, 0xE0, 0xE8, 0xDE, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xFD, 0x0F, 0xFF, 0xFF, 0xFE, 0x39, 0xC4, 0x03, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xFE, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE7, 0xEE, 0xFC,
  0xF8, 0xFC, 0xEC, 0xEE, 0xE6, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x08,
  0x4D, 0xFF, 0xFF, 0xFE, 0x77, 0xE6, 0x3E, 0x63, 0xE6, 0x3E, 0x63, 0xE6,
  0x3E, 0x63, 0x08, 0xDE, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0x10, 0x7C, 0xFE, 0xC6, 0xC6, 0xC7, 0xC6, 0xE6, 0xFE, 0x7C, 0x08, 0xDE,
  0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE6, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0,
  0x20, 0xFF, 0xFF, 0x3C, 0x78, 0xF1, 0xF7, 0xFE, 0xEC, 0x18, 0x30, 0x60,
  0xC0, 0x0E, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x23, 0xFF, 0xB0, 0xF1,
  0xE3, 0xE7, 0xFB, 0xE0, 0x30, 0xCF, 0xFF, 0x71, 0xC7, 0x1C, 0x71, 0xF3,
  0xC0, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xFB, 0xFF, 0x7E, 0xE3, 0xB3, 0x99,
  0xCE, 0xC3, 0x61, 0xF0, 0xF0, 0x78, 0x1C, 0x00, 0xE7, 0x3B, 0x39, 0x9B,
  0x4C, 0xDB, 0xE7, 0xDF, 0x3E, 0xF0, 0xF7, 0x87, 0x3C, 0x38, 0xE0, 0xE7,
  0x76, 0x3E, 0x3C, 0x3C, 0x3E, 0x7E, 0x77, 0xE7, 0xE3, 0xB3, 0x9D, 0xCE,
  0xC3, 0x61, 0xF0, 0xF0, 0x38, 0x1C, 0x0C, 0x0E, 0x0F, 0x07, 0x00, 0x7E,
  0xF8, 0x70, 0xC3, 0x8E, 0x1C, 0x7F, 0xFE, 0x1C, 0xF3, 0x0C, 0x30, 0xCF,
  0x38, 0x70, 0xC3, 0x0C, 0x38, 0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE7, 0x18, 0xC6, 0x31, 0xE7, 0x73, 0x18, 0xC6, 0x73, 0x00, 0x03, 0xFF,
  0xFC, 0x20,
};

const GFXglyph NotoSans_Condensed_ExtraBold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 12, 5, 1, -12 },
  { 6, 6, 4, 8, 1, -12 },
  { 9, 9, 12, 10, 0, -12 },
  { 23, 7, 14, 9, 1, -13 },
  { 36, 14, 12, 14, 0, -12 },
  { 57, 11, 12, 11, 0, -12 },
  { 74, 2, 4, 4, 1, -12 },
  { 75, 4, 15, 6, 1, -12 },
  { 83, 5, 15, 6, 0, -12 },
  { 93, 8, 8, 8, 0, -13 },
  { 101, 7, 8, 9, 1, -10 },
  { 108, 3, 4, 5, 1, -2 },
  { 110, 5, 3, 5, 0, -6 },
  { 112, 3, 3, 5, 1, -3 },
  { 114, 7, 12, 7, 0, -12 },
  { 125, 7, 12, 9, 1, -12 },
  { 136, 6, 12, 9, 1, -12 },
  { 145, 8, 12, 9, 0, -12 },
  { 157, 7, 12, 9, 1, -12 },
  { 168, 8, 12, 9, 0, -12 },
  { 180, 7, 12, 9, 1, -12 },
  { 191, 7, 12, 9, 1, -12 },
  { 202, 7, 12, 9, 1, -12 },
  { 213, 7, 12, 9, 1, -12 },
  { 224, 8, 12, 9, 0, -12 },
  { 236, 3, 9, 5, 1, -9 },
  { 240, 3, 11, 5, 1, -9 },
  { 245, 7, 8, 9, 1, -10 },
  { 252, 7, 6, 9, 1, -9 },
  { 258, 7, 8, 9, 1, -10 },
  { 265, 7, 12, 7, 0, -12 },
  { 276, 12, 13, 13, 1, -12 },
  { 296, 10, 12, 10, 0, -12 },
  { 311, 8, 12, 10, 1, -12 },
  { 323, 8, 12, 9, 1, -12 },
  { 335, 9, 12, 11, 1, -12 },
  { 349, 6, 12, 8, 1, -12 },
  { 358, 6, 12, 8, 1, -12 },
  { 367, 9, 12, 11, 1, -12 },
  { 381, 9, 12, 11, 1, -12 },
  { 395, 6, 12, 6, 0, -12 },
  { 404, 5, 16, 5, -1, -12 },
  { 414, 9, 12, 10, 1, -12 },
  { 428, 7, 12, 8, 1, -12 },
  { 439, 12, 12, 14, 1, -12 },
  { 457, 10, 12, 12, 1, -12 },
  { 472, 9, 12, 11, 1, -12 },
  { 486, 8, 12, 9, 1, -12 },
  { 498, 9, 15, 11, 1, -12 },
  { 515, 9, 12, 10, 1, -12 },
  { 529, 7, 12, 8, 1, -12 },
  { 540, 8, 12, 8, 0, -12 },
  { 552, 9, 12, 11, 1, -12 },
  { 566, 10, 12, 10, 0, -12 },
  { 581, 14, 12, 14, 0, -12 },
  { 602, 9, 12, 9, 0, -12 },
  { 616, 9, 12, 9, 0, -12 },
  { 630, 8, 12, 8, 0, -12 },
  { 642, 4, 15, 5, 1, -12 },
  { 650, 7, 12, 7, 0, -12 },
  { 661, 4, 15, 5, 0, -12 },
  { 669, 9, 8, 9, 0, -12 },
  { 678, 8, 2, 8, 0, 1 },
  { 680, 4, 3, 6, 1, -13 },
  { 682, 7, 10, 9, 1, -10 },
  { 691, 8, 13, 9, 1, -13 },
  { 704, 6, 10, 8, 1, -10 },
  { 712, 7, 13, 9, 1, -13 },
  { 724, 7, 10, 9, 1, -10 },
  { 733, 6, 13, 6, 0, -13 },
  { 743, 7, 14, 9, 1, -10 },
  { 756, 8, 13, 9, 1, -13 },
  { 769, 3, 13, 5, 1, -13 },
  { 774, 5, 17, 5, -1, -13 },
  { 785, 8, 13, 9, 1, -13 },
  { 798, 3, 13, 5, 1, -13 },
  { 803, 12, 10, 14, 1, -10 },
  { 818, 8, 10, 9, 1, -10 },
  { 828, 8, 10, 9, 1, -10 },
  { 838, 8, 14, 9, 1, -10 },
  { 852, 7, 14, 9, 1, -10 },
  { 865, 5, 10, 7, 1, -10 },
  { 872, 6, 10, 7, 1, -10 },
  { 880, 6, 11, 6, 0, -11 },
  { 889, 7, 9, 9, 1, -9 },
  { 897, 9, 9, 9, 0, -9 },
  { 908, 13, 9, 13, 0, -9 },
  { 923, 8, 9, 8, 0, -9 },
  { 932, 9, 13, 9, 0, -9 },
  { 947, 7, 9, 7, 0, -9 },
  { 955, 6, 15, 6, 0, -12 },
  { 967, 2, 17, 8, 3, -13 },
  { 972, 5, 15, 6, 1, -12 },
  { 982, 7, 4, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_ExtraBold17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD17PT7B_H_
