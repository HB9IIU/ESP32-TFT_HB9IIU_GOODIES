#ifndef _NOTOSANS_CONDENSED_EXTRABOLD40PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x04, 0x3E, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC0, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xE1, 0xF0,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x3C,
  0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x07, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x0F, 0x8F, 0x00, 0x7C, 0xF8,
  0x03, 0xE7, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C,
  0x78, 0x03, 0xE3, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x03,
  0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xBC, 0xF9, 0xC2,
  0x7C, 0xE0, 0x3E, 0x70, 0x1F, 0xB8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3B, 0xF0,
  0x1D, 0xFC, 0x0E, 0xFF, 0x07, 0x7F, 0xF3, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0xFF, 0x80, 0x78,
  0x03, 0xFF, 0x81, 0xF0, 0x07, 0xDF, 0x03, 0xE0, 0x1F, 0x1E, 0x0F, 0x80,
  0x3E, 0x3C, 0x1F, 0x00, 0x7C, 0x7C, 0x3C, 0x00, 0xF8, 0xF8, 0xF8, 0x01,
  0xF1, 0xF1, 0xE0, 0x03, 0xE3, 0xE7, 0xC0, 0x07, 0xC7, 0xCF, 0x06, 0x0F,
  0x8F, 0x3E, 0x3F, 0x8F, 0xBE, 0x7C, 0xFF, 0x9F, 0xFC, 0xF3, 0xFF, 0x1F,
  0xF3, 0xE7, 0xFF, 0x1F, 0xC7, 0x9F, 0x3E, 0x1F, 0x1F, 0x3E, 0x3C, 0x00,
  0x3C, 0x7C, 0x78, 0x00, 0xF8, 0xF8, 0xF0, 0x01, 0xE1, 0xF1, 0xE0, 0x07,
  0xC3, 0xE3, 0xC0, 0x0F, 0x87, 0xC7, 0x80, 0x1E, 0x0F, 0x8F, 0x00, 0x7C,
  0x1F, 0x3E, 0x00, 0xF0, 0x1F, 0xFC, 0x03, 0xE0, 0x3F, 0xF0, 0x07, 0x80,
  0x3F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xF8, 0xFC,
  0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xCF,
  0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xC1, 0xF8, 0x7F, 0xE1, 0xFC, 0x7F, 0xF8, 0xFE, 0x7F, 0xFE, 0x7E, 0x3F,
  0xFF, 0x3F, 0x3F, 0x9F, 0xFF, 0x9F, 0xC7, 0xFF, 0x8F, 0xC1, 0xFF, 0xC7,
  0xE0, 0x7F, 0xC3, 0xF8, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xC7,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0x80, 0x07, 0xE1,
  0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3F,
  0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0xF8,
  0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x87,
  0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x61, 0xE3, 0x9F, 0x7F, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xC1, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0x7C,
  0x0F, 0xCF, 0x87, 0xE3, 0xF0, 0x78, 0x70, 0x04, 0x10, 0x00, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xEF, 0xE7, 0xF1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xF7, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x7F, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1,
  0xF8, 0xFC, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0,
  0x07, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC,
  0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0xFE, 0xFD, 0xF3, 0xF7, 0x8F, 0xCC, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0x9F, 0xE3, 0x83, 0xF8, 0x40, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0x1F, 0xE3, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0x9F, 0x81, 0xF3,
  0xF0, 0x3C, 0x7E, 0x0F, 0x8F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x1F, 0x07,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFA, 0x00, 0xFD, 0xC0, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF,
  0x1F, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xF8, 0x23, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC3, 0x81, 0xF3, 0xF8, 0xFD, 0xFF, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE1, 0xFD, 0xFC, 0x7E, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E,
  0x1F, 0x9F, 0x87, 0xE3, 0xF3, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xCF, 0xE7, 0xE1, 0xFB,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0x7F,
  0x3F, 0xDF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xCF,
  0xE7, 0xE1, 0xFB, 0xF8, 0x7E, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFE, 0x1F, 0xDF, 0x87, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC7, 0xFB, 0xF0, 0xFC, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x8E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF,
  0x80, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE,
  0x7F, 0xFF, 0x7C, 0x7F, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xC3, 0xE0, 0x30, 0x3E, 0x7C, 0x1F, 0xF9, 0xE7, 0x87, 0xFF,
  0x9E, 0x78, 0xFF, 0xF1, 0xFF, 0x8F, 0x8F, 0x1F, 0xF1, 0xF0, 0xF0, 0xFF,
  0x1F, 0x0F, 0x0F, 0xF1, 0xE0, 0xF0, 0xFF, 0x1E, 0x0F, 0x0F, 0xF1, 0xE0,
  0xF0, 0xFF, 0x1E, 0x0F, 0x1F, 0xF1, 0xE1, 0xF1, 0xFF, 0x1F, 0x1F, 0x1E,
  0xF1, 0xF3, 0xFB, 0xEF, 0x0F, 0xFF, 0xFC, 0xF8, 0xFF, 0xBF, 0xC7, 0x87,
  0xF1, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xC0,
  0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7E, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFB, 0xF0, 0xFE,
  0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8,
  0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0xDF, 0x1F, 0xE0, 0x23, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x13, 0xFE, 0x0E,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF0,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFC, 0x1F, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xCF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0x3E, 0x3F, 0x80,
  0x27, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF7,
  0xF0, 0x3F, 0x7F, 0x03, 0xF3, 0xF8, 0x3F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xE1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8,
  0x7F, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xCF, 0xF0, 0xF0, 0x00, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xC3,
  0xF8, 0xFC, 0x3F, 0x8F, 0xC7, 0xF0, 0xFC, 0xFE, 0x0F, 0xCF, 0xE0, 0xFD,
  0xFC, 0x0F, 0xDF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFE, 0xFE, 0x0F, 0xC7, 0xF0,
  0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC1, 0xFC, 0xFC, 0x1F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xF0, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xBE, 0x07, 0xFF, 0xFB, 0xE0, 0xFB, 0xFF, 0xBE, 0x0F, 0xBF,
  0xF9, 0xF0, 0xFB, 0xFF, 0xDF, 0x1F, 0x3F, 0xFD, 0xF1, 0xF3, 0xFF, 0xDF,
  0x1F, 0x3F, 0xFC, 0xF9, 0xF3, 0xFF, 0xCF, 0xBE, 0x3F, 0xFC, 0xFB, 0xE3,
  0xFF, 0xCF, 0xFE, 0x3F, 0xFC, 0x7F, 0xC3, 0xFF, 0xC7, 0xFC, 0x3F, 0xFC,
  0x7F, 0xC3, 0xFF, 0xC7, 0xFC, 0x3F, 0xFC, 0x3F, 0x83, 0xFF, 0xC3, 0xF8,
  0x3F, 0xFC, 0x3F, 0x83, 0xFF, 0xC1, 0xF0, 0x3F, 0xFC, 0x1F, 0x03, 0xF0,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0x0F, 0xFE, 0xFE, 0x3F, 0xF9, 0xF8, 0xFF,
  0xE7, 0xF3, 0xFF, 0xCF, 0xCF, 0xFF, 0x3F, 0x3F, 0xFC, 0x7E, 0xFF, 0xF1,
  0xFB, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xDF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xF9,
  0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x01,
  0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F,
  0xC0, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xFC,
  0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xF9, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0xFE, 0x01, 0xFD,
  0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0xCF, 0xE0,
  0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFC, 0x3F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8,
  0xFC, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0xFC,
  0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0x87,
  0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xF8, 0x18, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0xEF, 0xF0, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xF8, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xC0, 0x7E, 0x7E, 0x07, 0xF0,
  0x1F, 0x9F, 0x81, 0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0x83, 0xF9, 0xF8, 0x1F,
  0xE0, 0xFC, 0x3F, 0x0F, 0xF8, 0x3F, 0x0F, 0xC3, 0xFE, 0x0F, 0xC3, 0xF0,
  0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0xF1, 0xF8, 0x3F, 0x0F, 0x7C, 0x7E, 0x07,
  0xE7, 0xDF, 0x1F, 0x81, 0xF9, 0xF3, 0xC7, 0xE0, 0x7E, 0x7C, 0xF9, 0xF8,
  0x1F, 0x9F, 0x3E, 0x7C, 0x03, 0xE7, 0xCF, 0xBF, 0x00, 0xFB, 0xE3, 0xEF,
  0xC0, 0x3E, 0xF8, 0x7B, 0xF0, 0x0F, 0xFE, 0x1E, 0xFC, 0x03, 0xFF, 0x87,
  0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7E, 0x01, 0xF9, 0xFC,
  0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0x7E, 0x3F,
  0x81, 0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0x3F, 0x01, 0xFC, 0xFE, 0x07,
  0xE1, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0,
  0x7E, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xE7, 0xE0, 0x3F,
  0x9F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFE, 0x1F, 0x81, 0xF8, 0x7E, 0x07,
  0xE3, 0xF8, 0x1F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xBE, 0x00, 0xFB, 0xF0, 0x1F,
  0x1F, 0x01, 0xF1, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0xFC, 0x7E, 0x07, 0xC7,
  0xC0, 0x7E, 0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x87, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0x3C, 0x0F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF1, 0xF3, 0xF8, 0x40, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x03, 0xFF, 0x8F,
  0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x3F, 0xDF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFE,
  0x78, 0xFE, 0x3C, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0xFE, 0x3F,
  0x7F, 0xCF, 0xDF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xC7, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFD, 0xFF, 0x3E, 0x3F, 0x80, 0x03,
  0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0x04, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x02, 0x3F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x0F, 0xE7, 0xE3, 0xFE, 0xFC, 0xFF, 0xDF, 0x9F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFE, 0x3F, 0xDF, 0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF,
  0x83, 0xFB, 0xF0, 0x7F, 0x7F, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF1, 0xFF, 0x7E, 0x1F, 0xC7, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x1F, 0x9F, 0x83, 0xE7, 0xE0, 0xFD, 0xF8,
  0x3F, 0x7E, 0x0F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x8F, 0xF3, 0xE3,
  0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x60, 0x0F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xF9, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xE7, 0xE3, 0xFE,
  0xFC, 0xFF, 0xDF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x3F, 0xDF, 0x83,
  0xFB, 0xF0, 0x7F, 0x7E, 0x07, 0xEF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xF0, 0x7F, 0x7F, 0x0F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFB, 0xF1, 0xFF, 0x7E, 0x1F, 0xCF,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC4, 0x03, 0xF8, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x0D, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0xFE, 0x3F, 0x7F, 0xCF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x38, 0xFB, 0xFF, 0xFF,
  0xEF, 0x84, 0x00, 0x01, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x00,
  0x03, 0x80, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0x80, 0x40, 0x00, 0x00,
  0x01, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xE7, 0xF8, 0x38, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x1F,
  0xCF, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0xFE, 0x0F, 0xCF,
  0xC0, 0xFD, 0xF8, 0x0F, 0xDF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0xFE, 0x1F, 0xC7, 0xCF, 0xF9, 0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xF8, 0x7F, 0x07,
  0xFF, 0xC1, 0xF8, 0x3F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF0, 0x7E, 0x0F, 0xFF,
  0x03, 0xF0, 0x7F, 0xF8, 0x1F, 0x83, 0xFF, 0xC0, 0xFC, 0x1F, 0xFE, 0x07,
  0xE0, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0x81, 0xF8, 0x3F, 0xFC, 0x0F, 0xC1,
  0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0x03, 0xF0, 0x7F, 0xF8, 0x1F, 0x83, 0xFF,
  0xC0, 0xFC, 0x1F, 0xFE, 0x07, 0xE0, 0xFC, 0xF8, 0xFE, 0x3E, 0x7F, 0xCF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFE, 0x1F, 0x9F,
  0x83, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7F, 0x7F,
  0x0F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xF8, 0x00, 0xF8, 0xFE, 0x3F, 0x7F, 0xCF, 0xDF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF7, 0xFE, 0xFD,
  0xFF, 0x3F, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x0F, 0xE7, 0xE3, 0xFE, 0xFC, 0xFF, 0xDF, 0x9F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFE, 0x3F, 0xDF, 0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x07, 0xEF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF,
  0x83, 0xFB, 0xF0, 0x7F, 0x7F, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFB, 0xF1, 0xFF, 0x7E, 0x1F, 0xCF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xC7, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xF0, 0x7F, 0xF9, 0xFF, 0xF3,
  0xFF, 0xEF, 0xE7, 0x9F, 0x81, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0xC0, 0x7F, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0x8F, 0xFC, 0x00,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xDF, 0x3F, 0xE7, 0xC7, 0xF1, 0xF0, 0xFE, 0x03,
  0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF9, 0xF8, 0x1F,
  0x9F, 0x80, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0xFD, 0xF8, 0x7F, 0x83,
  0xF7, 0xE1, 0xFE, 0x0F, 0x9F, 0x87, 0xF8, 0x7E, 0x7E, 0x1F, 0xE1, 0xF8,
  0xF8, 0x7F, 0xC7, 0xE3, 0xF3, 0xFF, 0x1F, 0x8F, 0xCF, 0xBC, 0xFC, 0x3F,
  0x3C, 0xF3, 0xF0, 0xFC, 0xF3, 0xCF, 0xC1, 0xF3, 0xCF, 0xBF, 0x07, 0xCF,
  0x3E, 0xF8, 0x1F, 0xFC, 0xFB, 0xE0, 0x7F, 0xF1, 0xEF, 0x80, 0xFF, 0x87,
  0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF,
  0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3,
  0xF9, 0xFC, 0x1F, 0x9F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xBF, 0x83, 0xF9,
  0xF8, 0x3F, 0x1F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE,
  0x03, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x07, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x8F, 0x81, 0xF9, 0xF8,
  0x0F, 0x9F, 0x80, 0xF9, 0xF8, 0x0F, 0xDF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0x80, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x78, 0x1F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0x07, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xE0, 0x3F, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0x80, 0x00,
  0x0C, 0x00, 0x5F, 0xF0, 0x1F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xF8, 0x07, 0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraBold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 29, 11, 2, -29 },
  { 27, 15, 11, 19, 2, -29 },
  { 48, 21, 29, 22, 1, -29 },
  { 125, 17, 32, 20, 2, -30 },
  { 193, 31, 29, 34, 1, -29 },
  { 306, 25, 29, 26, 1, -29 },
  { 397, 6, 11, 10, 2, -29 },
  { 406, 11, 35, 13, 2, -29 },
  { 455, 10, 35, 13, 1, -29 },
  { 499, 18, 17, 19, 1, -30 },
  { 538, 18, 20, 20, 1, -24 },
  { 583, 8, 10, 11, 1, -5 },
  { 593, 11, 5, 13, 1, -13 },
  { 600, 7, 7, 11, 2, -7 },
  { 607, 17, 29, 17, 0, -29 },
  { 669, 18, 29, 20, 1, -29 },
  { 735, 14, 29, 20, 2, -29 },
  { 786, 18, 29, 20, 1, -29 },
  { 852, 18, 29, 20, 1, -29 },
  { 918, 19, 29, 20, 1, -29 },
  { 987, 17, 29, 20, 2, -29 },
  { 1049, 18, 29, 20, 1, -29 },
  { 1115, 18, 29, 20, 1, -29 },
  { 1181, 18, 29, 20, 1, -29 },
  { 1247, 18, 29, 20, 1, -29 },
  { 1313, 7, 22, 11, 2, -22 },
  { 1333, 8, 27, 11, 1, -22 },
  { 1360, 18, 20, 20, 1, -24 },
  { 1405, 18, 13, 20, 1, -21 },
  { 1435, 18, 20, 20, 1, -24 },
  { 1480, 16, 29, 17, 0, -29 },
  { 1538, 28, 32, 32, 2, -29 },
  { 1650, 24, 29, 24, 0, -29 },
  { 1737, 18, 29, 23, 3, -29 },
  { 1803, 19, 29, 22, 2, -29 },
  { 1872, 20, 29, 25, 3, -29 },
  { 1945, 14, 29, 19, 3, -29 },
  { 1996, 14, 29, 19, 3, -29 },
  { 2047, 20, 29, 25, 2, -29 },
  { 2120, 20, 29, 26, 3, -29 },
  { 2193, 12, 29, 14, 1, -29 },
  { 2237, 11, 38, 12, -2, -29 },
  { 2290, 20, 29, 23, 3, -29 },
  { 2363, 15, 29, 18, 3, -29 },
  { 2418, 28, 29, 34, 3, -29 },
  { 2520, 22, 29, 28, 3, -29 },
  { 2600, 23, 29, 26, 2, -29 },
  { 2684, 17, 29, 22, 3, -29 },
  { 2746, 23, 36, 26, 2, -29 },
  { 2850, 20, 29, 23, 3, -29 },
  { 2923, 17, 29, 19, 1, -29 },
  { 2985, 18, 29, 19, 1, -29 },
  { 3051, 20, 29, 25, 3, -29 },
  { 3124, 23, 29, 23, 0, -29 },
  { 3208, 34, 29, 34, 0, -29 },
  { 3332, 22, 29, 22, 0, -29 },
  { 3412, 22, 29, 22, 0, -29 },
  { 3492, 18, 29, 19, 1, -29 },
  { 3558, 10, 36, 13, 2, -29 },
  { 3603, 17, 29, 17, 0, -29 },
  { 3665, 9, 36, 13, 1, -29 },
  { 3706, 20, 19, 22, 1, -29 },
  { 3754, 18, 4, 18, 0, 3 },
  { 3763, 10, 7, 14, 2, -31 },
  { 3772, 17, 22, 21, 1, -22 },
  { 3819, 18, 30, 22, 2, -30 },
  { 3887, 16, 22, 18, 1, -22 },
  { 3931, 19, 30, 22, 1, -30 },
  { 4003, 18, 22, 20, 1, -22 },
  { 4053, 15, 31, 14, 0, -31 },
  { 4112, 19, 32, 22, 1, -22 },
  { 4188, 18, 30, 22, 2, -30 },
  { 4256, 7, 31, 11, 2, -31 },
  { 4284, 11, 41, 11, -2, -31 },
  { 4341, 20, 30, 22, 2, -30 },
  { 4416, 6, 30, 11, 2, -30 },
  { 4439, 29, 22, 33, 2, -22 },
  { 4519, 18, 22, 22, 2, -22 },
  { 4569, 19, 22, 22, 1, -22 },
  { 4622, 18, 32, 22, 2, -22 },
  { 4694, 19, 32, 22, 1, -22 },
  { 4770, 13, 22, 16, 2, -22 },
  { 4806, 15, 22, 17, 1, -22 },
  { 4848, 13, 27, 15, 1, -27 },
  { 4892, 18, 22, 22, 2, -22 },
  { 4942, 20, 22, 20, 0, -22 },
  { 4997, 30, 22, 30, 0, -22 },
  { 5080, 20, 22, 20, 0, -22 },
  { 5135, 20, 32, 20, 0, -22 },
  { 5215, 15, 22, 17, 1, -22 },
  { 5257, 13, 36, 15, 1, -29 },
  { 5316, 5, 40, 18, 7, -31 },
  { 5341, 13, 36, 15, 1, -29 },
  { 5400, 18, 7, 20, 1, -18 },
};

const GFXfont NotoSans_Condensed_ExtraBold40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD40PT7B_H_
