#ifndef _NOTOSANS_CONDENSED_EXTRABOLD21PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0x00, 0xEF, 0xE0, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0x0C, 0xC1, 0x98, 0x37, 0x06, 0xE7, 0xFE, 0xFF, 0xC6, 0x60,
  0xCC, 0x19, 0x9F, 0xFF, 0xFF, 0x9D, 0x83, 0x30, 0x66, 0x0C, 0xC0, 0x08,
  0x04, 0x1F, 0xFF, 0xEE, 0x97, 0x43, 0xE0, 0xF8, 0x3F, 0x07, 0x82, 0xF1,
  0x7C, 0xFF, 0xFB, 0xF8, 0x10, 0x08, 0x00, 0x78, 0x30, 0xFC, 0x70, 0xDC,
  0x60, 0xCC, 0xE0, 0xCC, 0xC0, 0xCD, 0xC0, 0xDD, 0x9E, 0xFD, 0xBE, 0x7B,
  0xB7, 0x03, 0x73, 0x07, 0x73, 0x06, 0x73, 0x0E, 0x37, 0x0C, 0x3E, 0x1C,
  0x1E, 0x3E, 0x03, 0xF8, 0x1D, 0xE0, 0xE7, 0x07, 0x70, 0x3F, 0x80, 0xF8,
  0x0F, 0x8E, 0xFE, 0xF7, 0x7F, 0x39, 0xF9, 0xC7, 0x8F, 0xFE, 0x7F, 0xF1,
  0xFB, 0xE0, 0xFF, 0xFE, 0x3C, 0xE7, 0x1C, 0x63, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x87, 0x1C, 0x38, 0xF0, 0xF1, 0xC3, 0x8E, 0x38, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x8E, 0x73, 0xC0, 0x0C, 0x03, 0x04, 0xC9,
  0xFE, 0xFF, 0xC7, 0x83, 0xF1, 0xEE, 0x13, 0x00, 0x1C, 0x0E, 0x07, 0x03,
  0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xFE, 0xEE, 0xEC,
  0xFF, 0xFE, 0xEF, 0xE0, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x70,
  0x38, 0x18, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0x80, 0x3E, 0x3F, 0xBF,
  0xDC, 0xEE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFF, 0xF3,
  0xF8, 0xF8, 0x0E, 0x3C, 0xFB, 0xFF, 0xED, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x80, 0x7E, 0x7F, 0xBF, 0xC8, 0xE0, 0x70, 0x38, 0x3C,
  0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0xFF, 0xFF, 0xFE, 0x7E, 0x7F, 0xBF,
  0xC8, 0xE0, 0x70, 0x38, 0xF8, 0x7C, 0x3F, 0x03, 0xC1, 0xE0, 0xFF, 0xF7,
  0xFB, 0xF8, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x1F, 0x86, 0xE3, 0xB8, 0xCE,
  0x73, 0xBF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0xE0, 0x38, 0x7F, 0x3F, 0x9F,
  0xDC, 0x0E, 0x07, 0xE3, 0xFD, 0xFE, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xF7,
  0xFB, 0xF8, 0x1F, 0x1F, 0x9F, 0xDE, 0x0E, 0x07, 0x73, 0xFD, 0xFF, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7F, 0xFB, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0x70, 0x38, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0x83, 0xC1, 0xE0,
  0x3E, 0x3F, 0xBD, 0xDC, 0x7E, 0x73, 0xF9, 0xF8, 0x7C, 0x7F, 0x73, 0xF8,
  0xFC, 0x7E, 0x7F, 0xF9, 0xF8, 0x3E, 0x3F, 0xBF, 0xDC, 0xFE, 0x3F, 0x1F,
  0x9F, 0xFF, 0xFF, 0x9D, 0xC0, 0xC0, 0xED, 0xF7, 0xF3, 0xF0, 0x6F, 0xF6,
  0x00, 0x00, 0x0F, 0xFE, 0x6F, 0xF6, 0x00, 0x00, 0x07, 0xFE, 0xEE, 0xC0,
  0x00, 0x81, 0xC3, 0xE7, 0xEF, 0x87, 0x03, 0xF0, 0x7E, 0x0F, 0x81, 0xC0,
  0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x60, 0x3C,
  0x0F, 0xC1, 0xF8, 0x3C, 0x7E, 0xFC, 0xF0, 0x60, 0x20, 0x00, 0x7E, 0xFF,
  0x7F, 0x47, 0x07, 0x0F, 0x1E, 0x1C, 0x38, 0x38, 0x00, 0x00, 0x38, 0x3C,
  0x38, 0x0F, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x7E, 0xDD, 0xFD,
  0xF3, 0x3B, 0xE6, 0x77, 0xCC, 0xEF, 0x99, 0xDB, 0x3B, 0xB7, 0x7F, 0xEE,
  0x21, 0x0E, 0x00, 0x0F, 0x1C, 0x0F, 0xF8, 0x03, 0x80, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0x3F, 0x01, 0xDC, 0x0E, 0xE0, 0xE7, 0x07, 0x38, 0x38, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xE7, 0x0F, 0x78, 0x3B, 0xC1, 0xE0, 0xFF, 0x3F,
  0xEF, 0xFF, 0xCF, 0xF1, 0xFC, 0xFF, 0xFB, 0xFE, 0xFF, 0xFC, 0x7F, 0x1F,
  0xC7, 0xFF, 0xFF, 0xEF, 0xF0, 0x1F, 0x8F, 0xF7, 0xF9, 0xC0, 0xF0, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x7F, 0x8F, 0xE1, 0xF8,
  0xFE, 0x1F, 0xF3, 0xFF, 0x78, 0xEF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x3F, 0xC7, 0xF9, 0xEF, 0xFD, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x1F, 0xE7, 0xF9, 0xFF, 0x3C, 0x0F, 0x01, 0xE0, 0x38,
  0xFF, 0x1F, 0xE3, 0xFE, 0x1F, 0xC3, 0xB8, 0x77, 0xFE, 0x7F, 0xC7, 0xF0,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x38, 0xFF, 0xF7, 0x9C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7B, 0xFF, 0xC0, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0x3F, 0xEF, 0x10,
  0xF1, 0xFE, 0x3B, 0xCF, 0x7B, 0xCF, 0x71, 0xFE, 0x3F, 0x87, 0xF8, 0xFF,
  0x1E, 0xF3, 0xDE, 0x79, 0xCF, 0x3D, 0xE3, 0xBC, 0x78, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFE, 0xC7, 0xFD, 0x8F, 0xFB,
  0x9B, 0xFF, 0x37, 0xF6, 0xEF, 0xEF, 0xDF, 0xDF, 0x3F, 0xBE, 0x7F, 0x3C,
  0xFE, 0x71, 0xFC, 0xE3, 0x80, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xFE,
  0x7E, 0xE7, 0xEF, 0x7E, 0x77, 0xF7, 0x7F, 0x3F, 0xF3, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF0, 0xF0, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xFF,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xF7, 0x0E, 0x7F, 0xE3,
  0xFC, 0x1F, 0x80, 0xFE, 0x3F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x3B,
  0xFE, 0xFF, 0x3F, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x1F, 0x83,
  0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF,
  0x0F, 0xF0, 0xF7, 0x0E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0xFE, 0x1F, 0xF3, 0xFE, 0x79, 0xEF, 0x3D, 0xE7, 0xBD,
  0xE7, 0xFC, 0xFF, 0x1E, 0xE3, 0xDE, 0x79, 0xCF, 0x3D, 0xE3, 0xBC, 0x78,
  0x3F, 0x7F, 0xFF, 0xE1, 0xE0, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0x07, 0x87,
  0xFF, 0xFE, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xB8, 0xF7, 0xFC, 0xFF, 0x87, 0xE0, 0xE0, 0x7F, 0x0F, 0x70, 0xE7,
  0x0E, 0x70, 0xE3, 0x9E, 0x39, 0xC3, 0x9C, 0x39, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xE1, 0xC3, 0xF8, 0x78, 0xEF, 0x1E,
  0x39, 0xC7, 0x8E, 0x73, 0xE3, 0x9C, 0xF9, 0xE7, 0x3F, 0x70, 0xED, 0xDC,
  0x3B, 0x77, 0x0F, 0xCD, 0xC3, 0xF3, 0x70, 0xFC, 0xF8, 0x1E, 0x3E, 0x07,
  0x8F, 0x81, 0xE1, 0xE0, 0xF1, 0xE7, 0x1E, 0x79, 0xC3, 0xBC, 0x3F, 0x81,
  0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x83, 0xBC, 0x79, 0xC7,
  0x1E, 0xF0, 0xF0, 0xF0, 0xEE, 0x3D, 0xC7, 0x1C, 0xE3, 0xB8, 0x7F, 0x07,
  0xE0, 0xF8, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x7F, 0xDF, 0xF7, 0xFC, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0x81, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF9, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03,
  0x81, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E,
  0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xC0,
  0x06, 0x01, 0xC0, 0x3C, 0x0F, 0x81, 0xB8, 0x77, 0x0C, 0x73, 0x8E, 0x60,
  0xFC, 0x1C, 0xFF, 0xFF, 0xF0, 0xF3, 0x8E, 0x1C, 0x3F, 0x9F, 0xC8, 0xF0,
  0x7B, 0xFF, 0xFF, 0xCF, 0xE7, 0xF3, 0xFF, 0xEF, 0x70, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE6, 0x3B, 0xEF, 0xFB, 0xCE, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xF3, 0xFF, 0xEF, 0xFB, 0xBC, 0x1E, 0x7F, 0x7E, 0xF2, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0x7F, 0x3E, 0x03, 0x81, 0xC0, 0xE0, 0x73, 0xBB, 0xFF,
  0xFF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xBD, 0xFE, 0xF3, 0x1C,
  0x3F, 0x9F, 0xDC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC0, 0xE0, 0x78, 0x9F, 0xC7,
  0xE0, 0x1F, 0x3E, 0x3E, 0x38, 0x3E, 0xFE, 0xFE, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x39, 0xBF, 0xFF, 0xFE, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xFB, 0xDF, 0xEF, 0x70, 0x38, 0x1F, 0xFF, 0xFE, 0x7E,
  0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE7, 0x3B, 0xEF, 0xFB, 0xCE, 0xF3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xEF, 0xE0, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x38, 0xF3, 0x80, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xEF, 0xBE, 0xF0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE1, 0xF8, 0xFE, 0x7B, 0x9C, 0xEE, 0x3F, 0x8F, 0xE3, 0xFC,
  0xE7, 0x38, 0xEE, 0x3F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0x19, 0xFF, 0xFF, 0xFF, 0xFF, 0x9E, 0x7F, 0x3C, 0xFC, 0x71, 0xF8, 0xE3,
  0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x70, 0xE7, 0x3B,
  0xEF, 0xFB, 0xCE, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0x1C, 0x1F, 0xC7, 0xFB, 0xCE, 0xE3, 0xB8, 0xFE, 0x3F, 0x8E, 0xE3,
  0xBD, 0xE7, 0xF0, 0xF8, 0xE6, 0x3B, 0xEF, 0xFB, 0xCE, 0xF3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xF3, 0xFF, 0xEF, 0xFB, 0xBC, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x00, 0x39, 0xBF, 0xFF, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xFB, 0xDF, 0xEF, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE7, 0xDF,
  0xFF, 0xFF, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x39, 0xFF, 0xFF,
  0x1F, 0x1F, 0x9F, 0x8F, 0x0F, 0xBF, 0xFF, 0xE0, 0x38, 0x70, 0xFF, 0xFF,
  0xE7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xF3, 0xE3, 0xC0, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF3, 0xFF, 0xDF, 0xEF, 0xB0, 0xE1,
  0xFE, 0x39, 0xC7, 0x39, 0xE7, 0x38, 0x77, 0x0E, 0xE1, 0xF8, 0x1F, 0x03,
  0xE0, 0x78, 0x0F, 0x00, 0xE3, 0xC7, 0xF3, 0xCF, 0x73, 0xCE, 0x73, 0xCE,
  0x77, 0xEE, 0x76, 0xEE, 0x36, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x78, 0x1C, 0x78, 0xF1, 0xDC, 0xF7, 0xB8, 0xFE, 0x3F, 0x07, 0xC1,
  0xE0, 0xFC, 0x3F, 0x1E, 0xE7, 0x3B, 0xC7, 0xE1, 0xFE, 0x39, 0xC7, 0x39,
  0xE7, 0x38, 0x77, 0x0E, 0xE1, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x07, 0x00,
  0xE0, 0x3C, 0x1F, 0x03, 0xE0, 0x70, 0x00, 0x7F, 0x7F, 0x7F, 0x0F, 0x0E,
  0x1C, 0x1C, 0x38, 0x78, 0x7F, 0xFF, 0xFF, 0x0E, 0x3C, 0x70, 0xE1, 0xC3,
  0x87, 0x1C, 0xF9, 0xE1, 0xE1, 0xC1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C,
  0x3E, 0x7C, 0xF3, 0x87, 0x0E, 0x1C, 0x38, 0xF1, 0xE0, 0xF8, 0xFF, 0xE7,
  0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraBold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 15, 6, 1, -15 },
  { 9, 8, 5, 10, 1, -15 },
  { 14, 11, 15, 12, 0, -15 },
  { 35, 9, 17, 11, 1, -16 },
  { 55, 16, 15, 18, 1, -15 },
  { 85, 13, 15, 14, 1, -15 },
  { 110, 3, 5, 5, 1, -15 },
  { 112, 6, 18, 7, 1, -15 },
  { 126, 6, 18, 7, 0, -15 },
  { 140, 10, 9, 10, 0, -16 },
  { 152, 9, 11, 11, 1, -13 },
  { 165, 4, 6, 6, 1, -3 },
  { 168, 5, 3, 7, 1, -7 },
  { 170, 4, 3, 6, 1, -3 },
  { 172, 9, 15, 9, 0, -15 },
  { 189, 9, 15, 11, 1, -15 },
  { 206, 7, 15, 11, 1, -15 },
  { 220, 9, 15, 11, 1, -15 },
  { 237, 9, 15, 11, 1, -15 },
  { 254, 10, 15, 11, 0, -15 },
  { 273, 9, 15, 11, 1, -15 },
  { 290, 9, 15, 11, 1, -15 },
  { 307, 9, 15, 11, 1, -15 },
  { 324, 9, 15, 11, 1, -15 },
  { 341, 9, 15, 11, 1, -15 },
  { 358, 4, 12, 6, 1, -12 },
  { 364, 4, 15, 6, 1, -12 },
  { 372, 9, 11, 11, 1, -13 },
  { 385, 9, 7, 11, 1, -11 },
  { 393, 9, 11, 11, 1, -13 },
  { 406, 8, 15, 9, 0, -15 },
  { 421, 15, 17, 17, 1, -15 },
  { 453, 13, 15, 13, 0, -15 },
  { 478, 10, 15, 12, 1, -15 },
  { 497, 10, 15, 11, 1, -15 },
  { 516, 11, 15, 13, 1, -15 },
  { 537, 8, 15, 10, 1, -15 },
  { 552, 8, 15, 10, 1, -15 },
  { 567, 11, 15, 13, 1, -15 },
  { 588, 11, 15, 14, 1, -15 },
  { 609, 6, 15, 8, 1, -15 },
  { 621, 6, 20, 6, -1, -15 },
  { 636, 11, 15, 12, 1, -15 },
  { 657, 8, 15, 10, 1, -15 },
  { 672, 15, 15, 18, 1, -15 },
  { 701, 12, 15, 15, 1, -15 },
  { 724, 12, 15, 14, 1, -15 },
  { 747, 10, 15, 11, 1, -15 },
  { 766, 12, 19, 14, 1, -15 },
  { 795, 11, 15, 12, 1, -15 },
  { 816, 8, 15, 10, 1, -15 },
  { 831, 10, 15, 10, 0, -15 },
  { 850, 11, 15, 13, 1, -15 },
  { 871, 12, 15, 12, 0, -15 },
  { 894, 18, 15, 18, 0, -15 },
  { 928, 12, 15, 12, 0, -15 },
  { 951, 11, 15, 11, 0, -15 },
  { 972, 10, 15, 10, 0, -15 },
  { 991, 5, 18, 7, 1, -15 },
  { 1003, 9, 15, 9, 0, -15 },
  { 1020, 5, 18, 7, 0, -15 },
  { 1032, 11, 10, 11, 0, -15 },
  { 1046, 10, 2, 9, 0, 2 },
  { 1049, 5, 3, 7, 1, -16 },
  { 1051, 9, 12, 11, 1, -12 },
  { 1065, 10, 16, 12, 1, -16 },
  { 1085, 8, 12, 9, 1, -12 },
  { 1097, 9, 16, 12, 1, -16 },
  { 1115, 9, 12, 11, 1, -12 },
  { 1129, 8, 16, 7, 0, -16 },
  { 1145, 9, 17, 12, 1, -12 },
  { 1165, 10, 16, 12, 1, -16 },
  { 1185, 4, 16, 6, 1, -16 },
  { 1193, 6, 21, 6, -1, -16 },
  { 1209, 10, 16, 11, 1, -16 },
  { 1229, 3, 16, 6, 1, -16 },
  { 1235, 15, 12, 17, 1, -12 },
  { 1258, 10, 12, 12, 1, -12 },
  { 1273, 10, 12, 11, 1, -12 },
  { 1288, 10, 17, 12, 1, -12 },
  { 1310, 9, 17, 12, 1, -12 },
  { 1330, 7, 12, 8, 1, -12 },
  { 1341, 7, 12, 9, 1, -12 },
  { 1352, 7, 14, 8, 0, -14 },
  { 1365, 9, 12, 12, 1, -12 },
  { 1379, 11, 12, 11, 0, -12 },
  { 1396, 16, 12, 16, 0, -12 },
  { 1420, 10, 12, 10, 0, -12 },
  { 1435, 11, 17, 11, 0, -12 },
  { 1459, 8, 12, 9, 0, -12 },
  { 1471, 7, 18, 8, 0, -15 },
  { 1487, 2, 21, 10, 4, -16 },
  { 1493, 7, 18, 8, 1, -15 },
  { 1509, 9, 3, 11, 1, -9 },
};

const GFXfont NotoSans_Condensed_ExtraBold21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD21PT7B_H_
