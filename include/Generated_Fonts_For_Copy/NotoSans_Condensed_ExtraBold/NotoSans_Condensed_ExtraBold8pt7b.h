#ifndef _NOTOSANS_CONDENSED_EXTRABOLD8PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x30, 0xFC, 0x55, 0xF6, 0xF6, 0x2F, 0xC3, 0xB6, 0x49, 0x52,
  0xD2, 0xE2, 0xA5, 0x80, 0x62, 0x99, 0xD9, 0x3C, 0xF0, 0x6B, 0x48, 0x98,
  0x95, 0x5C, 0x4F, 0xE0, 0x22, 0xF2, 0x60, 0xC0, 0xC0, 0x25, 0x25, 0x00,
  0x6F, 0xDD, 0xF6, 0x3D, 0x92, 0x40, 0x6B, 0x22, 0x4F, 0x6B, 0x26, 0x3E,
  0x26, 0x6A, 0xF2, 0x64, 0xE3, 0x3E, 0x74, 0xAF, 0xD6, 0xF3, 0x22, 0x64,
  0x6F, 0x66, 0x96, 0x6F, 0x97, 0x36, 0xC3, 0xC1, 0x80, 0x16, 0xC3, 0xFF,
  0x86, 0x3C, 0xF4, 0xA0, 0x80, 0x39, 0x1B, 0xED, 0xBD, 0x03, 0x80, 0x63,
  0x94, 0xAF, 0x4C, 0xD6, 0xFB, 0xC0, 0x35, 0xCC, 0x47, 0xCA, 0xBB, 0xAE,
  0xEB, 0xB0, 0xEB, 0xA0, 0x32, 0x71, 0xF5, 0xBC, 0xBB, 0xFF, 0xBB, 0xE9,
  0x25, 0xC0, 0x24, 0x92, 0x5E, 0xBA, 0xCC, 0xAB, 0x92, 0x49, 0xC0, 0x9E,
  0xF7, 0xBE, 0xD4, 0x9D, 0xDF, 0xBB, 0x72, 0xF3, 0x95, 0xB8, 0xD6, 0xF9,
  0x00, 0x72, 0xF3, 0x95, 0xB8, 0x60, 0xCA, 0xAC, 0xEB, 0x6D, 0xC6, 0xBE,
  0xF6, 0x66, 0x66, 0xBB, 0xBB, 0xBE, 0x9E, 0x94, 0xA6, 0x30, 0x97, 0x2F,
  0xD3, 0x66, 0xCD, 0x80, 0xD7, 0x66, 0x7D, 0x95, 0x66, 0x22, 0xF2, 0x24,
  0x4F, 0xFF, 0xFC, 0x89, 0x22, 0x40, 0xD5, 0x5C, 0x26, 0x79, 0xF0, 0xC0,
  0x77, 0xBF, 0xCC, 0xFD, 0xDF, 0x7B, 0x30, 0x11, 0xFD, 0xD7, 0x7F, 0xC7,
  0x6B, 0xA4, 0x80, 0xFD, 0xD7, 0x1E, 0xCC, 0xFD, 0xDD, 0xCF, 0xF0, 0xCF,
  0xFE, 0xCC, 0xFE, 0xFD, 0xFF, 0xF0, 0xFF, 0x5D, 0x75, 0xFD, 0xDD, 0x7D,
  0xD7, 0xFD, 0xDF, 0xCC, 0xFD, 0xD7, 0x11, 0xFB, 0x60, 0xF8, 0xF0, 0x5D,
  0x26, 0xDD, 0xD7, 0x96, 0x66, 0xB7, 0xF7, 0x9A, 0xF6, 0x6F, 0xD6, 0x66,
  0x6C, 0xE9, 0x70, 0x69, 0x64, 0x98, 0xFF, 0xC9, 0x34, 0xB0, 0x5B,
};

const GFXglyph NotoSans_Condensed_ExtraBold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 4, 0, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 6, 4, 0, -6 },
  { 10, 7, 6, 7, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 2, 2, 2, 0, -6 },
  { 21, 3, 7, 3, 0, -6 },
  { 24, 2, 7, 3, 0, -6 },
  { 26, 4, 3, 4, 0, -6 },
  { 28, 4, 4, 4, 0, -5 },
  { 30, 2, 2, 2, 0, -1 },
  { 31, 2, 1, 3, 0, -3 },
  { 32, 2, 1, 2, 0, -1 },
  { 33, 3, 6, 3, 0, -6 },
  { 36, 4, 6, 4, 0, -6 },
  { 39, 3, 6, 4, 0, -6 },
  { 42, 4, 6, 4, 0, -6 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 4, 6, 4, 0, -6 },
  { 63, 4, 6, 4, 0, -6 },
  { 66, 2, 4, 2, 0, -4 },
  { 67, 2, 5, 2, 0, -4 },
  { 69, 4, 4, 4, 0, -5 },
  { 71, 4, 2, 4, 0, -4 },
  { 72, 4, 4, 4, 0, -5 },
  { 74, 3, 6, 3, 0, -6 },
  { 77, 6, 7, 6, 0, -6 },
  { 83, 5, 6, 5, 0, -6 },
  { 87, 3, 6, 5, 1, -6 },
  { 90, 4, 6, 4, 0, -6 },
  { 93, 4, 6, 5, 1, -6 },
  { 96, 2, 6, 4, 1, -6 },
  { 98, 2, 6, 4, 1, -6 },
  { 100, 5, 6, 5, 0, -6 },
  { 104, 4, 6, 5, 1, -6 },
  { 107, 3, 6, 3, 0, -6 },
  { 110, 3, 8, 2, -1, -6 },
  { 113, 4, 6, 5, 1, -6 },
  { 116, 3, 6, 4, 1, -6 },
  { 119, 5, 6, 7, 1, -6 },
  { 123, 4, 6, 6, 1, -6 },
  { 126, 5, 6, 5, 0, -6 },
  { 130, 3, 6, 4, 1, -6 },
  { 133, 5, 7, 5, 0, -6 },
  { 138, 4, 6, 5, 1, -6 },
  { 141, 4, 6, 4, 0, -6 },
  { 144, 4, 6, 4, 0, -6 },
  { 147, 4, 6, 5, 1, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 7, 6, 7, 0, -6 },
  { 160, 4, 6, 4, 0, -6 },
  { 163, 4, 6, 4, 0, -6 },
  { 166, 4, 6, 4, 0, -6 },
  { 169, 2, 7, 3, 0, -6 },
  { 171, 3, 6, 3, 0, -6 },
  { 174, 2, 7, 3, 0, -6 },
  { 176, 4, 4, 4, 0, -6 },
  { 178, 4, 1, 4, 0, 0 },
  { 179, 2, 1, 3, 0, -6 },
  { 180, 4, 4, 4, 0, -4 },
  { 182, 4, 6, 4, 0, -6 },
  { 185, 3, 4, 4, 0, -4 },
  { 187, 4, 6, 4, 0, -6 },
  { 190, 4, 4, 4, 0, -4 },
  { 192, 3, 6, 3, 0, -6 },
  { 195, 4, 6, 4, 0, -4 },
  { 198, 4, 6, 4, 0, -6 },
  { 201, 2, 6, 2, 0, -6 },
  { 203, 2, 8, 2, 0, -6 },
  { 205, 4, 6, 4, 0, -6 },
  { 208, 2, 6, 2, 0, -6 },
  { 210, 6, 4, 7, 0, -4 },
  { 213, 4, 4, 4, 0, -4 },
  { 215, 4, 4, 4, 0, -4 },
  { 217, 4, 6, 4, 0, -4 },
  { 220, 4, 6, 4, 0, -4 },
  { 223, 3, 4, 3, 0, -4 },
  { 225, 3, 4, 3, 0, -4 },
  { 227, 3, 5, 3, 0, -5 },
  { 229, 4, 4, 4, 0, -4 },
  { 231, 4, 4, 4, 0, -4 },
  { 233, 6, 4, 6, 0, -4 },
  { 236, 4, 4, 4, 0, -4 },
  { 238, 4, 6, 4, 0, -4 },
  { 241, 3, 4, 3, 0, -4 },
  { 243, 3, 7, 3, 0, -6 },
  { 246, 1, 8, 4, 1, -6 },
  { 247, 3, 7, 3, 0, -6 },
  { 250, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_ExtraBold8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD8PT7B_H_
