#ifndef _NOTOSANS_CONDENSED_EXTRABOLD16PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0x6D, 0xB0, 0x5F, 0x00, 0xDF, 0x7C, 0xF3, 0x1B, 0x0D, 0x04,
  0x8F, 0xF3, 0x61, 0xB3, 0xFD, 0xFE, 0x24, 0x16, 0x1B, 0x00, 0x11, 0xFF,
  0xF5, 0xD3, 0xC3, 0xC7, 0x1F, 0x7F, 0xC4, 0x10, 0x30, 0x03, 0xC6, 0x16,
  0x61, 0x93, 0x0C, 0x90, 0x2D, 0xB9, 0xEF, 0xE6, 0xDB, 0x06, 0xD8, 0x66,
  0xC3, 0x36, 0x30, 0xE0, 0x08, 0x0F, 0x87, 0x61, 0xD8, 0x3E, 0x0F, 0x07,
  0xDD, 0xBF, 0xE7, 0xB9, 0xE7, 0xF8, 0xF7, 0xFF, 0x36, 0x6E, 0xCC, 0xCC,
  0xCC, 0xCE, 0x66, 0x30, 0xC3, 0x1C, 0x63, 0x18, 0xE7, 0x39, 0x8C, 0x67,
  0x33, 0x00, 0x19, 0x35, 0xFF, 0xF3, 0xCD, 0xC9, 0x00, 0x30, 0x60, 0xC7,
  0xFF, 0xE6, 0x0C, 0x18, 0x76, 0x6E, 0xFF, 0xC0, 0x5F, 0x00, 0x0E, 0x18,
  0x30, 0xC1, 0x83, 0x0C, 0x18, 0x70, 0xC1, 0x86, 0x00, 0x30, 0xF3, 0xF6,
  0x6C, 0xD9, 0xF3, 0xE7, 0xCD, 0x9B, 0xF3, 0xC0, 0x3B, 0xFF, 0xB1, 0x8C,
  0x63, 0x18, 0xC6, 0x18, 0xFF, 0xFA, 0x30, 0x61, 0xC7, 0x0C, 0x38, 0xE3,
  0xFF, 0xF0, 0x33, 0xFF, 0xC3, 0x0D, 0xE7, 0x87, 0x0E, 0x3F, 0xFE, 0x0E,
  0x1E, 0x1E, 0x3E, 0x3E, 0x6E, 0xCE, 0xFF, 0xFF, 0x0E, 0x0E, 0xFF, 0xFC,
  0x30, 0xFF, 0xF0, 0xC3, 0x8F, 0xFF, 0x80, 0x0C, 0xFB, 0xD6, 0x0D, 0x1F,
  0xBF, 0x67, 0xCF, 0x9B, 0xF3, 0xC0, 0xFF, 0xFE, 0x06, 0x0E, 0x0C, 0x0C,
  0x1C, 0x18, 0x38, 0x38, 0x70, 0x18, 0x7E, 0x76, 0x66, 0x7E, 0x3C, 0x3C,
  0x7E, 0x67, 0xE7, 0x7E, 0x3C, 0x18, 0x7C, 0x7E, 0x66, 0xE7, 0x67, 0x7F,
  0x3E, 0x06, 0x0E, 0x7C, 0x78, 0xDF, 0x00, 0x17, 0xC0, 0x67, 0x60, 0x00,
  0x07, 0x66, 0xE0, 0x02, 0x1C, 0xF7, 0x8E, 0x0F, 0x07, 0x83, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x81, 0x83, 0xC1, 0xE1, 0xEF, 0x38, 0x40, 0x33, 0xF7,
  0xC3, 0x0C, 0x73, 0x8C, 0x00, 0xC7, 0x0C, 0x04, 0x07, 0xF1, 0x83, 0x63,
  0x3D, 0xF7, 0xB6, 0xE4, 0xDD, 0x9B, 0x9B, 0x7B, 0xBB, 0x00, 0x38, 0xC3,
  0xF8, 0x1E, 0x07, 0x83, 0xE0, 0xD8, 0x37, 0x1C, 0xC7, 0xF1, 0xFE, 0x7F,
  0xB8, 0xEE, 0x1C, 0xFE, 0xFE, 0xE6, 0xE6, 0xFE, 0xFE, 0xE6, 0xE7, 0xE6,
  0xFE, 0xFC, 0x18, 0xFD, 0xFF, 0x0E, 0x18, 0x30, 0x60, 0xE1, 0xC5, 0xF9,
  0xF0, 0xFC, 0xFE, 0xE7, 0xE7, 0xE3, 0xE3, 0xE7, 0xE7, 0xEF, 0xFE, 0xFC,
  0xFF, 0xFE, 0x38, 0xFF, 0xFE, 0x38, 0xE3, 0xFF, 0xC0, 0xFF, 0xFE, 0x38,
  0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x00, 0x0C, 0x3F, 0x7E, 0xE0, 0xE0, 0xCF,
  0xCF, 0xCF, 0xE3, 0xE3, 0x7F, 0x3F, 0xE3, 0xE3, 0xE3, 0xE3, 0xFF, 0xFF,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xF9, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0xFE,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0x78, 0xE7, 0xEE, 0xEE,
  0xFC, 0xF8, 0xFC, 0xFC, 0xEE, 0xEE, 0xE7, 0xE7, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0xFF, 0xC0, 0xF0, 0xFE, 0x3F, 0xC7, 0xEC, 0xFD, 0xB7,
  0xB6, 0xF6, 0xDE, 0x7B, 0xCE, 0x79, 0xCF, 0x39, 0x80, 0xF1, 0xF8, 0xFE,
  0x7B, 0x3D, 0x9E, 0xEF, 0x37, 0x9F, 0xC7, 0xE3, 0xF0, 0xE0, 0x18, 0x3F,
  0x1F, 0xDC, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xF3, 0x9F, 0xC7, 0xC0,
  0xFD, 0xFF, 0xBF, 0x3E, 0xFF, 0xFF, 0x70, 0xE1, 0xC3, 0x80, 0x18, 0x3F,
  0x1F, 0xDC, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xF3, 0x9F, 0xC7, 0xC0,
  0x60, 0x38, 0x0E, 0xFC, 0xFE, 0xE6, 0xE6, 0xEE, 0xFC, 0xFC, 0xEC, 0xEE,
  0xE6, 0xE7, 0x33, 0xFF, 0xF0, 0xE3, 0xC7, 0x87, 0x0E, 0x7F, 0xFE, 0xFF,
  0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0x7F, 0x3E, 0xE3, 0xB1, 0xD8, 0xCE,
  0x67, 0x71, 0xB8, 0xD8, 0x6C, 0x3E, 0x0E, 0x07, 0x00, 0xE7, 0x1F, 0x9C,
  0x66, 0x73, 0x99, 0xEE, 0x67, 0xB1, 0xF6, 0xC7, 0xDB, 0x0F, 0x2C, 0x3C,
  0xF0, 0xF3, 0x83, 0x8E, 0x00, 0xE7, 0xBB, 0x8D, 0x87, 0xC1, 0xC0, 0xE0,
  0xF8, 0x7C, 0x77, 0x33, 0xB8, 0xE0, 0xE3, 0xB3, 0x9D, 0x86, 0xC3, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xFF, 0xFC, 0x38, 0x61, 0xC7,
  0x0C, 0x38, 0x61, 0xFF, 0xF8, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF,
  0xF0, 0xC1, 0xC1, 0x83, 0x03, 0x06, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x70,
  0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x18, 0x1C, 0x3C, 0x36,
  0x66, 0x63, 0xC3, 0xFF, 0xFC, 0xE7, 0x3C, 0xFD, 0x18, 0x77, 0xEC, 0xF9,
  0xBF, 0x7E, 0xC1, 0x83, 0x06, 0xEF, 0xFD, 0xF1, 0xE3, 0xC7, 0xDF, 0xFE,
  0xE0, 0x7F, 0xEE, 0x70, 0xC3, 0x0C, 0x7F, 0x78, 0x0E, 0x1C, 0x3B, 0xFF,
  0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0xFB, 0xB0, 0x79, 0xFB, 0x36, 0x7F, 0xF8,
  0x30, 0x7E, 0x7C, 0x3D, 0xE7, 0x1E, 0xF9, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x77, 0xFF, 0x3E, 0x7C, 0xF9, 0xF3, 0xFF, 0x7E, 0x1E, 0x3F, 0xE7, 0x80,
  0xC1, 0x83, 0x06, 0xEF, 0xFD, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x30, 0xF3,
  0xFF, 0xFF, 0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC0, 0xC0,
  0xC0, 0xC7, 0xCE, 0xDC, 0xD8, 0xF8, 0xFC, 0xCC, 0xCE, 0xC7, 0xFF, 0xFF,
  0xFF, 0xDD, 0xDF, 0xFF, 0xB9, 0xE7, 0x3C, 0xE7, 0x9C, 0xF3, 0x9E, 0x73,
  0xCE, 0x60, 0xDD, 0xFF, 0xBE, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x79, 0xFB,
  0x3E, 0x7C, 0x78, 0xF3, 0xFE, 0x78, 0xDD, 0xFF, 0xBE, 0x3C, 0x78, 0xFB,
  0xFF, 0xDD, 0x83, 0x06, 0x0C, 0x00, 0x77, 0xFF, 0x3E, 0x7C, 0xF9, 0xF3,
  0xFF, 0x7E, 0x1C, 0x38, 0x70, 0xE0, 0xDF, 0xFF, 0xCC, 0x63, 0x18, 0xC0,
  0x7F, 0xF3, 0xCF, 0x9E, 0x7F, 0xF0, 0x30, 0xC7, 0xBE, 0x71, 0xC7, 0x1C,
  0x71, 0xF3, 0xC0, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFB, 0xFF, 0x76, 0xE7,
  0xE7, 0x66, 0x66, 0x7E, 0x3C, 0x3C, 0x3C, 0x18, 0xE6, 0x3E, 0xF7, 0x6F,
  0x66, 0xF6, 0x6F, 0x66, 0x96, 0x39, 0xE3, 0x9C, 0x39, 0xC0, 0xE7, 0x66,
  0x7E, 0x3C, 0x3C, 0x3C, 0x7E, 0x6E, 0xE7, 0xE7, 0xE7, 0x66, 0x66, 0x7E,
  0x3C, 0x3C, 0x3C, 0x18, 0x18, 0x38, 0x70, 0x60, 0x7D, 0xF1, 0xC6, 0x38,
  0xC6, 0x3F, 0xFC, 0x09, 0xCE, 0x63, 0x19, 0xDC, 0xF1, 0x8C, 0x63, 0x1C,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC7, 0x0C, 0x30, 0xC3, 0x87, 0x3C,
  0xC3, 0x0C, 0x73, 0xCC, 0x00, 0x71, 0xFF, 0x8E,
};

const GFXglyph NotoSans_Condensed_ExtraBold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 4, 1, -11 },
  { 6, 6, 4, 8, 1, -11 },
  { 9, 9, 11, 9, 0, -11 },
  { 22, 6, 13, 8, 1, -12 },
  { 32, 13, 12, 13, 0, -12 },
  { 52, 10, 12, 10, 0, -12 },
  { 67, 2, 4, 4, 1, -11 },
  { 68, 4, 15, 5, 1, -12 },
  { 76, 5, 15, 5, 0, -12 },
  { 86, 7, 7, 8, 0, -12 },
  { 93, 7, 8, 8, 1, -10 },
  { 100, 4, 4, 4, 0, -2 },
  { 102, 5, 2, 5, 0, -5 },
  { 104, 3, 3, 4, 1, -3 },
  { 106, 7, 12, 7, 0, -12 },
  { 117, 7, 12, 8, 1, -12 },
  { 128, 5, 11, 8, 1, -11 },
  { 135, 7, 12, 8, 0, -12 },
  { 146, 6, 12, 8, 1, -12 },
  { 155, 8, 11, 8, 0, -11 },
  { 166, 6, 11, 8, 1, -11 },
  { 175, 7, 12, 8, 1, -12 },
  { 186, 8, 11, 8, 0, -11 },
  { 197, 8, 12, 8, 0, -12 },
  { 209, 8, 12, 8, 0, -12 },
  { 221, 3, 9, 4, 1, -9 },
  { 225, 4, 11, 4, 0, -9 },
  { 231, 7, 8, 8, 1, -10 },
  { 238, 7, 5, 8, 1, -8 },
  { 243, 7, 8, 8, 1, -10 },
  { 250, 6, 12, 7, 0, -12 },
  { 259, 11, 13, 13, 1, -12 },
  { 277, 10, 11, 10, 0, -11 },
  { 291, 8, 11, 9, 1, -11 },
  { 302, 7, 12, 9, 1, -12 },
  { 313, 8, 11, 10, 1, -11 },
  { 324, 6, 11, 8, 1, -11 },
  { 333, 6, 11, 7, 1, -11 },
  { 342, 8, 12, 10, 1, -12 },
  { 354, 8, 11, 10, 1, -11 },
  { 365, 5, 11, 6, 0, -11 },
  { 372, 5, 14, 5, -1, -11 },
  { 381, 8, 11, 9, 1, -11 },
  { 392, 6, 11, 7, 1, -11 },
  { 401, 11, 11, 13, 1, -11 },
  { 417, 9, 11, 11, 1, -11 },
  { 430, 9, 12, 11, 1, -12 },
  { 444, 7, 11, 9, 1, -11 },
  { 454, 9, 15, 11, 1, -12 },
  { 471, 8, 11, 9, 1, -11 },
  { 482, 6, 12, 8, 1, -12 },
  { 491, 7, 11, 8, 0, -11 },
  { 501, 8, 11, 10, 1, -11 },
  { 512, 9, 11, 9, 0, -11 },
  { 525, 14, 11, 13, 0, -11 },
  { 545, 9, 11, 9, 0, -11 },
  { 558, 9, 11, 9, 0, -11 },
  { 571, 7, 11, 8, 0, -11 },
  { 581, 4, 15, 5, 1, -12 },
  { 589, 7, 12, 7, 0, -12 },
  { 600, 4, 15, 5, 0, -12 },
  { 608, 8, 7, 9, 0, -11 },
  { 615, 7, 2, 7, 0, 1 },
  { 617, 4, 2, 6, 1, -12 },
  { 618, 7, 9, 8, 0, -9 },
  { 626, 7, 12, 9, 1, -12 },
  { 637, 6, 9, 7, 1, -9 },
  { 644, 7, 12, 9, 1, -12 },
  { 655, 7, 9, 8, 1, -9 },
  { 663, 6, 12, 5, 0, -12 },
  { 672, 7, 13, 9, 1, -9 },
  { 684, 7, 12, 9, 1, -12 },
  { 695, 2, 12, 4, 1, -12 },
  { 698, 4, 16, 4, -1, -12 },
  { 706, 8, 12, 9, 1, -12 },
  { 718, 2, 12, 4, 1, -12 },
  { 721, 11, 9, 13, 1, -9 },
  { 734, 7, 9, 9, 1, -9 },
  { 742, 7, 9, 9, 1, -9 },
  { 750, 7, 13, 9, 1, -9 },
  { 762, 7, 13, 9, 1, -9 },
  { 774, 5, 9, 6, 1, -9 },
  { 780, 5, 9, 7, 1, -9 },
  { 786, 6, 11, 6, 0, -11 },
  { 795, 7, 9, 9, 1, -9 },
  { 803, 8, 9, 8, 0, -9 },
  { 812, 12, 9, 12, 0, -9 },
  { 826, 8, 9, 8, 0, -9 },
  { 835, 8, 13, 8, 0, -9 },
  { 848, 6, 9, 7, 0, -9 },
  { 855, 5, 15, 6, 0, -12 },
  { 865, 2, 16, 7, 3, -12 },
  { 869, 6, 15, 6, 0, -12 },
  { 881, 8, 3, 8, 0, -7 },
};

const GFXfont NotoSans_Condensed_ExtraBold16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD16PT7B_H_
