#ifndef _NOTOSANS_CONDENSED_EXTRABOLD45PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0xFE, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xF7, 0xE3, 0xFB, 0xF1, 0xFD, 0xF8,
  0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0x9F, 0x07, 0xC0, 0x00, 0xF8,
  0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1,
  0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xE1, 0xE0, 0x03, 0xE3,
  0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC7,
  0xC0, 0x07, 0xC7, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0x8F, 0x80, 0x0F, 0x8F,
  0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0x9C, 0x33, 0xF3, 0x80,
  0x7E, 0x70, 0x0F, 0xCE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3B, 0xF8, 0x07, 0x3F, 0x80, 0xE7, 0xF8, 0x1C, 0xFF,
  0xE3, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3F,
  0xF0, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0x7C, 0x00, 0x7F, 0xF8, 0x07, 0xC0,
  0x07, 0xCF, 0xC0, 0xF8, 0x00, 0x7C, 0x7C, 0x0F, 0x80, 0x0F, 0xC7, 0xC1,
  0xF8, 0x00, 0xFC, 0x7C, 0x1F, 0x00, 0x0F, 0xC7, 0xC1, 0xF0, 0x00, 0xF8,
  0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0xFC, 0x7C, 0x7C, 0x00,
  0x0F, 0xC7, 0xC7, 0xC3, 0xC0, 0x7C, 0x7C, 0xF8, 0xFF, 0x07, 0xCF, 0xCF,
  0x9F, 0xF8, 0x7F, 0xF9, 0xF9, 0xFF, 0xC3, 0xFF, 0x9F, 0x3F, 0xFE, 0x1F,
  0xF1, 0xF3, 0xE7, 0xE0, 0xFE, 0x3E, 0x3E, 0x3E, 0x03, 0x83, 0xE7, 0xE3,
  0xE0, 0x00, 0x7C, 0x7E, 0x3E, 0x00, 0x07, 0xC7, 0xE3, 0xF0, 0x00, 0xF8,
  0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x3E, 0x00,
  0x1F, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0x3E, 0x3E, 0x00, 0x3E, 0x03, 0xF7,
  0xE0, 0x03, 0xE0, 0x1F, 0xFC, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x07, 0xC0,
  0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F,
  0x87, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0xFE, 0x0F, 0xFE, 0x0F, 0xE1, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF,
  0x1F, 0xC7, 0xFF, 0xF9, 0xFC, 0x7F, 0x3F, 0xDF, 0xC7, 0xF1, 0xFF, 0xF8,
  0xFE, 0x1F, 0xFF, 0x8F, 0xE0, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF9, 0xFE, 0x07,
  0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xF0, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x03,
  0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x41,
  0xF0, 0x27, 0x0F, 0x1E, 0x7E, 0xF7, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0,
  0x1F, 0xBF, 0x83, 0xF9, 0xF8, 0x3F, 0x1F, 0xC0, 0xF0, 0xF0, 0x06, 0x06,
  0x00, 0x00, 0x40, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x9F, 0xCF, 0xE7,
  0xE3, 0xF1, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0x7E, 0x08, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xEF, 0xF3,
  0xF8, 0xFE, 0xFE, 0x0F, 0xDF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF9, 0xFC, 0x7F, 0x3F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x7F,
  0x3C, 0x7F, 0x18, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xBF, 0xE3,
  0xC0, 0xFE, 0x18, 0x0F, 0xE1, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0x3F, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3E, 0x3F, 0xE1, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xBF, 0x80,
  0xFD, 0xFC, 0x07, 0xCF, 0xE0, 0x7C, 0x7F, 0x07, 0xE3, 0xF8, 0x3E, 0x1F,
  0xC3, 0xF0, 0xFE, 0x1F, 0x07, 0xF1, 0xF8, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x7C, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC6, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0xF0, 0x23, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x3F, 0x07, 0xEF, 0xF8, 0x7E, 0xFF, 0xC7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x3F, 0x7F, 0x07, 0xF7, 0xF0,
  0x7F, 0x7F, 0x87, 0xF3, 0xFD, 0xFF, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0, 0x7F, 0x7F,
  0x07, 0xF7, 0xF0, 0x7E, 0x7F, 0x07, 0xE3, 0xF8, 0xFE, 0x3F, 0xDF, 0xE1,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0, 0x7F, 0x7E, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xF7, 0xF0,
  0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xDF, 0xE7, 0xF0, 0xFE, 0x7F, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xF3, 0xF0, 0x7E, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC2, 0x0F, 0xFC,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0x7E, 0x18, 0x1F, 0x1F, 0xDF, 0xEF, 0xF7, 0xF9, 0xFC, 0xFC, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xE3, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFF,
  0x07, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xE3, 0xFC,
  0xC0, 0x7F, 0x20, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x07, 0xFC,
  0x7E, 0x7E, 0x1F, 0xFE, 0x3E, 0x7C, 0x3F, 0xFE, 0x3E, 0x7C, 0x3F, 0xFE,
  0x3E, 0xF8, 0x7E, 0x3E, 0x1F, 0xF8, 0x7C, 0x3E, 0x1F, 0xF8, 0xFC, 0x3E,
  0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E,
  0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1E, 0xF8, 0xF8, 0x7E,
  0x3E, 0xF8, 0xF8, 0x7E, 0x3E, 0xF8, 0xFC, 0xFF, 0x7C, 0xF8, 0x7F, 0xFF,
  0xFC, 0xFC, 0x3F, 0xEF, 0xF8, 0x7C, 0x3F, 0xC7, 0xF0, 0x7C, 0x0F, 0x83,
  0xC0, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x80, 0x1F, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xF0, 0x07,
  0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFE,
  0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xF8, 0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF,
  0x81, 0xFD, 0xFC, 0x1F, 0xEF, 0xE3, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0x83, 0xFD, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0xFF, 0xEF, 0xC7, 0xF8, 0x0C, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0C, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0x83, 0xFE, 0x7F, 0x03, 0xFE, 0xFE,
  0x03, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x07, 0xF9,
  0xFC, 0x3F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0x7F,
  0x1F, 0xF0, 0x04, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80,
  0x7F, 0x7F, 0x80, 0xFE, 0xFF, 0x01, 0xFC, 0xFF, 0x03, 0xF9, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC1, 0xFF, 0x1F, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0x9F, 0xF8,
  0xFF, 0x83, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFB, 0xF8, 0x0F,
  0xF7, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x87, 0xF8,
  0x7F, 0x0F, 0xF0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x03, 0xF9, 0xFE, 0x07,
  0xF7, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xF3, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFD, 0xF0, 0x1F, 0xFF,
  0xFD, 0xF8, 0x1F, 0x7F, 0xFD, 0xF8, 0x1F, 0x7F, 0xFF, 0xF8, 0x3F, 0x7F,
  0xFE, 0xFC, 0x3F, 0x7F, 0xFE, 0xFC, 0x3E, 0x7F, 0xFE, 0xFC, 0x3E, 0x7F,
  0xFE, 0x7C, 0x7E, 0x7F, 0xFE, 0x7E, 0x7E, 0x7F, 0xFE, 0x7E, 0x7C, 0x7F,
  0xFE, 0x7E, 0xFC, 0x7F, 0xFE, 0x3E, 0xFC, 0x7F, 0xFE, 0x3F, 0xF8, 0x7F,
  0xFE, 0x3F, 0xF8, 0x7F, 0xFE, 0x3F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF8, 0x7F,
  0xFE, 0x1F, 0xF0, 0x7F, 0xFE, 0x1F, 0xF0, 0x7F, 0xFE, 0x1F, 0xF0, 0x7F,
  0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F,
  0xFE, 0x07, 0xE0, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0x7F, 0x07, 0xFF, 0xBF, 0x83, 0xFF, 0xCF, 0xE1, 0xFF, 0xE7, 0xF0, 0xFF,
  0xF9, 0xFC, 0x7F, 0xFC, 0xFE, 0x3F, 0xFE, 0x7F, 0x9F, 0xFF, 0x1F, 0xCF,
  0xFF, 0x8F, 0xE7, 0xFF, 0xC3, 0xFB, 0xFF, 0xE1, 0xFD, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x0C, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0x9F, 0xE0, 0x1F, 0xE7, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFF,
  0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC,
  0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE,
  0x1F, 0xEF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0xFE, 0x1F, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0x3F, 0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F,
  0xE7, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x80,
  0x7F, 0x9F, 0xE0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0x83, 0xFC, 0x7F, 0x07, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC3, 0xFC, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xC7,
  0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFF, 0x7F,
  0x00, 0xFF, 0x00, 0x60, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F,
  0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x1C, 0xFE, 0x01, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFD, 0xFE, 0x0F,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xE7,
  0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x03,
  0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x07, 0xE3, 0xF8,
  0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x03, 0xF3,
  0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0x80, 0xFE, 0x7F, 0x01, 0xFE, 0x03,
  0xF9, 0xFC, 0x07, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xE0, 0x3F, 0x9F, 0xC0,
  0xFF, 0xC0, 0xFC, 0x3F, 0x03, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0xF0, 0x7F, 0x0F, 0xE1, 0xFF, 0xC1, 0xFC, 0x1F, 0x87,
  0xFF, 0x87, 0xE0, 0x7E, 0x1F, 0x7E, 0x3F, 0x81, 0xFC, 0x7C, 0xF8, 0xFE,
  0x07, 0xF1, 0xF3, 0xE3, 0xF8, 0x1F, 0xCF, 0xCF, 0x8F, 0xE0, 0x3F, 0x3F,
  0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0xFD, 0xFC, 0x03, 0xF3, 0xE1, 0xF7, 0xF0,
  0x0F, 0xEF, 0x87, 0xDF, 0xC0, 0x3F, 0xFE, 0x1F, 0x7F, 0x00, 0x7F, 0xF8,
  0x7D, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF,
  0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0x81, 0xFC, 0x3F,
  0xC0, 0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xE0, 0x07, 0xF7,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xEF, 0xF0,
  0x0F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F,
  0xC3, 0xF8, 0x0F, 0xE3, 0xFC, 0x07, 0xF9, 0xFC, 0x03, 0xFD, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xF7,
  0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0x9F, 0x00, 0x3F, 0x3F, 0x00, 0x7E,
  0x3E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7C, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x01,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0xF0, 0xFE, 0x08, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0x87, 0xF7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xF1, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFB, 0xF3, 0xFF,
  0x3F, 0x1F, 0xE1, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0xFC, 0xFF, 0x8F, 0xDF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFE, 0xFF, 0x9F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xDF, 0xFC,
  0xFD, 0xFF, 0x8F, 0x87, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xE7,
  0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF9, 0xFC, 0x09, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x6F, 0xF9, 0xF7,
  0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x7C, 0x7F,
  0x1F, 0xF7, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0x7F, 0x9F, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xF3, 0xF0, 0xFE, 0x3F,
  0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFE, 0x3F, 0x9F, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0x3F, 0xC0, 0xE7,
  0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xC4,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE3, 0xF1, 0xFF,
  0x3F, 0x3F, 0xFB, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xF7, 0xF9, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x40, 0x0F, 0xF7, 0x01, 0xFE, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC7, 0xF0, 0xFC, 0xFF, 0x8F, 0xDF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0x08, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00,
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x00, 0x80, 0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07,
  0xE0, 0x08, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x87, 0xC0, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8,
  0x7F, 0x0F, 0xE3, 0xF8, 0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x03, 0xF3, 0xF8,
  0x0F, 0xDF, 0xC0, 0x3F, 0x7F, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF,
  0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x7F, 0x03, 0xF0, 0xF9, 0xFF, 0x8F, 0xFC, 0xFD,
  0xFF, 0xDF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE,
  0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE,
  0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE,
  0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE,
  0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE,
  0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE,
  0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xF8, 0x7F, 0x0F, 0x8F, 0xF8,
  0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F,
  0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F,
  0xEF, 0xF1, 0xFC, 0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F,
  0xBF, 0x80, 0xFD, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0x9F, 0xC1, 0xFC,
  0xFF, 0x1F, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0xF8, 0x7E, 0x0F, 0xCF, 0xF8, 0xFD, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xEF, 0xF9, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFD,
  0xFF, 0xCF, 0xCF, 0xF8, 0xFC, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE3,
  0xF1, 0xFF, 0x3F, 0x3F, 0xFB, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xF7, 0xF9, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x7F, 0xE3, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xF8,
  0x73, 0xF8, 0x09, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x0F, 0xFF, 0x0F, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF,
  0xF9, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC6, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0x9F,
  0x1F, 0xE3, 0xE0, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3,
  0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x87, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC1, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0x7F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0xFE, 0x01, 0xF9, 0xF8, 0x03, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xDF, 0x81, 0xFE, 0x07, 0xF7,
  0xF0, 0x7F, 0x81, 0xF9, 0xFC, 0x1F, 0xF0, 0xFE, 0x7F, 0x0F, 0xFC, 0x3F,
  0x8F, 0xC3, 0xFF, 0x0F, 0xE3, 0xF0, 0xFF, 0xC3, 0xF0, 0xFE, 0x3F, 0xF0,
  0xFC, 0x3F, 0x8F, 0xFC, 0x7F, 0x0F, 0xE7, 0xCF, 0x9F, 0xC1, 0xF9, 0xF3,
  0xE7, 0xE0, 0x7E, 0x7C, 0xF9, 0xF8, 0x1F, 0x9F, 0x3E, 0x7E, 0x07, 0xF7,
  0xCF, 0xBF, 0x80, 0xFD, 0xE1, 0xEF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F,
  0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1,
  0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x3F, 0x80, 0xFE, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFE, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0xCF, 0xF0,
  0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x9F, 0xC0, 0xFE, 0xFF, 0x03, 0xFC, 0xFE,
  0x01, 0xFF, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0,
  0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x87,
  0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFE, 0xFE,
  0x01, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0x00,
  0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x09, 0xFF, 0x00, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xD0, 0x01,
  0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraBold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 33, 12, 2, -32 },
  { 34, 17, 11, 21, 2, -32 },
  { 58, 24, 32, 25, 1, -32 },
  { 154, 19, 37, 23, 2, -34 },
  { 242, 36, 33, 38, 1, -33 },
  { 391, 28, 33, 29, 1, -33 },
  { 507, 7, 11, 11, 2, -32 },
  { 517, 12, 40, 15, 2, -33 },
  { 577, 12, 40, 15, 1, -33 },
  { 637, 20, 20, 22, 1, -34 },
  { 687, 19, 22, 23, 2, -27 },
  { 740, 9, 12, 12, 1, -6 },
  { 754, 12, 6, 14, 1, -15 },
  { 763, 8, 8, 12, 2, -7 },
  { 771, 19, 32, 19, 0, -32 },
  { 847, 19, 33, 23, 2, -33 },
  { 926, 16, 32, 23, 2, -32 },
  { 990, 20, 33, 23, 1, -33 },
  { 1073, 20, 33, 23, 1, -33 },
  { 1156, 21, 32, 23, 1, -32 },
  { 1240, 19, 32, 23, 2, -32 },
  { 1316, 20, 33, 23, 1, -33 },
  { 1399, 20, 32, 23, 1, -32 },
  { 1479, 20, 33, 23, 1, -33 },
  { 1562, 20, 33, 23, 1, -33 },
  { 1645, 8, 26, 12, 2, -25 },
  { 1671, 9, 31, 12, 1, -25 },
  { 1706, 20, 23, 23, 1, -28 },
  { 1764, 19, 14, 23, 2, -23 },
  { 1798, 20, 23, 23, 2, -28 },
  { 1856, 18, 34, 19, 0, -33 },
  { 1933, 32, 35, 36, 2, -32 },
  { 2073, 27, 32, 27, 0, -32 },
  { 2181, 21, 32, 26, 3, -32 },
  { 2265, 21, 33, 24, 2, -33 },
  { 2352, 23, 32, 28, 3, -32 },
  { 2444, 16, 32, 21, 3, -32 },
  { 2508, 16, 32, 21, 3, -32 },
  { 2572, 23, 33, 28, 2, -33 },
  { 2667, 23, 32, 29, 3, -32 },
  { 2759, 14, 32, 16, 1, -32 },
  { 2815, 13, 42, 13, -3, -32 },
  { 2884, 23, 32, 26, 3, -32 },
  { 2976, 17, 32, 21, 3, -32 },
  { 3044, 32, 32, 38, 3, -32 },
  { 3172, 25, 32, 31, 3, -32 },
  { 3272, 26, 33, 30, 2, -33 },
  { 3380, 20, 32, 24, 3, -32 },
  { 3460, 26, 41, 30, 2, -33 },
  { 3594, 23, 32, 26, 3, -32 },
  { 3686, 18, 33, 21, 2, -33 },
  { 3761, 20, 32, 22, 1, -32 },
  { 3841, 22, 32, 28, 3, -32 },
  { 3929, 26, 32, 26, 0, -32 },
  { 4033, 38, 32, 38, 0, -32 },
  { 4185, 25, 32, 25, 0, -32 },
  { 4285, 24, 32, 24, 0, -32 },
  { 4381, 20, 32, 22, 1, -32 },
  { 4461, 11, 40, 14, 2, -33 },
  { 4516, 19, 32, 19, 0, -32 },
  { 4592, 11, 40, 14, 1, -33 },
  { 4647, 23, 20, 24, 1, -32 },
  { 4705, 20, 5, 20, 0, 3 },
  { 4718, 12, 7, 15, 2, -34 },
  { 4729, 20, 25, 23, 1, -25 },
  { 4792, 20, 34, 25, 3, -34 },
  { 4877, 17, 25, 20, 2, -25 },
  { 4931, 20, 34, 25, 2, -34 },
  { 5016, 19, 25, 23, 2, -25 },
  { 5076, 16, 34, 15, 1, -34 },
  { 5144, 20, 36, 25, 2, -25 },
  { 5234, 20, 34, 25, 3, -34 },
  { 5319, 8, 35, 12, 2, -35 },
  { 5354, 12, 46, 12, -2, -35 },
  { 5423, 22, 34, 24, 3, -34 },
  { 5517, 7, 34, 12, 3, -34 },
  { 5547, 32, 25, 37, 3, -25 },
  { 5647, 20, 25, 25, 3, -25 },
  { 5710, 21, 25, 24, 2, -25 },
  { 5776, 20, 36, 25, 3, -25 },
  { 5866, 20, 36, 25, 2, -25 },
  { 5956, 14, 25, 18, 3, -25 },
  { 6000, 17, 25, 19, 1, -25 },
  { 6054, 15, 30, 17, 1, -30 },
  { 6111, 19, 25, 25, 3, -25 },
  { 6171, 23, 25, 23, 0, -25 },
  { 6243, 34, 25, 34, 0, -25 },
  { 6350, 22, 25, 22, 0, -25 },
  { 6419, 23, 36, 23, 0, -25 },
  { 6523, 17, 25, 19, 1, -25 },
  { 6577, 14, 39, 17, 1, -32 },
  { 6646, 5, 44, 21, 8, -34 },
  { 6674, 15, 39, 17, 1, -32 },
  { 6748, 21, 8, 23, 1, -20 },
};

const GFXfont NotoSans_Condensed_ExtraBold45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD45PT7B_H_
