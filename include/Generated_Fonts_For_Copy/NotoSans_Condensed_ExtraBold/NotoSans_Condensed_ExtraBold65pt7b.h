#ifndef _NOTOSANS_CONDENSED_EXTRABOLD65PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold65pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F,
  0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE3, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x03, 0xFC, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFE, 0x7F, 0x83, 0xC0, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xDF, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F,
  0xF9, 0xFF, 0x07, 0xFC, 0xFF, 0x83, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0,
  0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF0, 0x3F, 0xE7, 0xF8, 0x1F, 0xF3, 0xFC,
  0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFE, 0xF3, 0xF9, 0xFF, 0x1E, 0x07, 0x3F,
  0xE3, 0xC0, 0x27, 0xFC, 0x78, 0x00, 0xFF, 0x8F, 0x00, 0x1F, 0xF1, 0xE0,
  0x03, 0xFF, 0x3C, 0x00, 0x7F, 0xF7, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7B, 0xFF,
  0x00, 0x0F, 0x3F, 0xE0, 0x01, 0xE3, 0xFC, 0x00, 0x3C, 0x7F, 0xC0, 0x07,
  0x8F, 0xFE, 0x00, 0xF3, 0xFF, 0xF0, 0x1E, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x3F, 0x83, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x1F,
  0xC1, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xC3, 0xF8, 0x02, 0x00,
  0x7F, 0x87, 0xF8, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0xFF, 0x1F, 0xC3, 0xFF,
  0xC0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF8,
  0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0xFE, 0x3F, 0xE7, 0xF8, 0x3F, 0xFC, 0x3F,
  0xC7, 0xF8, 0xFF, 0x03, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x1F, 0x81,
  0xFE, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x0F,
  0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0xF8, 0x0F, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F,
  0xF8, 0x7F, 0xF7, 0xFF, 0xBF, 0xF8, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xBF, 0xFC, 0x07, 0xFF, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xDF,
  0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x04, 0x03, 0xF8, 0x02, 0x3C, 0x1F, 0xC0, 0xF1, 0xFC, 0xFE, 0x3F,
  0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x01,
  0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0x83, 0xFC, 0x00, 0xFC,
  0x0F, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF,
  0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x7F, 0xE7, 0xFC, 0x7F, 0xC7, 0xFC,
  0x7F, 0x87, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x07, 0xF9, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0xFF, 0x07, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE,
  0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x07,
  0xFE, 0x7F, 0xE0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x7F,
  0xE0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0,
  0x7F, 0xE3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC,
  0xFF, 0xDF, 0xF1, 0xFF, 0x9F, 0xC7, 0xFF, 0x1F, 0x0F, 0xFE, 0x1C, 0x1F,
  0xFC, 0x10, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFC, 0x0F, 0xFE, 0x1F, 0x00, 0x7F,
  0xE1, 0xE0, 0x07, 0xFE, 0x0C, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE1, 0xF0, 0x0F, 0xFE, 0x0C, 0x00, 0x7F, 0xE0, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xEF,
  0xF8, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0x3F, 0xE0, 0x01, 0xFE, 0x7F,
  0xC0, 0x03, 0xF9, 0xFF, 0x80, 0x0F, 0xF3, 0xFF, 0x00, 0x3F, 0xC7, 0xFE,
  0x00, 0x7F, 0x8F, 0xFC, 0x01, 0xFE, 0x1F, 0xF8, 0x03, 0xFC, 0x3F, 0xF0,
  0x0F, 0xF0, 0x7F, 0xE0, 0x1F, 0xE0, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0x80,
  0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xDF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x1F, 0x9F, 0xFF, 0xC1, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFD, 0xF8,
  0x0F, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xC0, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x40, 0x03, 0xFE,
  0x3F, 0xF0, 0x1F, 0xF3, 0xFF, 0xC0, 0xFF, 0xBF, 0xFF, 0x0F, 0xFB, 0xFF,
  0xFC, 0x7F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x83, 0xFF, 0xBF, 0xF8, 0x0F, 0xFD, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF,
  0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0x1F,
  0xF8, 0x1F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x7F, 0xE3, 0xFF,
  0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x03,
  0xFF, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x0F, 0xFC,
  0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x8F, 0xFE, 0x3F,
  0xF8, 0x3F, 0xF9, 0xFF, 0x80, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xEF,
  0xFE, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x02, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x1F, 0xF8, 0x1F, 0xF9,
  0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF,
  0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xC3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xBF, 0xE0, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0x8F, 0xF8, 0x07, 0xF8, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF,
  0xEF, 0xFE, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x3F, 0xC7, 0xFE, 0x7F, 0xEF, 0xFE, 0xFF,
  0xEF, 0xFF, 0xFF, 0xE7, 0xFE, 0x7F, 0xE3, 0xFC, 0x0F, 0x00, 0x0F, 0xC0,
  0xFF, 0x0F, 0xFC, 0x7F, 0xE7, 0xFF, 0xBF, 0xFD, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF0, 0xFF, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0x80,
  0x7F, 0xF1, 0x80, 0x0F, 0xFC, 0x40, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0xFE,
  0x1F, 0xC3, 0xFC, 0x0F, 0xFF, 0xFC, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xF0,
  0xFE, 0x7F, 0x83, 0xFF, 0xFF, 0xC3, 0xF9, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F,
  0xE7, 0xF0, 0x7F, 0xC3, 0xF8, 0x3F, 0xBF, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F,
  0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFF, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xFF,
  0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x87, 0xF8, 0x0F, 0xE0, 0x7F, 0xFE,
  0x1F, 0xE0, 0x3F, 0x81, 0xFF, 0xF8, 0x7F, 0x80, 0xFE, 0x07, 0xFF, 0xE1,
  0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x87, 0xF8, 0x0F, 0xE0, 0x7E, 0xFE, 0x1F,
  0xE0, 0x7F, 0x83, 0xFB, 0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE,
  0x07, 0xF8, 0x3F, 0xBF, 0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0xFE, 0x0F, 0xF0,
  0xFF, 0x87, 0xF3, 0xF8, 0x3F, 0xE7, 0xFF, 0x3F, 0xCF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xC1, 0xFF, 0xFD, 0xFF, 0xF8, 0x7F, 0x03, 0xFF, 0xE7,
  0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x03, 0xFF,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0xFF, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0xFD,
  0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0x7F,
  0xF0, 0x0F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x81, 0xFF, 0xF7, 0xFF, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xDF, 0xFC, 0x3F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC,
  0x03, 0xC3, 0xFF, 0xC0, 0x03, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x08, 0xFF, 0xF8, 0x00, 0xE1, 0xFF,
  0xF8, 0x1F, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0xF0, 0x1F, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x9F, 0xFC, 0x01,
  0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE,
  0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0xBF, 0xF8, 0x03, 0xFF,
  0x9F, 0xFC, 0x03, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x07, 0x81, 0xFF, 0xE0, 0x00, 0x40, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xFC, 0x00,
  0xFF, 0xCF, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x9F,
  0xF8, 0x03, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xC3,
  0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xFC,
  0x01, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xEF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F, 0xF0, 0x07, 0xFE,
  0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFC,
  0x7F, 0xE0, 0x0F, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x9F, 0xF8, 0x01, 0xFF,
  0xCF, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xFF, 0xF7, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xBF, 0xC0, 0x3F, 0xDF, 0xFF, 0xFD, 0xFE, 0x01,
  0xFE, 0xFF, 0xFF, 0xEF, 0xF8, 0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xC0, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFE, 0x07, 0xF9, 0xFF, 0xFF, 0xCF, 0xF0, 0x3F, 0xCF,
  0xFF, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0xFF, 0xF1, 0xFE, 0x1F, 0xE3, 0xFF,
  0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xC7, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFE, 0x7F, 0x87, 0xFF, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xFF, 0xF8,
  0x7F, 0x9F, 0xE1, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xE0, 0x0F, 0xFC, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF,
  0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0xBF, 0xF0, 0x3F, 0xFF, 0xFB, 0xFF, 0x03,
  0xFF, 0xFF, 0x9F, 0xF8, 0x3F, 0xFF, 0xF9, 0xFF, 0x83, 0xFF, 0xFF, 0x8F,
  0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFE, 0x3F, 0xFF,
  0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0x3F, 0xFF, 0xF8, 0x3F, 0xF3,
  0xFF, 0xFF, 0x83, 0xFF, 0x9F, 0xFF, 0xF8, 0x1F, 0xF9, 0xFF, 0xFF, 0x81,
  0xFF, 0x9F, 0xFF, 0xF8, 0x0F, 0xFD, 0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xF0,
  0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xF9,
  0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0x7F,
  0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F,
  0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE1, 0xFF, 0xF7, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xEF, 0xFE, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x07, 0xFF,
  0x3F, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xEF,
  0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x03,
  0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0xE3, 0xFF,
  0xC0, 0x0F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x87, 0xFF,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFE, 0x1F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x8F, 0xFE,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0,
  0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xF8,
  0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0x03,
  0xF1, 0xFF, 0x80, 0x1C, 0x3F, 0xF0, 0x00, 0x87, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xBF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xBF, 0xF0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0xFF,
  0xE7, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x9F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFB, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xEF, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xDF, 0xE0, 0xFF, 0xC0, 0x3F,
  0xE0, 0x7F, 0xBF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x7F, 0x83, 0xFF,
  0x00, 0xFF, 0xC3, 0xFC, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x87, 0xF9, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0xF0, 0x03, 0xFE, 0x1F,
  0xE3, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0xC0, 0x0F,
  0xFC, 0xFF, 0x8F, 0xF1, 0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x1F, 0xE3, 0xFE,
  0x00, 0x1F, 0xF3, 0xFC, 0x1F, 0xC7, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x3F,
  0xDF, 0xF8, 0x00, 0x7F, 0xCF, 0xF0, 0x7F, 0xBF, 0xF0, 0x00, 0xFF, 0x9F,
  0xE0, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x01, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x03, 0xFB, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x07, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x1F,
  0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xF9,
  0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F,
  0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0x1F, 0xFE, 0x07, 0x80, 0x7F, 0xF0, 0x20, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xF3, 0xFF, 0xF8, 0xFF,
  0x1F, 0xFF, 0x0F, 0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE1,
  0xFE, 0x03, 0xFF, 0x3F, 0xFC, 0x1F, 0xFB, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF,
  0xC7, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xDF, 0xFC,
  0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFE,
  0xFF, 0xF0, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xDF, 0xFF, 0xE3, 0xFE, 0x7F,
  0xFE, 0x1F, 0xE1, 0xFF, 0xE0, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFC, 0x0E, 0x0F, 0xFE, 0x00, 0x87, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x27, 0xFF, 0x00, 0x18, 0xFF, 0xF0, 0x1E, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0xFF, 0xC1, 0xFF,
  0xF3, 0xFF, 0x0F, 0xFF, 0xEF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF,
  0xF7, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD,
  0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00,
  0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F,
  0xF7, 0xFE, 0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x3F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xDF, 0xF0, 0x7F, 0xFE, 0x7F, 0xC0, 0xFF,
  0xF1, 0xFF, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0x9F, 0xF8,
  0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x08,
  0x7F, 0xF0, 0x00, 0xC3, 0xFF, 0xC0, 0x7E, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0x78, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0x1F, 0xF0, 0x7F, 0xFE, 0x7F,
  0xC3, 0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xF7, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x7F, 0xFD, 0xFF,
  0xC0, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0x7F, 0xE0,
  0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7,
  0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF,
  0x80, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xEF, 0xFC, 0x1F, 0xFF, 0xBF, 0xF0, 0x3F, 0xFC, 0xFF,
  0xC0, 0x7F, 0xC3, 0xFF, 0x00, 0x38, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0xC0,
  0x00, 0xFF, 0xE3, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x03, 0xFE, 0x3F, 0xFC, 0x1F, 0xF3,
  0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0xC7, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x7F, 0xFB,
  0xFF, 0xC1, 0xFF, 0xDF, 0xFC, 0x07, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF8, 0x3E, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xC0, 0x1C, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF,
  0x80, 0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE3,
  0xFF, 0x00, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x7F,
  0xE0, 0x07, 0xFD, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xC3,
  0xFF, 0x01, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x9F,
  0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFC,
  0x3F, 0xFC, 0x0F, 0xFF, 0x8F, 0xF1, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x7F, 0xF8, 0x3F, 0xC7, 0xFF, 0xE1, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF8, 0xFF, 0xF7, 0xFF, 0x03, 0xFF, 0xBF, 0xF8, 0x0F, 0xFD,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0,
  0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01,
  0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFF,
  0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF8,
  0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xEF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x7F, 0xF8, 0x3F, 0xC7, 0xFF, 0xE1, 0xFF, 0x3F, 0xFF, 0x8F, 0xFB, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF0, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFD, 0xFF, 0xE0, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0xC7, 0xFC, 0xFF, 0xFC, 0x3F, 0xF3,
  0xFF, 0xC1, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0x0F, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0x1F, 0xF0,
  0x7F, 0xFE, 0x7F, 0xC3, 0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xF7, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8,
  0x7F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xDF, 0xF8, 0x03,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF,
  0x80, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0,
  0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x0F,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xEF, 0xFC, 0x1F, 0xFF, 0xBF, 0xF0,
  0x3F, 0xFC, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x00, 0x3C, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC3, 0xFD, 0xFE, 0x3F, 0xEF, 0xF3, 0xFF, 0x7F, 0xDF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFE, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x7F, 0xF0, 0xFC, 0xFF, 0xC0, 0x39, 0xFF, 0x80, 0x13, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x81, 0xFF,
  0xFC, 0x00, 0x07, 0x40, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x83, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x43, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x03, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xEF, 0xF1, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0x8F, 0xF0, 0x7F, 0xE0, 0x7F,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF0, 0x01, 0xFF,
  0x9F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC,
  0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F,
  0xCF, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x07,
  0xFF, 0x80, 0x7F, 0xCF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xFE, 0x07, 0xFC, 0x3F, 0xF0,
  0x7F, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xBF, 0x83, 0xFF, 0x07, 0xFC,
  0x1F, 0xDF, 0xC1, 0xFF, 0x03, 0xFF, 0x0F, 0xEF, 0xE0, 0xFF, 0x81, 0xFF,
  0x87, 0xF7, 0xF8, 0x7F, 0xC0, 0x7F, 0xC7, 0xFB, 0xFC, 0x7F, 0xE0, 0x3F,
  0xE3, 0xF8, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFC, 0x7F, 0x1F, 0xF0, 0x0F,
  0xF8, 0xFE, 0x3F, 0x8F, 0xF8, 0x07, 0xFE, 0x7F, 0x1F, 0xC7, 0xFC, 0x01,
  0xFF, 0x3F, 0x8F, 0xF7, 0xFE, 0x00, 0xFF, 0xBF, 0xC3, 0xFB, 0xFE, 0x00,
  0x7F, 0xDF, 0xC1, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xE0, 0xFE, 0xFF, 0x80,
  0x0F, 0xF7, 0xF0, 0x7F, 0x7F, 0xC0, 0x07, 0xFB, 0xF8, 0x3F, 0xBF, 0xC0,
  0x03, 0xFD, 0xFC, 0x1F, 0xDF, 0xE0, 0x01, 0xFF, 0xFE, 0x07, 0xEF, 0xF0,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x07, 0xFE,
  0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x02, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x06, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x08, 0xFF, 0xE0, 0x00,
  0x5F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xA0, 0x00, 0x7F, 0xF9, 0x00, 0x00, 0x3E,
  0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBold65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 47, 18, 3, -46 },
  { 66, 25, 16, 31, 3, -46 },
  { 116, 34, 46, 36, 1, -46 },
  { 312, 27, 53, 33, 3, -49 },
  { 491, 51, 48, 55, 2, -47 },
  { 797, 40, 48, 42, 2, -47 },
  { 1037, 10, 16, 16, 3, -46 },
  { 1057, 17, 57, 21, 3, -47 },
  { 1179, 18, 57, 21, 1, -47 },
  { 1308, 29, 29, 31, 1, -50 },
  { 1414, 29, 32, 33, 2, -39 },
  { 1530, 12, 17, 18, 2, -8 },
  { 1556, 17, 9, 21, 2, -22 },
  { 1576, 11, 12, 18, 3, -11 },
  { 1593, 27, 48, 27, 0, -47 },
  { 1755, 29, 48, 33, 2, -47 },
  { 1929, 23, 46, 33, 3, -46 },
  { 2062, 28, 47, 33, 2, -47 },
  { 2227, 28, 48, 33, 2, -47 },
  { 2395, 31, 46, 33, 1, -46 },
  { 2574, 27, 47, 33, 3, -46 },
  { 2733, 29, 48, 33, 2, -47 },
  { 2907, 29, 46, 33, 2, -46 },
  { 3074, 29, 48, 33, 2, -47 },
  { 3248, 29, 48, 33, 2, -47 },
  { 3422, 12, 37, 18, 3, -36 },
  { 3478, 13, 45, 18, 2, -36 },
  { 3552, 29, 33, 33, 2, -40 },
  { 3672, 29, 21, 33, 2, -33 },
  { 3749, 29, 33, 33, 2, -40 },
  { 3869, 26, 48, 27, 0, -47 },
  { 4025, 46, 52, 51, 3, -47 },
  { 4324, 39, 46, 39, 0, -46 },
  { 4549, 31, 46, 38, 4, -46 },
  { 4728, 30, 48, 35, 3, -47 },
  { 4908, 33, 46, 40, 4, -46 },
  { 5098, 23, 46, 31, 5, -46 },
  { 5231, 23, 46, 30, 5, -46 },
  { 5364, 34, 48, 41, 3, -47 },
  { 5568, 33, 46, 42, 5, -46 },
  { 5758, 19, 46, 23, 2, -46 },
  { 5868, 19, 60, 19, -4, -46 },
  { 6011, 33, 46, 37, 5, -46 },
  { 6201, 25, 46, 30, 4, -46 },
  { 6345, 45, 46, 54, 5, -46 },
  { 6604, 36, 46, 45, 5, -46 },
  { 6811, 37, 48, 43, 3, -47 },
  { 7033, 29, 46, 35, 4, -46 },
  { 7200, 37, 58, 43, 3, -47 },
  { 7469, 33, 46, 37, 4, -46 },
  { 7659, 27, 48, 31, 2, -47 },
  { 7821, 29, 46, 32, 1, -46 },
  { 7988, 33, 47, 41, 4, -46 },
  { 8182, 37, 46, 37, 0, -46 },
  { 8395, 55, 46, 55, 0, -46 },
  { 8712, 36, 46, 36, 0, -46 },
  { 8919, 35, 46, 35, 0, -46 },
  { 9121, 29, 46, 32, 1, -46 },
  { 9288, 15, 58, 20, 4, -47 },
  { 9397, 27, 48, 27, 0, -47 },
  { 9559, 16, 58, 20, 1, -47 },
  { 9675, 33, 29, 35, 1, -46 },
  { 9795, 29, 6, 29, 0, 5 },
  { 9817, 17, 11, 22, 3, -50 },
  { 9841, 28, 37, 34, 2, -36 },
  { 9971, 29, 50, 36, 4, -49 },
  { 10153, 26, 37, 29, 2, -36 },
  { 10274, 30, 50, 36, 2, -49 },
  { 10462, 29, 37, 33, 2, -36 },
  { 10597, 23, 50, 22, 1, -50 },
  { 10741, 30, 52, 36, 2, -36 },
  { 10936, 29, 49, 36, 4, -49 },
  { 11114, 10, 50, 18, 4, -50 },
  { 11177, 16, 66, 18, -2, -50 },
  { 11309, 31, 49, 35, 4, -49 },
  { 11499, 10, 49, 17, 4, -49 },
  { 11561, 46, 36, 54, 4, -36 },
  { 11768, 29, 36, 36, 4, -36 },
  { 11899, 31, 37, 35, 2, -36 },
  { 12043, 29, 52, 36, 4, -36 },
  { 12232, 30, 52, 36, 2, -36 },
  { 12427, 21, 36, 25, 4, -36 },
  { 12522, 23, 37, 27, 2, -36 },
  { 12629, 22, 44, 24, 1, -43 },
  { 12750, 28, 37, 36, 4, -36 },
  { 12880, 33, 36, 33, 0, -36 },
  { 13029, 49, 36, 49, 0, -36 },
  { 13250, 32, 36, 32, 0, -36 },
  { 13394, 33, 52, 33, 0, -36 },
  { 13609, 25, 36, 27, 1, -36 },
  { 13722, 21, 58, 24, 1, -47 },
  { 13875, 8, 65, 30, 11, -50 },
  { 13940, 21, 58, 24, 2, -47 },
  { 14093, 29, 12, 33, 2, -29 },
};

const GFXfont NotoSans_Condensed_ExtraBold65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold65pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD65PT7B_H_
