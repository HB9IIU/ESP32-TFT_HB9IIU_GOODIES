#ifndef _NOTOSANS_CONDENSED_EXTRABOLD27PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xE7, 0x00, 0x0F, 0xFF,
  0xDE, 0xFB, 0xFC, 0xF7, 0x3D, 0xC7, 0x71, 0xDC, 0x77, 0x1C, 0x0E, 0x70,
  0x39, 0xC0, 0xE7, 0x03, 0xB8, 0x1C, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1C, 0xE0, 0x73, 0x81, 0x9C, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xE3, 0x9C,
  0x0E, 0x70, 0x3B, 0x81, 0xCE, 0x07, 0x38, 0x00, 0x06, 0x00, 0x60, 0x07,
  0x03, 0xFE, 0x7F, 0xEF, 0xFE, 0xF6, 0x2F, 0x60, 0xF6, 0x07, 0xE0, 0x7F,
  0x81, 0xFC, 0x07, 0xE0, 0x7E, 0x06, 0xF8, 0x6F, 0xE7, 0xEF, 0xFE, 0xFF,
  0xC3, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0x03, 0xF0, 0x38,
  0x1F, 0x83, 0x81, 0xDE, 0x1C, 0x0E, 0x71, 0xC0, 0x73, 0x8E, 0x03, 0x9C,
  0xF0, 0x1C, 0xE7, 0x00, 0xE7, 0x39, 0xC7, 0x3B, 0x9F, 0x9F, 0x9D, 0xFC,
  0xFD, 0xCE, 0xF1, 0x0E, 0x73, 0x80, 0xE7, 0x9C, 0x07, 0x3C, 0xE0, 0x79,
  0xE7, 0x03, 0x87, 0x38, 0x1C, 0x3F, 0x81, 0xC1, 0xFC, 0x1E, 0x07, 0xC0,
  0x02, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0x8E, 0x03, 0xC7,
  0x01, 0xE7, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC7, 0x9F, 0xE7, 0xCF,
  0xF3, 0xCF, 0xBD, 0xE7, 0x9F, 0xF3, 0xC7, 0xF1, 0xE1, 0xF8, 0xF9, 0xFC,
  0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xF3, 0xF0, 0xFF, 0x9C, 0xE7, 0x39, 0xC0,
  0x0E, 0x3C, 0x71, 0xE3, 0x8F, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x0F, 0xF0, 0x78, 0x38,
  0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x08, 0xE2, 0xFF, 0xEF, 0xFE, 0xFF, 0xF1, 0xF0, 0x3F, 0x87, 0xBC,
  0x7B, 0xC3, 0x18, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7B,
  0xDE, 0xEF, 0x7B, 0x9C, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0xF0, 0x00,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xC0, 0x78, 0x00, 0x06, 0x01, 0xF8, 0x3F, 0xC7, 0xFE, 0x79, 0xEF, 0x9E,
  0xF1, 0xEF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xEF, 0x9E, 0x7B, 0xE7, 0xFC, 0x3F, 0xC1, 0xF8, 0x07, 0xC3, 0xF1,
  0xFC, 0xFF, 0x7F, 0xFF, 0xF7, 0x7C, 0x9F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x06, 0x03, 0xF8,
  0xFF, 0xCF, 0xFE, 0x73, 0xE4, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x04, 0x07, 0xF8, 0xFF, 0xC7, 0xFE, 0x61, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x3F, 0xC3, 0xF0, 0x3F, 0x83, 0xFE, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x1F, 0xC3, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x83, 0xBC, 0x3D, 0xE1,
  0xCF, 0x1E, 0x78, 0xE3, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0xF8, 0x7F, 0xC7, 0xFE, 0x43, 0xE0, 0x1E, 0x01, 0xF0,
  0x1F, 0x01, 0xEE, 0x7E, 0xFF, 0xEF, 0xFC, 0x7F, 0x00, 0x00, 0x80, 0xFE,
  0x1F, 0xE3, 0xFE, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x38, 0xF7, 0xCF, 0xFE,
  0xFF, 0xEF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0x79, 0xE7, 0xFE,
  0x3F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x00, 0x04, 0x03, 0xFC, 0x7F,
  0xE7, 0xFE, 0xF1, 0xEF, 0x1E, 0xF9, 0xE7, 0xBE, 0x7F, 0xC3, 0xF8, 0x3F,
  0x87, 0xFC, 0xF9, 0xEF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFE, 0x7F,
  0xE3, 0xF8, 0x04, 0x03, 0xF8, 0x7F, 0xC7, 0xFE, 0xF9, 0xEF, 0x1E, 0xF1,
  0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x3E, 0xF0, 0x0E, 0x01,
  0xE0, 0x1E, 0x07, 0xC7, 0xFC, 0x7F, 0x87, 0xE0, 0x77, 0xFE, 0xF3, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFD, 0xE0, 0x77, 0xFE, 0xF3, 0x00, 0x00, 0x00,
  0x00, 0xF7, 0xBD, 0xDE, 0xF7, 0xB8, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F,
  0x0F, 0xE3, 0xF8, 0xFC, 0x0F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x07, 0xF3, 0xFC, 0xFE, 0x0F, 0x80, 0xE0,
  0x08, 0x00, 0x04, 0x0F, 0xF3, 0xFF, 0x3F, 0xF6, 0x3E, 0x03, 0xC0, 0x78,
  0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xC0, 0x3F,
  0xFC, 0x0F, 0x03, 0xC3, 0xC0, 0x3C, 0x70, 0xE3, 0x9C, 0x7F, 0x3B, 0x9F,
  0xE7, 0xE7, 0x9C, 0xFC, 0xE3, 0x9F, 0x9C, 0x73, 0xF3, 0x8E, 0x7E, 0x71,
  0xCF, 0xCE, 0x39, 0xF9, 0xFF, 0xF7, 0x9F, 0xFE, 0x71, 0xE7, 0x8F, 0x00,
  0x00, 0xF0, 0x04, 0x0F, 0xDF, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x3C, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFF, 0xCF, 0xFE, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF,
  0xFE, 0xFF, 0xCF, 0xFE, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x01, 0x00, 0x7F, 0x87, 0xFE, 0x7F,
  0xE7, 0xE3, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7F, 0x71, 0xFF, 0x87,
  0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0xFC, 0xF0, 0xFB,
  0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xBC, 0x1E,
  0xF0, 0x7B, 0xC3, 0xEF, 0x0F, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFE, 0xFF,
  0xBF, 0xEF, 0xFB, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x00,
  0x80, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3E, 0x19, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFD, 0xE0, 0xF7,
  0x83, 0xDF, 0x0F, 0x7E, 0x3C, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xC0, 0xFF, 0xFF, 0x7E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F,
  0xFF, 0xFE, 0xFC, 0xF8, 0xF0, 0x7F, 0xC3, 0xEF, 0x1F, 0x3C, 0x78, 0xF3,
  0xE3, 0xCF, 0x0F, 0x7C, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF0, 0xF3, 0xE3, 0xCF, 0x8F, 0x1E, 0x3C, 0x7C, 0xF0, 0xF3, 0xC3, 0xEF,
  0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0x7F, 0xF8, 0xEF, 0xF7, 0x3D, 0xFE,
  0xE7, 0xBF, 0xDE, 0xE7, 0xFB, 0xDC, 0xFF, 0x3F, 0x9F, 0xE7, 0xE3, 0xFC,
  0xFC, 0x7F, 0x9F, 0x8F, 0xF1, 0xF1, 0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0x80,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0xCF, 0xF7, 0x9F, 0xEF, 0xBF, 0xCF, 0x7F, 0x9F, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xF8,
  0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x7E, 0x7C, 0x3E,
  0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0x3E, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF3, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x7E, 0x7C, 0x3E, 0x78, 0x1E, 0xF8,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF,
  0x87, 0xFF, 0x3F, 0xF9, 0xE7, 0xEF, 0x1F, 0x78, 0xFB, 0xC7, 0xDE, 0x3E,
  0xFF, 0xE7, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0x3C, 0x79, 0xF3, 0xC7, 0x9E,
  0x3E, 0xF0, 0xF7, 0x87, 0xFC, 0x3E, 0x04, 0x07, 0xF9, 0xFF, 0xBF, 0xEF,
  0x8D, 0xE0, 0x3C, 0x07, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFB, 0xFE, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0xBF, 0x7F, 0xF3, 0xFF, 0x87, 0xF0,
  0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0xFB, 0xC1, 0xE7, 0x83, 0xC7, 0x87, 0x8F,
  0x1F, 0x1E, 0x3C, 0x3C, 0x78, 0x3C, 0xF0, 0x7B, 0xC0, 0xF7, 0x80, 0xEF,
  0x01, 0xDE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0xF0, 0x78, 0x3F, 0xE0, 0xF8, 0x79, 0xE1, 0xF0, 0xF3, 0xC3, 0xE1, 0xE7,
  0x87, 0xC3, 0xCF, 0x1F, 0x8F, 0x9E, 0x3F, 0x9E, 0x1E, 0x77, 0x3C, 0x3C,
  0xEE, 0x78, 0x7B, 0xDC, 0xF0, 0xF7, 0xB9, 0xE1, 0xEE, 0x7F, 0x81, 0xDC,
  0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x87,
  0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0xF8, 0xF8, 0xF1,
  0xE1, 0xE7, 0xC1, 0xEF, 0x03, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x01, 0xFF, 0x03, 0xDE, 0x0F, 0xBE, 0x1E,
  0x3C, 0x7C, 0x7C, 0xF0, 0x7B, 0xE0, 0xF8, 0xF8, 0x3E, 0xF0, 0xF9, 0xF1,
  0xE1, 0xE3, 0xC3, 0xCF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0,
  0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xF0, 0x0E, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0xF0, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xFF, 0x03, 0x80, 0x1E, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xE0, 0x7B, 0x81, 0xCF, 0x0F, 0x1C, 0x38, 0x70, 0xE1,
  0xE7, 0x83, 0xBC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF0, 0xF0,
  0xF0, 0xE0, 0x1F, 0x8F, 0xF8, 0xFF, 0x98, 0xF0, 0x1E, 0x03, 0xCF, 0xFB,
  0xFF, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0xFE, 0xFD, 0xDF, 0x38, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF7, 0x8F, 0xFC, 0xFF,
  0xEF, 0xBE, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1,
  0xFF, 0x9E, 0xFF, 0xEE, 0xFC, 0xE7, 0x80, 0x1F, 0xCF, 0xF7, 0xFD, 0xF3,
  0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x81, 0xF3, 0x7F, 0xCF,
  0xF1, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x1E,
  0xF3, 0xFF, 0x7F, 0xF7, 0xDF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF8, 0xFF, 0x9F, 0x7F, 0xF7, 0xFF, 0x3E, 0x70, 0x1F, 0x83,
  0xFC, 0x7F, 0xE7, 0x9E, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x07, 0x82, 0x7F, 0xE3, 0xFE, 0x1F, 0xC0, 0x07, 0x07, 0xF1,
  0xF8, 0xFE, 0x3C, 0x0F, 0x03, 0xFB, 0xFE, 0xFF, 0x8F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00,
  0x1E, 0x73, 0xFF, 0x7F, 0xF7, 0xDF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x9F, 0x7F, 0xF7, 0xFF, 0x3E, 0xF0, 0x0F,
  0x00, 0xF4, 0x1F, 0x7F, 0xE7, 0xFE, 0x7F, 0xC0, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF7, 0x8E, 0xFE, 0xFF, 0xEF, 0xBE, 0xF1,
  0xEF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xF0, 0x73, 0xFE, 0xF2, 0x01, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x1C, 0x3C, 0xF8, 0xF0, 0x80, 0x07,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x9F, 0xFD, 0xFB, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC3, 0xFE, 0x3E, 0xF3, 0xE7, 0x9E, 0x3D, 0xE1,
  0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0xF3, 0xC7, 0x9F, 0x3C,
  0x79, 0xE3, 0xEF, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xCF, 0x9D, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD,
  0xFD, 0xFF, 0x1F, 0x1F, 0xE3, 0xC3, 0xFC, 0x78, 0x7F, 0x8F, 0x0F, 0xF1,
  0xE1, 0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0xF8, 0xF0, 0xFF, 0x1E, 0x1F, 0xE3,
  0xC3, 0xFC, 0x78, 0x78, 0xE7, 0xCE, 0xFE, 0xFF, 0xEF, 0xBE, 0xF1, 0xEF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xF0, 0x1F, 0x81, 0xFE, 0x1F, 0xF8, 0xF3, 0xEF, 0x8F, 0x78,
  0x7B, 0xC3, 0xDE, 0x1F, 0xF0, 0xFF, 0x87, 0xBE, 0x3C, 0xF3, 0xE7, 0xFE,
  0x1F, 0xF0, 0x7E, 0x00, 0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0xBE, 0xF1, 0xFF,
  0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xFF, 0xBE, 0xFF, 0xEF,
  0xFC, 0xF7, 0x8F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00,
  0x1E, 0x73, 0xFF, 0x7F, 0xF7, 0xDF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x9F, 0x7F, 0xF7, 0xFF, 0x3E, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xE7, 0xEF, 0xEF, 0xFF,
  0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x3F,
  0x1F, 0xEF, 0xFB, 0xC6, 0xF0, 0x3E, 0x0F, 0xE1, 0xFC, 0x1F, 0x81, 0xE0,
  0x7F, 0x1E, 0xFF, 0xBF, 0xEF, 0xF0, 0x1C, 0x0E, 0x07, 0x07, 0xFF, 0xFF,
  0xFC, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFA, 0x7F,
  0x1F, 0x8F, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF9, 0xFF, 0xFF, 0xFD, 0xDF, 0x38,
  0xF0, 0x7F, 0xE1, 0xE7, 0x87, 0x9E, 0x3E, 0x78, 0xF0, 0xF3, 0xC3, 0xCF,
  0x0F, 0x78, 0x1D, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x00, 0xF0, 0xF8, 0xF7, 0x8F, 0x8F, 0x79, 0xF8, 0xF7, 0x9F,
  0x8F, 0x79, 0xF9, 0xE7, 0x9D, 0xDE, 0x3D, 0xDD, 0xE3, 0xD9, 0xDE, 0x3F,
  0x9D, 0xC3, 0xF9, 0xFC, 0x1F, 0x9F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0x81,
  0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF8, 0xFB, 0xC7, 0x9F, 0x3C, 0x7B, 0xC1,
  0xFE, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF8, 0x7B,
  0xC7, 0xCF, 0x3C, 0x7B, 0xE3, 0xE0, 0xF0, 0x7F, 0xE1, 0xE7, 0x87, 0x9E,
  0x3E, 0x7C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x78, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80,
  0x3C, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x00, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE,
  0x0F, 0x03, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0x87, 0xC7, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x1F, 0x3F, 0x1E, 0x0F, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xF8, 0x7C, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF8, 0x7C, 0x3F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1F, 0x07, 0xE0, 0xF1, 0xF9, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x8F, 0xC7, 0xC3, 0xE0, 0x78, 0x1F, 0xF3, 0xFF, 0xFC, 0xFF, 0x81,
  0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraBold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 10, 7, 13, 1, -19 },
  { 22, 14, 19, 15, 1, -19 },
  { 56, 12, 23, 14, 1, -21 },
  { 91, 21, 20, 23, 1, -20 },
  { 144, 17, 20, 18, 1, -20 },
  { 187, 5, 7, 7, 1, -19 },
  { 192, 7, 24, 9, 1, -20 },
  { 213, 8, 24, 9, 0, -20 },
  { 237, 12, 12, 13, 1, -21 },
  { 255, 12, 13, 14, 1, -16 },
  { 275, 5, 8, 7, 1, -4 },
  { 280, 7, 4, 9, 1, -9 },
  { 284, 5, 4, 7, 1, -4 },
  { 287, 11, 20, 11, 0, -20 },
  { 315, 12, 20, 14, 1, -20 },
  { 345, 10, 19, 14, 1, -19 },
  { 369, 12, 20, 14, 1, -20 },
  { 399, 12, 20, 14, 1, -20 },
  { 429, 13, 19, 14, 0, -19 },
  { 460, 12, 19, 14, 1, -19 },
  { 489, 12, 20, 14, 1, -20 },
  { 519, 12, 19, 14, 1, -19 },
  { 548, 12, 20, 14, 1, -20 },
  { 578, 12, 20, 14, 1, -20 },
  { 608, 5, 15, 7, 1, -15 },
  { 618, 5, 19, 7, 1, -15 },
  { 630, 12, 14, 14, 1, -17 },
  { 651, 12, 9, 14, 1, -14 },
  { 665, 12, 14, 14, 1, -17 },
  { 686, 11, 20, 11, 0, -20 },
  { 714, 19, 22, 21, 1, -20 },
  { 767, 16, 19, 16, 0, -19 },
  { 805, 12, 19, 16, 2, -19 },
  { 834, 13, 20, 15, 1, -20 },
  { 867, 14, 19, 17, 2, -19 },
  { 901, 10, 19, 13, 2, -19 },
  { 925, 9, 19, 13, 2, -19 },
  { 947, 14, 20, 17, 1, -20 },
  { 982, 14, 19, 18, 2, -19 },
  { 1016, 8, 19, 10, 1, -19 },
  { 1035, 8, 25, 8, -2, -19 },
  { 1060, 14, 19, 16, 2, -19 },
  { 1094, 10, 19, 12, 2, -19 },
  { 1118, 19, 19, 23, 2, -19 },
  { 1164, 15, 19, 19, 2, -19 },
  { 1200, 16, 20, 18, 1, -20 },
  { 1240, 12, 19, 15, 2, -19 },
  { 1269, 16, 25, 18, 1, -20 },
  { 1319, 13, 19, 15, 2, -19 },
  { 1350, 11, 20, 13, 1, -20 },
  { 1378, 13, 19, 13, 0, -19 },
  { 1409, 13, 19, 17, 2, -19 },
  { 1440, 15, 19, 15, 0, -19 },
  { 1476, 23, 19, 23, 0, -19 },
  { 1531, 15, 19, 15, 0, -19 },
  { 1567, 15, 19, 15, 0, -19 },
  { 1603, 12, 19, 13, 1, -19 },
  { 1632, 7, 24, 8, 1, -20 },
  { 1653, 11, 20, 11, 0, -20 },
  { 1681, 6, 24, 8, 1, -20 },
  { 1699, 14, 12, 15, 0, -19 },
  { 1720, 12, 3, 12, 0, 2 },
  { 1725, 7, 5, 9, 1, -21 },
  { 1730, 11, 15, 14, 1, -15 },
  { 1751, 12, 21, 15, 2, -21 },
  { 1783, 10, 15, 12, 1, -15 },
  { 1802, 12, 21, 15, 1, -21 },
  { 1834, 12, 15, 14, 1, -15 },
  { 1857, 10, 21, 9, 0, -21 },
  { 1884, 12, 21, 15, 1, -15 },
  { 1916, 12, 21, 15, 2, -21 },
  { 1948, 5, 21, 7, 1, -21 },
  { 1962, 7, 27, 7, -1, -21 },
  { 1986, 13, 21, 15, 2, -21 },
  { 2021, 4, 21, 7, 2, -21 },
  { 2032, 19, 15, 22, 2, -15 },
  { 2068, 12, 15, 15, 2, -15 },
  { 2091, 13, 15, 15, 1, -15 },
  { 2116, 12, 21, 15, 2, -15 },
  { 2148, 12, 21, 15, 1, -15 },
  { 2180, 8, 15, 11, 2, -15 },
  { 2195, 10, 15, 11, 1, -15 },
  { 2214, 9, 18, 10, 0, -18 },
  { 2235, 11, 15, 15, 2, -15 },
  { 2256, 14, 15, 14, 0, -15 },
  { 2283, 20, 15, 20, 0, -15 },
  { 2321, 13, 15, 13, 0, -15 },
  { 2346, 14, 21, 14, 0, -15 },
  { 2383, 10, 15, 11, 1, -15 },
  { 2402, 9, 23, 10, 0, -19 },
  { 2428, 3, 27, 12, 5, -21 },
  { 2439, 9, 23, 10, 1, -19 },
  { 2465, 12, 5, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_ExtraBold27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD27PT7B_H_
