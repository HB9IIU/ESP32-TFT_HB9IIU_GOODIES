#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_Condensed_ExtraBold
// Headers: 67

#include "NotoSans_Condensed_ExtraBold6pt7b.h"
#include "NotoSans_Condensed_ExtraBold7pt7b.h"
#include "NotoSans_Condensed_ExtraBold8pt7b.h"
#include "NotoSans_Condensed_ExtraBold9pt7b.h"
#include "NotoSans_Condensed_ExtraBold10pt7b.h"
#include "NotoSans_Condensed_ExtraBold11pt7b.h"
#include "NotoSans_Condensed_ExtraBold12pt7b.h"
#include "NotoSans_Condensed_ExtraBold13pt7b.h"
#include "NotoSans_Condensed_ExtraBold14pt7b.h"
#include "NotoSans_Condensed_ExtraBold15pt7b.h"
#include "NotoSans_Condensed_ExtraBold16pt7b.h"
#include "NotoSans_Condensed_ExtraBold17pt7b.h"
#include "NotoSans_Condensed_ExtraBold18pt7b.h"
#include "NotoSans_Condensed_ExtraBold19pt7b.h"
#include "NotoSans_Condensed_ExtraBold20pt7b.h"
#include "NotoSans_Condensed_ExtraBold21pt7b.h"
#include "NotoSans_Condensed_ExtraBold22pt7b.h"
#include "NotoSans_Condensed_ExtraBold23pt7b.h"
#include "NotoSans_Condensed_ExtraBold24pt7b.h"
#include "NotoSans_Condensed_ExtraBold25pt7b.h"
#include "NotoSans_Condensed_ExtraBold26pt7b.h"
#include "NotoSans_Condensed_ExtraBold27pt7b.h"
#include "NotoSans_Condensed_ExtraBold28pt7b.h"
#include "NotoSans_Condensed_ExtraBold29pt7b.h"
#include "NotoSans_Condensed_ExtraBold30pt7b.h"
#include "NotoSans_Condensed_ExtraBold31pt7b.h"
#include "NotoSans_Condensed_ExtraBold32pt7b.h"
#include "NotoSans_Condensed_ExtraBold33pt7b.h"
#include "NotoSans_Condensed_ExtraBold34pt7b.h"
#include "NotoSans_Condensed_ExtraBold35pt7b.h"
#include "NotoSans_Condensed_ExtraBold36pt7b.h"
#include "NotoSans_Condensed_ExtraBold37pt7b.h"
#include "NotoSans_Condensed_ExtraBold38pt7b.h"
#include "NotoSans_Condensed_ExtraBold39pt7b.h"
#include "NotoSans_Condensed_ExtraBold40pt7b.h"
#include "NotoSans_Condensed_ExtraBold41pt7b.h"
#include "NotoSans_Condensed_ExtraBold42pt7b.h"
#include "NotoSans_Condensed_ExtraBold43pt7b.h"
#include "NotoSans_Condensed_ExtraBold44pt7b.h"
#include "NotoSans_Condensed_ExtraBold45pt7b.h"
#include "NotoSans_Condensed_ExtraBold46pt7b.h"
#include "NotoSans_Condensed_ExtraBold47pt7b.h"
#include "NotoSans_Condensed_ExtraBold48pt7b.h"
#include "NotoSans_Condensed_ExtraBold49pt7b.h"
#include "NotoSans_Condensed_ExtraBold50pt7b.h"
#include "NotoSans_Condensed_ExtraBold51pt7b.h"
#include "NotoSans_Condensed_ExtraBold52pt7b.h"
#include "NotoSans_Condensed_ExtraBold53pt7b.h"
#include "NotoSans_Condensed_ExtraBold54pt7b.h"
#include "NotoSans_Condensed_ExtraBold55pt7b.h"
#include "NotoSans_Condensed_ExtraBold56pt7b.h"
#include "NotoSans_Condensed_ExtraBold57pt7b.h"
#include "NotoSans_Condensed_ExtraBold58pt7b.h"
#include "NotoSans_Condensed_ExtraBold59pt7b.h"
#include "NotoSans_Condensed_ExtraBold60pt7b.h"
#include "NotoSans_Condensed_ExtraBold61pt7b.h"
#include "NotoSans_Condensed_ExtraBold62pt7b.h"
#include "NotoSans_Condensed_ExtraBold63pt7b.h"
#include "NotoSans_Condensed_ExtraBold64pt7b.h"
#include "NotoSans_Condensed_ExtraBold65pt7b.h"
#include "NotoSans_Condensed_ExtraBold66pt7b.h"
#include "NotoSans_Condensed_ExtraBold67pt7b.h"
#include "NotoSans_Condensed_ExtraBold68pt7b.h"
#include "NotoSans_Condensed_ExtraBold69pt7b.h"
#include "NotoSans_Condensed_ExtraBold70pt7b.h"
#include "NotoSans_Condensed_ExtraBold71pt7b.h"
#include "NotoSans_Condensed_ExtraBold72pt7b.h"
