#ifndef _NOTOSANS_LIGHTITALIC71PT7B_H_
#define _NOTOSANS_LIGHTITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x1E, 0x03, 0xC7,
  0x80, 0xF3, 0xE0, 0x7C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0x78, 0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x38,
  0x70, 0x0E, 0x1C, 0x03, 0x8F, 0x01, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x38,
  0x07, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0,
  0xE0, 0xF8, 0x03, 0xF0, 0x38, 0x06, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C,
  0x07, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xF8, 0x0E, 0x00,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x00, 0xFC, 0x70,
  0x00, 0x00, 0x1F, 0xDC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0x9F, 0x80, 0x00, 0x01, 0xC3, 0xF0, 0x00,
  0x00, 0x70, 0x3E, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x1C, 0x07, 0xC0, 0x80, 0x07,
  0x03, 0xE0, 0x38, 0x03, 0xC3, 0xF0, 0x0F, 0xE0, 0xE3, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x3F, 0xFE,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0xF0,
  0x00, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x78, 0x1F, 0x83, 0x80,
  0x07, 0x83, 0xC1, 0xFF, 0x8E, 0x00, 0x1C, 0x1E, 0x0F, 0xFF, 0x3C, 0x00,
  0xF0, 0x70, 0x7C, 0x3E, 0xF0, 0x07, 0x83, 0xC3, 0xC0, 0x7B, 0xC0, 0x1E,
  0x1E, 0x1E, 0x00, 0xF7, 0x80, 0xF0, 0xF0, 0x70, 0x03, 0xDF, 0x0F, 0x83,
  0xC3, 0xC0, 0x0F, 0x3F, 0xFC, 0x1E, 0x0E, 0x00, 0x3C, 0xFF, 0xE0, 0xF0,
  0x78, 0x00, 0xF0, 0xFF, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0xF0, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x0F, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x00, 0x79, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x1E, 0x00, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x3E,
  0x00, 0x07, 0x87, 0xC0, 0x03, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x00,
  0x7C, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC1,
  0xE0, 0x00, 0x07, 0x80, 0x78, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x0F, 0x00,
  0x00, 0x0F, 0x87, 0x81, 0xE0, 0x00, 0x00, 0xF1, 0xF0, 0x3C, 0x00, 0x00,
  0x0F, 0x7C, 0x07, 0x80, 0x00, 0x01, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0x80, 0x00, 0x07, 0xFE, 0x00, 0xF8,
  0x00, 0x03, 0xF3, 0xC0, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x01, 0xFC, 0x00,
  0xFE, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x3C, 0xF9, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1, 0xE3, 0x87,
  0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x80, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0xF8, 0x03, 0x80, 0x03, 0xFC, 0x07, 0x00, 0x01, 0xFE,
  0x0C, 0x00, 0x00, 0xFE, 0x38, 0x00, 0x00, 0x3F, 0x70, 0x01, 0xC0, 0x1F,
  0xEF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x1F, 0x80, 0x78, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x60, 0x01, 0xE0, 0x00, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x78, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFC, 0xF0,
  0x7F, 0x1E, 0x1F, 0xC7, 0xCF, 0xE0, 0xF3, 0xF8, 0x1E, 0x3C, 0x03, 0xC6,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x18, 0x00, 0x00, 0xF8,
  0x02, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x83, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x81, 0x00, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x01,
  0xF7, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x1C, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1F, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0x38, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x06, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x80, 0x00, 0x3E, 0x07, 0xFF, 0x00, 0x0F, 0x07, 0xFF, 0xF0, 0x03, 0xC7,
  0xFF, 0xFE, 0x01, 0xF3, 0xE0, 0x1F, 0xC0, 0x79, 0xE0, 0x01, 0xF0, 0x1E,
  0xE0, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x1E,
  0x1F, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x03, 0xF0, 0xF0,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x81,
  0xF0, 0x00, 0x1D, 0xE0, 0x7E, 0x00, 0x0F, 0x78, 0x0F, 0xC0, 0x0F, 0xBC,
  0x01, 0xFF, 0xFF, 0xCF, 0x00, 0x3F, 0xFF, 0xC3, 0xC0, 0x03, 0xFF, 0xC1,
  0xE0, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x1F, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07,
  0xE0, 0x3F, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xC1, 0xC0, 0x03,
  0xF0, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xFF, 0x80, 0x07, 0x83, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x0E, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3C, 0x78,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF1, 0xE0, 0x01, 0xF0, 0x00, 0xE0, 0x03,
  0xCF, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x3C, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x3C, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xF7, 0x80, 0x0F, 0x00,
  0x01, 0xC0, 0x03, 0xDE, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x70, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x3D, 0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xFF,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xBC, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x1E, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x00, 0x7B, 0xC0, 0x1E, 0x00, 0x01,
  0xC0, 0x01, 0xEF, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x3C, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x00, 0xF3, 0xC0,
  0x1E, 0x00, 0x07, 0xC0, 0x07, 0x8F, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1E,
  0x3C, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xF0, 0xF0, 0x03, 0xC0, 0x07, 0xF0,
  0x07, 0x83, 0xC0, 0x0F, 0x00, 0x79, 0xC0, 0x3E, 0x0F, 0x00, 0x3E, 0x03,
  0xC7, 0x83, 0xF0, 0x1C, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x78, 0x00,
  0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x03, 0xF8,
  0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xF8,
  0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x03,
  0xC0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0x03,
  0xF8, 0x00, 0x01, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x08, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x18, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFE, 0x3C, 0x00, 0x00,
  0xFF, 0xFF, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0x8F, 0x00, 0x00, 0x7F, 0xFF,
  0xC7, 0x80, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x00, 0x7C, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x20, 0x0F, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00,
  0x01, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xDF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xBE, 0x00, 0x00, 0x00, 0x7F, 0xC7, 0x80, 0x00, 0x00,
  0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0x78,
  0x00, 0x00, 0x00, 0x7B, 0x80, 0x0E, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x01, 0xE7, 0x00, 0x00,
  0x00, 0x79, 0xE0, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x0F, 0x1E,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0x78, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xC0, 0x00,
  0x03, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x0F, 0x07,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0x70, 0x00,
  0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x01,
  0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x07, 0x80, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00,
  0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xC0, 0xF0, 0x00,
  0xF0, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x77, 0x80, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF0, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xC0,
  0x07, 0x9E, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x80, 0x0F,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x07, 0x80,
  0x00, 0x07, 0x8F, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x0F, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x03, 0xFC, 0x00,
  0x1E, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x03, 0xF8,
  0x01, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x03, 0xFC, 0x00, 0x1E,
  0x00, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x03, 0xF0, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x08, 0x00, 0x00, 0x3F, 0x00, 0xE0, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x78, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0x0F, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0xF0,
  0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x7C, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x78, 0x00, 0x70, 0x0F, 0x00, 0x01,
  0xC0, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x01, 0xF0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78,
  0x0F, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00,
  0xE0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x00, 0x07, 0xFE, 0x03, 0xC0, 0x07, 0xFF,
  0xC0, 0xE0, 0x07, 0xFF, 0xFC, 0x38, 0x03, 0xF8, 0x1F, 0x0E, 0x01, 0xF8,
  0x01, 0xE7, 0x80, 0xFC, 0x00, 0x39, 0xE0, 0x7E, 0x00, 0x07, 0x70, 0x1F,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x01, 0xF8,
  0x0F, 0x00, 0x00, 0xEE, 0x03, 0xE0, 0x00, 0x77, 0x80, 0x78, 0x00, 0x39,
  0xE0, 0x1F, 0x00, 0x3C, 0x78, 0x03, 0xF0, 0x3E, 0x1C, 0x00, 0xFF, 0xFF,
  0x07, 0x00, 0x1F, 0xFF, 0x81, 0xC0, 0x01, 0xFF, 0x80, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x1F, 0xF8, 0x00, 0x1E, 0x0F, 0xFF, 0xC0, 0x03, 0xC3,
  0xFF, 0xFC, 0x00, 0xF0, 0xF8, 0x1F, 0x80, 0x1E, 0x3C, 0x00, 0xF8, 0x03,
  0xCE, 0x00, 0x0F, 0x80, 0x7B, 0x80, 0x00, 0xF0, 0x0E, 0xE0, 0x00, 0x1E,
  0x03, 0xF8, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x00, 0x3C, 0x0F, 0xC0, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1F,
  0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xDC, 0x00, 0x07, 0xC0, 0x7B, 0x80, 0x01,
  0xF8, 0x0F, 0x38, 0x00, 0x7E, 0x01, 0xC7, 0xC0, 0x3F, 0x80, 0x38, 0x7F,
  0xFF, 0xE0, 0x0F, 0x07, 0xFF, 0xF0, 0x01, 0xC0, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFE, 0x01, 0xE0, 0x1F, 0x80, 0x01, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x10, 0x07, 0xF0, 0x07, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x03, 0xC0, 0x00,
  0x7F, 0xFE, 0x0F, 0x00, 0x07, 0xFF, 0xFC, 0x3C, 0x00, 0x3F, 0x80, 0xF8,
  0xF0, 0x01, 0xF8, 0x00, 0xF3, 0xC0, 0x0F, 0xC0, 0x01, 0xDE, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x1F, 0x80, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x03,
  0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0x00, 0x00, 0xEF, 0x00, 0x3E, 0x00, 0x07,
  0xBC, 0x00, 0x78, 0x00, 0x3C, 0xF0, 0x01, 0xF0, 0x01, 0xE3, 0x80, 0x03,
  0xF0, 0x1F, 0x0E, 0x00, 0x0F, 0xFF, 0xF8, 0x78, 0x00, 0x1F, 0xFF, 0x81,
  0xE0, 0x00, 0x1F, 0xFC, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFE, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0x78, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1F, 0x1E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x03, 0xF8, 0x78, 0x01,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x18, 0x07, 0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x70, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xBF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x70, 0x00, 0x7F, 0xFE, 0x07, 0x00, 0x1F, 0xFF, 0xF0, 0x70, 0x03,
  0xF8, 0x0F, 0x8F, 0x00, 0x7E, 0x00, 0x3C, 0xF0, 0x0F, 0xC0, 0x01, 0xCE,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0xFE, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x7E, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x1F, 0xC0,
  0x3C, 0x00, 0x03, 0xBC, 0x03, 0xE0, 0x00, 0x7B, 0xC0, 0x1E, 0x00, 0x0F,
  0x3C, 0x01, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0xC0, 0x7C, 0x78, 0x00, 0xFF,
  0xFF, 0x87, 0x80, 0x07, 0xFF, 0xE0, 0x78, 0x00, 0x1F, 0xF8, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x08, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x1F, 0xF8, 0x00, 0x3C, 0x1F, 0xFF, 0x80, 0x0F, 0x0F,
  0xFF, 0xF0, 0x07, 0x87, 0xC0, 0x7E, 0x01, 0xE3, 0xC0, 0x0F, 0x80, 0x79,
  0xE0, 0x01, 0xF0, 0x1E, 0xE0, 0x00, 0x3C, 0x07, 0x70, 0x00, 0x0F, 0x03,
  0xF8, 0x00, 0x03, 0xC0, 0xFE, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x1E, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x03, 0xE0, 0x07,
  0x80, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x03, 0xC0, 0x0F, 0x80,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x03, 0xC7,
  0xE0, 0x00, 0x00, 0xF3, 0xFC, 0x00, 0x00, 0x3D, 0xEF, 0x00, 0x00, 0x0E,
  0xF3, 0xE0, 0x00, 0x03, 0xF8, 0x78, 0x00, 0x01, 0xFC, 0x1F, 0x00, 0x00,
  0x7E, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01,
  0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0x87, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x0F, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xE0, 0x1E, 0x78, 0x01, 0xE1,
  0xF0, 0x07, 0xC0, 0x3C, 0xE0, 0x03, 0xE3, 0x80, 0x07, 0x80, 0x73, 0x80,
  0x03, 0xCE, 0x00, 0x0F, 0x80, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3C, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0xFF, 0x00, 0x0E,
  0x07, 0xFF, 0xE0, 0x03, 0x83, 0xFF, 0xFC, 0x01, 0xE1, 0xF8, 0x3F, 0x80,
  0x78, 0xF0, 0x03, 0xE0, 0x1E, 0x78, 0x00, 0x7C, 0x07, 0xB8, 0x00, 0x0F,
  0x03, 0xDC, 0x00, 0x03, 0xC0, 0xFE, 0x00, 0x00, 0xF0, 0x3F, 0x80, 0x00,
  0x3C, 0x0F, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x03, 0xC1, 0xF8, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x03, 0xFF, 0x00, 0x00, 0x70, 0x3F, 0xFF, 0x00, 0x01, 0xC1,
  0xFF, 0xFE, 0x00, 0x0F, 0x0F, 0x81, 0xF8, 0x00, 0x3C, 0x78, 0x01, 0xF0,
  0x00, 0xF3, 0x80, 0x03, 0xE0, 0x03, 0x9C, 0x00, 0x07, 0x80, 0x0E, 0xE0,
  0x00, 0x1E, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0x00, 0xF0,
  0x07, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x01, 0xDC, 0x00, 0x07, 0xC0, 0x0F, 0x70, 0x00, 0x3F,
  0x00, 0x3C, 0xE0, 0x01, 0xF8, 0x00, 0xF3, 0xE0, 0x1F, 0xC0, 0x03, 0xC7,
  0xFF, 0xFE, 0x00, 0x1E, 0x0F, 0xFF, 0xE0, 0x00, 0x78, 0x0F, 0xFE, 0x00,
  0x01, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x01, 0xC0, 0x07, 0xFF, 0xE0, 0x70, 0x07, 0xFF, 0xFC, 0x1C, 0x03,
  0xF8, 0x0F, 0x8F, 0x01, 0xF8, 0x00, 0xF3, 0xC0, 0xFC, 0x00, 0x1C, 0xE0,
  0x7E, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x03,
  0xF0, 0x3C, 0x00, 0x01, 0xFC, 0x0F, 0x00, 0x00, 0xEF, 0x03, 0xE0, 0x00,
  0x7B, 0xC0, 0x78, 0x00, 0x3C, 0xF0, 0x1F, 0x00, 0x1E, 0x78, 0x03, 0xF0,
  0x1F, 0x1E, 0x00, 0xFF, 0xFF, 0x87, 0x80, 0x1F, 0xFF, 0x81, 0xE0, 0x01,
  0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1F, 0xE0, 0x1C, 0x0F, 0xFC, 0x03,
  0x83, 0xFF, 0x80, 0xF1, 0xFC, 0x20, 0x1E, 0x3C, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0x80, 0x7E, 0x03, 0xE0, 0x00, 0x60, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x80, 0x00, 0x3E, 0x0C, 0x00, 0x07, 0xE0,
  0xF8, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x08, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0xF0,
  0x00, 0x03, 0xF0, 0x3C, 0x00, 0x01, 0xFC, 0x0F, 0x00, 0x00, 0xEE, 0x03,
  0xC0, 0x00, 0x73, 0x80, 0xF8, 0x00, 0x39, 0xE0, 0x1F, 0x00, 0x3E, 0x78,
  0x07, 0xE0, 0x3E, 0x1E, 0x00, 0xFF, 0xFF, 0x07, 0x00, 0x1F, 0xFF, 0x81,
  0xC0, 0x03, 0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x7C, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xB8, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x70, 0x00, 0x3C, 0x78,
  0x00, 0x1C, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x79, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0xE3, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0x00, 0x0F, 0x03, 0x80,
  0x07, 0x8E, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0x3C, 0x01,
  0xE0, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x81, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x0E, 0x03, 0xC0, 0x0F, 0x03, 0xC0,
  0x1C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x70, 0x78, 0x00, 0x78, 0x78, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x01,
  0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xC7, 0x80, 0x07,
  0x9E, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x0E, 0x70, 0x00, 0x3D, 0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x7C, 0x00, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x8F, 0xFF, 0x80, 0x00, 0x5F, 0xFF, 0xF0, 0x00, 0x7F,
  0xEF, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFA,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0,
};

const GFXglyph NotoSans_LightItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 16, 52, 17, 2, -51 },
  { 105, 18, 19, 25, 8, -51 },
  { 148, 43, 51, 45, 2, -51 },
  { 423, 34, 58, 39, 3, -54 },
  { 670, 46, 52, 55, 6, -51 },
  { 969, 43, 52, 48, 3, -51 },
  { 1249, 7, 19, 14, 8, -51 },
  { 1266, 21, 62, 19, 3, -51 },
  { 1429, 22, 62, 19, -5, -51 },
  { 1600, 31, 31, 38, 8, -54 },
  { 1721, 33, 34, 41, 5, -42 },
  { 1862, 12, 17, 16, -3, -8 },
  { 1888, 18, 4, 22, 2, -21 },
  { 1897, 6, 7, 17, 2, -6 },
  { 1903, 33, 51, 24, -3, -51 },
  { 2114, 34, 52, 39, 4, -51 },
  { 2335, 19, 51, 39, 11, -51 },
  { 2457, 37, 51, 39, 0, -51 },
  { 2693, 35, 52, 39, 2, -51 },
  { 2921, 37, 51, 39, 1, -51 },
  { 3157, 35, 52, 39, 3, -51 },
  { 3385, 34, 52, 39, 5, -51 },
  { 3606, 33, 51, 39, 7, -51 },
  { 3817, 35, 52, 39, 3, -51 },
  { 4045, 34, 52, 39, 3, -51 },
  { 4266, 13, 39, 17, 2, -38 },
  { 4330, 18, 47, 17, -3, -38 },
  { 4436, 33, 33, 41, 5, -42 },
  { 4573, 33, 18, 41, 5, -34 },
  { 4648, 33, 33, 41, 5, -42 },
  { 4785, 25, 52, 30, 6, -51 },
  { 4948, 54, 56, 60, 4, -50 },
  { 5326, 40, 51, 39, -4, -51 },
  { 5581, 39, 51, 43, 3, -51 },
  { 5830, 39, 52, 42, 6, -51 },
  { 6084, 42, 51, 48, 3, -51 },
  { 6352, 37, 51, 37, 3, -51 },
  { 6588, 37, 51, 34, 3, -51 },
  { 6824, 41, 52, 49, 6, -51 },
  { 7091, 45, 51, 48, 3, -51 },
  { 7378, 25, 51, 21, 0, -51 },
  { 7538, 30, 64, 18, -12, -51 },
  { 7778, 42, 51, 39, 3, -51 },
  { 8046, 27, 51, 34, 3, -51 },
  { 8219, 55, 51, 59, 3, -51 },
  { 8570, 46, 51, 49, 3, -51 },
  { 8864, 43, 52, 51, 6, -51 },
  { 9144, 37, 51, 40, 3, -51 },
  { 9380, 43, 63, 51, 6, -51 },
  { 9719, 37, 51, 40, 3, -51 },
  { 9955, 36, 52, 36, 1, -51 },
  { 10189, 34, 51, 35, 7, -51 },
  { 10406, 43, 52, 49, 6, -51 },
  { 10686, 38, 51, 39, 7, -51 },
  { 10929, 57, 51, 60, 8, -51 },
  { 11293, 46, 51, 36, -4, -51 },
  { 11587, 35, 51, 35, 7, -51 },
  { 11811, 42, 51, 38, -1, -51 },
  { 12079, 27, 62, 21, -1, -51 },
  { 12289, 12, 51, 24, 7, -51 },
  { 12366, 27, 62, 21, -5, -51 },
  { 12576, 34, 32, 40, 3, -51 },
  { 12712, 28, 3, 27, -6, 7 },
  { 12723, 10, 11, 18, 10, -54 },
  { 12737, 34, 39, 40, 4, -38 },
  { 12903, 35, 55, 41, 2, -54 },
  { 13144, 29, 39, 32, 4, -38 },
  { 13286, 38, 55, 41, 4, -54 },
  { 13548, 29, 39, 35, 4, -38 },
  { 13690, 39, 71, 21, -9, -54 },
  { 14037, 36, 55, 41, 2, -38 },
  { 14285, 34, 54, 40, 2, -54 },
  { 14515, 15, 52, 17, 2, -52 },
  { 14613, 27, 69, 17, -10, -52 },
  { 14846, 34, 54, 33, 2, -54 },
  { 15076, 16, 54, 17, 2, -54 },
  { 15184, 55, 38, 61, 2, -38 },
  { 15446, 34, 39, 40, 2, -39 },
  { 15612, 32, 39, 40, 4, -38 },
  { 15768, 38, 55, 41, -1, -38 },
  { 16030, 34, 55, 41, 4, -38 },
  { 16264, 27, 38, 27, 2, -38 },
  { 16393, 28, 39, 30, 1, -38 },
  { 16530, 21, 48, 23, 4, -47 },
  { 16656, 34, 39, 40, 4, -38 },
  { 16822, 32, 38, 31, 3, -38 },
  { 16974, 47, 38, 49, 4, -38 },
  { 17198, 37, 38, 33, -2, -38 },
  { 17374, 42, 55, 31, -7, -38 },
  { 17663, 32, 38, 31, -1, -38 },
  { 17815, 27, 62, 24, 1, -51 },
  { 18025, 4, 71, 39, 19, -54 },
  { 18061, 26, 62, 24, -3, -51 },
  { 18263, 33, 8, 41, 5, -29 },
};

const GFXfont NotoSans_LightItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_LIGHTITALIC71PT7B_H_
