#ifndef _NOTOSANS_LIGHTITALIC70PT7B_H_
#define _NOTOSANS_LIGHTITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xC0,
  0x00, 0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07,
  0x8F, 0x01, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0x87,
  0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1E, 0x3C, 0x07, 0x0E, 0x01, 0xC3, 0x80,
  0x70, 0xE0, 0x1C, 0x38, 0x06, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xE7, 0x3F, 0xC0, 0x1F, 0x87, 0x81, 0xC0, 0x1F, 0x03, 0x80,
  0x20, 0x1F, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x03, 0xF0,
  0xE0, 0x00, 0x00, 0xFE, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0x3F, 0x80, 0x00, 0x03, 0x87, 0xE0, 0x00,
  0x01, 0xC1, 0xF0, 0x00, 0x00, 0xE0, 0x7C, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x7C, 0x10, 0x01, 0xE0, 0x7C,
  0x0E, 0x00, 0xE0, 0xFC, 0x07, 0xF0, 0x71, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF0,
  0x07, 0xEF, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x70, 0x07,
  0x80, 0x78, 0x00, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x00, 0x78, 0x03, 0xC0,
  0x0E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x01, 0xE0, 0x03,
  0x80, 0x03, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00,
  0x3C, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x0E,
  0x00, 0x1E, 0x07, 0x80, 0x60, 0x70, 0x00, 0xE0, 0x78, 0x3F, 0xE3, 0x80,
  0x0F, 0x07, 0x83, 0xFF, 0x9C, 0x00, 0x78, 0x38, 0x7F, 0xFE, 0xF0, 0x07,
  0x83, 0xC3, 0xC0, 0xF7, 0x80, 0x3C, 0x3C, 0x3C, 0x03, 0xFC, 0x03, 0xC3,
  0xC3, 0xC0, 0x1E, 0xF0, 0x3C, 0x1C, 0x1E, 0x00, 0x77, 0xFF, 0xC1, 0xE1,
  0xE0, 0x03, 0x9F, 0xFC, 0x1E, 0x0E, 0x00, 0x1C, 0x7F, 0xC1, 0xE0, 0xF0,
  0x00, 0xE0, 0xF0, 0x0E, 0x07, 0x80, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x38, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x81,
  0xE0, 0x0F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x0F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x8F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x03, 0xC3, 0xF0, 0x07, 0x80,
  0x01, 0xE1, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0x80, 0x0F, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x87, 0x80,
  0x00, 0x3E, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x3C, 0x00, 0x00, 0x3E, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0xDE,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x3C,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x7C,
  0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x1E, 0x00, 0xFE, 0x00, 0xFF, 0x03, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x7C, 0xF1,
  0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x1E, 0x38, 0x70, 0xE1,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xF0, 0x0E, 0x00,
  0x0F, 0xF0, 0x38, 0x00, 0x07, 0xF0, 0xE0, 0x00, 0x07, 0xF3, 0x80, 0x00,
  0x03, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0x87, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x7C, 0x0F,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x02, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x79, 0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1F, 0x3C, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F,
  0xFC, 0x03, 0xF7, 0x81, 0xFD, 0xE0, 0x7E, 0x3C, 0x3F, 0x87, 0x8F, 0xC0,
  0xF3, 0xF0, 0x3E, 0x38, 0x07, 0x84, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x03, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x81, 0x00, 0x00, 0x07, 0xE0, 0x38,
  0x00, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0x07, 0xC7, 0x80, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x1E,
  0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3D, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x01, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x08,
  0x00, 0x00, 0x7E, 0x01, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0x08, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xC0, 0x01, 0xE0, 0xFF,
  0xF8, 0x00, 0xF1, 0xFF, 0xFF, 0x00, 0xF1, 0xFC, 0x3F, 0xC0, 0x79, 0xE0,
  0x03, 0xF0, 0x3D, 0xE0, 0x00, 0xF8, 0x1F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00,
  0x3C, 0x1F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F,
  0x81, 0xE0, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x0E, 0xF0, 0x0F, 0x80, 0x0F,
  0xBC, 0x03, 0xFC, 0x1F, 0x8F, 0x00, 0x3F, 0xFF, 0xC7, 0x80, 0x07, 0xFF,
  0xE1, 0xE0, 0x00, 0x7F, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x1F,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0x70, 0x00, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xF0, 0x0F, 0xE0, 0xC0, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x0E, 0x0F, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x78, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xC7, 0x80,
  0x07, 0xE0, 0x07, 0x80, 0x1E, 0x78, 0x00, 0x7C, 0x00, 0x38, 0x00, 0xF3,
  0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x03, 0x9C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1D, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x0F, 0x70, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x7B, 0x80, 0x1E, 0x00,
  0x03, 0xC0, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0xEF, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x78,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x7B, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x03,
  0xDC, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1C, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x01, 0xE7, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0E, 0x38, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0xF1, 0xE0, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0x0F, 0x00, 0x78,
  0x00, 0xEE, 0x00, 0xF8, 0x78, 0x01, 0xE0, 0x0F, 0x70, 0x0F, 0x83, 0xC0,
  0x0F, 0x80, 0xF3, 0xC0, 0xF8, 0x1E, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0x80,
  0x70, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xC0, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x1E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00,
  0x07, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x00, 0xFE, 0x01,
  0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x01, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0x00, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x1E, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x00, 0x04, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xFF, 0x8F, 0x00, 0x00, 0x7F, 0xFF, 0x87, 0x80, 0x00, 0x3F, 0xFF, 0xC3,
  0xC0, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x7E, 0x00,
  0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x20, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x03,
  0xF0, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xDE, 0xF0, 0x00, 0x00, 0x01, 0xEF,
  0x3E, 0x00, 0x00, 0x00, 0x7F, 0x87, 0x80, 0x00, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xB8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0x70, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0xE7, 0x80, 0x00, 0x00,
  0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x07, 0x8E, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x0F, 0x1C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x00, 0x01,
  0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x07, 0x83, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x01, 0xE0, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x07, 0x80, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x38,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x0F, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x0E,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x3C, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF0,
  0x01, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x78, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0xF0, 0x03, 0x9F, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x78, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xC3, 0xE0, 0x00,
  0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x81, 0xE0,
  0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0x00, 0x07, 0x83, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x78,
  0x00, 0x00, 0xF1, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x78, 0x01, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x0F, 0x00, 0x00,
  0x03, 0xDC, 0x00, 0x70, 0x00, 0x00, 0x1E, 0xE0, 0x07, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x01, 0xF8, 0x03,
  0xC0, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x07, 0xF0, 0x03,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x1F,
  0x80, 0x00, 0x10, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x01, 0x00, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x7E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x00, 0x3D, 0xF0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x0E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x0E,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0x80,
  0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0x78,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x38, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x3C,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x3C, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x70,
  0x01, 0xFF, 0xFC, 0x1C, 0x00, 0xFF, 0xFF, 0x8F, 0x00, 0xFE, 0x01, 0xE3,
  0x80, 0x7E, 0x00, 0x1C, 0xE0, 0x1F, 0x00, 0x07, 0x78, 0x0F, 0x80, 0x00,
  0xFE, 0x07, 0xC0, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1F, 0x81, 0xE0, 0x00,
  0x07, 0xE0, 0x78, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x01, 0xFC, 0x07, 0x80,
  0x00, 0x7F, 0x01, 0xF0, 0x00, 0x3B, 0xC0, 0x3C, 0x00, 0x3C, 0xE0, 0x0F,
  0x80, 0x1E, 0x38, 0x01, 0xF0, 0x1F, 0x0E, 0x00, 0x7F, 0xFF, 0x87, 0x80,
  0x0F, 0xFF, 0xC1, 0xE0, 0x00, 0xFF, 0xC0, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3F, 0x00, 0x00,
  0xF0, 0x3F, 0xF8, 0x00, 0x1E, 0x1F, 0xFF, 0xC0, 0x07, 0x87, 0xFF, 0xFC,
  0x00, 0xF1, 0xF0, 0x0F, 0x80, 0x1E, 0x78, 0x00, 0xF8, 0x03, 0xDC, 0x00,
  0x0F, 0x00, 0x77, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x00, 0x1E, 0x03, 0xF8,
  0x00, 0x03, 0xC0, 0x7E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x1E, 0xC0,
  0x00, 0x3E, 0x03, 0xDC, 0x00, 0x0F, 0x80, 0x79, 0xC0, 0x03, 0xE0, 0x0E,
  0x3E, 0x01, 0xF8, 0x01, 0xC3, 0xFF, 0xFE, 0x00, 0x78, 0x3F, 0xFF, 0x80,
  0x0E, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x01, 0xFC, 0x00, 0x60, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x20, 0x1F, 0x80, 0x1E,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0x80, 0x78, 0x00, 0x07, 0xFF, 0x81, 0xE0,
  0x00, 0x7F, 0xFF, 0x07, 0x00, 0x07, 0xFF, 0xFE, 0x3C, 0x00, 0x3F, 0x80,
  0x3C, 0xF0, 0x01, 0xF8, 0x00, 0x73, 0xC0, 0x07, 0xC0, 0x00, 0xEF, 0x00,
  0x3E, 0x00, 0x01, 0xB8, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0x80,
  0x00, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x03, 0xF8,
  0x01, 0xE0, 0x00, 0x1D, 0xE0, 0x07, 0xC0, 0x00, 0xE7, 0x00, 0x0F, 0x00,
  0x07, 0x1C, 0x00, 0x3E, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0x03, 0xE3, 0xC0,
  0x01, 0xFF, 0xFE, 0x0E, 0x00, 0x03, 0xFF, 0xF0, 0x38, 0x00, 0x03, 0xFF,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x0F, 0x3E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xC7, 0x80, 0x01, 0xFC, 0x78, 0x00, 0xFF, 0x07, 0x8F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x1F, 0xC0, 0x1F, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x40, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x07, 0x00, 0x0F, 0xFF,
  0xE0, 0xF0, 0x03, 0xFF, 0xFF, 0x0E, 0x00, 0x7F, 0x00, 0x78, 0xE0, 0x0F,
  0xC0, 0x03, 0xDE, 0x00, 0xF8, 0x00, 0x1D, 0xE0, 0x1F, 0x00, 0x00, 0xDC,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0xFC, 0x03, 0xC0,
  0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x03, 0xBC, 0x03, 0xE0, 0x00, 0x73, 0x80,
  0x1E, 0x00, 0x0E, 0x78, 0x01, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0x80, 0x7C,
  0x78, 0x00, 0xFF, 0xFF, 0x07, 0x00, 0x07, 0xFF, 0xE0, 0xF0, 0x00, 0x1F,
  0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x1F, 0xC0, 0x00, 0xF0, 0x3F, 0xFC, 0x00, 0x3C, 0x3F, 0xFF,
  0x80, 0x1E, 0x1F, 0xFF, 0xF0, 0x07, 0x8F, 0x80, 0x7E, 0x01, 0xE7, 0x80,
  0x0F, 0x80, 0x7B, 0xC0, 0x01, 0xE0, 0x1D, 0xC0, 0x00, 0x78, 0x0F, 0xE0,
  0x00, 0x1F, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x00, 0x78, 0x1F, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x07, 0x80,
  0x1F, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0x0F,
  0x1F, 0x80, 0x00, 0x07, 0x9F, 0xC0, 0x00, 0x03, 0xDE, 0xF0, 0x00, 0x01,
  0xDE, 0x78, 0x00, 0x00, 0xFE, 0x3E, 0x00, 0x00, 0xFE, 0x0F, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x03, 0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0E, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x78, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xE3, 0xC0,
  0x3E, 0x1F, 0x00, 0xF8, 0x07, 0x9C, 0x00, 0x78, 0x70, 0x01, 0xF0, 0x1C,
  0xE0, 0x01, 0xE3, 0x80, 0x07, 0xC0, 0x77, 0x00, 0x03, 0x9C, 0x00, 0x0F,
  0x03, 0xD8, 0x00, 0x0E, 0xE0, 0x00, 0x3C, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x38, 0x0F, 0xFF, 0x00, 0x0E, 0x0F, 0xFF, 0xE0,
  0x07, 0x87, 0xFF, 0xFC, 0x01, 0xE3, 0xE0, 0x1F, 0x80, 0x79, 0xE0, 0x03,
  0xE0, 0x1C, 0xF0, 0x00, 0x78, 0x0F, 0x78, 0x00, 0x1F, 0x03, 0xFC, 0x00,
  0x07, 0xC0, 0xFE, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x7F,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70,
  0x1F, 0xFC, 0x00, 0x01, 0xC1, 0xFF, 0xFC, 0x00, 0x0F, 0x0F, 0xFF, 0xF8,
  0x00, 0x3C, 0x7C, 0x03, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0xC0, 0x03, 0x9E,
  0x00, 0x0F, 0x00, 0x0E, 0xE0, 0x00, 0x3E, 0x00, 0x7B, 0x80, 0x00, 0x78,
  0x01, 0xFC, 0x00, 0x01, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x01, 0xD8, 0x00, 0x07,
  0xC0, 0x0F, 0x70, 0x00, 0x3E, 0x00, 0x3C, 0xE0, 0x01, 0xF0, 0x00, 0xF3,
  0xE0, 0x1F, 0x80, 0x03, 0xC7, 0xFF, 0xFC, 0x00, 0x1E, 0x0F, 0xFF, 0xE0,
  0x00, 0x78, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x1C,
  0x00, 0x7F, 0xFF, 0x07, 0x80, 0x3F, 0xFF, 0xF0, 0xE0, 0x0F, 0xE0, 0x0F,
  0x1C, 0x03, 0xF0, 0x00, 0xE7, 0x80, 0x7C, 0x00, 0x0E, 0xF0, 0x1F, 0x00,
  0x00, 0xDC, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x1F, 0x80, 0xF0, 0x00,
  0x07, 0xF0, 0x1E, 0x00, 0x01, 0xDE, 0x03, 0xE0, 0x00, 0x73, 0x80, 0x3C,
  0x00, 0x1E, 0xF0, 0x07, 0xC0, 0x0F, 0x9E, 0x00, 0x7C, 0x03, 0xE3, 0xC0,
  0x0F, 0xFF, 0xF0, 0x78, 0x00, 0xFF, 0xFC, 0x1E, 0x00, 0x07, 0xFE, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1C, 0x0F, 0xFC, 0x03,
  0x83, 0xFF, 0x00, 0xF0, 0xFF, 0xE0, 0x1E, 0x3E, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xD8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x81, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x80, 0x00, 0x3E, 0x18, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x04,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0xFC, 0x1E, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x7E, 0x07, 0x80,
  0x00, 0x7F, 0x03, 0xC0, 0x00, 0x77, 0x81, 0xF0, 0x00, 0x73, 0xC0, 0xF8,
  0x00, 0xF1, 0xC0, 0x3F, 0x01, 0xF0, 0xE0, 0x0F, 0xFF, 0xF0, 0x70, 0x03,
  0xFF, 0xF0, 0x78, 0x00, 0xFF, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xCF, 0x00,
  0x03, 0xBC, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x73, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x0F, 0x00, 0x0E,
  0x3C, 0x00, 0x78, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0x70, 0x01, 0xC1,
  0xC0, 0x0F, 0x81, 0xC0, 0x0F, 0x07, 0x00, 0x3C, 0x07, 0x80, 0x38, 0x1C,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x70, 0x07, 0x80, 0x78, 0x07, 0x01, 0xC0,
  0x3E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xE0, 0x1E, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x78,
  0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x83, 0x80, 0x1E, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x01,
  0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x07, 0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x38, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xE7, 0x80, 0x01, 0xEF,
  0x00, 0x03, 0x9E, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0,
  0x00, 0x3B, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xEE, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x3E, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x4F, 0xFF, 0xE0, 0x00, 0x6F, 0xFF, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xFF, 0xFB, 0x00, 0x01, 0xFF, 0xF1, 0x00,
  0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_LightItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 15, 51, 17, 2, -50 },
  { 97, 18, 18, 25, 8, -50 },
  { 138, 43, 50, 44, 2, -50 },
  { 407, 33, 57, 39, 3, -53 },
  { 643, 45, 52, 55, 6, -51 },
  { 936, 42, 52, 47, 3, -51 },
  { 1209, 7, 18, 14, 8, -50 },
  { 1225, 21, 61, 19, 3, -50 },
  { 1386, 21, 61, 19, -5, -50 },
  { 1547, 30, 31, 38, 8, -53 },
  { 1664, 33, 33, 40, 5, -41 },
  { 1801, 12, 17, 15, -3, -8 },
  { 1827, 17, 4, 22, 2, -21 },
  { 1836, 6, 7, 16, 2, -6 },
  { 1842, 32, 50, 23, -3, -50 },
  { 2042, 33, 52, 39, 4, -51 },
  { 2257, 19, 50, 39, 11, -50 },
  { 2376, 36, 51, 39, 0, -51 },
  { 2606, 35, 52, 39, 2, -51 },
  { 2834, 36, 50, 39, 1, -50 },
  { 3059, 35, 51, 39, 3, -50 },
  { 3283, 33, 52, 39, 5, -51 },
  { 3498, 32, 50, 39, 7, -50 },
  { 3698, 35, 52, 39, 3, -51 },
  { 3926, 34, 52, 39, 3, -51 },
  { 4147, 12, 39, 16, 2, -38 },
  { 4206, 17, 47, 16, -3, -38 },
  { 4306, 33, 33, 40, 5, -42 },
  { 4443, 32, 17, 40, 5, -33 },
  { 4511, 33, 33, 40, 5, -42 },
  { 4648, 25, 52, 29, 6, -51 },
  { 4811, 53, 56, 59, 4, -50 },
  { 5182, 39, 50, 39, -4, -50 },
  { 5426, 38, 50, 42, 3, -50 },
  { 5664, 39, 52, 41, 5, -51 },
  { 5918, 42, 50, 47, 3, -50 },
  { 6181, 36, 50, 37, 3, -50 },
  { 6406, 36, 50, 34, 3, -50 },
  { 6631, 41, 52, 48, 5, -51 },
  { 6898, 45, 50, 48, 3, -50 },
  { 7180, 24, 50, 21, 0, -50 },
  { 7330, 29, 63, 18, -11, -50 },
  { 7559, 42, 50, 39, 3, -50 },
  { 7822, 26, 50, 34, 3, -50 },
  { 7985, 55, 50, 58, 3, -50 },
  { 8329, 45, 50, 48, 3, -50 },
  { 8611, 43, 52, 50, 5, -51 },
  { 8891, 36, 50, 39, 3, -50 },
  { 9116, 43, 63, 50, 5, -51 },
  { 9455, 36, 50, 40, 3, -50 },
  { 9680, 35, 52, 35, 1, -51 },
  { 9908, 35, 50, 35, 6, -50 },
  { 10127, 42, 51, 48, 6, -50 },
  { 10395, 37, 50, 38, 7, -50 },
  { 10627, 56, 50, 59, 8, -50 },
  { 10977, 45, 50, 36, -4, -50 },
  { 11259, 34, 50, 35, 7, -50 },
  { 11472, 41, 50, 37, -1, -50 },
  { 11729, 27, 61, 21, -1, -50 },
  { 11935, 12, 50, 23, 7, -50 },
  { 12010, 26, 61, 21, -5, -50 },
  { 12209, 33, 31, 39, 3, -50 },
  { 12337, 27, 3, 27, -6, 7 },
  { 12348, 10, 12, 18, 10, -54 },
  { 12363, 34, 39, 39, 3, -38 },
  { 12529, 35, 54, 40, 2, -53 },
  { 12766, 28, 39, 32, 4, -38 },
  { 12903, 38, 54, 40, 3, -53 },
  { 13160, 28, 39, 35, 4, -38 },
  { 13297, 39, 71, 20, -9, -54 },
  { 13644, 36, 55, 40, 2, -38 },
  { 13892, 34, 53, 40, 2, -53 },
  { 14118, 15, 51, 16, 2, -51 },
  { 14214, 26, 68, 16, -9, -51 },
  { 14435, 33, 53, 33, 2, -53 },
  { 14654, 15, 53, 16, 2, -53 },
  { 14754, 54, 38, 60, 2, -38 },
  { 15011, 34, 38, 40, 2, -38 },
  { 15173, 32, 39, 39, 4, -38 },
  { 15329, 38, 55, 40, -1, -38 },
  { 15591, 35, 55, 40, 3, -38 },
  { 15832, 27, 38, 27, 2, -38 },
  { 15961, 27, 39, 30, 1, -38 },
  { 16093, 20, 47, 22, 4, -46 },
  { 16211, 33, 38, 40, 4, -37 },
  { 16368, 31, 37, 31, 3, -37 },
  { 16512, 46, 37, 48, 4, -37 },
  { 16725, 36, 37, 33, -2, -37 },
  { 16892, 41, 54, 31, -7, -37 },
  { 17169, 32, 37, 31, -1, -37 },
  { 17317, 26, 61, 24, 1, -50 },
  { 17516, 3, 70, 38, 19, -53 },
  { 17543, 26, 61, 24, -3, -50 },
  { 17742, 33, 8, 40, 5, -29 },
};

const GFXfont NotoSans_LightItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_LIGHTITALIC70PT7B_H_
