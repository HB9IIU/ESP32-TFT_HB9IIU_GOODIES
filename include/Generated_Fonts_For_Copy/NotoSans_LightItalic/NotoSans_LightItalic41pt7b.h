#ifndef _NOTOSANS_LIGHTITALIC41PT7B_H_
#define _NOTOSANS_LIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x3C, 0x1E, 0x0E, 0x00, 0x71, 0xD8,
  0x76, 0x19, 0x86, 0xE1, 0xB0, 0x6C, 0x33, 0x0C, 0xC3, 0x20, 0xC0, 0x00,
  0x1C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x07, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x30, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xC0, 0x30, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01,
  0x81, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x1F, 0xFE, 0x07, 0xB7, 0xC1, 0xC6, 0x08, 0x70,
  0xC0, 0x0C, 0x18, 0x03, 0x86, 0x00, 0x60, 0xC0, 0x0E, 0x18, 0x01, 0xC3,
  0x00, 0x1C, 0x40, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x01, 0x1C, 0x00, 0x61, 0x80, 0x0C, 0x38, 0x01, 0x83, 0x00, 0x30,
  0xE0, 0x0C, 0x1C, 0x01, 0x83, 0x10, 0x30, 0xE3, 0x86, 0x78, 0x7F, 0xFC,
  0x01, 0xFE, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x40, 0xFC, 0x00, 0x30, 0x31, 0xC0, 0x0C, 0x0C,
  0x18, 0x03, 0x83, 0x83, 0x00, 0x60, 0x60, 0x70, 0x18, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0xC0, 0x60, 0x30, 0x30, 0x0C, 0x06, 0x0C, 0x01, 0x80,
  0xC3, 0x00, 0x70, 0x18, 0xE0, 0x0C, 0x06, 0x18, 0xF9, 0x80, 0xC6, 0x3F,
  0xB8, 0x39, 0x8E, 0x33, 0x06, 0x33, 0x83, 0x73, 0x8C, 0x60, 0x67, 0xE3,
  0x18, 0x0C, 0x30, 0xE3, 0x01, 0x80, 0x18, 0x60, 0x30, 0x06, 0x18, 0x06,
  0x01, 0x83, 0x01, 0xC0, 0x70, 0x60, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xC0, 0x30, 0x30, 0x38, 0x06, 0x06, 0x06, 0x00, 0xE1, 0x81,
  0x80, 0x0E, 0xF0, 0x60, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xE1, 0xC0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0x60, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x00,
  0xC0, 0x03, 0x83, 0x80, 0x01, 0x87, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x38, 0x03, 0x38, 0x18,
  0x07, 0x70, 0x1C, 0x06, 0x60, 0x0E, 0x0E, 0xE0, 0x07, 0x0C, 0xC0, 0x03,
  0x18, 0xC0, 0x03, 0xB8, 0xC0, 0x01, 0xF0, 0xC0, 0x00, 0xE0, 0xC0, 0x01,
  0xE0, 0xE0, 0x03, 0xF0, 0x70, 0x0E, 0x38, 0x3F, 0xFC, 0x18, 0x1F, 0xF0,
  0x1C, 0x76, 0x66, 0xEC, 0xCC, 0xC8, 0x00, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0xC0, 0xC0, 0x38,
  0x30, 0x07, 0x8C, 0x00, 0x7A, 0x01, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x7C,
  0x00, 0x39, 0x00, 0x1C, 0x60, 0x0E, 0x18, 0x07, 0x03, 0x00, 0x80, 0xC0,
  0x00, 0x38, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x0E, 0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x38, 0x61, 0xC0,
  0x7F, 0xFF, 0xF0, 0x2F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x0F, 0x3E, 0x03, 0x80, 0xE0,
  0xE0, 0x1C, 0x38, 0x01, 0x86, 0x00, 0x39, 0xC0, 0x07, 0x30, 0x00, 0xEE,
  0x00, 0x1D, 0xC0, 0x03, 0xB0, 0x00, 0x76, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x00, 0x07, 0x60,
  0x00, 0xCC, 0x00, 0x19, 0x80, 0x07, 0x30, 0x00, 0xC6, 0x00, 0x38, 0xC0,
  0x06, 0x1C, 0x01, 0xC1, 0x80, 0x70, 0x38, 0x1C, 0x03, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xE0, 0x3C, 0x1F, 0x87, 0x73, 0xCD, 0xE1, 0x98, 0x30,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x00,
  0x7E, 0x7C, 0x07, 0x80, 0xE0, 0x10, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE0, 0x00, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0xF8, 0xF8, 0x0E, 0x00, 0xE0,
  0x40, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x07, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0xE1,
  0x80, 0x1E, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xB0, 0x00, 0x1C,
  0xC0, 0x00, 0xE7, 0x00, 0x03, 0x1C, 0x00, 0x18, 0x60, 0x00, 0xC1, 0x80,
  0x06, 0x06, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xC0, 0x0E, 0x03, 0x00, 0x70,
  0x0C, 0x03, 0x80, 0x30, 0x0C, 0x01, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x18,
  0x1C, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xDF, 0x00, 0x1F, 0xFC,
  0x01, 0xC1, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x08, 0x00, 0xF0, 0xC0, 0x1E, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xFC, 0x03, 0xF1,
  0x80, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x1F, 0xC0,
  0xCF, 0xFC, 0x1B, 0x81, 0xC7, 0xC0, 0x1C, 0xF0, 0x01, 0x9C, 0x00, 0x33,
  0x80, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xE6,
  0x00, 0x1C, 0xC0, 0x03, 0x1C, 0x00, 0xE1, 0x80, 0x38, 0x38, 0x0E, 0x03,
  0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x01, 0xE3, 0xE0, 0x38, 0x0E,
  0x07, 0x00, 0x70, 0x60, 0x07, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x0E, 0x00,
  0x70, 0x60, 0x06, 0x06, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0x87, 0x80, 0x1F,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0x0E, 0x03, 0xC0, 0x70, 0x70,
  0x03, 0x86, 0x00, 0x18, 0xE0, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0xCC,
  0x00, 0x1C, 0xC0, 0x01, 0x8E, 0x00, 0x38, 0x60, 0x03, 0x07, 0x80, 0xF0,
  0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x0F, 0x1E,
  0x03, 0x80, 0xE0, 0xE0, 0x0E, 0x38, 0x00, 0xC6, 0x00, 0x19, 0xC0, 0x03,
  0x38, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x0E,
  0x60, 0x01, 0xCE, 0x00, 0x78, 0xE0, 0x1F, 0x1E, 0x0E, 0xC1, 0xFF, 0x98,
  0x0F, 0xC7, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x40, 0x3C, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x87, 0x8F, 0x1C,
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x3F, 0xE1, 0xF9, 0xF1, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x07, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x03, 0x18, 0x01, 0xFC, 0x06, 0x30, 0x0F, 0xFC, 0x0C, 0xC0, 0x38,
  0x18, 0x19, 0x80, 0xC0, 0x30, 0x36, 0x03, 0x00, 0xE0, 0x6C, 0x0E, 0x01,
  0x80, 0xD8, 0x18, 0x03, 0x01, 0xB0, 0x70, 0x06, 0x03, 0xC0, 0xC0, 0x18,
  0x07, 0x81, 0x80, 0x30, 0x1F, 0x03, 0x00, 0x60, 0x36, 0x06, 0x01, 0xC0,
  0x6C, 0x0C, 0x07, 0x81, 0x9C, 0x1C, 0x0B, 0x07, 0x18, 0x1C, 0x77, 0x3C,
  0x30, 0x1F, 0x87, 0xF0, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xCE, 0x00, 0x03, 0x9C, 0x00,
  0x06, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x01,
  0x81, 0x80, 0x07, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x30, 0x0E, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x18, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x38, 0x00,
  0xC0, 0x60, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x0E, 0x00, 0x06,
  0x38, 0x00, 0x0C, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x70, 0x07, 0x81,
  0xC0, 0x07, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x60, 0x01, 0xC3, 0x80,
  0x07, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00, 0x1C,
  0x1C, 0x07, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x06, 0x00, 0x70, 0x18,
  0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00,
  0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE1,
  0x80, 0x07, 0x0E, 0x00, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0x00, 0x20, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x06, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0x00, 0xF8, 0x07,
  0x00, 0x3C, 0x06, 0x00, 0x1E, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x18,
  0x00, 0x07, 0x18, 0x00, 0x07, 0x38, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x30,
  0x00, 0x0E, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38, 0x60,
  0x00, 0x70, 0x60, 0x01, 0xE0, 0x60, 0x03, 0xC0, 0xE0, 0x1F, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC1, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0xFF,
  0x01, 0xE0, 0x03, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x07, 0xFE, 0xE0, 0x07, 0xFC, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x38, 0x70, 0x00, 0x38, 0x38, 0x00, 0x30, 0x3C, 0x00, 0x30,
  0x1E, 0x00, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x0E,
  0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x18,
  0x1C, 0x00, 0x06, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x60, 0x00,
  0x38, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x70, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x01, 0x81,
  0x80, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03,
  0x03, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x00, 0x03, 0xFC, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x0F, 0x03,
  0x00, 0x1C, 0x07, 0x00, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x06,
  0x01, 0xC0, 0x06, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0C,
  0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x1D,
  0xE0, 0x00, 0x1B, 0x70, 0x00, 0x1E, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x18, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x06, 0x00, 0x60, 0x07, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x03, 0x80, 0xE0, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3E, 0x06, 0xC0, 0x00, 0x36, 0x06, 0xC0,
  0x00, 0x7E, 0x06, 0xC0, 0x00, 0x6E, 0x06, 0xC0, 0x00, 0xEC, 0x0E, 0xE0,
  0x00, 0xCC, 0x0C, 0x60, 0x01, 0x8C, 0x0C, 0x60, 0x03, 0x9C, 0x0C, 0x60,
  0x03, 0x18, 0x0C, 0x60, 0x07, 0x18, 0x1C, 0x60, 0x06, 0x18, 0x18, 0x60,
  0x0C, 0x38, 0x18, 0x30, 0x0C, 0x38, 0x18, 0x30, 0x18, 0x30, 0x38, 0x30,
  0x38, 0x30, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x70, 0x70, 0x30, 0x30,
  0x60, 0x70, 0x30, 0x38, 0xC0, 0x60, 0x70, 0x18, 0xC0, 0x60, 0x70, 0x19,
  0x80, 0x60, 0x60, 0x1B, 0x80, 0xE0, 0x60, 0x1B, 0x00, 0xE0, 0x60, 0x1F,
  0x00, 0xC0, 0xE0, 0x1E, 0x00, 0xC0, 0xC0, 0x1C, 0x00, 0xC0, 0xC0, 0x0C,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x78, 0x00, 0x1C,
  0x1B, 0x00, 0x07, 0x06, 0xC0, 0x01, 0x81, 0xB8, 0x00, 0x60, 0x66, 0x00,
  0x18, 0x39, 0xC0, 0x0E, 0x0C, 0x30, 0x03, 0x03, 0x0C, 0x00, 0xC0, 0xC3,
  0x80, 0x30, 0x30, 0x60, 0x0C, 0x1C, 0x1C, 0x07, 0x06, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0x60, 0x38, 0x18, 0x38, 0x06, 0x0E, 0x0E, 0x01, 0xC3,
  0x83, 0x00, 0x30, 0xC0, 0xC0, 0x0C, 0x30, 0x30, 0x03, 0x8C, 0x1C, 0x00,
  0x67, 0x07, 0x00, 0x1D, 0xC1, 0x80, 0x03, 0x60, 0x60, 0x00, 0xD8, 0x18,
  0x00, 0x3E, 0x0E, 0x00, 0x07, 0x83, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x78,
  0x03, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xB8, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x38, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0F, 0x00,
  0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xC0, 0x3C, 0x0E, 0x00, 0xE0, 0x60, 0x03,
  0x83, 0x00, 0x1C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x60,
  0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x61, 0xC0, 0x07, 0x0E, 0x00, 0x70,
  0x60, 0x1F, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x78, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x30,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x18, 0x1C, 0x00,
  0x1C, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xC0, 0x3C, 0x0E, 0x00, 0x60, 0x60,
  0x03, 0x83, 0x00, 0x1C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x0E, 0x00, 0x18,
  0x60, 0x01, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0xE1, 0xC0, 0x0E, 0x0E, 0x00,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x18, 0x1C, 0x01, 0xC0, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x38, 0x03, 0x01, 0xC0, 0x1C,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x83, 0x00, 0x1C, 0x38, 0x00, 0x61, 0xC0,
  0x03, 0x8C, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0xF0, 0x78, 0x02, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x0C, 0x01, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x01,
  0x87, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x70, 0xC0, 0x00,
  0x30, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x18, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x70,
  0x00, 0x1C, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0x18, 0x00, 0x1C, 0x60, 0x00, 0x61, 0x80, 0x03, 0x86, 0x00, 0x1C, 0x18,
  0x00, 0x70, 0x60, 0x03, 0x81, 0xC0, 0x0C, 0x07, 0x00, 0x70, 0x1C, 0x01,
  0x80, 0x30, 0x0E, 0x00, 0xC0, 0x30, 0x03, 0x01, 0xC0, 0x0C, 0x06, 0x00,
  0x30, 0x38, 0x00, 0xC0, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x18, 0x00, 0x38,
  0xE0, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xB0, 0x00, 0xF0, 0x01,
  0x98, 0x00, 0xD8, 0x01, 0xCC, 0x00, 0x6C, 0x00, 0xC6, 0x00, 0x76, 0x00,
  0x63, 0x00, 0x33, 0x00, 0x71, 0x80, 0x39, 0x80, 0x30, 0xC0, 0x18, 0xC0,
  0x38, 0x60, 0x1C, 0x60, 0x18, 0x38, 0x0C, 0x30, 0x1C, 0x1C, 0x0E, 0x18,
  0x0C, 0x0E, 0x06, 0x0C, 0x0E, 0x07, 0x07, 0x06, 0x06, 0x03, 0x83, 0x03,
  0x03, 0x01, 0xC1, 0x81, 0x83, 0x00, 0x61, 0x80, 0xC1, 0x80, 0x30, 0xC0,
  0x61, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x0C, 0x60, 0x1C, 0xE0, 0x06, 0x60,
  0x0E, 0x60, 0x03, 0x30, 0x03, 0x70, 0x01, 0xB8, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0xD8, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xC1, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x37, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x70, 0x00,
  0x70, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x7E, 0x00, 0x0E, 0x60, 0x00, 0xC6, 0x00, 0x1C, 0x70, 0x03, 0x87,
  0x00, 0x70, 0x30, 0x06, 0x03, 0x00, 0xE0, 0x38, 0x1C, 0x01, 0x81, 0x80,
  0x18, 0x38, 0x01, 0x87, 0x00, 0x1C, 0x60, 0x00, 0xCE, 0x00, 0x0D, 0xC0,
  0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xC0, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE0,
  0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x60, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x03, 0x08, 0x00, 0xE1, 0x80, 0x18,
  0x30, 0x07, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x0E, 0x00, 0xC1, 0x80,
  0x18, 0x70, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0x78, 0x00,
  0x0C, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xE1, 0x87, 0x0C, 0x18, 0x30, 0x01,
  0xFC, 0x30, 0x3F, 0xE3, 0x07, 0x03, 0x60, 0xE0, 0x16, 0x1C, 0x01, 0xE3,
  0x80, 0x1E, 0x30, 0x00, 0xC7, 0x00, 0x0C, 0x70, 0x01, 0xC6, 0x00, 0x1C,
  0xE0, 0x01, 0xCE, 0x00, 0x18, 0xE0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03,
  0x8C, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0x60, 0x1B, 0x07, 0x03,
  0x30, 0x3F, 0xE6, 0x01, 0xF8, 0x60, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x61, 0xF8, 0x06, 0x7F, 0xC0, 0xEE, 0x0E,
  0x0D, 0x80, 0x70, 0xF0, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x1C, 0x00,
  0x31, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x38, 0x00, 0x33, 0x80,
  0x07, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xE7, 0x00, 0x0C, 0x78,
  0x01, 0xC6, 0x80, 0x38, 0x6C, 0x07, 0x06, 0x7F, 0xE0, 0xC3, 0xF8, 0x00,
  0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xC0, 0x41, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x07, 0xF0, 0xC0, 0x3F, 0xE3, 0x03, 0xC0, 0xDC, 0x0E, 0x01, 0xE0, 0x70,
  0x03, 0x83, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03,
  0x06, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00,
  0xF8, 0x18, 0x06, 0xC0, 0x70, 0x33, 0x00, 0xFF, 0x8C, 0x01, 0xFC, 0x30,
  0x00, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xC0, 0xE1, 0xC0, 0x71, 0xC0, 0x19,
  0xC0, 0x0C, 0xC0, 0x0E, 0xE0, 0x06, 0x70, 0x0F, 0x30, 0x1E, 0x1F, 0xFE,
  0x1F, 0xF8, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x81, 0xFF, 0xC0, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x23, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x18, 0x0F, 0xF8, 0xC1, 0xE0, 0x66, 0x0E, 0x01, 0xE0, 0xE0, 0x07, 0x0E,
  0x00, 0x38, 0x60, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x61, 0x80, 0x03,
  0x1C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x30, 0x00, 0x61, 0x80,
  0x07, 0x0C, 0x00, 0x38, 0x70, 0x03, 0xC3, 0x80, 0x3E, 0x0C, 0x03, 0x60,
  0x70, 0x33, 0x01, 0xFF, 0x18, 0x07, 0xF1, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x08,
  0x01, 0xC0, 0x78, 0x3C, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x61, 0xF8, 0x06,
  0x7F, 0xE0, 0xEE, 0x0E, 0x0D, 0x80, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06,
  0x38, 0x00, 0xE3, 0x80, 0x0E, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00,
  0x18, 0xE0, 0x03, 0x80, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C,
  0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x8E, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0x06,
  0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x00, 0xC0, 0xE0, 0x0C, 0x1C, 0x00,
  0xC3, 0x80, 0x1C, 0x70, 0x01, 0x8E, 0x00, 0x19, 0xC0, 0x01, 0xBC, 0x00,
  0x3F, 0xE0, 0x03, 0xC6, 0x00, 0x38, 0x70, 0x03, 0x03, 0x00, 0x30, 0x38,
  0x07, 0x01, 0x80, 0x70, 0x1C, 0x06, 0x00, 0xC0, 0x60, 0x0E, 0x06, 0x00,
  0x60, 0xE0, 0x07, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C,
  0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0C,
  0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06,
  0x03, 0x03, 0x80, 0x06, 0x1F, 0x81, 0xFC, 0x06, 0x7F, 0xC3, 0xFE, 0x0C,
  0xE1, 0xC6, 0x0E, 0x0D, 0x80, 0xCC, 0x07, 0x0F, 0x00, 0xF8, 0x07, 0x0E,
  0x00, 0xF0, 0x07, 0x0E, 0x00, 0xF0, 0x07, 0x1C, 0x00, 0xE0, 0x07, 0x1C,
  0x00, 0xE0, 0x06, 0x18, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x06, 0x38,
  0x01, 0xC0, 0x0E, 0x38, 0x01, 0xC0, 0x0E, 0x30, 0x01, 0x80, 0x0C, 0x30,
  0x01, 0x80, 0x0C, 0x30, 0x01, 0x80, 0x0C, 0x70, 0x03, 0x80, 0x1C, 0x70,
  0x03, 0x00, 0x1C, 0x60, 0x03, 0x00, 0x18, 0x60, 0x03, 0x00, 0x18, 0x60,
  0x07, 0x00, 0x38, 0xE0, 0x07, 0x00, 0x38, 0x06, 0x1F, 0xC0, 0x67, 0xFE,
  0x0C, 0xE0, 0xE0, 0xDC, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00,
  0x71, 0xC0, 0x07, 0x1C, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x63, 0x80,
  0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x1C, 0x70,
  0x01, 0xC7, 0x00, 0x1C, 0x60, 0x01, 0x86, 0x00, 0x18, 0xE0, 0x03, 0x8E,
  0x00, 0x38, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x3C, 0x0E, 0x07, 0x00, 0xE1,
  0xC0, 0x0C, 0x70, 0x01, 0xCC, 0x00, 0x1B, 0x80, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xB8,
  0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0x8C, 0x00, 0x71, 0xC0, 0x1C, 0x1C,
  0x0F, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0x87, 0xE0, 0x06, 0x7F,
  0xC0, 0x33, 0x83, 0x80, 0xD8, 0x07, 0x03, 0xC0, 0x0C, 0x0E, 0x00, 0x30,
  0x38, 0x00, 0xC1, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60,
  0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0, 0x01,
  0x83, 0x00, 0x0E, 0x1C, 0x00, 0x30, 0x78, 0x01, 0xC1, 0xA0, 0x0E, 0x06,
  0xC0, 0x70, 0x19, 0xFF, 0x80, 0xE3, 0xF8, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xFC, 0x30, 0x3F, 0xE3, 0x0F, 0x03, 0x30, 0xE0, 0x1F, 0x1C, 0x00, 0xE3,
  0x80, 0x0E, 0x30, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xC6, 0x00, 0x0C,
  0xE0, 0x00, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCC, 0x00, 0x18, 0xC0, 0x03,
  0x8C, 0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0xF8, 0x60, 0x1B, 0x07, 0x03,
  0x30, 0x3F, 0xE3, 0x01, 0xFC, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x06, 0x1F, 0x06, 0x7F, 0x0C,
  0xE0, 0x0D, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xC3, 0x80, 0xC3, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x18, 0x07, 0x8F, 0xFF, 0x81,
  0xFF, 0x00, 0x02, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x03, 0xFF, 0xFF,
  0xF1, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x1C, 0x00, 0x71, 0xC0, 0x07,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x63, 0x80, 0x0E, 0x38, 0x00,
  0xE3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x01, 0xC7, 0x00,
  0x18, 0x60, 0x01, 0x86, 0x00, 0x38, 0x60, 0x03, 0x8E, 0x00, 0x78, 0xE0,
  0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x1B, 0x07, 0x03, 0x30, 0x7F, 0xE3, 0x03,
  0xF8, 0x60, 0xC0, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x3B, 0x80, 0x0C, 0x60,
  0x07, 0x18, 0x03, 0x86, 0x00, 0xC1, 0x80, 0x70, 0x60, 0x18, 0x1C, 0x0E,
  0x07, 0x03, 0x00, 0xC1, 0xC0, 0x30, 0x60, 0x0C, 0x38, 0x03, 0x1C, 0x00,
  0xC6, 0x00, 0x33, 0x80, 0x0E, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x0E, 0xE0,
  0x1E, 0x00, 0xEE, 0x01, 0xE0, 0x0C, 0x60, 0x3E, 0x01, 0xC6, 0x03, 0x60,
  0x18, 0x60, 0x77, 0x03, 0x86, 0x06, 0x30, 0x30, 0x60, 0x63, 0x07, 0x06,
  0x0C, 0x30, 0x60, 0x60, 0xC3, 0x0E, 0x06, 0x18, 0x30, 0xC0, 0x61, 0x83,
  0x1C, 0x06, 0x30, 0x31, 0x80, 0x63, 0x03, 0x38, 0x06, 0x60, 0x33, 0x00,
  0x66, 0x03, 0x30, 0x06, 0xC0, 0x36, 0x00, 0x6C, 0x03, 0x60, 0x07, 0x80,
  0x3E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38,
  0x30, 0x03, 0x81, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x38, 0x18, 0x00, 0xC1,
  0x80, 0x07, 0x1C, 0x00, 0x19, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xCC, 0x00, 0x0E, 0x60,
  0x00, 0xE1, 0x80, 0x0E, 0x0C, 0x00, 0xE0, 0x30, 0x06, 0x01, 0x80, 0x60,
  0x0E, 0x07, 0x00, 0x30, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x03, 0x80,
  0x06, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x01, 0x80, 0x70, 0x01, 0xC0, 0x60, 0x00, 0xC0,
  0xE0, 0x00, 0xC0, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC3,
  0x80, 0x00, 0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x8E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0xFC, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0xFC, 0x01, 0xC0, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x2F, 0xF8, 0x07, 0x87, 0xC3, 0xC0, 0x3F, 0xE8, 0x00, 0xF0,
};

const GFXglyph NotoSans_LightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 29, 10, 1, -29 },
  { 34, 10, 10, 14, 5, -29 },
  { 47, 25, 29, 26, 1, -29 },
  { 138, 19, 33, 23, 2, -31 },
  { 217, 27, 30, 32, 3, -30 },
  { 319, 24, 30, 28, 2, -30 },
  { 409, 4, 10, 8, 5, -29 },
  { 414, 13, 35, 11, 1, -29 },
  { 471, 13, 35, 11, -3, -29 },
  { 528, 18, 18, 22, 5, -31 },
  { 569, 19, 19, 23, 3, -24 },
  { 615, 7, 10, 9, -2, -5 },
  { 624, 10, 2, 13, 1, -12 },
  { 627, 4, 4, 10, 1, -4 },
  { 629, 19, 29, 14, -2, -29 },
  { 698, 19, 30, 23, 3, -30 },
  { 770, 11, 29, 23, 6, -29 },
  { 810, 21, 30, 23, 0, -30 },
  { 889, 21, 30, 23, 1, -30 },
  { 968, 22, 29, 23, 0, -29 },
  { 1048, 20, 29, 23, 2, -29 },
  { 1121, 19, 30, 23, 3, -30 },
  { 1193, 19, 29, 23, 4, -29 },
  { 1262, 20, 30, 23, 2, -30 },
  { 1337, 19, 30, 23, 2, -30 },
  { 1409, 7, 22, 10, 1, -22 },
  { 1429, 10, 27, 10, -2, -22 },
  { 1463, 19, 19, 23, 3, -24 },
  { 1509, 19, 11, 23, 3, -20 },
  { 1536, 19, 19, 23, 3, -24 },
  { 1582, 15, 30, 17, 3, -30 },
  { 1639, 31, 33, 34, 2, -29 },
  { 1767, 23, 29, 23, -2, -29 },
  { 1851, 22, 29, 25, 2, -29 },
  { 1931, 23, 30, 24, 3, -30 },
  { 2018, 24, 29, 28, 2, -29 },
  { 2105, 21, 29, 22, 2, -29 },
  { 2182, 21, 29, 20, 2, -29 },
  { 2259, 24, 30, 28, 3, -30 },
  { 2349, 26, 29, 28, 2, -29 },
  { 2444, 14, 29, 12, 0, -29 },
  { 2495, 18, 36, 10, -7, -29 },
  { 2576, 24, 29, 23, 2, -29 },
  { 2663, 15, 29, 20, 2, -29 },
  { 2718, 32, 29, 34, 2, -29 },
  { 2834, 26, 29, 28, 2, -29 },
  { 2929, 25, 30, 29, 3, -30 },
  { 3023, 21, 29, 23, 2, -29 },
  { 3100, 25, 37, 29, 3, -30 },
  { 3216, 21, 29, 23, 2, -29 },
  { 3293, 20, 30, 21, 1, -30 },
  { 3368, 20, 29, 20, 4, -29 },
  { 3441, 25, 29, 28, 3, -29 },
  { 3532, 22, 29, 22, 4, -29 },
  { 3612, 33, 29, 34, 5, -29 },
  { 3732, 26, 29, 21, -2, -29 },
  { 3827, 20, 29, 20, 4, -29 },
  { 3900, 23, 29, 22, 0, -29 },
  { 3984, 15, 35, 12, 0, -29 },
  { 4050, 7, 29, 14, 4, -29 },
  { 4076, 16, 35, 12, -3, -29 },
  { 4146, 19, 18, 23, 2, -29 },
  { 4189, 17, 2, 16, -4, 4 },
  { 4194, 6, 6, 10, 6, -31 },
  { 4199, 20, 22, 23, 2, -22 },
  { 4254, 20, 31, 24, 1, -31 },
  { 4332, 17, 22, 19, 2, -22 },
  { 4379, 22, 31, 24, 2, -31 },
  { 4465, 17, 22, 20, 2, -22 },
  { 4512, 23, 41, 12, -5, -31 },
  { 4630, 21, 32, 24, 1, -22 },
  { 4714, 20, 31, 23, 1, -31 },
  { 4792, 9, 30, 10, 1, -30 },
  { 4826, 16, 40, 10, -6, -30 },
  { 4906, 20, 31, 19, 1, -31 },
  { 4984, 9, 31, 10, 1, -31 },
  { 5019, 32, 22, 35, 1, -22 },
  { 5107, 20, 22, 23, 1, -22 },
  { 5162, 19, 22, 23, 2, -22 },
  { 5215, 22, 32, 24, -1, -22 },
  { 5303, 20, 32, 24, 2, -22 },
  { 5383, 16, 22, 16, 1, -22 },
  { 5427, 17, 22, 18, 0, -22 },
  { 5474, 12, 27, 13, 2, -27 },
  { 5515, 20, 22, 23, 2, -22 },
  { 5570, 18, 22, 18, 2, -22 },
  { 5620, 28, 22, 28, 2, -22 },
  { 5697, 21, 22, 19, -1, -22 },
  { 5755, 24, 32, 18, -4, -22 },
  { 5851, 19, 22, 18, -1, -22 },
  { 5904, 15, 35, 14, 1, -29 },
  { 5970, 2, 41, 22, 11, -31 },
  { 5981, 15, 35, 14, -2, -29 },
  { 6047, 19, 5, 23, 3, -17 },
};

const GFXfont NotoSans_LightItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_LIGHTITALIC41PT7B_H_
