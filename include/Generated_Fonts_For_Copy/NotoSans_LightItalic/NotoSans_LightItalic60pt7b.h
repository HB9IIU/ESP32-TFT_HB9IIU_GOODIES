#ifndef _NOTOSANS_LIGHTITALIC60PT7B_H_
#define _NOTOSANS_LIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xC0,
  0x00, 0x3C, 0x1E, 0x78, 0x3C, 0xE0, 0x79, 0xC0, 0xE7, 0x81, 0xCF, 0x03,
  0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x38, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0x8E,
  0x07, 0x18, 0x0E, 0x30, 0x18, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x01, 0xF0, 0xE0, 0xE0, 0x3E, 0x0E, 0x02, 0x03, 0xC0, 0xE0, 0x00,
  0x78, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x70, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0x78, 0x38, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xF3, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x6F, 0xC0, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0xE1, 0xF0, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x07, 0x80, 0x01, 0xC0,
  0x78, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x0F, 0x00,
  0x01, 0x80, 0xF0, 0x00, 0x38, 0x1E, 0x08, 0x03, 0x87, 0xC0, 0xF8, 0x39,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x78, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x1F, 0x3E, 0x00, 0x03, 0x80,
  0x78, 0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x38,
  0x00, 0x70, 0x0F, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0x38, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x01,
  0xC1, 0xE0, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x0E, 0x0F,
  0xE3, 0x80, 0x1C, 0x38, 0x7F, 0xE7, 0x00, 0x70, 0xF1, 0xFF, 0xEE, 0x01,
  0xE1, 0xC7, 0x81, 0xDE, 0x03, 0x87, 0x0E, 0x03, 0xDC, 0x0E, 0x1C, 0x38,
  0x03, 0xBE, 0x7C, 0x78, 0x70, 0x07, 0x3F, 0xF0, 0xE1, 0xC0, 0x0E, 0x3F,
  0x83, 0x83, 0x80, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x38, 0x00, 0x3C, 0x1C,
  0x00, 0x70, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x03, 0x80,
  0x07, 0x80, 0xE0, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x01, 0xC0, 0xF0,
  0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x38, 0x00, 0x03, 0xFF, 0x00, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1C,
  0x0F, 0x80, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x00, 0x03, 0xBF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x78, 0x7C, 0x03, 0x80, 0x07, 0x87, 0x80, 0x1E, 0x00,
  0x38, 0x38, 0x00, 0x78, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0x1C, 0x3C, 0x00,
  0x0F, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0xE0,
  0x70, 0x00, 0x03, 0x8F, 0x07, 0x80, 0x00, 0x1E, 0xF0, 0x3C, 0x00, 0x00,
  0x7F, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0x80, 0x01, 0xF3,
  0x80, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0xFE, 0x1F, 0xE0, 0x78, 0x03, 0xFF,
  0xFC, 0x01, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0x80, 0x03, 0x40, 0x00, 0x00,
  0x00, 0x3C, 0xF3, 0x8E, 0x79, 0xE7, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x0C,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x04, 0x00, 0x60, 0x01, 0x80, 0x38, 0x00, 0xF8, 0x0E, 0x00,
  0x3F, 0x83, 0x80, 0x03, 0xF8, 0xC0, 0x00, 0x1F, 0x30, 0x00, 0x01, 0xFC,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x71, 0x80, 0x00, 0x38, 0x70, 0x00, 0x3C, 0x0C, 0x00,
  0x1E, 0x03, 0x80, 0x0F, 0x80, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x60, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xF0, 0x77, 0xFF, 0xFF, 0x30, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x03, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x3F, 0x70, 0x3E, 0x38, 0x7E, 0x1C, 0xFC, 0x1E, 0x3C, 0x0F,
  0x18, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x06, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x18, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x10, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x30, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00,
  0xF0, 0x07, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x0F, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x0C, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x3F, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x0F, 0x0F, 0xFE, 0x00, 0x71, 0xFF, 0xF8, 0x03, 0x9F, 0x07,
  0xE0, 0x3D, 0xE0, 0x0F, 0x81, 0xDC, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0xF0,
  0x7C, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0x1F, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x7C, 0x00, 0xF0, 0x07, 0x80,
  0x03, 0xC0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x38, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x03,
  0xE0, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x05, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x80, 0x7C, 0x01, 0xE0,
  0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x1C,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xF0, 0xF0, 0x00,
  0x7E, 0x0F, 0x80, 0x1E, 0xE0, 0x7E, 0x07, 0xDE, 0x03, 0xFF, 0xF1, 0xE0,
  0x1F, 0xFE, 0x1C, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x08, 0x00, 0xFC, 0x00, 0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0x60, 0x00,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x78, 0x03, 0xE2, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x38, 0x3C, 0x00, 0x1F,
  0xFE, 0x00, 0xE0, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xC7, 0x00, 0x1F, 0x80,
  0xF0, 0x07, 0x1C, 0x00, 0xF8, 0x03, 0xC0, 0x1C, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x73, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xCE, 0x00, 0xE0, 0x00, 0xE0,
  0x07, 0x70, 0x07, 0x80, 0x07, 0x00, 0x1D, 0xC0, 0x1C, 0x00, 0x1C, 0x00,
  0x77, 0x00, 0x70, 0x00, 0x70, 0x01, 0xDC, 0x03, 0x80, 0x01, 0xC0, 0x0E,
  0xF0, 0x0E, 0x00, 0x0E, 0x00, 0x3B, 0x80, 0x38, 0x00, 0x38, 0x00, 0xEE,
  0x00, 0xE0, 0x00, 0xE0, 0x07, 0xB8, 0x03, 0x80, 0x07, 0x80, 0x1C, 0xE0,
  0x0E, 0x00, 0x1C, 0x00, 0x73, 0x80, 0x38, 0x00, 0xF0, 0x03, 0x8E, 0x00,
  0xE0, 0x07, 0xC0, 0x1E, 0x3C, 0x03, 0x80, 0x1B, 0x80, 0xF0, 0x70, 0x0F,
  0x00, 0xCE, 0x07, 0x81, 0xC0, 0x1E, 0x0F, 0x3C, 0x3C, 0x07, 0x00, 0x7F,
  0xF8, 0x7F, 0xE0, 0x1C, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x38, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x3E,
  0x00, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0xF8, 0x07, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xC0,
  0x0E, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xE0,
  0x70, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x01,
  0xE0, 0x07, 0xE0, 0x00, 0x10, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x78, 0x03, 0xFE, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x01, 0xC0, 0x00, 0x7E,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x1C, 0x00, 0x0F, 0xE0,
  0x07, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x03,
  0xE0, 0x07, 0xE0, 0x00, 0x0C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFE, 0x3C, 0x00, 0x0F, 0xFF, 0xC7,
  0x80, 0x01, 0xFF, 0xF8, 0xE0, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x7C, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x30, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x03,
  0xE0, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x1C, 0x7C,
  0x00, 0x00, 0x03, 0x9F, 0x80, 0x00, 0x00, 0x77, 0xF8, 0x00, 0x00, 0x1F,
  0xEF, 0x00, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x00, 0x7E, 0x1E, 0x00, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x1E, 0xE0,
  0x00, 0x00, 0x7B, 0x80, 0x73, 0x80, 0x00, 0x01, 0xDE, 0x01, 0xCE, 0x00,
  0x00, 0x0F, 0x78, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x1C, 0xE0, 0x00,
  0x01, 0xC7, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x1C, 0x03, 0x8F, 0x00, 0x00,
  0x38, 0xF0, 0x0E, 0x1C, 0x00, 0x01, 0xE3, 0xC0, 0x38, 0x70, 0x00, 0x07,
  0x0E, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x07, 0x87, 0x00, 0x00, 0xE0,
  0xE0, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x70, 0x70, 0x00, 0x3C, 0x1E,
  0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x0F, 0x03, 0x80, 0x07, 0x81, 0xC0,
  0x3C, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x3C, 0x03,
  0x80, 0xE0, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x78,
  0x0E, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x70, 0x03, 0xC0, 0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x00, 0xE0, 0x03, 0x8E,
  0x00, 0x38, 0x07, 0x80, 0x0E, 0x78, 0x00, 0xE0, 0x1E, 0x00, 0x39, 0xC0,
  0x07, 0x80, 0x70, 0x00, 0xEE, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xB8, 0x00,
  0x78, 0x07, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x03, 0xE0, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x3F, 0x00,
  0x00, 0x0F, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x00, 0xE0,
  0x1F, 0xE0, 0x00, 0x03, 0x80, 0x73, 0x80, 0x00, 0x0E, 0x01, 0xCF, 0x00,
  0x00, 0x78, 0x07, 0x3C, 0x00, 0x01, 0xC0, 0x1C, 0x70, 0x00, 0x07, 0x00,
  0xF1, 0xE0, 0x00, 0x1C, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x0E, 0x0F, 0x00,
  0x03, 0xC0, 0x38, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x07,
  0x81, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0x1E, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x01, 0xC0, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x03, 0x80, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x78, 0x00, 0x70, 0x0E, 0x01, 0xE0,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x1C, 0x00, 0x0F, 0x07,
  0x00, 0x70, 0x00, 0x1C, 0x1C, 0x03, 0xC0, 0x00, 0x70, 0x70, 0x0F, 0x00,
  0x01, 0xE3, 0xC0, 0x38, 0x00, 0x03, 0x8F, 0x00, 0xE0, 0x00, 0x0F, 0x38,
  0x07, 0x80, 0x00, 0x1C, 0xE0, 0x1E, 0x00, 0x00, 0x73, 0x80, 0x70, 0x00,
  0x01, 0xEE, 0x01, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0x00, 0x00, 0x0F, 0xC0,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00,
  0x01, 0xF0, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x7F, 0x80, 0x0E,
  0x00, 0x0F, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x7F,
  0x80, 0x0E, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xE0, 0x38,
  0x00, 0x0F, 0x80, 0x70, 0x00, 0x7E, 0x01, 0xE0, 0x3F, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x1E, 0x00,
  0xF8, 0x00, 0x08, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x08, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x3F, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1D,
  0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x39,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x79, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x71,
  0xC0, 0x01, 0xE0, 0x70, 0x00, 0xF1, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE1,
  0xE0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0xC0,
  0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0xE0, 0x07, 0x80, 0x70, 0x03, 0x80,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x1E, 0x00,
  0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x3C, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x78, 0x00,
  0xE0, 0xF0, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0xE1, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF1, 0xC0, 0x00, 0x79, 0xE0, 0x00,
  0xF3, 0xC0, 0x00, 0x79, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x07,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x78,
  0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x38, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x00, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C,
  0x38, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0x38, 0x0F, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x81, 0xC0, 0x1F, 0xFE, 0x0E, 0x01,
  0xFC, 0xF8, 0xE0, 0x1F, 0x00, 0xE7, 0x01, 0xE0, 0x03, 0xB8, 0x1E, 0x00,
  0x0D, 0xC1, 0xE0, 0x00, 0x7E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF8, 0x3C, 0x00,
  0x1F, 0x80, 0xE0, 0x01, 0xDC, 0x07, 0x80, 0x1C, 0xE0, 0x1E, 0x01, 0xC7,
  0x00, 0xFC, 0x7C, 0x38, 0x03, 0xFF, 0xC1, 0x80, 0x0F, 0xF8, 0x1C, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x04, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x78,
  0x7F, 0xF8, 0x03, 0x8F, 0xEF, 0xE0, 0x1C, 0xF0, 0x0F, 0x80, 0xEF, 0x00,
  0x3C, 0x0F, 0x60, 0x00, 0xF0, 0x76, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x38, 0x78,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0xF0, 0x76, 0x00, 0x0F, 0x83, 0xB8, 0x00, 0xF8,
  0x1C, 0xE0, 0x0F, 0x81, 0xC7, 0xC7, 0xF8, 0x0E, 0x1F, 0xFF, 0x00, 0x70,
  0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xE7, 0xE0, 0x1F, 0x00, 0x10, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF8, 0x01, 0x80, 0x7F, 0x8F, 0xC0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x80, 0x3C, 0x00, 0x1F, 0xF0, 0x38, 0x00, 0x7F, 0xFC, 0x38, 0x00, 0xFF,
  0x7E, 0x38, 0x03, 0xF0, 0x0F, 0x78, 0x03, 0xC0, 0x03, 0x78, 0x07, 0x80,
  0x03, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x1F, 0x80, 0xF0, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x37, 0x00, 0x70, 0x00,
  0x77, 0x00, 0x78, 0x01, 0xE7, 0x00, 0x7C, 0x03, 0xCE, 0x00, 0x3F, 0x1F,
  0x8E, 0x00, 0x1F, 0xFE, 0x0E, 0x00, 0x0F, 0xFC, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xEF, 0xE0, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x00, 0x01,
  0xC7, 0x80, 0x01, 0xE3, 0x80, 0x01, 0xE3, 0xC0, 0x03, 0xF1, 0xE0, 0x07,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x80, 0xF8, 0x01, 0xC0,
  0x7F, 0x0F, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x20, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x3F, 0xF0, 0x30, 0x03, 0xFF, 0xE1, 0xC0, 0x1F, 0xEF, 0xC7,
  0x01, 0xF8, 0x07, 0x9C, 0x07, 0x80, 0x06, 0xF0, 0x3C, 0x00, 0x1F, 0x81,
  0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7E, 0x07, 0x80,
  0x01, 0xB8, 0x0E, 0x00, 0x0E, 0xE0, 0x3C, 0x00, 0xF7, 0x80, 0x78, 0x07,
  0x9C, 0x01, 0xF8, 0xFC, 0x70, 0x03, 0xFF, 0xC1, 0xC0, 0x07, 0xFE, 0x0F,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x08, 0x00,
  0x1F, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x80, 0x03, 0xC0, 0xFF, 0x80, 0x3C,
  0x3F, 0xFC, 0x03, 0x87, 0xEF, 0xE0, 0x39, 0xE0, 0x1F, 0x03, 0x9C, 0x00,
  0xF0, 0x7B, 0x00, 0x07, 0x07, 0x60, 0x00, 0x70, 0x7E, 0x00, 0x07, 0x07,
  0xC0, 0x00, 0x70, 0x78, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x70, 0xF0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C,
  0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x30, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x07, 0xC0, 0x38, 0x00,
  0xF8, 0x03, 0x80, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00,
  0x70, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x1E, 0x7C, 0x00, 0x01, 0xCF, 0xE0, 0x00, 0x1D, 0xFE, 0x00, 0x01, 0xFC,
  0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80,
  0x03, 0x80, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3C, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x0E, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x38, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0xE3, 0xF7, 0xF0, 0x7E, 0xFE, 0x03, 0x9E, 0x03, 0xC3, 0xC0, 0x78, 0x0E,
  0xE0, 0x07, 0x1C, 0x00, 0xF0, 0x7B, 0x00, 0x1E, 0xE0, 0x03, 0xC1, 0xD8,
  0x00, 0x7F, 0x00, 0x07, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1C, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0,
  0x00, 0x0E, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x0F, 0xFC, 0x00,
  0xE0, 0xFF, 0xF8, 0x07, 0x1F, 0xFF, 0xC0, 0x39, 0xF0, 0x1F, 0x01, 0xDE,
  0x00, 0x78, 0x1E, 0xE0, 0x01, 0xC0, 0xEE, 0x00, 0x0F, 0x07, 0xE0, 0x00,
  0x78, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1C, 0x1F, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x1C, 0x1E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x01, 0xFE, 0x7F,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x70, 0x1F, 0xF0, 0x00, 0x70, 0x7F, 0xF8,
  0x00, 0x70, 0xFD, 0xFC, 0x00, 0x73, 0xC0, 0x3E, 0x00, 0x73, 0x80, 0x1E,
  0x00, 0xF7, 0x00, 0x0F, 0x00, 0xEE, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF0,
  0x0E, 0xC0, 0x01, 0xF0, 0x0E, 0xE0, 0x03, 0xE0, 0x0E, 0x70, 0x07, 0xC0,
  0x1E, 0x7C, 0x7F, 0x80, 0x1E, 0x3F, 0xFE, 0x00, 0x1C, 0x0F, 0xFC, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0xC0, 0x1F, 0xFF, 0x0E, 0x01, 0xFE, 0xFC, 0x70, 0x3F,
  0x00, 0xF3, 0x81, 0xE0, 0x03, 0xBC, 0x1E, 0x00, 0x0F, 0xC1, 0xE0, 0x00,
  0x3E, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x1F, 0x87, 0x80, 0x01, 0xF8, 0x3C, 0x00, 0x0D, 0xC0, 0xE0, 0x00,
  0xEE, 0x07, 0x80, 0x1E, 0xF0, 0x1E, 0x01, 0xE7, 0x00, 0xFC, 0x7E, 0x38,
  0x03, 0xFF, 0xC1, 0xC0, 0x0F, 0xFC, 0x1E, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x81, 0xFE, 0x07, 0x07, 0xF8, 0x0E, 0x3F, 0xF0, 0x1C, 0xF0, 0x00, 0x3B,
  0xC0, 0x00, 0xF6, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xCF, 0xF0, 0x78, 0x00, 0xE1, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x88, 0x00, 0x1E, 0x1C, 0x00, 0x7C, 0x3F, 0x87, 0xF0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x1C, 0x07, 0xFF,
  0x00, 0x7F, 0xC0, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1C, 0x1E,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3F,
  0x07, 0x80, 0x03, 0xF8, 0x3C, 0x00, 0x3B, 0x80, 0xF0, 0x03, 0x9C, 0x07,
  0x80, 0x38, 0xE0, 0x1F, 0x9F, 0x87, 0x00, 0xFF, 0xF8, 0x38, 0x01, 0xFF,
  0x03, 0x80, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x1C, 0x00,
  0x07, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0xE0,
  0x0E, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x1C,
  0x1E, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x78, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xF0, 0x00, 0x7C, 0x00, 0x0E, 0x70, 0x00, 0x7C, 0x00, 0x1E, 0x70, 0x00,
  0xEC, 0x00, 0x1C, 0x70, 0x00, 0xEC, 0x00, 0x3C, 0x70, 0x01, 0xCC, 0x00,
  0x38, 0x70, 0x01, 0xCE, 0x00, 0x78, 0x70, 0x03, 0x8E, 0x00, 0x70, 0x70,
  0x03, 0x8E, 0x00, 0xF0, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x0E,
  0x01, 0xE0, 0x70, 0x0F, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x0E, 0x03, 0xC0,
  0x70, 0x1E, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x0E, 0x07, 0x80, 0x70, 0x3C,
  0x0E, 0x07, 0x80, 0x78, 0x38, 0x0E, 0x07, 0x00, 0x78, 0x78, 0x0E, 0x0F,
  0x00, 0x78, 0x70, 0x0F, 0x0E, 0x00, 0x78, 0xF0, 0x0F, 0x1E, 0x00, 0x78,
  0xE0, 0x07, 0x1C, 0x00, 0x79, 0xE0, 0x07, 0x3C, 0x00, 0x39, 0xC0, 0x07,
  0x38, 0x00, 0x3B, 0xC0, 0x07, 0x78, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00,
  0x3B, 0x80, 0x07, 0x70, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x78, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x77, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x13, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x7E, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE8, 0x00, 0x07, 0xF8,
};

const GFXglyph NotoSans_LightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 13, 44, 14, 2, -43 },
  { 73, 15, 16, 21, 7, -43 },
  { 103, 36, 43, 38, 2, -43 },
  { 297, 28, 48, 33, 3, -45 },
  { 465, 39, 44, 47, 5, -43 },
  { 680, 37, 45, 41, 2, -44 },
  { 889, 6, 16, 12, 7, -43 },
  { 901, 18, 52, 16, 2, -43 },
  { 1018, 18, 52, 16, -4, -43 },
  { 1135, 26, 27, 32, 7, -46 },
  { 1223, 28, 28, 34, 4, -35 },
  { 1321, 10, 15, 13, -3, -7 },
  { 1340, 15, 3, 19, 2, -18 },
  { 1346, 5, 6, 14, 2, -5 },
  { 1350, 28, 43, 20, -3, -43 },
  { 1501, 28, 45, 33, 4, -44 },
  { 1659, 17, 43, 33, 9, -43 },
  { 1751, 31, 43, 33, 0, -43 },
  { 1918, 31, 44, 33, 1, -43 },
  { 2089, 31, 43, 33, 1, -43 },
  { 2256, 30, 44, 33, 2, -43 },
  { 2421, 29, 45, 33, 4, -44 },
  { 2585, 28, 43, 33, 6, -43 },
  { 2736, 29, 45, 33, 3, -44 },
  { 2900, 28, 44, 33, 3, -43 },
  { 3054, 10, 33, 14, 2, -32 },
  { 3096, 15, 40, 14, -3, -32 },
  { 3171, 28, 28, 34, 4, -36 },
  { 3269, 27, 15, 34, 5, -29 },
  { 3320, 28, 28, 34, 4, -36 },
  { 3418, 21, 44, 25, 5, -43 },
  { 3534, 46, 48, 50, 3, -43 },
  { 3810, 33, 43, 33, -3, -43 },
  { 3988, 32, 43, 36, 3, -43 },
  { 4160, 33, 44, 35, 5, -43 },
  { 4342, 35, 43, 40, 3, -43 },
  { 4531, 30, 43, 32, 3, -43 },
  { 4693, 30, 43, 29, 3, -43 },
  { 4855, 35, 44, 41, 5, -43 },
  { 5048, 38, 43, 41, 3, -43 },
  { 5253, 21, 43, 18, 0, -43 },
  { 5366, 25, 54, 15, -10, -43 },
  { 5535, 35, 43, 33, 3, -43 },
  { 5724, 22, 43, 29, 3, -43 },
  { 5843, 46, 43, 49, 3, -43 },
  { 6091, 38, 43, 41, 3, -43 },
  { 6296, 36, 45, 43, 5, -44 },
  { 6499, 31, 43, 34, 3, -43 },
  { 6666, 36, 54, 43, 5, -44 },
  { 6909, 31, 43, 34, 3, -43 },
  { 7076, 30, 44, 30, 1, -43 },
  { 7241, 29, 43, 30, 6, -43 },
  { 7397, 36, 44, 41, 5, -43 },
  { 7595, 32, 43, 33, 6, -43 },
  { 7767, 48, 43, 50, 7, -43 },
  { 8025, 38, 43, 30, -3, -43 },
  { 8230, 29, 43, 30, 6, -43 },
  { 8386, 35, 43, 32, -1, -43 },
  { 8575, 23, 52, 18, -1, -43 },
  { 8725, 10, 43, 20, 6, -43 },
  { 8779, 22, 52, 18, -4, -43 },
  { 8922, 28, 27, 34, 3, -43 },
  { 9017, 23, 3, 23, -5, 6 },
  { 9026, 8, 10, 15, 9, -46 },
  { 9036, 29, 34, 33, 3, -33 },
  { 9160, 29, 47, 34, 2, -46 },
  { 9331, 25, 34, 27, 3, -33 },
  { 9438, 32, 47, 34, 3, -46 },
  { 9626, 25, 34, 30, 3, -33 },
  { 9733, 33, 60, 17, -7, -46 },
  { 9981, 30, 47, 34, 2, -33 },
  { 10158, 28, 46, 34, 2, -46 },
  { 10319, 13, 44, 14, 2, -44 },
  { 10391, 23, 58, 14, -8, -44 },
  { 10558, 28, 46, 28, 2, -46 },
  { 10719, 13, 46, 14, 2, -46 },
  { 10794, 46, 33, 52, 2, -33 },
  { 10984, 29, 33, 34, 2, -33 },
  { 11104, 28, 33, 34, 3, -32 },
  { 11220, 32, 47, 34, -1, -33 },
  { 11408, 29, 47, 34, 3, -33 },
  { 11579, 23, 32, 23, 2, -32 },
  { 11671, 23, 34, 26, 1, -33 },
  { 11769, 18, 41, 19, 3, -40 },
  { 11862, 29, 33, 34, 3, -32 },
  { 11982, 26, 32, 26, 3, -32 },
  { 12086, 40, 32, 41, 3, -32 },
  { 12246, 31, 32, 28, -2, -32 },
  { 12370, 35, 46, 26, -6, -32 },
  { 12572, 27, 32, 26, -1, -32 },
  { 12680, 22, 52, 20, 1, -43 },
  { 12823, 3, 60, 33, 16, -46 },
  { 12846, 23, 52, 20, -3, -43 },
  { 12996, 28, 6, 34, 4, -24 },
};

const GFXfont NotoSans_LightItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_LIGHTITALIC60PT7B_H_
