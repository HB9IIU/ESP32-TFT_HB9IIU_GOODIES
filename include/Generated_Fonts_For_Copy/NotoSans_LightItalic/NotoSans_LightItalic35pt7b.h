#ifndef _NOTOSANS_LIGHTITALIC35PT7B_H_
#define _NOTOSANS_LIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0xE0, 0xE0, 0x71, 0xB0, 0xD8, 0xCC, 0x64, 0x36, 0x1B, 0x09, 0x84, 0x86,
  0x00, 0x00, 0x20, 0x60, 0x03, 0x02, 0x00, 0x18, 0x10, 0x00, 0x81, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x10, 0x30, 0x3F, 0xFF,
  0xF8, 0x0C, 0x18, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x20, 0x01,
  0x83, 0x00, 0x08, 0x18, 0x00, 0xC0, 0x80, 0xFF, 0xFF, 0xE0, 0x20, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x04, 0x0C, 0x00, 0x60,
  0x40, 0x03, 0x06, 0x00, 0x10, 0x30, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x1F, 0xF8, 0x39, 0x9C, 0x38, 0xC0, 0x18, 0x40,
  0x08, 0x20, 0x0C, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xE4, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xCC, 0x00, 0x43, 0x00, 0x21, 0x80,
  0x30, 0xC0, 0x18, 0x60, 0x08, 0x62, 0x04, 0x71, 0xFF, 0xF0, 0x7F, 0xE0,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x18,
  0x33, 0x80, 0x60, 0xC3, 0x00, 0xC3, 0x06, 0x03, 0x06, 0x0C, 0x0C, 0x08,
  0x18, 0x10, 0x30, 0x30, 0x60, 0x60, 0x61, 0x80, 0xC0, 0xC6, 0x01, 0x81,
  0x08, 0x03, 0x06, 0x33, 0xE6, 0x0C, 0xCE, 0x6C, 0x33, 0x30, 0xDC, 0xC6,
  0x60, 0xDF, 0x19, 0x81, 0x80, 0x63, 0x03, 0x01, 0x86, 0x04, 0x03, 0x08,
  0x08, 0x0C, 0x30, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC0, 0xC1, 0x81, 0x83,
  0x06, 0x03, 0x06, 0x18, 0x03, 0x38, 0x60, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0x9C, 0x00, 0x38, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C,
  0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x06, 0x70,
  0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x60, 0x00, 0x39, 0xC0, 0x73,
  0x83, 0x01, 0x8C, 0x06, 0x0C, 0x60, 0x1C, 0x31, 0x80, 0x31, 0x8C, 0x00,
  0x6C, 0x30, 0x00, 0xF0, 0xE0, 0x03, 0x81, 0x80, 0x1E, 0x07, 0x01, 0xCC,
  0x0F, 0x3E, 0x38, 0x1F, 0xE0, 0x70, 0x76, 0x66, 0x4C, 0xCC, 0x80, 0x00,
  0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x60, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x00, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x0C, 0x18, 0x1E, 0x30, 0x0F, 0x40, 0x07, 0xBF,
  0x03, 0xFE, 0x0F, 0x00, 0x32, 0x00, 0xC6, 0x03, 0x0C, 0x0C, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x0C, 0x71, 0x86, 0x30, 0xC6, 0x18, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xCF, 0x01,
  0x81, 0xC1, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x18, 0xC0, 0x06, 0x60, 0x03,
  0x70, 0x01, 0xB0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x0E, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x03, 0x98,
  0x01, 0x8E, 0x01, 0xC3, 0x00, 0xC1, 0xC1, 0xC0, 0x7B, 0xC0, 0x1F, 0xC0,
  0x00, 0x01, 0xC0, 0xF0, 0xF8, 0x76, 0x71, 0xB8, 0x60, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0x00, 0xFF, 0x00,
  0xF9, 0xE0, 0x70, 0x1C, 0x08, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xE7, 0x83, 0x80,
  0xE1, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x62, 0x00, 0x71, 0xF3, 0xF0, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x00, 0xD8,
  0x00, 0x33, 0x00, 0x0C, 0x60, 0x03, 0x08, 0x00, 0xC3, 0x00, 0x38, 0x60,
  0x0E, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x81,
  0x80, 0x30, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x08, 0x01, 0xC3, 0xF7, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0xFC, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x20, 0x18, 0xFE, 0x0D, 0xC3, 0x87, 0x80,
  0xE3, 0x80, 0x31, 0x80, 0x19, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30,
  0x01, 0x98, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0xE1, 0xC0, 0xE0, 0x7D, 0xE0,
  0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xCF, 0x03, 0x80, 0xC1, 0x80, 0x70, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06,
  0x18, 0x06, 0x0C, 0x07, 0x07, 0x07, 0x01, 0xCE, 0x00, 0x3C, 0x00, 0x7E,
  0x00, 0xE1, 0xC0, 0xC0, 0x70, 0xC0, 0x18, 0xC0, 0x0E, 0x60, 0x03, 0x30,
  0x01, 0x98, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x60, 0xF9, 0xE0,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0x9C, 0x0C, 0x06, 0x18, 0x03, 0x38,
  0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60,
  0x07, 0x30, 0x07, 0x30, 0x0B, 0x1C, 0x3E, 0x0F, 0xE6, 0x01, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xE0, 0xEF, 0xC0, 0xFF, 0x00, 0x0C, 0x71, 0xC2, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x8E, 0x00, 0x01, 0x81, 0xC0, 0xE0,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x1C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x3F, 0xC7, 0xDE, 0x40, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x18, 0x18, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x31, 0x80, 0x3E, 0x06, 0x30, 0x1F, 0xF0, 0x4C, 0x0E, 0x04,
  0x09, 0x83, 0x81, 0x81, 0xA0, 0x60, 0x30, 0x3C, 0x18, 0x06, 0x05, 0x83,
  0x01, 0x81, 0xB0, 0x40, 0x30, 0x36, 0x18, 0x06, 0x06, 0xC3, 0x01, 0xC1,
  0x98, 0x20, 0x30, 0x33, 0x06, 0x0B, 0x0C, 0x60, 0xE7, 0x67, 0x0C, 0x0F,
  0x87, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x04, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xD8,
  0x00, 0x0D, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0x70,
  0x80, 0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x18,
  0x0C, 0x03, 0x00, 0xC0, 0x7F, 0xFC, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x0C,
  0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x66,
  0x00, 0x03, 0xE0, 0x00, 0x30, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0xC0, 0x1C,
  0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x61, 0x80, 0x70, 0xFF, 0xF0, 0x3F, 0xFC, 0x0C, 0x01,
  0x83, 0x00, 0x30, 0xC0, 0x0E, 0x60, 0x03, 0x98, 0x00, 0x66, 0x00, 0x39,
  0x80, 0x0C, 0x60, 0x03, 0x30, 0x01, 0xCC, 0x01, 0xE3, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x1E, 0x00, 0x87, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFB, 0xF0, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x0C, 0x03, 0xC0, 0xC0, 0x0E,
  0x0C, 0x00, 0x60, 0xC0, 0x07, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00,
  0x31, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00,
  0x03, 0x30, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x60,
  0x00, 0xC6, 0x00, 0x18, 0x60, 0x03, 0x8C, 0x00, 0xF0, 0xC0, 0x3C, 0x0F,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xE0, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0x80, 0x30, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x1F, 0xEC, 0x01, 0xFE, 0xC0, 0x20,
  0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0xCE, 0x00,
  0x18, 0x60, 0x01, 0x87, 0x00, 0x18, 0x38, 0x01, 0x81, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x07,
  0xF0, 0x3C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0xFE,
  0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x1F, 0xE0, 0x3F, 0x80, 0x00,
  0x06, 0x00, 0x70, 0x60, 0x0E, 0x0C, 0x01, 0xC0, 0xC0, 0x38, 0x0C, 0x07,
  0x00, 0xC0, 0xE0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x18, 0x60, 0x01, 0x8C,
  0x00, 0x19, 0x80, 0x03, 0x38, 0x00, 0x36, 0xC0, 0x03, 0xCC, 0x00, 0x30,
  0xE0, 0x03, 0x06, 0x00, 0x60, 0x70, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xE0,
  0xC0, 0x06, 0x00, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xD0, 0x00,
  0x6C, 0x1B, 0x00, 0x1D, 0x86, 0x60, 0x03, 0x60, 0xCC, 0x00, 0xCC, 0x19,
  0x80, 0x19, 0x83, 0x30, 0x06, 0x30, 0x62, 0x00, 0xC6, 0x18, 0x40, 0x31,
  0x83, 0x0C, 0x0C, 0x30, 0x61, 0x81, 0x86, 0x0C, 0x30, 0x60, 0xC1, 0x86,
  0x0C, 0x18, 0x60, 0xC3, 0x06, 0x0C, 0x08, 0x60, 0xC1, 0x81, 0x98, 0x18,
  0x30, 0x36, 0x03, 0x04, 0x06, 0xC0, 0xE1, 0x80, 0xF0, 0x18, 0x30, 0x1E,
  0x03, 0x06, 0x03, 0x80, 0x60, 0xC0, 0x30, 0x0C, 0x00, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0xF0, 0x00, 0xC3, 0xC0, 0x06, 0x0D, 0x80, 0x18, 0x36,
  0x00, 0x61, 0x98, 0x01, 0x86, 0x30, 0x06, 0x18, 0xC0, 0x30, 0x61, 0x80,
  0xC1, 0x86, 0x03, 0x0C, 0x18, 0x0C, 0x30, 0x30, 0x30, 0xC0, 0xC1, 0x83,
  0x01, 0x86, 0x0C, 0x06, 0x18, 0x60, 0x18, 0x61, 0x80, 0x31, 0x86, 0x00,
  0xCC, 0x18, 0x01, 0xB0, 0x60, 0x06, 0xC3, 0x00, 0x1B, 0x0C, 0x00, 0x38,
  0x30, 0x00, 0xE0, 0xC0, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0x3E, 0x01,
  0xC0, 0x38, 0x18, 0x00, 0xE1, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00,
  0xEE, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x76, 0x00, 0x03, 0x30, 0x00, 0x19, 0xC0, 0x01, 0x86, 0x00,
  0x1C, 0x38, 0x01, 0xC0, 0xE0, 0x1C, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xC0, 0x38, 0x30, 0x06, 0x0C, 0x01, 0xC3,
  0x00, 0x30, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80,
  0x38, 0xC0, 0x1C, 0x30, 0x1E, 0x0F, 0xFF, 0x03, 0xFC, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0x3E, 0x01, 0xC0, 0x38, 0x18, 0x00, 0xE1, 0x80, 0x03, 0x1C, 0x00,
  0x18, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x19, 0xC0,
  0x01, 0x86, 0x00, 0x1C, 0x38, 0x01, 0xC0, 0xE0, 0x1C, 0x03, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0xC0, 0x38, 0x30, 0x06, 0x0C, 0x01, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x60,
  0x03, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x38, 0xC0, 0x1C, 0x3F, 0xFE,
  0x0F, 0xFC, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x01, 0x81, 0x80, 0x60, 0x60, 0x1C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00,
  0x38, 0xC0, 0x06, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0x80, 0x41, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE2, 0x00, 0xE1, 0xF7, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x0E, 0x30, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x70,
  0x03, 0x81, 0xC0, 0x38, 0x07, 0xDF, 0x80, 0x1F, 0xF0, 0x00, 0xE0, 0x00,
  0xEC, 0x00, 0x19, 0x80, 0x07, 0x30, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x06,
  0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60,
  0x18, 0x0C, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x18, 0x01, 0x87, 0x00,
  0x30, 0xC0, 0x02, 0x38, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x3C, 0x00, 0xE0, 0x06, 0xC0, 0x0E, 0x00, 0x6C, 0x01, 0xA0, 0x0E,
  0xC0, 0x1A, 0x00, 0xCC, 0x03, 0x20, 0x0C, 0xC0, 0x32, 0x01, 0x8C, 0x02,
  0x30, 0x18, 0xC0, 0x63, 0x03, 0x04, 0x06, 0x30, 0x30, 0x40, 0xC3, 0x06,
  0x06, 0x0C, 0x30, 0x60, 0x61, 0x83, 0x0C, 0x06, 0x18, 0x30, 0xC0, 0x63,
  0x03, 0x1C, 0x06, 0x30, 0x31, 0x80, 0x66, 0x03, 0x18, 0x06, 0x60, 0x33,
  0x00, 0x6C, 0x03, 0x30, 0x06, 0xC0, 0x36, 0x00, 0x78, 0x01, 0x60, 0x07,
  0x80, 0x14, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C,
  0x03, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x10, 0x60, 0x00, 0x31,
  0x80, 0x00, 0x67, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x66, 0x00,
  0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x18, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x38, 0x00, 0xC0, 0xE0,
  0x00, 0xC0, 0xC0, 0x01, 0xD8, 0x00, 0xE6, 0x00, 0x31, 0x80, 0x18, 0x30,
  0x0E, 0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x18, 0x70, 0x06, 0x18,
  0x01, 0x8C, 0x00, 0x27, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0xC3, 0x0C, 0x30, 0xC1, 0x04, 0x18, 0x61,
  0x86, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0x41, 0x06, 0x18, 0x61, 0x86, 0x0C,
  0x01, 0xFC, 0x07, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0x20, 0x03, 0x30, 0x06, 0x10, 0x06, 0x18, 0x0C, 0x18, 0x0C,
  0x08, 0x18, 0x0C, 0x30, 0x04, 0x30, 0x06, 0x60, 0x06, 0x60, 0x02, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x18, 0x61, 0x0C, 0x03, 0xE1, 0x83,
  0xFC, 0x87, 0x06, 0xC3, 0x01, 0xE3, 0x00, 0x73, 0x80, 0x39, 0x80, 0x18,
  0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00,
  0xC6, 0x00, 0xE3, 0x00, 0xF1, 0x80, 0x50, 0xE0, 0xD8, 0x3D, 0xCC, 0x0F,
  0xC6, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x3C, 0x06, 0x7F, 0x82,
  0x60, 0xC3, 0x40, 0x31, 0xE0, 0x18, 0xE0, 0x0C, 0x60, 0x06, 0x70, 0x03,
  0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x77, 0x00, 0x33, 0x80,
  0x19, 0xC0, 0x18, 0xE0, 0x1C, 0x58, 0x1C, 0x67, 0x3C, 0x31, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0xF1, 0xE0, 0x46, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF3, 0x81, 0xFE, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x03, 0xE1, 0x80, 0xFF, 0x30, 0x70, 0x34,
  0x0C, 0x03, 0x83, 0x00, 0x70, 0xE0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x30,
  0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x07, 0x0C, 0x00, 0xC1,
  0x80, 0x38, 0x30, 0x07, 0x06, 0x01, 0x60, 0xE0, 0x6C, 0x0F, 0x71, 0x00,
  0xFC, 0x60, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xE1, 0xC6, 0x03, 0x30, 0x0D,
  0xC0, 0x36, 0x01, 0xD8, 0x0E, 0xC3, 0xF3, 0xFF, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x10, 0xF3, 0xC1, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x13, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0xC0, 0xFF, 0x30, 0xE0, 0x68, 0x30, 0x0E, 0x18, 0x03,
  0x8E, 0x00, 0xE3, 0x00, 0x38, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x1C, 0x60, 0x06, 0x18, 0x03, 0x86, 0x00, 0xE1, 0x80,
  0x58, 0x70, 0x34, 0x0F, 0x73, 0x01, 0xF8, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x80, 0x70, 0x38, 0xF8, 0x07,
  0xFC, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x3C, 0x06, 0x7F, 0x82,
  0x60, 0xC3, 0x40, 0x31, 0xE0, 0x18, 0xE0, 0x0C, 0x60, 0x06, 0x70, 0x06,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x66, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x0E, 0x60, 0x06, 0x30, 0x03, 0x00,
  0x02, 0x07, 0x06, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0xC0, 0x00, 0x08, 0x00, 0x70, 0x01, 0x80, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x9C, 0x03,
  0xE0, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x03, 0x86, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x63, 0x00,
  0x33, 0x00, 0x1B, 0xC0, 0x0F, 0x60, 0x07, 0x18, 0x07, 0x0C, 0x03, 0x03,
  0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x60, 0x1C, 0x30, 0x06, 0x00,
  0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60,
  0x60, 0xC0, 0xC0, 0x0C, 0x7C, 0x0F, 0x81, 0x1F, 0xC3, 0xF8, 0x26, 0x19,
  0xC3, 0x8D, 0x01, 0xA0, 0x31, 0xC0, 0x38, 0x06, 0x38, 0x07, 0x00, 0xC6,
  0x00, 0xC0, 0x19, 0xC0, 0x18, 0x03, 0x30, 0x06, 0x00, 0xC6, 0x00, 0xC0,
  0x18, 0xC0, 0x18, 0x03, 0x18, 0x03, 0x00, 0x66, 0x00, 0xC0, 0x0C, 0xC0,
  0x18, 0x03, 0x18, 0x03, 0x00, 0x63, 0x00, 0x60, 0x0C, 0x60, 0x0C, 0x01,
  0x98, 0x03, 0x00, 0x33, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x7E, 0x06, 0x7F,
  0x86, 0x60, 0xC3, 0x60, 0x31, 0xE0, 0x18, 0xE0, 0x0C, 0x60, 0x06, 0x70,
  0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xE6, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x0E, 0x60, 0x06, 0x30, 0x03,
  0x00, 0x01, 0xF0, 0x07, 0xFC, 0x1C, 0x0E, 0x18, 0x06, 0x30, 0x07, 0x60,
  0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xE0, 0x1C, 0x60, 0x38, 0x3C,
  0xF0, 0x1F, 0xC0, 0x03, 0x0F, 0x00, 0x47, 0xF8, 0x09, 0x83, 0x03, 0x60,
  0x30, 0x78, 0x06, 0x0E, 0x00, 0xC1, 0x80, 0x18, 0x70, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x01,
  0x87, 0x00, 0x60, 0xE0, 0x1C, 0x16, 0x07, 0x06, 0x73, 0xC0, 0xC7, 0xE0,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xE1, 0x83, 0xFC,
  0xC7, 0x03, 0x43, 0x00, 0xE3, 0x00, 0x73, 0x80, 0x39, 0x80, 0x1C, 0xC0,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xC6,
  0x00, 0xE3, 0x00, 0x71, 0x80, 0x58, 0xE0, 0x6C, 0x3D, 0xEC, 0x0F, 0xC6,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x78, 0x47, 0xC2, 0x60, 0x36,
  0x01, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xC0, 0x46, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x80, 0x73, 0xEF, 0x87, 0xFC, 0x00, 0x0C,
  0x03, 0x00, 0x80, 0x60, 0x3F, 0xFF, 0xF3, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x39, 0x87, 0xE0, 0x18, 0x01, 0x8C, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x19, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30,
  0x03, 0x18, 0x03, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0xF1,
  0x80, 0x50, 0xC0, 0xD8, 0x39, 0xCC, 0x0F, 0xC6, 0x00, 0xC0, 0x07, 0x80,
  0x1B, 0x00, 0x36, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x18, 0x1C, 0x30, 0x30,
  0x60, 0xE0, 0xC1, 0x81, 0x86, 0x03, 0x0C, 0x06, 0x30, 0x0C, 0x60, 0x09,
  0x80, 0x1B, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0F, 0x01, 0xE0, 0x36, 0x03, 0xC0, 0x6C, 0x0D, 0x81, 0x98,
  0x1B, 0x03, 0x30, 0x66, 0x0C, 0x60, 0xCC, 0x18, 0xC3, 0x18, 0x61, 0x86,
  0x30, 0xC3, 0x18, 0x23, 0x82, 0x30, 0x46, 0x04, 0xC0, 0xCC, 0x09, 0x81,
  0xB0, 0x1A, 0x03, 0x60, 0x2C, 0x07, 0x80, 0x50, 0x0F, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x38, 0x00, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0x60, 0x30, 0x18,
  0x18, 0x03, 0x0E, 0x00, 0xC7, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1E, 0x00, 0x0D, 0x80, 0x07, 0x30, 0x03, 0x8C, 0x00,
  0xC1, 0x80, 0x60, 0x60, 0x30, 0x18, 0x18, 0x03, 0x0E, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0x80, 0x60, 0x06, 0x03, 0x00, 0x30, 0x30, 0x01, 0x83, 0x80, 0x0C,
  0x18, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x04, 0x70, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFE,
  0x1F, 0xFC, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x78,
  0x07, 0x80, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x03, 0xC0, 0x1C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x03, 0x80, 0x1F, 0x00, 0x08,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0,
  0x1F, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0xE0, 0x07,
  0x00, 0xE0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x3C, 0x02, 0x00,
  0x00, 0x7E, 0x01, 0xEF, 0xC3, 0x81, 0xFE, 0x00, 0x10,
};

const GFXglyph NotoSans_LightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 25, 8, 1, -25 },
  { 26, 9, 9, 12, 4, -25 },
  { 37, 21, 25, 22, 1, -25 },
  { 103, 17, 29, 19, 1, -27 },
  { 165, 23, 25, 27, 3, -25 },
  { 237, 22, 25, 24, 1, -25 },
  { 306, 4, 9, 7, 4, -25 },
  { 311, 11, 31, 9, 1, -25 },
  { 354, 10, 31, 9, -2, -25 },
  { 393, 15, 16, 19, 4, -27 },
  { 423, 16, 17, 20, 3, -21 },
  { 457, 6, 9, 8, -2, -4 },
  { 464, 9, 2, 11, 1, -10 },
  { 467, 3, 3, 8, 1, -3 },
  { 469, 17, 25, 12, -2, -25 },
  { 523, 17, 25, 19, 2, -25 },
  { 577, 10, 25, 19, 5, -25 },
  { 609, 18, 25, 19, 0, -25 },
  { 666, 17, 25, 19, 1, -25 },
  { 720, 19, 25, 19, 0, -25 },
  { 780, 18, 25, 19, 1, -25 },
  { 837, 17, 25, 19, 2, -25 },
  { 891, 17, 25, 19, 3, -25 },
  { 945, 17, 25, 19, 2, -25 },
  { 999, 16, 25, 19, 2, -25 },
  { 1049, 6, 19, 8, 1, -19 },
  { 1064, 9, 24, 8, -2, -19 },
  { 1091, 16, 17, 20, 3, -21 },
  { 1125, 16, 9, 20, 3, -17 },
  { 1143, 16, 17, 20, 3, -21 },
  { 1177, 12, 25, 15, 3, -25 },
  { 1215, 27, 28, 29, 2, -25 },
  { 1310, 20, 25, 19, -2, -25 },
  { 1373, 18, 25, 21, 2, -25 },
  { 1430, 19, 25, 21, 3, -25 },
  { 1490, 20, 25, 24, 2, -25 },
  { 1553, 18, 25, 18, 2, -25 },
  { 1610, 18, 25, 17, 2, -25 },
  { 1667, 20, 25, 24, 3, -25 },
  { 1730, 22, 25, 24, 2, -25 },
  { 1799, 12, 25, 11, 0, -25 },
  { 1837, 15, 31, 9, -6, -25 },
  { 1896, 20, 25, 19, 2, -25 },
  { 1959, 13, 25, 17, 2, -25 },
  { 2000, 27, 25, 29, 2, -25 },
  { 2085, 22, 25, 24, 2, -25 },
  { 2154, 21, 25, 25, 3, -25 },
  { 2220, 18, 25, 20, 2, -25 },
  { 2277, 21, 31, 25, 3, -25 },
  { 2359, 18, 25, 20, 2, -25 },
  { 2416, 17, 25, 18, 1, -25 },
  { 2470, 17, 25, 17, 3, -25 },
  { 2524, 21, 25, 24, 3, -25 },
  { 2590, 19, 25, 19, 3, -25 },
  { 2650, 28, 25, 29, 4, -25 },
  { 2738, 23, 25, 18, -2, -25 },
  { 2810, 18, 25, 17, 3, -25 },
  { 2867, 20, 25, 19, 0, -25 },
  { 2930, 13, 31, 10, 0, -25 },
  { 2981, 6, 25, 12, 4, -25 },
  { 3000, 14, 31, 10, -3, -25 },
  { 3055, 16, 15, 20, 2, -25 },
  { 3085, 14, 2, 13, -3, 3 },
  { 3089, 5, 6, 9, 5, -27 },
  { 3093, 17, 19, 20, 2, -19 },
  { 3134, 17, 27, 20, 1, -27 },
  { 3192, 14, 19, 16, 2, -19 },
  { 3226, 19, 27, 20, 2, -27 },
  { 3291, 14, 19, 17, 2, -19 },
  { 3325, 19, 35, 10, -4, -27 },
  { 3409, 18, 27, 20, 1, -19 },
  { 3470, 17, 27, 20, 1, -27 },
  { 3528, 8, 26, 8, 1, -26 },
  { 3554, 14, 34, 8, -5, -26 },
  { 3614, 17, 27, 16, 1, -27 },
  { 3672, 8, 27, 8, 1, -27 },
  { 3699, 27, 19, 30, 1, -19 },
  { 3764, 17, 19, 20, 1, -19 },
  { 3805, 16, 19, 20, 2, -19 },
  { 3843, 19, 27, 20, -1, -19 },
  { 3908, 17, 27, 20, 2, -19 },
  { 3966, 13, 19, 13, 1, -19 },
  { 3997, 14, 19, 15, 0, -19 },
  { 4031, 10, 23, 11, 2, -23 },
  { 4060, 17, 19, 20, 2, -19 },
  { 4101, 15, 19, 15, 2, -19 },
  { 4137, 23, 19, 24, 2, -19 },
  { 4192, 18, 19, 16, -1, -19 },
  { 4235, 21, 27, 15, -4, -19 },
  { 4306, 15, 19, 15, 0, -19 },
  { 4342, 13, 31, 12, 1, -25 },
  { 4393, 2, 35, 19, 9, -27 },
  { 4402, 13, 31, 12, -2, -25 },
  { 4453, 16, 4, 20, 3, -14 },
};

const GFXfont NotoSans_LightItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_LIGHTITALIC35PT7B_H_
