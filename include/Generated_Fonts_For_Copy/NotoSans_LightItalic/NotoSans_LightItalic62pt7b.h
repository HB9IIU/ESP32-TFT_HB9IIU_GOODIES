#ifndef _NOTOSANS_LIGHTITALIC62PT7B_H_
#define _NOTOSANS_LIGHTITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x06, 0x00, 0x00, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x1E, 0x38,
  0x1E, 0x38, 0x1C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70,
  0x38, 0x60, 0x38, 0xE0, 0x38, 0xE0, 0x30, 0xE0, 0x30, 0xC0, 0x70, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0xFE, 0x73,
  0xF8, 0x0F, 0x83, 0x81, 0x80, 0xF8, 0x18, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x78, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0,
  0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x3E, 0x18, 0x00, 0x00, 0xF9, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0E, 0x7E, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x38, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x07, 0x82, 0x00, 0x60,
  0x7C, 0x18, 0x07, 0x07, 0xC0, 0xFC, 0x39, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0x80, 0x00, 0x38,
  0x07, 0x83, 0xC0, 0x00, 0x70, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x1E, 0x01,
  0xC0, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x3C, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x70, 0x00,
  0xF0, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x03,
  0x81, 0xC0, 0x00, 0xE0, 0x03, 0x83, 0x83, 0xF8, 0xE0, 0x07, 0x07, 0x07,
  0xFC, 0xE0, 0x07, 0x0F, 0x1F, 0xFE, 0xE0, 0x0E, 0x0E, 0x1E, 0x0F, 0xF0,
  0x0E, 0x1C, 0x38, 0x07, 0x70, 0x1C, 0x3C, 0x78, 0x07, 0x78, 0x7C, 0x78,
  0x70, 0x07, 0x3F, 0xF8, 0x70, 0xF0, 0x07, 0x1F, 0xE0, 0xE0, 0xE0, 0x07,
  0x07, 0xC1, 0xE0, 0xE0, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x07, 0x00, 0x03,
  0x81, 0xC0, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x1C,
  0x03, 0xC0, 0x03, 0x80, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x07, 0x00,
  0x01, 0xC0, 0xF0, 0x0E, 0x00, 0x01, 0xF1, 0xE0, 0x1E, 0x00, 0x00, 0xFF,
  0xC0, 0x3C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x7E, 0x00,
  0x00, 0x00, 0xF7, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x1F, 0x01,
  0xE0, 0x00, 0xE0, 0xF0, 0x03, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x00, 0x1C,
  0x3C, 0x00, 0x1E, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x03, 0x87, 0x80, 0x00,
  0xF0, 0x1E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x70, 0x00, 0x03, 0xC7, 0x81,
  0xC0, 0x00, 0x07, 0x9C, 0x0F, 0x00, 0x00, 0x1E, 0xF0, 0x3C, 0x00, 0x00,
  0x3F, 0x80, 0x70, 0x00, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0x1F, 0xC0, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x3C, 0x00, 0x0F,
  0x8F, 0x00, 0xFC, 0x00, 0xFC, 0x3C, 0x01, 0xFF, 0x7F, 0xC0, 0x78, 0x03,
  0xFF, 0xFE, 0x00, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0xF3, 0xCE, 0x38, 0xE7, 0x9C, 0x71, 0xC7, 0x18, 0xE3,
  0x8E, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x10, 0x01, 0xC0,
  0x03, 0x80, 0x38, 0x00, 0xFC, 0x07, 0x00, 0x0F, 0xE0, 0xC0, 0x00, 0x7E,
  0x18, 0x00, 0x01, 0xF7, 0x00, 0x10, 0x0F, 0xDF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x1C, 0x00,
  0x3C, 0x03, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xC0, 0x07, 0x00, 0x08, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80,
  0xE0, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x30, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x70, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0xF8, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF,
  0x03, 0xEE, 0x0F, 0xCE, 0x1F, 0x9E, 0x7E, 0x1E, 0xFC, 0x1E, 0xF0, 0x1C,
  0x40, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x10, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x81, 0xF8,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x40, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x60, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x01, 0xFF,
  0xBF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFC, 0x06, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x03, 0x00, 0x03, 0xC1,
  0xFF, 0x80, 0x0F, 0x1F, 0xFF, 0x80, 0x38, 0xFE, 0xFF, 0x00, 0xE7, 0x80,
  0x3E, 0x07, 0xB8, 0x00, 0x78, 0x1F, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3E,
  0x00, 0x7C, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x0F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0xFC, 0x3C, 0x00, 0x0F, 0xC1, 0xF0, 0x01, 0xEE, 0x07, 0xC0, 0x3E, 0xF0,
  0x1F, 0xFF, 0xE7, 0x80, 0x7F, 0xFC, 0x38, 0x00, 0xFF, 0x83, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x04, 0x00, 0x7F,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x78, 0x0F, 0x83, 0xF0, 0x7C, 0x07,
  0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1E, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC,
  0x18, 0x00, 0xF8, 0x80, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x0E, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0x0E, 0x0E, 0x00, 0x0F, 0xFF,
  0xE0, 0x0E, 0x1E, 0x00, 0x3F, 0x01, 0xE0, 0x0E, 0x1C, 0x00, 0x7C, 0x00,
  0xE0, 0x0E, 0x1C, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x38, 0x01, 0xE0, 0x01,
  0xC0, 0x0F, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x78, 0x03, 0xC0, 0x03,
  0xC0, 0x0E, 0x70, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x70, 0x07, 0x00, 0x03,
  0x80, 0x0E, 0x70, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x70, 0x07, 0x00, 0x07,
  0x80, 0x0E, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0x1E, 0xF0, 0x0E, 0x00, 0x07,
  0x00, 0x1C, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0x1C, 0xF0, 0x0E, 0x00, 0x0F,
  0x00, 0x3C, 0xF0, 0x0E, 0x00, 0x1F, 0x00, 0x38, 0xF0, 0x0E, 0x00, 0x1E,
  0x00, 0x78, 0xF0, 0x0F, 0x00, 0x3F, 0x00, 0xF0, 0x70, 0x0F, 0x00, 0x77,
  0x00, 0xE0, 0x70, 0x07, 0x80, 0xE7, 0x03, 0xE0, 0x70, 0x07, 0xE7, 0xC7,
  0xCF, 0xC0, 0x70, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x78, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x07,
  0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x0E, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3C, 0x00,
  0x7F, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0x00,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x0F, 0x80,
  0x70, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x3F,
  0x80, 0x03, 0x80, 0x1F, 0x80, 0x00, 0x20, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xE0, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x3E, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0xF8, 0x0E, 0x00,
  0x00, 0x0F, 0x80, 0x70, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x07,
  0xF8, 0x00, 0x70, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xE0,
  0x07, 0xE0, 0x00, 0x02, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xCF, 0x00, 0x01, 0xFF,
  0xF8, 0xF0, 0x00, 0x1F, 0xFF, 0x8F, 0x00, 0x01, 0xFF, 0xF8, 0xF0, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x02, 0x03, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x03, 0x80, 0x00, 0x1F,
  0x00, 0x1C, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x1C,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x00, 0x70, 0x3E, 0x00, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0x00,
  0x73, 0xF8, 0x00, 0x00, 0x03, 0xBD, 0xE0, 0x00, 0x00, 0x3F, 0xCF, 0x00,
  0x00, 0x01, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xEE,
  0x00, 0x00, 0x01, 0xDE, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xDC, 0x01, 0xEF,
  0x00, 0x00, 0x07, 0x9C, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x3C, 0x01, 0xC7,
  0x00, 0x00, 0x0F, 0x3C, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x3C, 0x03, 0xC7,
  0x00, 0x00, 0x1E, 0x38, 0x03, 0xC7, 0x00, 0x00, 0x1C, 0x38, 0x03, 0x87,
  0x00, 0x00, 0x3C, 0x78, 0x03, 0x87, 0x80, 0x00, 0x78, 0x78, 0x03, 0x83,
  0x80, 0x00, 0x70, 0x78, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x07, 0x83,
  0x80, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0xF0, 0x07, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x0F, 0x03,
  0xC0, 0x07, 0x80, 0xE0, 0x0F, 0x01, 0xC0, 0x07, 0x01, 0xE0, 0x0E, 0x01,
  0xC0, 0x0F, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x1E, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x70, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0xF0, 0x03, 0x80, 0x3C, 0x00,
  0xE0, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE1, 0xE0, 0x07, 0x80, 0x38, 0x00,
  0xE1, 0xC0, 0x07, 0x80, 0x38, 0x00, 0xF3, 0x80, 0x07, 0x80, 0x78, 0x00,
  0x77, 0x80, 0x07, 0x00, 0x78, 0x00, 0x77, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x7F, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x7E, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x00,
  0x0E, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0x00, 0xEF, 0x00,
  0x00, 0x1C, 0x01, 0xE7, 0x00, 0x00, 0x3C, 0x01, 0xC7, 0x80, 0x00, 0x3C,
  0x01, 0xC7, 0x80, 0x00, 0x3C, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x03, 0xC3,
  0xC0, 0x00, 0x38, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x03, 0x81, 0xE0, 0x00,
  0x78, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x07,
  0x80, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x1E, 0x00, 0x0E, 0x01,
  0xC0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x1C,
  0x00, 0x07, 0x83, 0xC0, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x3C, 0x00, 0x03,
  0x83, 0x80, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x3C, 0x00, 0x01, 0xC7, 0x80,
  0x38, 0x00, 0x01, 0xE7, 0x80, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x78, 0x00,
  0x00, 0xE7, 0x00, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0x00, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x00, 0x7E, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xF0, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF8, 0x07,
  0x00, 0x03, 0xF0, 0x0F, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x07, 0x00,
  0x03, 0xF0, 0x07, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFE,
  0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0x80, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x80, 0x00, 0x3F,
  0x01, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x70,
  0x01, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1C, 0xE0,
  0x00, 0x3C, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x03, 0xCE,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0xE3, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x78,
  0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x07, 0x00, 0x0F,
  0x07, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x80, 0x70, 0x01,
  0xE0, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x07, 0x00,
  0x3C, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x1E, 0x00, 0x78,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x07,
  0x80, 0xF0, 0x07, 0x00, 0xF0, 0x01, 0xE0, 0x38, 0x01, 0xC0, 0x78, 0x00,
  0x78, 0x1E, 0x00, 0x70, 0x1E, 0x00, 0x1E, 0x07, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x81, 0xC0, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1C,
  0x00, 0x03, 0x87, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0xE3,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x0E,
  0x78, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x1E, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x78, 0x03, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0,
  0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x70, 0x07, 0xFF, 0xC1, 0xC0, 0x3F, 0xDF,
  0x8E, 0x01, 0xF0, 0x0F, 0x38, 0x0F, 0x80, 0x0C, 0xE0, 0x7C, 0x00, 0x3B,
  0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7E, 0x0F,
  0x00, 0x01, 0xF8, 0x1C, 0x00, 0x0D, 0xC0, 0x78, 0x00, 0x77, 0x01, 0xE0,
  0x03, 0x9C, 0x03, 0xC0, 0x3C, 0x70, 0x0F, 0xE7, 0xE3, 0x80, 0x1F, 0xFF,
  0x0E, 0x00, 0x1F, 0xF0, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x30, 0x00, 0x1C, 0x0F, 0xF8, 0x00, 0x70, 0xFF, 0xF8, 0x03, 0xC7,
  0xE7, 0xF0, 0x0F, 0x3C, 0x03, 0xE0, 0x39, 0xC0, 0x07, 0x80, 0xEE, 0x00,
  0x0F, 0x07, 0xF0, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x01,
  0xC1, 0xF0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x1F, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x03, 0xC1, 0xD8, 0x00, 0x1E, 0x07,
  0x70, 0x00, 0xF0, 0x1C, 0xE0, 0x0F, 0xC0, 0xE1, 0xFB, 0xFC, 0x03, 0x83,
  0xFF, 0xE0, 0x0E, 0x07, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xFF, 0xD0, 0x03, 0xFF, 0xF8, 0x03, 0xFE, 0xFE, 0x01,
  0xF8, 0x01, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x03, 0x80, 0x3F, 0xCF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x30, 0x07, 0x80, 0x01, 0xFF, 0x81, 0xC0, 0x01, 0xFF, 0xF8, 0x70,
  0x00, 0xFF, 0x3F, 0x1C, 0x00, 0x7C, 0x01, 0xCF, 0x00, 0x3E, 0x00, 0x3B,
  0xC0, 0x1F, 0x00, 0x06, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x3B, 0x80, 0x1E, 0x00,
  0x1D, 0xE0, 0x07, 0x80, 0x0E, 0x78, 0x00, 0xF0, 0x0F, 0x1C, 0x00, 0x3F,
  0x9F, 0x87, 0x00, 0x07, 0xFF, 0xC1, 0xC0, 0x00, 0x7F, 0xC0, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x03, 0xFD, 0xFC, 0x01, 0xF8, 0x07, 0x80, 0xF8, 0x00, 0xE0,
  0x7C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0xF1, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x0E, 0x00,
  0x07, 0xC7, 0x80, 0x07, 0xE1, 0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0x01, 0xF0, 0x03, 0x80, 0x3F, 0xCF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x0F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xFC, 0x07, 0x00, 0x3F, 0xFF, 0x0E, 0x00, 0x7F, 0x9F, 0x8E, 0x00, 0xF8,
  0x03, 0x8E, 0x01, 0xF0, 0x01, 0xDE, 0x03, 0xE0, 0x00, 0xDC, 0x07, 0xC0,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xE0, 0x78, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x0F, 0xC0, 0x38, 0x00, 0x1D, 0xC0, 0x3C, 0x00,
  0x3B, 0xC0, 0x3C, 0x00, 0x73, 0x80, 0x1E, 0x01, 0xE3, 0x80, 0x1F, 0xCF,
  0xC3, 0x80, 0x0F, 0xFF, 0x87, 0x80, 0x03, 0xFE, 0x07, 0x80, 0x00, 0x60,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x80, 0x00,
  0xF8, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x1C, 0x0F, 0xFC, 0x00, 0x70, 0xFF, 0xF8, 0x03, 0xC7,
  0xF7, 0xF0, 0x0F, 0x3C, 0x03, 0xE0, 0x39, 0xC0, 0x07, 0x80, 0xEE, 0x00,
  0x0E, 0x07, 0xF0, 0x00, 0x38, 0x1F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x03,
  0x81, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x3E, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x87, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x3E,
  0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07,
  0x3F, 0x00, 0x00, 0x7B, 0xF8, 0x00, 0x03, 0xBD, 0xE0, 0x00, 0x1F, 0x87,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x78, 0x07, 0x80,
  0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x1C, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x01, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xC3,
  0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0x87, 0xEF, 0xC0, 0xFD, 0xFC, 0x03, 0x8E,
  0x01, 0xE1, 0xE0, 0x3E, 0x03, 0x9C, 0x00, 0xE3, 0x80, 0x1E, 0x03, 0xB8,
  0x00, 0xE7, 0x00, 0x0E, 0x07, 0xF0, 0x00, 0xF6, 0x00, 0x0F, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0E, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0x03, 0xFF, 0x00, 0x3C, 0x3F, 0xFE, 0x00, 0xE1, 0xFF,
  0xFC, 0x03, 0x8F, 0x00, 0xF8, 0x0E, 0x78, 0x01, 0xE0, 0x3B, 0x80, 0x03,
  0x81, 0xFC, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0xF0,
  0x7C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x0F, 0xF8, 0x00, 0x0E, 0x1F,
  0xFF, 0x00, 0x0E, 0x1F, 0x9F, 0xC0, 0x07, 0x1E, 0x01, 0xF0, 0x03, 0x9C,
  0x00, 0x78, 0x01, 0xDC, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0xFC,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x00, 0xE0, 0x1E,
  0x00, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0xEC, 0x00, 0x0F,
  0x00, 0x77, 0x00, 0x0F, 0x80, 0x39, 0xC0, 0x1F, 0x80, 0x3C, 0x7E, 0xFF,
  0x00, 0x1E, 0x1F, 0xFF, 0x00, 0x0F, 0x07, 0xFE, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x1C, 0x01, 0xFF, 0xF8, 0x70,
  0x07, 0xF9, 0xF8, 0xE0, 0x1F, 0x00, 0x71, 0xC0, 0x7C, 0x00, 0x77, 0x81,
  0xF0, 0x00, 0x6E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F,
  0xC1, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7E, 0x03, 0x80, 0x01, 0xDC,
  0x07, 0x80, 0x07, 0x78, 0x0F, 0x00, 0x1C, 0xF0, 0x0F, 0x00, 0xF1, 0xC0,
  0x1F, 0xCF, 0xC3, 0x80, 0x1F, 0xFF, 0x0F, 0x00, 0x0F, 0xF8, 0x1E, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x09, 0x01, 0xC0, 0xFE, 0x01, 0xC3, 0xFE, 0x03, 0x87, 0xFE, 0x03, 0x8F,
  0x00, 0x03, 0x9C, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xC0, 0x06, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x80, 0x00, 0xF0, 0xE0, 0x03,
  0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x9C, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x1F, 0x83, 0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x03, 0xF0, 0x1C, 0x00,
  0x1D, 0xC0, 0x78, 0x00, 0xE7, 0x01, 0xF0, 0x0F, 0x1C, 0x03, 0xFB, 0xF8,
  0x70, 0x07, 0xFF, 0xC3, 0x80, 0x0F, 0xFC, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0x38,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x01, 0xE0,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80,
  0x70, 0x00, 0x70, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00,
  0x38, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x38,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xDC, 0x00,
  0x0F, 0x80, 0x01, 0xE7, 0x00, 0x03, 0xE0, 0x00, 0x79, 0xC0, 0x01, 0xF8,
  0x00, 0x3C, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0x1C, 0x00, 0x3F, 0x80, 0x07,
  0x87, 0x00, 0x0E, 0xE0, 0x01, 0xE1, 0xC0, 0x07, 0xB8, 0x00, 0xF0, 0x70,
  0x01, 0xCE, 0x00, 0x3C, 0x1C, 0x00, 0xF3, 0xC0, 0x0E, 0x07, 0x00, 0x38,
  0xF0, 0x07, 0x81, 0xC0, 0x1E, 0x1C, 0x01, 0xC0, 0x78, 0x07, 0x07, 0x00,
  0xF0, 0x1E, 0x03, 0xC1, 0xC0, 0x38, 0x07, 0x80, 0xE0, 0x70, 0x1E, 0x01,
  0xE0, 0x78, 0x1C, 0x07, 0x00, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0x1E, 0x0F,
  0x01, 0xC0, 0xF0, 0x07, 0x83, 0x80, 0x70, 0x78, 0x01, 0xE1, 0xE0, 0x1C,
  0x1E, 0x00, 0x38, 0x70, 0x07, 0x0F, 0x00, 0x0E, 0x3C, 0x01, 0xE3, 0xC0,
  0x03, 0x8E, 0x00, 0x78, 0xE0, 0x00, 0xE3, 0x80, 0x1E, 0x78, 0x00, 0x39,
  0xC0, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x03, 0xB8, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x83, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x17, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0xBF, 0xC0, 0x07, 0xFF,
  0xE8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_LightItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 13, 45, 15, 2, -44 },
  { 75, 16, 16, 22, 7, -44 },
  { 107, 38, 44, 39, 2, -44 },
  { 316, 29, 51, 34, 3, -47 },
  { 501, 40, 46, 48, 5, -45 },
  { 731, 38, 46, 42, 2, -45 },
  { 950, 6, 16, 12, 7, -44 },
  { 962, 19, 54, 16, 2, -44 },
  { 1091, 18, 54, 16, -4, -44 },
  { 1213, 27, 27, 34, 7, -47 },
  { 1305, 28, 30, 35, 5, -37 },
  { 1410, 11, 15, 14, -3, -7 },
  { 1431, 15, 3, 19, 2, -18 },
  { 1437, 5, 6, 14, 2, -5 },
  { 1441, 29, 44, 21, -3, -44 },
  { 1601, 29, 46, 34, 4, -45 },
  { 1768, 16, 44, 34, 10, -44 },
  { 1856, 32, 45, 34, 0, -45 },
  { 2036, 32, 46, 34, 1, -45 },
  { 2220, 32, 44, 34, 1, -44 },
  { 2396, 31, 45, 34, 2, -44 },
  { 2571, 30, 46, 34, 4, -45 },
  { 2744, 29, 44, 34, 6, -44 },
  { 2904, 30, 46, 34, 3, -45 },
  { 3077, 29, 46, 34, 3, -45 },
  { 3244, 11, 35, 14, 2, -34 },
  { 3293, 16, 42, 14, -3, -34 },
  { 3377, 28, 29, 35, 5, -37 },
  { 3479, 28, 16, 35, 5, -30 },
  { 3535, 28, 29, 35, 5, -37 },
  { 3637, 22, 46, 26, 5, -45 },
  { 3764, 48, 50, 52, 3, -44 },
  { 4064, 34, 44, 34, -3, -44 },
  { 4251, 33, 44, 37, 3, -44 },
  { 4433, 34, 46, 37, 5, -45 },
  { 4629, 37, 44, 42, 3, -44 },
  { 4833, 32, 44, 33, 3, -44 },
  { 5009, 32, 44, 30, 3, -44 },
  { 5185, 36, 46, 42, 5, -45 },
  { 5392, 39, 44, 42, 3, -44 },
  { 5607, 22, 44, 19, 0, -44 },
  { 5728, 26, 55, 16, -10, -44 },
  { 5907, 37, 44, 34, 3, -44 },
  { 6111, 23, 44, 30, 3, -44 },
  { 6238, 48, 44, 51, 3, -44 },
  { 6502, 40, 44, 43, 3, -44 },
  { 6722, 37, 46, 45, 5, -45 },
  { 6935, 32, 44, 35, 3, -44 },
  { 7111, 37, 56, 45, 5, -45 },
  { 7370, 32, 44, 35, 3, -44 },
  { 7546, 31, 46, 31, 1, -45 },
  { 7725, 30, 44, 31, 6, -44 },
  { 7890, 38, 45, 42, 5, -44 },
  { 8104, 33, 44, 34, 6, -44 },
  { 8286, 50, 44, 52, 7, -44 },
  { 8561, 39, 44, 32, -3, -44 },
  { 8776, 31, 44, 31, 6, -44 },
  { 8947, 36, 44, 33, -1, -44 },
  { 9145, 24, 54, 18, -1, -44 },
  { 9307, 11, 44, 21, 6, -44 },
  { 9368, 23, 54, 18, -4, -44 },
  { 9524, 29, 28, 35, 3, -45 },
  { 9626, 24, 3, 24, -5, 6 },
  { 9635, 9, 9, 16, 9, -47 },
  { 9646, 30, 35, 35, 3, -34 },
  { 9778, 30, 48, 36, 2, -47 },
  { 9958, 26, 35, 28, 3, -34 },
  { 10072, 34, 48, 36, 3, -47 },
  { 10276, 26, 35, 31, 3, -34 },
  { 10390, 35, 62, 18, -8, -47 },
  { 10662, 32, 49, 36, 2, -34 },
  { 10858, 30, 47, 35, 2, -47 },
  { 11035, 13, 45, 14, 2, -45 },
  { 11109, 23, 60, 14, -8, -45 },
  { 11282, 29, 47, 29, 2, -47 },
  { 11453, 13, 47, 14, 2, -47 },
  { 11530, 48, 34, 53, 2, -34 },
  { 11734, 30, 34, 35, 2, -34 },
  { 11862, 29, 35, 35, 3, -34 },
  { 11989, 33, 49, 36, -1, -34 },
  { 12192, 31, 49, 36, 3, -34 },
  { 12382, 24, 34, 24, 2, -34 },
  { 12484, 24, 35, 27, 1, -34 },
  { 12589, 19, 42, 20, 3, -41 },
  { 12689, 30, 34, 35, 3, -33 },
  { 12817, 27, 33, 27, 3, -33 },
  { 12929, 42, 33, 43, 3, -33 },
  { 13103, 32, 33, 29, -2, -33 },
  { 13235, 36, 48, 27, -6, -33 },
  { 13451, 28, 33, 27, -1, -33 },
  { 13567, 23, 54, 21, 1, -44 },
  { 13723, 3, 62, 34, 17, -47 },
  { 13747, 23, 54, 21, -3, -44 },
  { 13903, 28, 7, 35, 5, -25 },
};

const GFXfont NotoSans_LightItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_LIGHTITALIC62PT7B_H_
