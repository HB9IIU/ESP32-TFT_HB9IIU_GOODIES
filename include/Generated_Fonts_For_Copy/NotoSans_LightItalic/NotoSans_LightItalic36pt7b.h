#ifndef _NOTOSANS_LIGHTITALIC36PT7B_H_
#define _NOTOSANS_LIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C,
  0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0xE0, 0x71, 0xB0, 0xD8, 0x6C, 0x36, 0x32, 0x1B, 0x0D, 0x84,
  0xC2, 0x41, 0x00, 0x00, 0x30, 0x20, 0x00, 0x81, 0x80, 0x06, 0x06, 0x00,
  0x18, 0x18, 0x00, 0x60, 0x40, 0x01, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x20, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x18, 0x18, 0x00, 0x60, 0x40,
  0x01, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x20, 0x00, 0x81, 0x80, 0x06,
  0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x60, 0x40, 0x01, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x20, 0x00, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3F, 0xC0,
  0x7F, 0xF8, 0x63, 0x08, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x40, 0x0C, 0x20,
  0x06, 0x30, 0x03, 0x98, 0x00, 0xEC, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03,
  0x70, 0x01, 0x9C, 0x00, 0xC6, 0x00, 0x41, 0x80, 0x21, 0x80, 0x30, 0xC0,
  0x18, 0xE2, 0x08, 0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x0C, 0x3F, 0x80, 0x30, 0xC3,
  0x00, 0x61, 0x83, 0x01, 0x86, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x18,
  0x30, 0x60, 0x20, 0xC0, 0xC0, 0xC3, 0x01, 0x81, 0x8C, 0x03, 0x03, 0x18,
  0xE6, 0x0C, 0x67, 0xEC, 0x19, 0x9C, 0x78, 0x66, 0x30, 0xDF, 0x8C, 0xC0,
  0x9E, 0x31, 0x81, 0x00, 0xC6, 0x06, 0x03, 0x0C, 0x0C, 0x06, 0x18, 0x18,
  0x18, 0x30, 0x30, 0x60, 0x60, 0x40, 0x80, 0xC1, 0x83, 0x01, 0x83, 0x0C,
  0x03, 0x0C, 0x30, 0x07, 0x30, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xFE, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x70, 0x03, 0x00, 0xC0, 0x0C, 0x03,
  0x00, 0x30, 0x1C, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x06, 0x38, 0x00,
  0x1B, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1D, 0x80, 0x01, 0xC3,
  0x00, 0xCE, 0x06, 0x06, 0x70, 0x1C, 0x19, 0x80, 0x30, 0xC6, 0x00, 0x67,
  0x38, 0x01, 0xD8, 0xC0, 0x03, 0xC1, 0x80, 0x0E, 0x06, 0x00, 0x7C, 0x1C,
  0x03, 0xB8, 0x3C, 0xF8, 0x60, 0x7F, 0xC0, 0xC0, 0x76, 0x66, 0x64, 0xCC,
  0xC8, 0x00, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01,
  0x80, 0x70, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x40,
  0x80, 0xE0, 0x80, 0x79, 0x80, 0x0F, 0x83, 0x03, 0xFF, 0x03, 0x80, 0x06,
  0x80, 0x0C, 0xC0, 0x38, 0xC0, 0x70, 0x60, 0x20, 0x60, 0x00, 0x70, 0x00,
  0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0C,
  0x71, 0x86, 0x30, 0xC6, 0x18, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01,
  0xC1, 0xC1, 0xC0, 0x60, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x60, 0x03,
  0x30, 0x01, 0xB8, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00,
  0x1F, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x03, 0xB0, 0x01, 0x98,
  0x00, 0xCC, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x60, 0xE0, 0x60, 0x3D, 0xE0,
  0x0F, 0xE0, 0x00, 0x01, 0x81, 0xC3, 0xE3, 0xB7, 0x37, 0x1A, 0x0C, 0x06,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xF0, 0x1E, 0x07, 0x01, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xE0, 0x00,
  0xFE, 0x00, 0xFF, 0xC0, 0xF0, 0x38, 0x10, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0xF8, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE2, 0x00, 0x70, 0xFD, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0xEC, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x06, 0x0C,
  0x01, 0xC1, 0x80, 0x70, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x30,
  0x30, 0x06, 0x0C, 0x00, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC4,
  0x00, 0x7F, 0xE0, 0x0C, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xE3, 0x00, 0x70, 0xFD, 0xF8, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x1F, 0x01,
  0xDF, 0xF0, 0x6C, 0x0E, 0x1E, 0x01, 0x87, 0x00, 0x31, 0x80, 0x0C, 0xE0,
  0x03, 0x38, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x18, 0x60, 0x06, 0x18, 0x03,
  0x86, 0x00, 0xC0, 0xC0, 0x60, 0x3E, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xC0, 0xE1, 0xC0, 0x30, 0xC0,
  0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x07, 0x03, 0x81,
  0xC3, 0x80, 0x7F, 0x00, 0x1E, 0x00, 0x7B, 0x80, 0x70, 0x60, 0xE0, 0x18,
  0x60, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00,
  0x33, 0x00, 0x30, 0xC0, 0x38, 0x7C, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0x03, 0x81, 0x83, 0x80, 0x61, 0x80, 0x31, 0x80, 0x0C, 0xC0,
  0x06, 0x60, 0x03, 0x70, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xE6, 0x00, 0x63,
  0x00, 0x71, 0xC0, 0x78, 0x7F, 0xEC, 0x1F, 0xCE, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x8E, 0x00, 0x03, 0x81, 0xC0,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x1C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x1F, 0xC3,
  0xFF, 0x18, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xE0, 0x3C, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x1C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x30, 0x0F, 0xF0, 0x66,
  0x07, 0x06, 0x0D, 0x81, 0xC0, 0xC0, 0xB0, 0x70, 0x18, 0x14, 0x0C, 0x06,
  0x07, 0x83, 0x00, 0xC0, 0xF0, 0x60, 0x18, 0x1E, 0x0C, 0x02, 0x03, 0xC1,
  0x80, 0xC0, 0xD8, 0x30, 0x18, 0x1B, 0x06, 0x07, 0x06, 0x60, 0xC1, 0xA0,
  0xCC, 0x0E, 0xE7, 0xF0, 0x80, 0xF8, 0x78, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x80,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xC0, 0x0C,
  0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x0E, 0x01, 0x80, 0x60, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0x60, 0x06, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0x61,
  0x80, 0x03, 0x30, 0x00, 0x37, 0x00, 0x03, 0x60, 0x00, 0x3E, 0x00, 0x03,
  0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x18, 0x0F, 0x07, 0x00, 0x70, 0xC0, 0x06,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x18,
  0x60, 0x0E, 0x0C, 0x07, 0x81, 0xFF, 0x80, 0x60, 0x7C, 0x0C, 0x00, 0xC1,
  0x80, 0x1C, 0x30, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x07, 0x30, 0x01, 0xC6, 0x00, 0xF0, 0xFF, 0xFC, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x03, 0xC0, 0x20, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x20, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xF8,
  0x01, 0x81, 0xF0, 0x1C, 0x01, 0xC0, 0xC0, 0x07, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x07, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0xE6, 0x00,
  0x06, 0x30, 0x00, 0x33, 0x80, 0x03, 0x98, 0x00, 0x18, 0xC0, 0x01, 0xC6,
  0x00, 0x1C, 0x30, 0x01, 0xC3, 0x00, 0x3C, 0x18, 0x07, 0xC0, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xFE, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x83, 0xFF,
  0xC0, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0xF0, 0x0C, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x0F, 0xF3, 0x00, 0x7F, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00,
  0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8E, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0xC0, 0x06, 0x07, 0x00, 0x30, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x80, 0x03, 0x0C, 0x00,
  0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x60, 0x00, 0xE1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x1F, 0xFF, 0xF0, 0xC0,
  0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61, 0xC0, 0x01,
  0x86, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x0E,
  0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x23, 0xC0, 0x7F, 0x00, 0x20, 0x00, 0x06, 0x00, 0x38, 0x30,
  0x03, 0x81, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xC0, 0x38, 0x06, 0x03, 0x00,
  0x30, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x70,
  0x00, 0x37, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x60, 0x00, 0xE3, 0x80, 0x06,
  0x0C, 0x00, 0x30, 0x70, 0x03, 0x81, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01, 0xC0, 0xC0,
  0x06, 0x06, 0x00, 0x38, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0xD0,
  0x00, 0x1E, 0x0D, 0x80, 0x03, 0x60, 0xD8, 0x00, 0x6E, 0x0D, 0x80, 0x06,
  0xC0, 0xD8, 0x00, 0xCC, 0x19, 0x80, 0x0C, 0xC1, 0x88, 0x01, 0x8C, 0x18,
  0xC0, 0x19, 0x81, 0x8C, 0x03, 0x18, 0x38, 0xC0, 0x61, 0x83, 0x0C, 0x06,
  0x18, 0x30, 0xC0, 0xC1, 0x83, 0x0C, 0x0C, 0x30, 0x30, 0x41, 0x83, 0x06,
  0x06, 0x18, 0x30, 0x60, 0x63, 0x03, 0x06, 0x06, 0x60, 0x30, 0x60, 0x66,
  0x06, 0x06, 0x06, 0xC0, 0x60, 0xC0, 0x2C, 0x06, 0x0C, 0x03, 0x80, 0x60,
  0xC0, 0x38, 0x0E, 0x0C, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x0E, 0x00,
  0x0C, 0x1C, 0x00, 0x30, 0x78, 0x00, 0x60, 0xD8, 0x00, 0xC1, 0xB0, 0x01,
  0x83, 0x30, 0x03, 0x06, 0x60, 0x0C, 0x18, 0xC0, 0x18, 0x30, 0xC0, 0x30,
  0x61, 0x80, 0x60, 0xC1, 0x81, 0xC3, 0x83, 0x03, 0x06, 0x06, 0x06, 0x0C,
  0x06, 0x0C, 0x18, 0x0C, 0x18, 0x30, 0x0C, 0x60, 0xC0, 0x18, 0xC1, 0x80,
  0x31, 0x83, 0x00, 0x33, 0x06, 0x00, 0x66, 0x0C, 0x00, 0x78, 0x30, 0x00,
  0xF0, 0x60, 0x01, 0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x80, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x00, 0x78, 0x0E, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x38,
  0x60, 0x00, 0x63, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x1D, 0x80,
  0x00, 0x76, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x18, 0xE0, 0x00, 0xE1, 0x80, 0x03, 0x07, 0x00,
  0x1C, 0x0E, 0x01, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0xC0, 0x60, 0x78, 0x38, 0x07, 0x0C, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x1C, 0x60,
  0x0E, 0x18, 0x07, 0x0C, 0x0F, 0x83, 0xFF, 0x80, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0x00, 0x78, 0x0E, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x38, 0x60,
  0x00, 0x63, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x1D, 0x80, 0x00,
  0x76, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xCC, 0x00,
  0x03, 0x30, 0x00, 0x18, 0xE0, 0x00, 0xE1, 0x80, 0x03, 0x07, 0x00, 0x1C,
  0x0E, 0x01, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x60, 0x78, 0x38, 0x07, 0x0C, 0x00,
  0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x18, 0x60, 0x0E, 0x18, 0x0F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xC0,
  0xC0, 0x30, 0x30, 0x1C, 0x0E, 0x06, 0x01, 0x81, 0x80, 0x60, 0x60, 0x0C,
  0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0xC0,
  0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x70, 0x18, 0x38, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC2, 0x00, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x0C, 0x30, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x60, 0x00, 0x63, 0x80, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x61, 0x80, 0x01,
  0x86, 0x00, 0x06, 0x18, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0x83, 0x80, 0x0E, 0x06, 0x00,
  0x70, 0x1C, 0x03, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xC0, 0x00,
  0xF8, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x31, 0x80, 0x0E,
  0x30, 0x01, 0x86, 0x00, 0x70, 0x60, 0x0C, 0x0C, 0x03, 0x81, 0x80, 0x60,
  0x30, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x06, 0x00,
  0x60, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0x6C, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x01, 0xB0, 0x01, 0xC0, 0x0D, 0x80,
  0x1E, 0x00, 0xEC, 0x00, 0xB0, 0x06, 0x60, 0x0D, 0x80, 0x73, 0x00, 0x6C,
  0x03, 0x0C, 0x06, 0x60, 0x18, 0x60, 0x33, 0x01, 0x83, 0x03, 0x18, 0x0C,
  0x18, 0x18, 0xC0, 0xC0, 0xC1, 0x86, 0x06, 0x06, 0x0C, 0x10, 0x60, 0x30,
  0xC0, 0x83, 0x01, 0x86, 0x04, 0x38, 0x0C, 0x60, 0x31, 0x80, 0x63, 0x01,
  0x8C, 0x03, 0x30, 0x0C, 0xC0, 0x19, 0x80, 0x66, 0x00, 0xD8, 0x03, 0x60,
  0x06, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x0C,
  0x07, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x63,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x76, 0x00, 0x00, 0xC6, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x30, 0x01,
  0x80, 0x70, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x70, 0x00, 0xC1, 0xC0,
  0x01, 0x80, 0xE0, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x39, 0x80, 0x0C, 0x30,
  0x06, 0x0C, 0x03, 0x83, 0x00, 0xC0, 0xC0, 0x60, 0x18, 0x30, 0x06, 0x1C,
  0x01, 0x86, 0x00, 0x33, 0x00, 0x0D, 0xC0, 0x03, 0x60, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0xF8,
  0x1F, 0xC0, 0xC3, 0x0C, 0x30, 0xC1, 0x06, 0x18, 0x61, 0x86, 0x08, 0x30,
  0xC3, 0x0C, 0x30, 0x41, 0x86, 0x18, 0x61, 0x82, 0x0C, 0x30, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x36, 0x00, 0x33, 0x00, 0x18, 0x80, 0x18, 0x60, 0x0C, 0x10, 0x0C,
  0x0C, 0x0C, 0x06, 0x06, 0x01, 0x06, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x19,
  0x80, 0x0D, 0x80, 0x03, 0xFF, 0xFC, 0xE3, 0x18, 0x61, 0x0C, 0x00, 0x40,
  0x01, 0xF8, 0xC3, 0xC6, 0x63, 0x81, 0xB3, 0x80, 0x71, 0x80, 0x39, 0xC0,
  0x1C, 0xC0, 0x0E, 0x60, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0xE6, 0x00, 0x63, 0x00, 0x71, 0x80, 0x38, 0xC0, 0x2C, 0x30, 0x36,
  0x1E, 0xF2, 0x07, 0xE3, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x20, 0x0C,
  0x7E, 0x03, 0x79, 0xC0, 0xF0, 0x18, 0x68, 0x06, 0x1C, 0x00, 0xC7, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x06, 0x70, 0x03, 0x9C, 0x00, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x58,
  0x1C, 0x33, 0x9E, 0x0C, 0x7F, 0x00, 0x00, 0x60, 0x07, 0xFC, 0x3C, 0x30,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x20, 0xF3, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x02, 0x0E, 0x03, 0xF9, 0x81, 0xE3, 0xB0, 0x70, 0x16, 0x1C, 0x03,
  0xC3, 0x00, 0x30, 0xE0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x1C,
  0x30, 0x07, 0x06, 0x01, 0xE0, 0x60, 0x6C, 0x0F, 0x79, 0x80, 0xFC, 0x30,
  0x00, 0x00, 0x40, 0x07, 0xF0, 0x3C, 0x70, 0xE0, 0x71, 0x80, 0x66, 0x00,
  0xDC, 0x03, 0x30, 0x0E, 0x60, 0x39, 0xFF, 0xE3, 0xFE, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x20, 0xFB,
  0xC0, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0xFC, 0x00, 0x38, 0x80, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x02,
  0x70, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x7F, 0x10,
  0x78, 0xEC, 0x38, 0x0B, 0x1C, 0x03, 0xC6, 0x00, 0x63, 0x80, 0x18, 0xC0,
  0x06, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03,
  0x18, 0x01, 0xC6, 0x00, 0x71, 0x80, 0x38, 0x60, 0x1E, 0x0C, 0x0D, 0x83,
  0xDE, 0x60, 0x7E, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x20, 0x0C, 0x0E, 0x0F, 0x03, 0xFF, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x10, 0x0C, 0x7F, 0x06, 0x63, 0xC3, 0x40,
  0x63, 0x40, 0x31, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x30,
  0x01, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x67, 0x00, 0x33, 0x00, 0x19,
  0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x60, 0x03, 0x30, 0x03, 0x80, 0x07,
  0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xC0,
  0xC0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x8C, 0x03, 0xF0,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x03, 0x86, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x23,
  0x00, 0x33, 0x80, 0x1B, 0xC0, 0x0F, 0x70, 0x07, 0x18, 0x06, 0x0E, 0x03,
  0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x60, 0x38, 0x60, 0x0C, 0x30, 0x07,
  0x00, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60,
  0x60, 0x60, 0xC0, 0xC0, 0x00, 0x10, 0x01, 0x00, 0xC7, 0xE0, 0xFC, 0x0D,
  0xC7, 0x18, 0xE0, 0xB0, 0x33, 0x07, 0x1A, 0x03, 0x40, 0x31, 0xC0, 0x3C,
  0x03, 0x1C, 0x03, 0x80, 0x31, 0x80, 0x38, 0x03, 0x18, 0x03, 0x00, 0x63,
  0x00, 0x30, 0x06, 0x30, 0x07, 0x00, 0x63, 0x00, 0x60, 0x06, 0x30, 0x06,
  0x00, 0xE7, 0x00, 0x60, 0x0C, 0x60, 0x06, 0x00, 0xC6, 0x00, 0xC0, 0x0C,
  0x60, 0x0C, 0x00, 0xC6, 0x00, 0xC0, 0x18, 0xC0, 0x0C, 0x01, 0x8C, 0x01,
  0xC0, 0x18, 0x00, 0x0C, 0x06, 0x3F, 0x83, 0x79, 0xE1, 0x70, 0x31, 0xA0,
  0x18, 0xE0, 0x0C, 0x70, 0x06, 0x30, 0x03, 0x38, 0x01, 0x98, 0x01, 0xCC,
  0x00, 0xC6, 0x00, 0x63, 0x00, 0x33, 0x80, 0x19, 0x80, 0x1C, 0xC0, 0x0C,
  0x60, 0x06, 0x30, 0x03, 0x38, 0x01, 0x98, 0x01, 0xC0, 0x03, 0xF8, 0x0F,
  0x1E, 0x1C, 0x06, 0x38, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x0E, 0x60, 0x1C, 0x70, 0x38, 0x3E, 0xF0, 0x1F, 0xC0, 0x00,
  0x02, 0x00, 0x31, 0xFC, 0x03, 0x79, 0xC0, 0x24, 0x06, 0x06, 0x80, 0x60,
  0x70, 0x03, 0x07, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x07,
  0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0xC0, 0x0E, 0x1C, 0x00,
  0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0x81, 0xE0, 0x70, 0x33, 0x9E, 0x03, 0x1F,
  0xC0, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x01, 0xFC, 0x43, 0xC7, 0x63, 0x80, 0xB3, 0x80, 0x79, 0x80,
  0x19, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x01, 0xB0, 0x01, 0x98,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x73, 0x00, 0x39, 0x80, 0x38, 0xC0, 0x3C,
  0x30, 0x36, 0x1E, 0xF3, 0x07, 0xE3, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x0C, 0x7C, 0x37, 0x90, 0xB0, 0x06, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x0F, 0xFC, 0x38, 0x70, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x31, 0x00, 0x63, 0xEF, 0x83,
  0xFE, 0x00, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x3F, 0xFF, 0xFC, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0x61, 0xF8, 0x18, 0x01, 0x8C, 0x00,
  0xCC, 0x00, 0x66, 0x00, 0x63, 0x00, 0x31, 0x80, 0x19, 0xC0, 0x0C, 0xC0,
  0x06, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x9C, 0x01, 0xCC, 0x00, 0xE6,
  0x00, 0xE3, 0x00, 0x71, 0x80, 0x58, 0xE0, 0x6C, 0x3D, 0xE4, 0x0F, 0xC6,
  0x00, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18, 0x60,
  0x30, 0x60, 0x30, 0x60, 0x60, 0x60, 0xE0, 0x60, 0xC0, 0x61, 0xC0, 0x61,
  0x80, 0x63, 0x00, 0x33, 0x00, 0x36, 0x00, 0x36, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0xC0, 0x18, 0x07, 0xC0, 0x38, 0x06, 0xC0, 0x38, 0x06,
  0xC0, 0x68, 0x0C, 0xC0, 0x48, 0x0C, 0xC0, 0xC8, 0x18, 0xC0, 0xCC, 0x18,
  0xC1, 0x8C, 0x30, 0xC1, 0x8C, 0x30, 0xC3, 0x0C, 0x60, 0x63, 0x0C, 0x60,
  0x66, 0x0C, 0xE0, 0x66, 0x0C, 0xC0, 0x6C, 0x0C, 0xC0, 0x6C, 0x0D, 0x80,
  0x78, 0x0D, 0x80, 0x78, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x0C, 0x00, 0xE0, 0xC0, 0x30, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x30, 0xE0,
  0x03, 0x38, 0x00, 0x66, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x01, 0xB8, 0x00, 0x73, 0x00, 0x1C, 0x60, 0x03, 0x06, 0x00,
  0xC0, 0xC0, 0x30, 0x0C, 0x0C, 0x01, 0x83, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x1C, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x60,
  0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06,
  0x0C, 0x00, 0x18, 0x70, 0x00, 0x31, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x30,
  0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x18, 0x07, 0xC0,
  0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x1E, 0x00, 0xF0, 0x01,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xF8, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x0F,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x70, 0x0F, 0x80, 0x30, 0x00, 0x38, 0x01, 0xFF, 0x81, 0xC3, 0xF7, 0x80,
  0x7E,
};

const GFXglyph NotoSans_LightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 26, 9, 1, -26 },
  { 27, 9, 10, 13, 4, -26 },
  { 39, 22, 26, 23, 1, -26 },
  { 111, 17, 29, 20, 2, -27 },
  { 173, 23, 26, 28, 3, -26 },
  { 248, 22, 26, 24, 1, -26 },
  { 320, 4, 10, 7, 4, -26 },
  { 325, 11, 32, 10, 1, -26 },
  { 369, 11, 32, 10, -3, -26 },
  { 413, 16, 16, 19, 4, -27 },
  { 445, 16, 17, 21, 3, -21 },
  { 479, 6, 9, 8, -2, -4 },
  { 486, 9, 2, 11, 1, -11 },
  { 489, 3, 3, 8, 1, -3 },
  { 491, 17, 26, 12, -2, -26 },
  { 547, 17, 26, 20, 2, -26 },
  { 603, 9, 26, 20, 6, -26 },
  { 633, 19, 26, 20, 0, -26 },
  { 695, 18, 26, 20, 1, -26 },
  { 754, 19, 26, 20, 0, -26 },
  { 816, 18, 26, 20, 1, -26 },
  { 875, 18, 26, 20, 2, -26 },
  { 934, 16, 26, 20, 4, -26 },
  { 986, 17, 26, 20, 2, -26 },
  { 1042, 17, 26, 20, 2, -26 },
  { 1098, 6, 19, 8, 1, -19 },
  { 1113, 9, 24, 8, -2, -19 },
  { 1140, 16, 16, 21, 3, -21 },
  { 1172, 16, 9, 21, 3, -17 },
  { 1190, 16, 16, 21, 3, -21 },
  { 1222, 13, 26, 15, 3, -26 },
  { 1265, 27, 29, 30, 2, -26 },
  { 1363, 20, 26, 20, -2, -26 },
  { 1428, 19, 26, 22, 2, -26 },
  { 1490, 20, 26, 21, 3, -26 },
  { 1555, 21, 26, 24, 2, -26 },
  { 1624, 18, 26, 19, 2, -26 },
  { 1683, 18, 26, 17, 2, -26 },
  { 1742, 21, 26, 25, 3, -26 },
  { 1811, 22, 26, 25, 2, -26 },
  { 1883, 13, 26, 11, 0, -26 },
  { 1926, 15, 33, 9, -6, -26 },
  { 1988, 21, 26, 20, 2, -26 },
  { 2057, 13, 26, 17, 2, -26 },
  { 2100, 28, 26, 30, 2, -26 },
  { 2191, 23, 26, 25, 2, -26 },
  { 2266, 22, 26, 26, 3, -26 },
  { 2338, 18, 26, 20, 2, -26 },
  { 2397, 22, 32, 26, 3, -26 },
  { 2485, 18, 26, 20, 2, -26 },
  { 2544, 18, 26, 18, 1, -26 },
  { 2603, 18, 26, 18, 3, -26 },
  { 2662, 22, 26, 25, 3, -26 },
  { 2734, 19, 26, 20, 4, -26 },
  { 2796, 29, 26, 30, 4, -26 },
  { 2891, 23, 26, 18, -2, -26 },
  { 2966, 18, 26, 18, 3, -26 },
  { 3025, 21, 26, 19, 0, -26 },
  { 3094, 13, 32, 11, 0, -26 },
  { 3146, 6, 26, 12, 4, -26 },
  { 3166, 14, 32, 11, -3, -26 },
  { 3222, 17, 16, 20, 2, -26 },
  { 3256, 14, 1, 14, -3, 4 },
  { 3258, 5, 6, 9, 5, -28 },
  { 3262, 17, 20, 20, 2, -20 },
  { 3305, 18, 27, 21, 1, -27 },
  { 3366, 15, 20, 16, 2, -20 },
  { 3404, 19, 27, 21, 2, -27 },
  { 3469, 15, 20, 18, 2, -20 },
  { 3507, 19, 37, 10, -4, -28 },
  { 3595, 18, 29, 21, 1, -20 },
  { 3661, 17, 27, 20, 1, -27 },
  { 3719, 8, 26, 8, 1, -26 },
  { 3745, 14, 35, 8, -5, -26 },
  { 3807, 17, 27, 17, 1, -27 },
  { 3865, 8, 27, 8, 1, -27 },
  { 3892, 28, 20, 31, 1, -20 },
  { 3962, 17, 20, 20, 1, -20 },
  { 4005, 16, 19, 20, 2, -19 },
  { 4043, 20, 29, 21, -1, -20 },
  { 4116, 17, 29, 21, 2, -20 },
  { 4178, 14, 19, 14, 1, -19 },
  { 4212, 15, 20, 15, 0, -20 },
  { 4250, 10, 24, 12, 2, -24 },
  { 4280, 17, 19, 20, 2, -19 },
  { 4321, 16, 19, 16, 2, -19 },
  { 4359, 24, 19, 25, 2, -19 },
  { 4416, 19, 19, 17, -1, -19 },
  { 4462, 22, 28, 16, -4, -19 },
  { 4539, 17, 19, 16, -1, -19 },
  { 4580, 13, 32, 12, 1, -26 },
  { 4632, 2, 36, 20, 10, -27 },
  { 4641, 14, 32, 12, -2, -26 },
  { 4697, 16, 4, 21, 3, -15 },
};

const GFXfont NotoSans_LightItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_LIGHTITALIC36PT7B_H_
