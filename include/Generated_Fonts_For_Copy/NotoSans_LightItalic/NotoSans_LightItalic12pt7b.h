#ifndef _NOTOSANS_LIGHTITALIC12PT7B_H_
#define _NOTOSANS_LIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0x80, 0x76, 0xD0, 0x12, 0x12, 0x14, 0x7F, 0x24,
  0x24, 0xFA, 0x48, 0x48, 0x13, 0xE9, 0x46, 0x18, 0xBA, 0x62, 0x00, 0x61,
  0x92, 0x94, 0x98, 0xAF, 0x59, 0x29, 0x49, 0xCE, 0x18, 0x24, 0x24, 0x28,
  0x30, 0x49, 0x8A, 0x84, 0x7A, 0x6A, 0x12, 0x24, 0x48, 0x88, 0x84, 0x40,
  0x21, 0x11, 0x11, 0x12, 0x24, 0x80, 0x13, 0x43, 0xD4, 0x50, 0x21, 0x3E,
  0x42, 0x10, 0x58, 0xE0, 0x80, 0x04, 0x10, 0x84, 0x10, 0x82, 0x10, 0xC0,
  0x32, 0x63, 0x18, 0xC6, 0x32, 0xE0, 0x2E, 0x94, 0x92, 0x40, 0x18, 0x90,
  0x41, 0x08, 0x42, 0x10, 0xF8, 0x18, 0x90, 0x41, 0x38, 0x30, 0x41, 0xF8,
  0x04, 0x31, 0x45, 0x29, 0x2F, 0xC2, 0x08, 0x1C, 0x82, 0x10, 0x78, 0x10,
  0x41, 0xF8, 0x1C, 0x84, 0x28, 0xDA, 0x28, 0xA2, 0xF0, 0xFC, 0x20, 0x84,
  0x10, 0x82, 0x10, 0x80, 0x32, 0x52, 0x97, 0x4E, 0x31, 0xF0, 0x32, 0x63,
  0x18, 0xBC, 0x22, 0xE0, 0x40, 0x20, 0x20, 0x00, 0x94, 0x09, 0xB0, 0xC1,
  0x80, 0xF8, 0x3E, 0xC1, 0x82, 0x6C, 0x00, 0xE1, 0x11, 0x24, 0x80, 0x80,
  0x0E, 0x18, 0x90, 0x33, 0x9A, 0x4D, 0x26, 0x95, 0x34, 0x80, 0x3E, 0x00,
  0x04, 0x08, 0x30, 0xA1, 0x27, 0xC8, 0xA1, 0xC2, 0x79, 0x14, 0x51, 0xFA,
  0x28, 0x62, 0xF0, 0x1E, 0x41, 0x04, 0x08, 0x10, 0x20, 0x40, 0x78, 0x78,
  0x89, 0x0A, 0x18, 0x30, 0x61, 0x44, 0xF0, 0x7D, 0x04, 0x10, 0xFA, 0x08,
  0x20, 0xF0, 0x7D, 0x04, 0x10, 0xFA, 0x08, 0x20, 0x80, 0x1E, 0x41, 0x04,
  0x08, 0x90, 0xA1, 0x42, 0x7C, 0x42, 0x85, 0x0A, 0x1F, 0xD0, 0xA1, 0x42,
  0x84, 0x32, 0x22, 0x24, 0x44, 0xC0, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11,
  0x38, 0x42, 0x89, 0x23, 0x8E, 0x12, 0x24, 0x48, 0x88, 0x44, 0x44, 0x88,
  0x88, 0xF0, 0x40, 0xB0, 0xD8, 0xAC, 0x6A, 0x55, 0x2A, 0xA5, 0x22, 0x92,
  0x00, 0x42, 0x85, 0x8B, 0x19, 0x32, 0xA3, 0x46, 0x84, 0x1C, 0xC5, 0x0C,
  0x18, 0x30, 0x60, 0xC2, 0x78, 0x71, 0x34, 0x51, 0x8B, 0xC8, 0x20, 0x80,
  0x1C, 0xC5, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x78, 0x20, 0x20, 0x79, 0x14,
  0x51, 0x8B, 0xC9, 0x24, 0x88, 0x1C, 0x84, 0x10, 0x30, 0x20, 0x82, 0xF0,
  0xFC, 0x82, 0x08, 0x20, 0x84, 0x10, 0x40, 0x42, 0x85, 0x0C, 0x18, 0x30,
  0xA1, 0x42, 0x78, 0x83, 0x0A, 0x14, 0x49, 0x0A, 0x18, 0x30, 0x40, 0x84,
  0x63, 0x18, 0xCA, 0x52, 0x95, 0x29, 0x4A, 0x61, 0x18, 0x44, 0x00, 0x21,
  0x12, 0x14, 0x14, 0x08, 0x18, 0x24, 0x44, 0xC4, 0x86, 0x24, 0x94, 0x60,
  0x84, 0x10, 0x40, 0x3E, 0x08, 0x10, 0x41, 0x04, 0x10, 0x20, 0xF8, 0x32,
  0x24, 0x44, 0x48, 0x88, 0xC0, 0xA9, 0x55, 0x40, 0x38, 0x44, 0x21, 0x08,
  0x44, 0x21, 0x38, 0x21, 0x94, 0x98, 0xC4, 0xF8, 0xC0, 0x32, 0x63, 0x18,
  0xCB, 0xC0, 0x20, 0x83, 0x89, 0x45, 0x14, 0x51, 0xB8, 0x3A, 0x21, 0x08,
  0x43, 0xC0, 0x04, 0x13, 0x52, 0x8A, 0x28, 0xA4, 0xF0, 0x32, 0x63, 0xE8,
  0x43, 0xC0, 0x0C, 0x43, 0x84, 0x20, 0x82, 0x08, 0x41, 0x04, 0x20, 0x18,
  0x94, 0x51, 0x86, 0x27, 0x82, 0x0B, 0xC0, 0x20, 0x82, 0x8D, 0x45, 0x14,
  0x51, 0x88, 0x20, 0x24, 0x92, 0x80, 0x08, 0x00, 0x21, 0x08, 0x42, 0x21,
  0x09, 0x80, 0x20, 0x82, 0x52, 0x51, 0x85, 0x14, 0x88, 0x24, 0xA4, 0x92,
  0x80, 0x19, 0x89, 0x94, 0x45, 0x11, 0x44, 0x92, 0x28, 0x88, 0x08, 0xD4,
  0x51, 0x45, 0x18, 0x80, 0x7C, 0x63, 0x18, 0xF8, 0x09, 0xD4, 0x51, 0x45,
  0x1B, 0xA0, 0x82, 0x00, 0x32, 0x63, 0x18, 0xCB, 0xC2, 0x10, 0x80, 0x3A,
  0x10, 0x84, 0x40, 0x32, 0x50, 0x41, 0x0B, 0xC0, 0x4E, 0x49, 0x26, 0x8C,
  0x63, 0x19, 0x78, 0x9C, 0xA9, 0x4C, 0x60, 0x93, 0xB2, 0xB4, 0xD4, 0xC8,
  0x88, 0x4C, 0xC2, 0x0C, 0x52, 0x20, 0x26, 0x48, 0xA1, 0x43, 0x02, 0x08,
  0x10, 0xC0, 0x78, 0x88, 0x84, 0x78, 0x19, 0x08, 0x42, 0x61, 0x08, 0x42,
  0x18, 0xFF, 0xF0, 0x20, 0x84, 0x21, 0x04, 0x44, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_LightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 4, 4, 1, -9 },
  { 7, 8, 9, 8, 0, -9 },
  { 16, 5, 10, 7, 1, -9 },
  { 23, 8, 9, 9, 1, -9 },
  { 32, 8, 9, 8, 0, -9 },
  { 41, 2, 4, 2, 1, -9 },
  { 42, 4, 11, 3, 0, -9 },
  { 48, 4, 11, 3, -1, -9 },
  { 54, 6, 5, 6, 1, -9 },
  { 58, 5, 6, 7, 1, -7 },
  { 62, 2, 3, 3, -1, -1 },
  { 63, 3, 1, 4, 0, -4 },
  { 64, 1, 1, 3, 0, -1 },
  { 65, 6, 9, 4, -1, -9 },
  { 72, 5, 9, 7, 1, -9 },
  { 78, 3, 9, 7, 2, -9 },
  { 82, 6, 9, 7, 0, -9 },
  { 89, 6, 9, 7, 0, -9 },
  { 96, 6, 9, 7, 0, -9 },
  { 103, 6, 9, 7, 0, -9 },
  { 110, 6, 9, 7, 1, -9 },
  { 117, 6, 9, 7, 1, -9 },
  { 124, 5, 9, 7, 1, -9 },
  { 130, 5, 9, 7, 1, -9 },
  { 136, 2, 6, 3, 0, -6 },
  { 138, 3, 8, 3, -1, -6 },
  { 141, 5, 5, 7, 1, -7 },
  { 145, 5, 3, 7, 1, -6 },
  { 147, 5, 5, 7, 1, -7 },
  { 151, 4, 9, 5, 1, -9 },
  { 156, 9, 10, 10, 1, -9 },
  { 168, 7, 9, 7, -1, -9 },
  { 176, 6, 9, 7, 1, -9 },
  { 183, 7, 9, 7, 1, -9 },
  { 191, 7, 9, 8, 1, -9 },
  { 199, 6, 9, 6, 1, -9 },
  { 206, 6, 9, 6, 1, -9 },
  { 213, 7, 9, 8, 1, -9 },
  { 221, 7, 9, 8, 1, -9 },
  { 229, 4, 9, 4, 0, -9 },
  { 234, 5, 11, 3, -2, -9 },
  { 241, 7, 9, 7, 1, -9 },
  { 249, 4, 9, 6, 1, -9 },
  { 254, 9, 9, 10, 1, -9 },
  { 265, 7, 9, 8, 1, -9 },
  { 273, 7, 9, 9, 1, -9 },
  { 281, 6, 9, 7, 1, -9 },
  { 288, 7, 11, 9, 1, -9 },
  { 298, 6, 9, 7, 1, -9 },
  { 305, 6, 9, 6, 0, -9 },
  { 312, 6, 9, 6, 1, -9 },
  { 319, 7, 9, 8, 1, -9 },
  { 327, 7, 9, 7, 1, -9 },
  { 335, 10, 9, 10, 1, -9 },
  { 347, 8, 9, 6, -1, -9 },
  { 356, 6, 9, 6, 1, -9 },
  { 363, 7, 9, 6, 0, -9 },
  { 371, 4, 11, 4, 0, -9 },
  { 377, 2, 9, 4, 1, -9 },
  { 380, 5, 11, 4, -1, -9 },
  { 387, 5, 6, 7, 1, -9 },
  { 391, 5, 1, 5, -1, 1 },
  { 392, 1, 2, 3, 2, -9 },
  { 393, 5, 7, 7, 1, -7 },
  { 398, 6, 9, 7, 0, -9 },
  { 405, 5, 7, 5, 1, -7 },
  { 410, 6, 9, 7, 1, -9 },
  { 417, 5, 7, 6, 1, -7 },
  { 422, 6, 12, 3, -1, -9 },
  { 431, 6, 10, 7, 0, -7 },
  { 439, 6, 9, 7, 0, -9 },
  { 446, 3, 9, 3, 0, -9 },
  { 450, 5, 12, 3, -2, -9 },
  { 458, 6, 9, 6, 0, -9 },
  { 465, 3, 9, 3, 0, -9 },
  { 469, 10, 7, 10, 0, -7 },
  { 478, 6, 7, 7, 0, -7 },
  { 484, 5, 6, 7, 1, -6 },
  { 488, 6, 10, 7, 0, -7 },
  { 496, 5, 10, 7, 1, -7 },
  { 503, 5, 6, 5, 0, -6 },
  { 507, 5, 7, 5, 0, -7 },
  { 512, 3, 8, 4, 1, -8 },
  { 515, 5, 6, 7, 1, -6 },
  { 519, 5, 6, 5, 1, -6 },
  { 523, 8, 6, 8, 1, -6 },
  { 529, 6, 6, 6, 0, -6 },
  { 534, 7, 9, 5, -1, -6 },
  { 542, 5, 6, 5, 0, -6 },
  { 546, 5, 11, 4, 0, -9 },
  { 553, 1, 12, 7, 3, -9 },
  { 555, 5, 11, 4, -1, -9 },
  { 562, 5, 1, 7, 1, -5 },
};

const GFXfont NotoSans_LightItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_LIGHTITALIC12PT7B_H_
