#ifndef _NOTOSANS_LIGHTITALIC16PT7B_H_
#define _NOTOSANS_LIGHTITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x22, 0x44, 0x00, 0xC0, 0x99, 0xAA, 0x09, 0x08, 0x84,
  0x9F, 0xF2, 0x21, 0x10, 0x91, 0xFE, 0x44, 0x24, 0x12, 0x00, 0x08, 0x3C,
  0xAA, 0x44, 0x86, 0x06, 0x0A, 0x14, 0x4B, 0xE1, 0x02, 0x00, 0x30, 0x09,
  0x09, 0x22, 0x44, 0x88, 0xA1, 0x15, 0xA5, 0x4B, 0x51, 0x12, 0x22, 0x48,
  0x89, 0x21, 0xC0, 0x0C, 0x09, 0x08, 0x84, 0x42, 0x40, 0xC1, 0xA1, 0x11,
  0x85, 0x41, 0x21, 0x9F, 0x30, 0xF0, 0x12, 0x44, 0x88, 0x88, 0x88, 0x88,
  0x84, 0x10, 0x82, 0x10, 0x84, 0x22, 0x10, 0x88, 0x84, 0x40, 0x11, 0x23,
  0x41, 0xF7, 0x19, 0x02, 0x00, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10,
  0x29, 0x40, 0xE0, 0xC0, 0x03, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x20, 0x40, 0xC0, 0x0C, 0x32, 0x42, 0x41, 0x41, 0x82, 0x82, 0x82, 0x82,
  0x84, 0x84, 0x78, 0x1B, 0xA4, 0x21, 0x08, 0x84, 0x21, 0x18, 0x0C, 0x33,
  0x01, 0x01, 0x01, 0x02, 0x06, 0x0C, 0x10, 0x20, 0x40, 0xFE, 0x0E, 0x31,
  0x01, 0x01, 0x01, 0x06, 0x1C, 0x02, 0x01, 0x02, 0x02, 0xFC, 0x03, 0x02,
  0x81, 0x41, 0x41, 0x21, 0x11, 0x09, 0xFF, 0x04, 0x02, 0x01, 0x00, 0x3F,
  0x20, 0x40, 0x40, 0x78, 0x04, 0x02, 0x02, 0x04, 0x04, 0xF8, 0x07, 0x18,
  0x20, 0x40, 0x40, 0x7C, 0xC2, 0x82, 0x82, 0x82, 0x84, 0x78, 0xFE, 0x08,
  0x10, 0x41, 0x02, 0x08, 0x10, 0x41, 0x02, 0x00, 0x0C, 0x32, 0x21, 0x41,
  0x22, 0x1C, 0x28, 0xC4, 0x82, 0x82, 0x84, 0x78, 0x18, 0x4D, 0x0A, 0x18,
  0x28, 0x51, 0x9D, 0x04, 0x08, 0x27, 0x80, 0x24, 0x00, 0x00, 0xC0, 0x11,
  0x00, 0x00, 0x02, 0x44, 0x80, 0x01, 0x06, 0x18, 0x60, 0xC0, 0x30, 0x0C,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x04, 0x03, 0x0C, 0x70,
  0x80, 0x31, 0x30, 0x41, 0x04, 0x62, 0x10, 0x40, 0x00, 0x30, 0x0F, 0xC3,
  0x02, 0x40, 0x14, 0x79, 0x88, 0x99, 0x11, 0x91, 0x19, 0x12, 0x9F, 0xE8,
  0x00, 0x40, 0x03, 0xF0, 0x03, 0x02, 0x81, 0x41, 0x20, 0x90, 0x88, 0x7C,
  0x41, 0x20, 0xA0, 0x60, 0x20, 0x3F, 0x21, 0x41, 0x41, 0x46, 0x7E, 0x42,
  0x81, 0x82, 0x82, 0xFC, 0x07, 0x0C, 0x48, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x60, 0x10, 0x07, 0xC0, 0x3F, 0x10, 0xD0, 0x28, 0x14, 0x0A,
  0x05, 0x03, 0x02, 0x81, 0x43, 0x3E, 0x00, 0x3F, 0x20, 0x40, 0x40, 0x42,
  0x7C, 0x40, 0x80, 0x80, 0x80, 0xFC, 0x3F, 0x20, 0x40, 0x40, 0x40, 0x7C,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x07, 0x06, 0x32, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x7A, 0x02, 0x80, 0xB0, 0x44, 0x10, 0xFC, 0x20, 0x48, 0x14, 0x09,
  0x02, 0x40, 0x9F, 0xE4, 0x12, 0x04, 0x81, 0x20, 0x48, 0x10, 0x3C, 0x41,
  0x04, 0x20, 0x82, 0x08, 0x21, 0x0E, 0x00, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x1C, 0x00, 0x21, 0x91, 0x11, 0x09,
  0x05, 0x03, 0x81, 0x21, 0x10, 0x84, 0x42, 0x20, 0x80, 0x20, 0x84, 0x10,
  0x41, 0x04, 0x20, 0x82, 0x0F, 0xC0, 0x30, 0x33, 0x03, 0x50, 0x55, 0x0A,
  0x50, 0xA5, 0x12, 0x49, 0x28, 0xA2, 0x8A, 0x48, 0xC4, 0x88, 0x40, 0x20,
  0x4C, 0x15, 0x09, 0x22, 0x48, 0x92, 0x24, 0x4A, 0x14, 0x83, 0x20, 0xC8,
  0x10, 0x06, 0x06, 0x62, 0x09, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x90, 0x24, 0x10, 0xF8, 0x3E, 0x21, 0x41, 0x41, 0x43, 0x7E, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x06, 0x06, 0x62, 0x09, 0x01, 0x40, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x90, 0x24, 0x10, 0xF8, 0x04, 0x01, 0x80, 0x20, 0x3E, 0x21,
  0x41, 0x41, 0x42, 0x7C, 0x48, 0x84, 0x84, 0x84, 0x82, 0x0E, 0x11, 0x20,
  0x20, 0x20, 0x10, 0x0C, 0x02, 0x02, 0x02, 0x06, 0xFC, 0xFF, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x48, 0x14, 0x09,
  0x02, 0x40, 0x90, 0x24, 0x0A, 0x04, 0x81, 0x10, 0x87, 0xC0, 0x81, 0x82,
  0x84, 0x84, 0x88, 0x88, 0x90, 0x90, 0x60, 0x60, 0x40, 0x86, 0x1C, 0x30,
  0xA2, 0x89, 0x14, 0x49, 0x24, 0x49, 0x22, 0x89, 0x14, 0x50, 0xA2, 0x86,
  0x18, 0x30, 0x40, 0x10, 0x42, 0x20, 0x90, 0x28, 0x04, 0x01, 0x00, 0xA0,
  0x48, 0x22, 0x10, 0x4C, 0x10, 0xC1, 0x42, 0x44, 0x24, 0x28, 0x30, 0x30,
  0x20, 0x20, 0x20, 0x20, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x40, 0x60, 0x20, 0x3F, 0x80, 0x1C, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x83, 0x80, 0xAA, 0x95, 0x54, 0x1C, 0x10, 0x82, 0x08, 0x21,
  0x04, 0x10, 0x41, 0x08, 0x23, 0x80, 0x08, 0x30, 0x61, 0x24, 0x48, 0x60,
  0xC1, 0xFC, 0xCC, 0x19, 0x66, 0x42, 0x82, 0x82, 0x84, 0x84, 0x8C, 0x74,
  0x10, 0x10, 0x20, 0x26, 0x39, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0xBC,
  0x1D, 0x94, 0x20, 0x82, 0x08, 0x20, 0x78, 0x01, 0x01, 0x01, 0x19, 0x66,
  0x42, 0x82, 0x82, 0x82, 0x84, 0x8C, 0x74, 0x18, 0x94, 0x61, 0xFA, 0x08,
  0x20, 0x78, 0x03, 0x82, 0x01, 0x03, 0xC0, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x81, 0x80, 0x0C, 0x99, 0x48, 0x48,
  0x24, 0x12, 0x09, 0x08, 0x8C, 0x3A, 0x01, 0x01, 0x10, 0x87, 0x80, 0x10,
  0x10, 0x20, 0x26, 0x39, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0xC2, 0x11,
  0x02, 0x22, 0x24, 0x44, 0x4C, 0x04, 0x10, 0x02, 0x08, 0x20, 0x84, 0x10,
  0x41, 0x04, 0x20, 0x82, 0x30, 0x10, 0x10, 0x20, 0x21, 0x22, 0x24, 0x28,
  0x50, 0x68, 0x48, 0x44, 0xC6, 0x11, 0x22, 0x22, 0x24, 0x44, 0x4C, 0x26,
  0x31, 0xDE, 0x48, 0x42, 0x42, 0x14, 0x20, 0xA1, 0x09, 0x08, 0x48, 0x42,
  0xC2, 0x10, 0x26, 0x39, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0xC2, 0x18,
  0xCD, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x78, 0x26, 0x39, 0x21, 0x21, 0x41,
  0x41, 0x41, 0x42, 0x7C, 0x80, 0x80, 0x80, 0x80, 0x19, 0x65, 0x42, 0x82,
  0x82, 0x82, 0x84, 0x8C, 0x74, 0x04, 0x04, 0x08, 0x08, 0x26, 0x70, 0x81,
  0x04, 0x08, 0x10, 0x20, 0xC0, 0x1C, 0xC5, 0x03, 0x03, 0x01, 0x01, 0x02,
  0xF8, 0x22, 0x3E, 0x84, 0x22, 0x10, 0x84, 0x38, 0x41, 0x42, 0x42, 0x82,
  0x82, 0x84, 0x84, 0x8C, 0xF4, 0x83, 0x0A, 0x14, 0x48, 0x92, 0x18, 0x30,
  0x40, 0x84, 0x31, 0x8A, 0x31, 0x4A, 0x49, 0x49, 0x4A, 0x29, 0x46, 0x30,
  0xC6, 0x00, 0x20, 0x88, 0x84, 0x81, 0x80, 0x80, 0xA0, 0x50, 0x44, 0xC2,
  0x00, 0x10, 0x44, 0x21, 0x08, 0x44, 0x11, 0x02, 0x80, 0xC0, 0x30, 0x08,
  0x02, 0x01, 0x00, 0x40, 0xE0, 0x00, 0x3E, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x20, 0xFC, 0x0C, 0x41, 0x04, 0x10, 0x8C, 0x08, 0x20, 0x84, 0x10, 0x40,
  0xC0, 0xFF, 0xFF, 0x18, 0x20, 0x82, 0x08, 0x20, 0x46, 0x10, 0x41, 0x08,
  0x62, 0x00, 0x60, 0x9F,
};

const GFXglyph NotoSans_LightItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 6, 2, -11 },
  { 9, 9, 11, 10, 1, -11 },
  { 22, 7, 13, 9, 1, -12 },
  { 34, 11, 12, 13, 1, -12 },
  { 51, 9, 12, 11, 1, -12 },
  { 65, 1, 4, 3, 2, -11 },
  { 66, 4, 14, 4, 1, -11 },
  { 73, 5, 14, 4, -1, -11 },
  { 82, 7, 7, 9, 2, -12 },
  { 89, 8, 7, 9, 1, -9 },
  { 96, 3, 4, 4, -1, -2 },
  { 98, 3, 1, 5, 1, -5 },
  { 99, 2, 1, 4, 0, -1 },
  { 100, 8, 11, 5, -1, -11 },
  { 111, 8, 12, 9, 1, -12 },
  { 123, 5, 11, 9, 2, -11 },
  { 130, 8, 12, 9, 0, -12 },
  { 142, 8, 12, 9, 0, -12 },
  { 154, 9, 11, 9, 0, -11 },
  { 167, 8, 11, 9, 1, -11 },
  { 178, 8, 12, 9, 1, -12 },
  { 190, 7, 11, 9, 2, -11 },
  { 200, 8, 12, 9, 1, -12 },
  { 212, 7, 12, 9, 1, -12 },
  { 223, 3, 9, 4, 0, -9 },
  { 227, 4, 11, 4, -1, -9 },
  { 233, 8, 8, 9, 1, -10 },
  { 241, 8, 4, 9, 1, -8 },
  { 245, 8, 8, 9, 1, -10 },
  { 253, 6, 12, 7, 1, -12 },
  { 262, 12, 12, 13, 1, -11 },
  { 280, 9, 11, 9, -1, -11 },
  { 293, 8, 11, 10, 1, -11 },
  { 304, 9, 12, 9, 1, -12 },
  { 318, 9, 11, 11, 1, -11 },
  { 331, 8, 11, 8, 1, -11 },
  { 342, 8, 11, 8, 1, -11 },
  { 353, 10, 12, 11, 1, -12 },
  { 368, 10, 11, 11, 1, -11 },
  { 382, 6, 11, 5, 0, -11 },
  { 391, 7, 14, 4, -3, -11 },
  { 404, 9, 11, 9, 1, -11 },
  { 417, 6, 11, 8, 1, -11 },
  { 426, 12, 11, 13, 1, -11 },
  { 443, 10, 11, 11, 1, -11 },
  { 457, 10, 12, 12, 1, -12 },
  { 472, 8, 11, 9, 1, -11 },
  { 483, 10, 15, 12, 1, -12 },
  { 502, 8, 11, 9, 1, -11 },
  { 513, 8, 12, 8, 0, -12 },
  { 525, 8, 11, 8, 1, -11 },
  { 536, 10, 11, 11, 1, -11 },
  { 550, 8, 11, 9, 2, -11 },
  { 561, 13, 11, 13, 2, -11 },
  { 579, 10, 11, 8, -1, -11 },
  { 593, 8, 11, 8, 1, -11 },
  { 604, 9, 11, 9, 0, -11 },
  { 617, 6, 14, 5, 0, -11 },
  { 628, 2, 11, 5, 2, -11 },
  { 631, 6, 14, 5, -1, -11 },
  { 642, 7, 8, 9, 1, -12 },
  { 649, 6, 1, 6, -1, 1 },
  { 650, 3, 2, 4, 2, -12 },
  { 651, 8, 9, 9, 1, -9 },
  { 660, 8, 12, 9, 0, -12 },
  { 672, 6, 9, 7, 1, -9 },
  { 679, 8, 12, 9, 1, -12 },
  { 691, 6, 9, 8, 1, -9 },
  { 698, 9, 16, 5, -2, -12 },
  { 716, 9, 13, 9, 0, -9 },
  { 731, 8, 12, 9, 0, -12 },
  { 743, 4, 12, 4, 0, -12 },
  { 749, 6, 16, 4, -2, -12 },
  { 761, 8, 12, 7, 0, -12 },
  { 773, 4, 12, 4, 0, -12 },
  { 779, 13, 9, 14, 0, -9 },
  { 794, 8, 9, 9, 0, -9 },
  { 803, 7, 9, 9, 1, -9 },
  { 811, 8, 13, 9, 0, -9 },
  { 824, 8, 13, 9, 1, -9 },
  { 837, 7, 9, 6, 0, -9 },
  { 845, 7, 9, 7, 0, -9 },
  { 853, 5, 11, 5, 1, -11 },
  { 860, 8, 9, 9, 1, -9 },
  { 869, 7, 9, 7, 1, -9 },
  { 877, 11, 9, 11, 1, -9 },
  { 890, 9, 9, 8, -1, -9 },
  { 901, 10, 13, 7, -2, -9 },
  { 918, 7, 9, 7, 0, -9 },
  { 926, 6, 14, 5, 0, -11 },
  { 937, 1, 16, 9, 4, -12 },
  { 939, 6, 14, 5, -1, -11 },
  { 950, 8, 2, 9, 1, -7 },
};

const GFXfont NotoSans_LightItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_LIGHTITALIC16PT7B_H_
