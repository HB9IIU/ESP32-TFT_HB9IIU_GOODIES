#ifndef _NOTOSANS_LIGHTITALIC43PT7B_H_
#define _NOTOSANS_LIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0xF0, 0x3C, 0x0E, 0x00, 0x30, 0xEE, 0x1D, 0xC3, 0x30, 0x66, 0x0C, 0xC3,
  0x98, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x06, 0x01, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x38, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x30, 0x18, 0x00, 0x1C,
  0x06, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0x03, 0xCC, 0xF0, 0x70, 0xC1, 0x0E, 0x18, 0x00,
  0xC1, 0x80, 0x0C, 0x18, 0x01, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC3, 0x00,
  0x0E, 0x30, 0x00, 0x7B, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x06, 0x78, 0x00, 0x63, 0x80, 0x06, 0x1C, 0x00, 0xC1, 0xC0, 0x0C,
  0x1C, 0x00, 0xC1, 0xC0, 0x0C, 0x18, 0x00, 0xC3, 0x88, 0x18, 0x70, 0xF9,
  0xBE, 0x0F, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0xC3, 0xFC,
  0x00, 0x30, 0x61, 0xC0, 0x0C, 0x18, 0x18, 0x03, 0x87, 0x03, 0x00, 0x60,
  0xC0, 0x60, 0x18, 0x18, 0x0C, 0x06, 0x07, 0x01, 0x81, 0xC0, 0xC0, 0x30,
  0x30, 0x18, 0x06, 0x0C, 0x03, 0x01, 0xC3, 0x80, 0x60, 0x30, 0xE0, 0x0C,
  0x06, 0x18, 0x71, 0x80, 0xC6, 0x3F, 0xB0, 0x31, 0xCE, 0x3E, 0x0E, 0x73,
  0x83, 0xE3, 0x8C, 0x60, 0x6F, 0xE3, 0x1C, 0x0C, 0xF8, 0xE3, 0x01, 0x80,
  0x18, 0x60, 0x30, 0x06, 0x1C, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x70, 0x60,
  0x18, 0x0C, 0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x18, 0x38,
  0x06, 0x07, 0x06, 0x00, 0xC0, 0xC1, 0x80, 0x1C, 0x38, 0x60, 0x01, 0xFE,
  0x1C, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x0E,
  0x0F, 0x00, 0x07, 0x01, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x0C, 0x00,
  0x38, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x38,
  0x00, 0x18, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x47,
  0x07, 0x00, 0x63, 0x80, 0xE0, 0x39, 0xC0, 0x18, 0x0C, 0xE0, 0x07, 0x07,
  0x38, 0x00, 0xE3, 0x8C, 0x00, 0x18, 0xC3, 0x00, 0x07, 0x70, 0xC0, 0x00,
  0xF8, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x1F, 0x03, 0x80, 0x0E, 0xE0, 0x78,
  0x0F, 0x1C, 0x0F, 0xFF, 0x83, 0x81, 0xFF, 0x80, 0xF0, 0x37, 0x76, 0x66,
  0x6C, 0xCC, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01,
  0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x01, 0xC0, 0xC0, 0x3C, 0x18, 0x01,
  0xE2, 0x00, 0x0F, 0xC0, 0x60, 0x7F, 0xFC, 0x07, 0xFF, 0x81, 0xB0, 0x00,
  0x66, 0x00, 0x18, 0x60, 0x07, 0x0C, 0x03, 0xC1, 0x80, 0x30, 0x18, 0x04,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0E, 0x1C, 0x30, 0xE1, 0x87,
  0x0C, 0x18, 0x60, 0xC3, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0x00, 0x6F, 0xFE,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03,
  0xC1, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0xE0, 0xC0, 0x06, 0x1C, 0x00, 0x73,
  0x80, 0x07, 0x38, 0x00, 0x73, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07,
  0x60, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00,
  0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00,
  0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xC0, 0x03, 0x8E, 0x00, 0x70, 0xE0,
  0x06, 0x07, 0x00, 0xE0, 0x78, 0x3C, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x00, 0x60, 0x3C, 0x0F, 0x87, 0xF1, 0xEC, 0xF1, 0xBC, 0x76, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xC0, 0x1F, 0x07, 0x80, 0xF0, 0x07, 0x01, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0x80, 0x3E, 0x0F, 0x01, 0xC0, 0x0E, 0x02, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x20,
  0x00, 0xE0, 0xE0, 0x0F, 0x83, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0xE6, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0x30, 0x00, 0x38, 0x60, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x80, 0x06, 0x07,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x30, 0x07, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x70, 0x03, 0x01, 0xC0, 0x06, 0x07, 0x00, 0x0C, 0x0F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC6, 0x00, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE1, 0x00, 0x0E, 0x0C, 0x01, 0xE0, 0x7F, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xF8, 0x10, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0xFC, 0x07,
  0x3F, 0xF0, 0x67, 0x07, 0x86, 0xC0, 0x18, 0xF8, 0x01, 0xCF, 0x00, 0x0C,
  0xE0, 0x00, 0xCE, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01,
  0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8E, 0x00, 0x38, 0x60, 0x03, 0x07, 0x00,
  0x70, 0x38, 0x1E, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x78, 0x3C, 0x07,
  0x00, 0xE0, 0x70, 0x03, 0x83, 0x00, 0x1C, 0x18, 0x00, 0x60, 0xC0, 0x03,
  0x06, 0x00, 0x38, 0x30, 0x01, 0x81, 0xC0, 0x1C, 0x06, 0x01, 0xC0, 0x38,
  0x3C, 0x00, 0xF7, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0x8F, 0x00,
  0xF0, 0x3C, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x86, 0x00, 0x0C, 0x70, 0x00,
  0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x06, 0x38,
  0x00, 0x70, 0xE0, 0x07, 0x07, 0x80, 0x70, 0x1F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xC1, 0xE0, 0x70, 0x0E, 0x0E,
  0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x38, 0x00, 0x33,
  0x80, 0x03, 0x38, 0x00, 0x33, 0x80, 0x03, 0x38, 0x00, 0x73, 0x80, 0x07,
  0x38, 0x00, 0xF1, 0xC0, 0x1F, 0x1E, 0x07, 0x70, 0xFF, 0xE6, 0x07, 0xF8,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x80,
  0x78, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x0F, 0x0F, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0xF0, 0xF0, 0xE0, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x3F, 0xFC, 0x38, 0x1E, 0x20, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x7F, 0x01, 0xC6, 0x00, 0xFF, 0xE0, 0x67,
  0x01, 0xE0, 0x60, 0x33, 0x01, 0xC0, 0x30, 0x1B, 0x80, 0xC0, 0x18, 0x0D,
  0x80, 0xC0, 0x1C, 0x06, 0xC0, 0xE0, 0x0C, 0x03, 0x60, 0x60, 0x06, 0x01,
  0xB0, 0x30, 0x07, 0x01, 0xF8, 0x18, 0x03, 0x00, 0xDC, 0x1C, 0x01, 0x80,
  0x6E, 0x0E, 0x01, 0xC0, 0x77, 0x07, 0x00, 0xE0, 0x33, 0x81, 0x80, 0xF0,
  0x38, 0xC0, 0xC0, 0xD8, 0x38, 0x60, 0x7F, 0xC7, 0xF8, 0x30, 0x1F, 0xC3,
  0xF8, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x04, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xB0, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x30,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x18, 0x00, 0x70, 0x1C,
  0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x03, 0x00, 0x0C, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0C, 0x0F, 0xF0, 0x18, 0x00, 0xE0,
  0x30, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06,
  0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x30, 0x70, 0x00, 0xE0, 0xC0,
  0x03, 0x81, 0x80, 0x3E, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1C, 0x01,
  0xE0, 0x30, 0x00, 0xE0, 0x60, 0x00, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x03,
  0x86, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0xE1, 0x80, 0x03, 0xC3, 0x00, 0x0F, 0x06, 0x00, 0xFC, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0xFC, 0x0F, 0x01, 0xE0, 0x01, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x60, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xC1, 0xFE,
  0x00, 0x60, 0x07, 0x80, 0x30, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x61, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x70,
  0x00, 0x06, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x63, 0x80, 0x00, 0x71, 0x80, 0x00, 0x38,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x38, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x3C,
  0x18, 0x00, 0x3C, 0x0C, 0x00, 0x7C, 0x06, 0x01, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0x80, 0x02, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xFC,
  0x60, 0x03, 0xFF, 0x38, 0x00, 0xFF, 0x8E, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x30, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80,
  0x70, 0x00, 0x60, 0x1F, 0x00, 0x78, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x70, 0x30, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x70, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x38,
  0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x06,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x07, 0x03, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0x70, 0x00,
  0x0C, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0xEF, 0x80, 0x3F, 0xC0, 0x07, 0xC0,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x0C,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x00,
  0x18, 0x07, 0x00, 0x06, 0x03, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xE1, 0xE0,
  0x00, 0x38, 0xF0, 0x00, 0x0C, 0x78, 0x00, 0x03, 0x38, 0x00, 0x01, 0xDF,
  0x00, 0x00, 0x7E, 0xC0, 0x00, 0x1F, 0x38, 0x00, 0x07, 0x06, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x03, 0x80,
  0x03, 0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x18, 0x01, 0x80, 0x07, 0x00, 0x60, 0x00, 0xC0, 0x38,
  0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3B, 0x00, 0x00, 0xD8, 0x19, 0x80, 0x00,
  0xCC, 0x0C, 0xC0, 0x00, 0xEE, 0x06, 0x60, 0x00, 0x67, 0x07, 0x30, 0x00,
  0x73, 0x03, 0x98, 0x00, 0x31, 0x81, 0x8E, 0x00, 0x38, 0xC0, 0xC3, 0x00,
  0x18, 0xE0, 0x61, 0x80, 0x18, 0x70, 0x70, 0xC0, 0x1C, 0x30, 0x38, 0x60,
  0x0C, 0x18, 0x18, 0x30, 0x0E, 0x0C, 0x0C, 0x1C, 0x06, 0x0E, 0x06, 0x0E,
  0x07, 0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x81, 0x83, 0x01, 0x81, 0x80,
  0xC3, 0x81, 0xC0, 0xC0, 0x61, 0x80, 0xE0, 0x60, 0x31, 0xC0, 0x70, 0x70,
  0x1C, 0xC0, 0x30, 0x38, 0x06, 0xC0, 0x18, 0x18, 0x03, 0x60, 0x1C, 0x0C,
  0x01, 0xE0, 0x0E, 0x0E, 0x00, 0xF0, 0x06, 0x07, 0x00, 0x70, 0x03, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x06, 0x03,
  0xC0, 0x00, 0x60, 0x3C, 0x00, 0x06, 0x03, 0xE0, 0x00, 0xE0, 0x76, 0x00,
  0x0E, 0x06, 0x60, 0x00, 0xC0, 0x67, 0x00, 0x0C, 0x06, 0x30, 0x00, 0xC0,
  0xE3, 0x80, 0x1C, 0x0E, 0x18, 0x01, 0xC0, 0xC1, 0x80, 0x18, 0x0C, 0x1C,
  0x01, 0x80, 0xC0, 0xC0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x38,
  0x18, 0x06, 0x03, 0x01, 0x80, 0x70, 0x30, 0x18, 0x03, 0x07, 0x03, 0x80,
  0x38, 0x70, 0x38, 0x01, 0x86, 0x03, 0x00, 0x18, 0x60, 0x30, 0x01, 0xC6,
  0x03, 0x00, 0x0C, 0xE0, 0x70, 0x00, 0xEE, 0x07, 0x00, 0x06, 0xC0, 0x60,
  0x00, 0x6C, 0x06, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03,
  0xC0, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x18, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0xE0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x0C, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC0, 0x70, 0x01, 0xE0,
  0x1F, 0x01, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x30, 0x7F, 0x00, 0xC0, 0x1E, 0x03, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0xE1, 0xC0, 0x07, 0x07, 0x00, 0x78, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x07, 0x18, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0D,
  0xC0, 0x00, 0x03, 0x70, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x83, 0x80, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x30, 0x7F,
  0x00, 0xC0, 0x0E, 0x03, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x00, 0xC1,
  0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80,
  0x07, 0x0C, 0x00, 0x38, 0x30, 0x01, 0xE1, 0xC0, 0x0F, 0x07, 0x03, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x38,
  0x06, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x70, 0x03,
  0x81, 0xC0, 0x06, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x60, 0x00, 0xC3,
  0x80, 0x03, 0x8E, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0,
  0xF8, 0x1E, 0x0F, 0x00, 0x20, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE1, 0x00, 0x0F, 0x0C, 0x01, 0xF0, 0x7F, 0xFE,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18,
  0x70, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x03,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x73, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x8C, 0x00, 0x0E,
  0x18, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0x81,
  0xC0, 0x06, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x18, 0x07, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0x60, 0x00, 0xC1, 0xC0, 0x01, 0x87, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x38,
  0x00, 0x0C, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x1B, 0x80, 0x0F, 0x80, 0x0E, 0xE0, 0x03, 0x60, 0x03, 0xB8, 0x00,
  0xD8, 0x01, 0xCE, 0x00, 0x66, 0x00, 0x73, 0x80, 0x19, 0x80, 0x18, 0xE0,
  0x0C, 0x60, 0x0E, 0x38, 0x03, 0x18, 0x03, 0x0E, 0x01, 0xC6, 0x01, 0xC1,
  0x80, 0x61, 0x80, 0x60, 0x60, 0x38, 0x60, 0x38, 0x18, 0x0C, 0x18, 0x0C,
  0x06, 0x07, 0x06, 0x07, 0x01, 0x81, 0x81, 0x81, 0xC0, 0x60, 0xE0, 0x60,
  0x60, 0x18, 0x30, 0x18, 0x38, 0x06, 0x1C, 0x07, 0x0C, 0x01, 0x86, 0x01,
  0xC7, 0x00, 0x63, 0x80, 0x71, 0x80, 0x18, 0xC0, 0x1C, 0xE0, 0x06, 0x70,
  0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x36, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x03, 0x00, 0x06, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x18, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x07, 0x00, 0x07, 0x00,
  0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x03,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xD8, 0x00, 0x1C, 0xC0, 0x01, 0xC7, 0x00, 0x0C, 0x18,
  0x00, 0xE0, 0xC0, 0x0E, 0x07, 0x00, 0x60, 0x38, 0x07, 0x00, 0xC0, 0x70,
  0x06, 0x07, 0x00, 0x38, 0x30, 0x01, 0xC3, 0x80, 0x06, 0x38, 0x00, 0x31,
  0x80, 0x01, 0xDC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x01,
  0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x70, 0x70, 0x30, 0x30, 0x30, 0x30,
  0x38, 0x38, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0E, 0x0E, 0x06, 0x06, 0x06, 0x06, 0x06, 0x07, 0x00, 0xFF, 0x00, 0xFF,
  0x01, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x64,
  0x00, 0x0C, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x30, 0x03, 0x83, 0x00, 0x30,
  0x30, 0x06, 0x01, 0x80, 0xE0, 0x18, 0x0C, 0x00, 0xC1, 0xC0, 0x0C, 0x18,
  0x00, 0xC3, 0x00, 0x06, 0x30, 0x00, 0x66, 0x00, 0x07, 0xE0, 0x00, 0x30,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xC7, 0x0E, 0x18, 0x30, 0xC0, 0x00,
  0xFE, 0x18, 0x1F, 0xF9, 0xC1, 0xE0, 0xEC, 0x1C, 0x03, 0x61, 0xC0, 0x0B,
  0x0C, 0x00, 0x78, 0xE0, 0x03, 0x86, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80,
  0x07, 0x18, 0x00, 0x39, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x70, 0x00, 0xE3,
  0x80, 0x07, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x03,
  0x60, 0xE0, 0x33, 0x07, 0x03, 0xB8, 0x1F, 0xF1, 0x80, 0x7F, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x87, 0xF0, 0x0C, 0x7F, 0xC0, 0x66, 0x07, 0x07, 0x60,
  0x1C, 0x3E, 0x00, 0xE1, 0xE0, 0x03, 0x0E, 0x00, 0x18, 0x70, 0x00, 0xC7,
  0x00, 0x06, 0x38, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00,
  0xE7, 0x00, 0x07, 0x38, 0x00, 0x31, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0xF0,
  0x01, 0xC7, 0x80, 0x1C, 0x36, 0x01, 0xE1, 0xB8, 0x1E, 0x0C, 0xFF, 0xE0,
  0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x78, 0x08, 0x38, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x04, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x03, 0xF8, 0x60, 0x1F, 0xF8, 0xC0, 0x78, 0x1B, 0x81, 0xC0, 0x1F, 0x07,
  0x00, 0x3C, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x60, 0x00, 0xE1, 0xC0,
  0x01, 0x83, 0x80, 0x03, 0x06, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x60, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0F,
  0x07, 0x00, 0x1E, 0x0E, 0x00, 0x78, 0x0E, 0x01, 0xB0, 0x1C, 0x0E, 0x60,
  0x1F, 0xF8, 0xC0, 0x1F, 0xC3, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x78,
  0x38, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xC0, 0x06,
  0x70, 0x03, 0x9C, 0x07, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0xF8, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x06, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x08, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x0C, 0x07, 0xFE, 0x30, 0x3C, 0x0C, 0xC1, 0xC0,
  0x1F, 0x0E, 0x00, 0x78, 0x30, 0x00, 0xE1, 0xC0, 0x03, 0x86, 0x00, 0x0E,
  0x38, 0x00, 0x30, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x70,
  0x00, 0x71, 0xC0, 0x01, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01,
  0xE1, 0xC0, 0x0F, 0x87, 0x00, 0x3C, 0x0E, 0x01, 0xB0, 0x38, 0x1C, 0xC0,
  0x7F, 0xE7, 0x00, 0xFE, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x02, 0x00, 0x38,
  0x0E, 0x03, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x87, 0xF0, 0x0C, 0x7F, 0xE0, 0x67, 0x07, 0x07, 0x60, 0x1C, 0x3E, 0x00,
  0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x0C, 0x38,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x60, 0x01, 0xC7, 0x00, 0x0C,
  0x38, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00,
  0x0C, 0x38, 0x00, 0x61, 0x80, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0xC0,
  0x01, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x1E, 0x0C, 0x01, 0xC0, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x1C,
  0x01, 0x81, 0xC0, 0x0C, 0x1C, 0x00, 0x61, 0xC0, 0x07, 0x1C, 0x00, 0x31,
  0xC0, 0x01, 0x9E, 0x00, 0x0D, 0xF0, 0x00, 0x79, 0xC0, 0x07, 0x8E, 0x00,
  0x38, 0x38, 0x01, 0x81, 0xC0, 0x0C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xC0, 0x30, 0x07, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xE0, 0xE0, 0x03, 0x80,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x00, 0x06, 0x1F, 0xC0, 0x7E, 0x03, 0x1F,
  0xF0, 0xFF, 0x81, 0x98, 0x38, 0xE0, 0xE1, 0xD8, 0x0C, 0xC0, 0x30, 0xD8,
  0x07, 0xC0, 0x18, 0x78, 0x03, 0xC0, 0x0C, 0x38, 0x01, 0xE0, 0x06, 0x1C,
  0x00, 0xE0, 0x03, 0x1C, 0x00, 0x70, 0x01, 0x8E, 0x00, 0x30, 0x01, 0xC6,
  0x00, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0x00, 0x61, 0x80, 0x0E, 0x00, 0x31,
  0xC0, 0x06, 0x00, 0x18, 0xE0, 0x03, 0x00, 0x1C, 0x60, 0x03, 0x80, 0x0E,
  0x30, 0x01, 0xC0, 0x06, 0x38, 0x00, 0xE0, 0x03, 0x1C, 0x00, 0x60, 0x03,
  0x8E, 0x00, 0x30, 0x01, 0xC6, 0x00, 0x38, 0x00, 0xE3, 0x00, 0x1C, 0x00,
  0x63, 0x80, 0x0C, 0x00, 0x30, 0x06, 0x1F, 0xE0, 0x31, 0xFF, 0x81, 0x9C,
  0x1C, 0x1D, 0x80, 0x70, 0xF8, 0x03, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0x87, 0x00, 0x1C, 0x30, 0x00,
  0xE3, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00, 0x1C, 0x30,
  0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00, 0x1C,
  0x30, 0x00, 0xE3, 0x80, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0x81, 0xC0, 0xE0, 0x0E, 0x1C, 0x00, 0x63, 0x80, 0x07, 0x38, 0x00, 0x73,
  0x00, 0x03, 0x70, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00,
  0xC6, 0x00, 0x1C, 0x70, 0x03, 0x87, 0x00, 0x78, 0x38, 0x0F, 0x01, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x01, 0x87, 0xF0, 0x03, 0x1F, 0xF0, 0x06, 0x70,
  0x70, 0x1D, 0x80, 0x70, 0x36, 0x00, 0xE0, 0x78, 0x00, 0xC0, 0xE0, 0x01,
  0x81, 0xC0, 0x03, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x60, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0x78, 0x01, 0xC0, 0xD8,
  0x07, 0x81, 0xB8, 0x1E, 0x03, 0x3F, 0xF8, 0x0E, 0x3F, 0xC0, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x18, 0x1F, 0xF8, 0xC1, 0xE0, 0x66, 0x1C,
  0x01, 0xF1, 0xC0, 0x0F, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0xC6, 0x00, 0x0E,
  0x70, 0x00, 0x73, 0x80, 0x03, 0x18, 0x00, 0x19, 0xC0, 0x01, 0xCE, 0x00,
  0x0E, 0x70, 0x00, 0x63, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0xC7,
  0x00, 0x3E, 0x38, 0x01, 0xE0, 0xE0, 0x1B, 0x07, 0x03, 0x98, 0x1F, 0xF9,
  0xC0, 0x7F, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x06, 0x1F, 0x83, 0x1F, 0x81, 0x9C,
  0x01, 0xD8, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3,
  0xC0, 0x61, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xCE, 0x01, 0xC7, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xE1, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0C, 0x00, 0x38, 0x60, 0x01, 0xC7,
  0x00, 0x0C, 0x38, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x38, 0xE0, 0x01,
  0xC7, 0x00, 0x0C, 0x38, 0x00, 0x61, 0x80, 0x07, 0x0C, 0x00, 0x38, 0xE0,
  0x01, 0xC7, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x0C, 0x00, 0x38,
  0xE0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x03, 0x60, 0xC0, 0x3B, 0x07, 0x03,
  0xB8, 0x3F, 0xF9, 0x80, 0x7F, 0x0C, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1B,
  0x80, 0x07, 0x30, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x0E, 0x18, 0x01, 0x83,
  0x80, 0x70, 0x70, 0x0C, 0x0E, 0x03, 0x80, 0xC0, 0xE0, 0x18, 0x1C, 0x03,
  0x07, 0x00, 0x60, 0xC0, 0x0C, 0x38, 0x01, 0xC6, 0x00, 0x39, 0xC0, 0x07,
  0x30, 0x00, 0x6E, 0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0x98, 0x03, 0xC0,
  0x1C, 0xC0, 0x1E, 0x00, 0xC6, 0x01, 0xB0, 0x0E, 0x30, 0x0D, 0x80, 0x71,
  0x80, 0xCC, 0x07, 0x0C, 0x06, 0x60, 0x38, 0x60, 0x73, 0x81, 0x83, 0x03,
  0x1C, 0x1C, 0x18, 0x38, 0x60, 0xC0, 0xC1, 0x83, 0x0E, 0x06, 0x1C, 0x18,
  0x60, 0x30, 0xC0, 0xC7, 0x01, 0x8E, 0x06, 0x30, 0x0C, 0x60, 0x33, 0x80,
  0x77, 0x01, 0x98, 0x03, 0xB0, 0x0D, 0xC0, 0x1F, 0x80, 0x6C, 0x00, 0xD8,
  0x03, 0x60, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x07,
  0x80, 0x00, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x38, 0x06, 0x00, 0xE0, 0x0E,
  0x03, 0x80, 0x0C, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x38, 0x70, 0x00, 0x31,
  0xC0, 0x00, 0x77, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x80, 0x00, 0xE3, 0x00,
  0x03, 0x87, 0x00, 0x0E, 0x06, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x1C, 0x07, 0x00, 0x18, 0x3C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x03,
  0x81, 0xC0, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x18, 0x00,
  0xE0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x60, 0x03, 0x80, 0x70, 0x01, 0xC0,
  0x30, 0x00, 0x60, 0x38, 0x00, 0x30, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0C,
  0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x1E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x3C, 0x07, 0xFF, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_LightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 31, 10, 1, -31 },
  { 40, 11, 11, 15, 5, -31 },
  { 56, 26, 31, 27, 1, -31 },
  { 157, 20, 36, 24, 2, -33 },
  { 247, 27, 31, 34, 4, -31 },
  { 352, 26, 31, 29, 2, -31 },
  { 453, 4, 11, 8, 5, -31 },
  { 459, 13, 38, 11, 2, -31 },
  { 521, 13, 38, 11, -3, -31 },
  { 583, 19, 19, 23, 5, -33 },
  { 629, 20, 20, 25, 3, -25 },
  { 679, 7, 11, 9, -2, -5 },
  { 689, 11, 3, 13, 1, -13 },
  { 694, 4, 4, 10, 1, -4 },
  { 696, 20, 31, 14, -2, -31 },
  { 774, 20, 31, 24, 3, -31 },
  { 852, 11, 31, 24, 7, -31 },
  { 895, 22, 31, 24, 0, -31 },
  { 981, 22, 31, 24, 1, -31 },
  { 1067, 23, 31, 24, 0, -31 },
  { 1157, 21, 31, 24, 2, -31 },
  { 1239, 20, 31, 24, 3, -31 },
  { 1317, 20, 31, 24, 4, -31 },
  { 1395, 21, 31, 24, 2, -31 },
  { 1477, 20, 31, 24, 2, -31 },
  { 1555, 8, 23, 10, 1, -23 },
  { 1578, 11, 29, 10, -2, -23 },
  { 1618, 20, 21, 25, 3, -26 },
  { 1671, 20, 11, 25, 3, -21 },
  { 1699, 20, 21, 25, 3, -26 },
  { 1752, 16, 31, 18, 3, -31 },
  { 1814, 33, 35, 36, 2, -31 },
  { 1959, 24, 31, 24, -2, -31 },
  { 2052, 23, 31, 26, 2, -31 },
  { 2142, 24, 31, 25, 3, -31 },
  { 2235, 25, 31, 29, 2, -31 },
  { 2332, 22, 31, 23, 2, -31 },
  { 2418, 22, 31, 21, 2, -31 },
  { 2504, 26, 31, 29, 3, -31 },
  { 2605, 27, 31, 29, 2, -31 },
  { 2710, 15, 31, 13, 0, -31 },
  { 2769, 18, 39, 11, -7, -31 },
  { 2857, 26, 31, 24, 2, -31 },
  { 2958, 16, 31, 21, 2, -31 },
  { 3020, 33, 31, 35, 2, -31 },
  { 3148, 28, 31, 30, 2, -31 },
  { 3257, 26, 31, 31, 3, -31 },
  { 3358, 22, 31, 24, 2, -31 },
  { 3444, 26, 38, 31, 3, -31 },
  { 3568, 22, 31, 24, 2, -31 },
  { 3654, 21, 31, 22, 1, -31 },
  { 3736, 21, 31, 21, 4, -31 },
  { 3818, 26, 31, 29, 4, -31 },
  { 3919, 23, 31, 23, 4, -31 },
  { 4009, 34, 31, 36, 5, -31 },
  { 4141, 27, 31, 22, -2, -31 },
  { 4246, 21, 31, 21, 4, -31 },
  { 4328, 25, 31, 23, 0, -31 },
  { 4425, 16, 38, 13, 0, -31 },
  { 4501, 8, 31, 14, 4, -31 },
  { 4532, 16, 38, 13, -3, -31 },
  { 4608, 20, 19, 24, 2, -31 },
  { 4656, 17, 2, 16, -4, 4 },
  { 4661, 6, 7, 11, 6, -33 },
  { 4667, 21, 23, 24, 2, -23 },
  { 4728, 21, 33, 25, 1, -33 },
  { 4815, 18, 23, 19, 2, -23 },
  { 4867, 23, 33, 25, 2, -33 },
  { 4962, 18, 23, 21, 2, -23 },
  { 5014, 23, 43, 13, -5, -33 },
  { 5138, 22, 33, 25, 1, -23 },
  { 5229, 21, 33, 24, 1, -33 },
  { 5316, 9, 31, 10, 1, -31 },
  { 5351, 16, 41, 10, -6, -31 },
  { 5433, 21, 33, 20, 1, -33 },
  { 5520, 10, 33, 10, 1, -33 },
  { 5562, 33, 23, 37, 1, -23 },
  { 5657, 21, 23, 24, 1, -23 },
  { 5718, 20, 23, 24, 2, -23 },
  { 5776, 23, 33, 25, -1, -23 },
  { 5871, 21, 33, 25, 2, -23 },
  { 5958, 17, 23, 17, 1, -23 },
  { 6007, 17, 23, 18, 0, -23 },
  { 6056, 13, 28, 14, 2, -28 },
  { 6102, 21, 23, 24, 2, -23 },
  { 6163, 19, 23, 19, 2, -23 },
  { 6218, 29, 23, 30, 2, -23 },
  { 6302, 23, 23, 20, -2, -23 },
  { 6369, 25, 33, 19, -4, -23 },
  { 6473, 20, 23, 19, -1, -23 },
  { 6531, 16, 38, 15, 1, -31 },
  { 6607, 2, 43, 23, 12, -33 },
  { 6618, 16, 38, 15, -2, -31 },
  { 6694, 20, 5, 25, 3, -18 },
};

const GFXfont NotoSans_LightItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_LIGHTITALIC43PT7B_H_
