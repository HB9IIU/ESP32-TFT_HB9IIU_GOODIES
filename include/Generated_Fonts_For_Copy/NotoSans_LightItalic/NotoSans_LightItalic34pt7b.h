#ifndef _NOTOSANS_LIGHTITALIC34PT7B_H_
#define _NOTOSANS_LIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC1,
  0x06, 0x0C, 0x18, 0x30, 0x40, 0x00, 0x00, 0x1C, 0x38, 0x70, 0x63, 0xB1,
  0x98, 0xC8, 0x6C, 0x26, 0x33, 0x19, 0x0C, 0x84, 0x00, 0x00, 0x60, 0x40,
  0x03, 0x06, 0x00, 0x10, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x40,
  0xC0, 0x06, 0x04, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x08, 0x18, 0x00,
  0xC0, 0x80, 0x06, 0x0C, 0x00, 0x20, 0x60, 0x03, 0x02, 0x00, 0x18, 0x30,
  0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x60, 0x40, 0x03, 0x06, 0x00, 0x10,
  0x30, 0x01, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x1F, 0x80, 0x3F, 0xF8, 0x31,
  0x08, 0x30, 0x80, 0x10, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x03, 0x10, 0x01,
  0x88, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0x38, 0x00, 0x8C,
  0x00, 0xC3, 0x00, 0x61, 0x80, 0x20, 0x80, 0x10, 0xC4, 0x18, 0xE3, 0xEF,
  0xC0, 0xFF, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x08, 0x7E, 0x00, 0xC3, 0x18, 0x02, 0x08, 0x30, 0x18, 0x60,
  0xC0, 0xC1, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0xC0, 0xC0, 0x86,
  0x03, 0x06, 0x30, 0x0C, 0x18, 0xCF, 0x30, 0x66, 0x7E, 0xC3, 0x33, 0x0F,
  0x19, 0x98, 0x37, 0xC6, 0x60, 0xCC, 0x31, 0x03, 0x01, 0x8C, 0x0C, 0x04,
  0x30, 0x30, 0x30, 0xC0, 0x81, 0x83, 0x06, 0x0C, 0x0C, 0x18, 0x20, 0x30,
  0x41, 0x80, 0xC3, 0x0C, 0x03, 0x98, 0x60, 0x07, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0xF0, 0x00, 0x61, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0x40, 0x60, 0x03, 0x06, 0x00, 0x18, 0x60, 0x00,
  0x6E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x30, 0x00, 0x61, 0xC0,
  0xE6, 0x06, 0x06, 0x60, 0x18, 0x63, 0x00, 0x63, 0x30, 0x03, 0xB1, 0x80,
  0x0F, 0x0C, 0x00, 0x30, 0x30, 0x03, 0xC1, 0xC0, 0x76, 0x07, 0x9F, 0x18,
  0x1F, 0xE0, 0x60, 0x6D, 0xAD, 0xB4, 0x80, 0x00, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x03,
  0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x0C, 0x10, 0x1E, 0x20, 0x07,
  0x40, 0x83, 0xFF, 0x07, 0x00, 0x1B, 0x00, 0x66, 0x01, 0x86, 0x06, 0x0C,
  0x04, 0x08, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x0C, 0x71, 0x86, 0x30, 0xC6, 0x38, 0xFF, 0xFF, 0x7F, 0x80, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x03, 0xFC, 0x07, 0x0E, 0x0E, 0x06, 0x1C, 0x03, 0x18, 0x03, 0x30,
  0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60,
  0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x38, 0x60, 0x70, 0x3D, 0xE0, 0x1F,
  0x80, 0x01, 0x83, 0xC7, 0x67, 0x3F, 0x32, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x60, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0x38, 0x38, 0x18,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xF8, 0xFF, 0xFE,
  0x00, 0x00, 0x70, 0x01, 0xFF, 0x03, 0xC1, 0xC1, 0x80, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x62,
  0x00, 0x61, 0xF3, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x36, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x30, 0x03,
  0x8C, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x18, 0x0C, 0x06,
  0x06, 0x01, 0x83, 0x00, 0x41, 0x80, 0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x03, 0xFF, 0x81, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0xF0, 0x07, 0xFE,
  0x01, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC4, 0x01, 0xC3,
  0xE7, 0xC0, 0xFF, 0x80, 0x00, 0x0E, 0x80, 0x7F, 0x80, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0xFC, 0x0C, 0xFF, 0x07, 0x80, 0xC3, 0x80, 0x71, 0x80, 0x19,
  0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x00,
  0xC3, 0x00, 0xC1, 0xC0, 0xE0, 0x79, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x03, 0xFC, 0x07, 0x0E, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x03,
  0x18, 0x03, 0x0C, 0x06, 0x0C, 0x0E, 0x06, 0x1C, 0x03, 0xF0, 0x07, 0xC0,
  0x1E, 0x70, 0x38, 0x38, 0x60, 0x1C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xE0, 0x38, 0x78, 0xF0, 0x3F, 0xC0,
  0x00, 0xC0, 0x07, 0xF8, 0x0E, 0x1C, 0x1C, 0x06, 0x18, 0x06, 0x30, 0x03,
  0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x07, 0x60, 0x06,
  0x30, 0x0E, 0x38, 0x36, 0x1F, 0xE6, 0x07, 0x8C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0xC7, 0x80,
  0xFF, 0x00, 0x1C, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0xE3, 0x80, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x38, 0x18, 0x0C,
  0x0C, 0x06, 0x06, 0x06, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x06, 0x07, 0xFC, 0x70, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x1C, 0x00, 0xE0,
  0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0xC0, 0x7F, 0x82, 0x60, 0x70, 0x60, 0xD8, 0x38, 0x18, 0x34, 0x0C,
  0x04, 0x0F, 0x06, 0x03, 0x03, 0xC1, 0x80, 0xC0, 0xB0, 0xC0, 0x20, 0x2C,
  0x30, 0x18, 0x1B, 0x0C, 0x06, 0x06, 0xC3, 0x03, 0x83, 0x30, 0xC0, 0xE1,
  0xCC, 0x18, 0xCC, 0xE3, 0x03, 0xE3, 0xF0, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x40, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x34, 0x00, 0x06, 0x80, 0x01, 0x98, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x03,
  0x8C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0xC0, 0x60, 0x18,
  0x0C, 0x06, 0x01, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0E, 0x00, 0xC1, 0x80,
  0x18, 0x60, 0x01, 0x0C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00,
  0x1F, 0x00, 0x03, 0x07, 0xFE, 0x03, 0x07, 0xE0, 0xC0, 0x18, 0x30, 0x07,
  0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06, 0x18, 0x01, 0x86,
  0x01, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x30, 0x1E, 0x0C, 0x01, 0x83, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x1C,
  0xC0, 0x06, 0x30, 0x07, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x0E, 0x00,
  0x1F, 0xFC, 0x0F, 0x07, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xFB, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0xC3, 0xF0, 0x0C, 0x03, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0xE1, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x07, 0x18, 0x00, 0x31, 0x80, 0x03, 0x30, 0x00,
  0x33, 0x00, 0x07, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x66, 0x00,
  0x0E, 0x60, 0x00, 0xC6, 0x00, 0x1C, 0x60, 0x03, 0x84, 0x00, 0x70, 0xC0,
  0x0E, 0x0C, 0x03, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x86,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x07, 0xFF, 0x86, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x03, 0xC0, 0xE0, 0x70,
  0x02, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x03, 0xFC, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0xE0, 0x01, 0x87, 0x00, 0x30, 0x38, 0x03,
  0x01, 0xF7, 0xF0, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x06, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x04, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x07, 0xF0, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x0F, 0xE0, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x06, 0x00, 0xF0, 0xC0, 0x1C, 0x0C,
  0x03, 0x80, 0xC0, 0x70, 0x0C, 0x0E, 0x01, 0x81, 0xC0, 0x18, 0x38, 0x01,
  0x86, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x80, 0x03, 0x78, 0x00,
  0x3C, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xE0, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x06, 0x03, 0x00, 0x60, 0x30, 0x04, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x00,
  0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x68, 0x3C, 0x00, 0x1E, 0x0B, 0x00, 0x0D, 0x86, 0x40,
  0x03, 0x61, 0x90, 0x01, 0x98, 0x66, 0x00, 0xCC, 0x19, 0x80, 0x33, 0x06,
  0x60, 0x18, 0xC3, 0x18, 0x06, 0x30, 0xC6, 0x03, 0x0C, 0x30, 0x80, 0xC6,
  0x0C, 0x30, 0x61, 0x82, 0x0C, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x60, 0xC6,
  0x0C, 0x18, 0x31, 0x83, 0x06, 0x04, 0xC0, 0xC3, 0x01, 0x20, 0x30, 0xC0,
  0x78, 0x0C, 0x30, 0x1C, 0x06, 0x0C, 0x07, 0x01, 0x83, 0x01, 0x80, 0x60,
  0x0E, 0x00, 0x1C, 0x38, 0x00, 0x60, 0xF0, 0x01, 0x83, 0xC0, 0x06, 0x09,
  0x80, 0x10, 0x66, 0x00, 0xC1, 0x98, 0x03, 0x06, 0x30, 0x0C, 0x18, 0xC0,
  0x30, 0x61, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60,
  0xC0, 0xC1, 0x82, 0x01, 0x8C, 0x18, 0x06, 0x30, 0x60, 0x18, 0xC1, 0x80,
  0x33, 0x06, 0x00, 0xCC, 0x30, 0x01, 0xE0, 0xC0, 0x07, 0x83, 0x00, 0x1E,
  0x0C, 0x00, 0x38, 0x30, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x07,
  0x83, 0xC0, 0xE0, 0x0E, 0x1C, 0x00, 0x63, 0x80, 0x07, 0x30, 0x00, 0x37,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xE0, 0x01, 0x86, 0x00,
  0x38, 0x38, 0x0F, 0x01, 0xF7, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x06,
  0x1F, 0x83, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x8C, 0x01, 0xC6, 0x01, 0xC3, 0xFF,
  0xC1, 0xFF, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x07, 0x83, 0xC0, 0xE0, 0x0E, 0x1C, 0x00,
  0x63, 0x80, 0x07, 0x30, 0x00, 0x37, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0xE0, 0x01, 0x86, 0x00, 0x38, 0x38, 0x0F, 0x01, 0xF7, 0xC0,
  0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0xFC, 0x06, 0x1F, 0x83, 0x00,
  0xC1, 0x80, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18,
  0x01, 0x8C, 0x01, 0x8C, 0x01, 0xC6, 0x07, 0x83, 0xFF, 0x81, 0xFF, 0x00,
  0xC1, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x06, 0x0C, 0x03,
  0x0C, 0x01, 0x86, 0x00, 0x63, 0x00, 0x31, 0x80, 0x1C, 0x00, 0x38, 0x03,
  0xFF, 0x07, 0x07, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x80, 0x38, 0xFB, 0xF0, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00,
  0x63, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x60, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0E, 0x00, 0x60, 0x38, 0x0E, 0x00,
  0xFB, 0xE0, 0x03, 0xFE, 0x00, 0xC0, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x19,
  0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x30, 0x60,
  0x1C, 0x08, 0x06, 0x03, 0x03, 0x80, 0xC0, 0xC0, 0x30, 0x60, 0x0C, 0x18,
  0x03, 0x0C, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x01, 0x30, 0x00,
  0x6C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x1B, 0x00, 0x78, 0x03, 0x60, 0x0F, 0x00,
  0xCC, 0x03, 0x60, 0x19, 0x80, 0x6C, 0x03, 0x30, 0x19, 0x80, 0xC6, 0x03,
  0x30, 0x18, 0xC0, 0xC6, 0x06, 0x18, 0x18, 0xC0, 0xC3, 0x06, 0x18, 0x30,
  0x60, 0xC3, 0x06, 0x04, 0x10, 0x21, 0x80, 0x86, 0x04, 0x30, 0x10, 0x80,
  0x84, 0x03, 0x30, 0x11, 0x80, 0x66, 0x03, 0x30, 0x0D, 0x80, 0x6C, 0x01,
  0xB0, 0x0D, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x1C, 0x06,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x06,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x66, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0C,
  0xC0, 0x00, 0x63, 0x00, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x0C, 0x07, 0x00, 0x18, 0x38,
  0x00, 0x60, 0xC0, 0x03, 0xB0, 0x01, 0x98, 0x01, 0x8C, 0x01, 0x82, 0x01,
  0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xE0, 0x18, 0x60, 0x0C, 0x60, 0x06,
  0x60, 0x01, 0x30, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0x03, 0xF8, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F,
  0xE0, 0x00, 0xC1, 0x86, 0x18, 0x61, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x10,
  0x61, 0x86, 0x18, 0x60, 0x83, 0x0C, 0x30, 0xC3, 0x03, 0xF0, 0x43, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x32,
  0x00, 0x31, 0x80, 0x18, 0xC0, 0x18, 0x20, 0x0C, 0x18, 0x0C, 0x04, 0x04,
  0x03, 0x06, 0x01, 0x86, 0x00, 0x43, 0x00, 0x33, 0x00, 0x1B, 0x80, 0x06,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x18, 0x61, 0x80, 0x07, 0xF3, 0x0E, 0x3B,
  0x18, 0x0B, 0x30, 0x0E, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x38,
  0xC0, 0x78, 0xE0, 0xD8, 0x73, 0x98, 0x3F, 0x10, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0xFE, 0x04, 0xE7, 0x86, 0xC0, 0xC3, 0xC0, 0x61, 0xC0, 0x18,
  0xC0, 0x0C, 0xE0, 0x06, 0x60, 0x03, 0x30, 0x03, 0x98, 0x01, 0x8C, 0x00,
  0xCC, 0x00, 0x66, 0x00, 0x63, 0x80, 0x31, 0xC0, 0x30, 0xB0, 0x38, 0xCE,
  0x78, 0x63, 0xF0, 0x00, 0x07, 0xFC, 0x38, 0x61, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0xE0, 0x7F, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x07, 0xF3, 0x03, 0x8E, 0xC1, 0x80,
  0xB0, 0xC0, 0x1C, 0x70, 0x06, 0x18, 0x01, 0x86, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x1C, 0x30,
  0x0F, 0x0C, 0x03, 0x83, 0x83, 0x60, 0x73, 0x98, 0x0F, 0xC6, 0x00, 0x07,
  0xF0, 0x38, 0xE1, 0xC0, 0xCC, 0x03, 0x30, 0x0D, 0x80, 0x66, 0x03, 0xB0,
  0x3C, 0xFF, 0xC3, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x04, 0x3C, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x03, 0xFE, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xF8, 0x83, 0x8E, 0xC3, 0x01, 0x63, 0x00,
  0x73, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30,
  0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0xF1, 0x80, 0xF0,
  0xE0, 0xD8, 0x39, 0xCC, 0x0F, 0xC6, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC1, 0x00, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0xFE, 0x09, 0xC7, 0x1B, 0x03, 0x1E, 0x03,
  0x1C, 0x03, 0x18, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x06,
  0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x06, 0x08,
  0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x18,
  0x60, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x1F, 0x80, 0xF8, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x07, 0x08, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x18, 0x60, 0x18, 0xC0,
  0x31, 0x80, 0x33, 0x00, 0x37, 0x00, 0x3D, 0x80, 0x39, 0x80, 0x70, 0xC0,
  0x60, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x40, 0x30, 0xC0, 0x30, 0xC0, 0x18,
  0x06, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83,
  0x0C, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x80, 0x08,
  0xFC, 0x1F, 0x82, 0x63, 0x9C, 0x71, 0xB0, 0x6C, 0x0C, 0x78, 0x1A, 0x03,
  0x1C, 0x07, 0x00, 0xC6, 0x01, 0xC0, 0x33, 0x80, 0x60, 0x0C, 0xC0, 0x18,
  0x03, 0x30, 0x06, 0x00, 0xCC, 0x01, 0x80, 0x63, 0x00, 0xC0, 0x19, 0x80,
  0x30, 0x06, 0x60, 0x0C, 0x01, 0x98, 0x03, 0x00, 0xC6, 0x01, 0x80, 0x31,
  0x80, 0x60, 0x0C, 0xC0, 0x18, 0x03, 0x30, 0x06, 0x00, 0xC0, 0x04, 0x10,
  0x08, 0xFE, 0x19, 0xCF, 0x1B, 0x03, 0x1E, 0x03, 0x1C, 0x03, 0x18, 0x03,
  0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0xE0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0x07, 0xF8, 0x1C, 0x38, 0x60, 0x31, 0x80, 0x37, 0x00, 0x6C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xD8, 0x01, 0xB0, 0x06, 0x30, 0x18, 0x3D, 0xE0, 0x3F, 0x80, 0x02, 0x3F,
  0x80, 0x4E, 0x78, 0x1B, 0x03, 0x03, 0xC0, 0x60, 0x70, 0x06, 0x0C, 0x00,
  0xC3, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x18, 0x30, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x18, 0x38, 0x03, 0x07, 0x00, 0xC0, 0xB0, 0x38,
  0x33, 0x9E, 0x06, 0x3F, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00,
  0x07, 0xF1, 0x0E, 0x3B, 0x18, 0x0B, 0x30, 0x07, 0x70, 0x06, 0x60, 0x06,
  0x60, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x1C, 0xC0, 0x3C, 0xC0, 0x38, 0xE0, 0xD8, 0x73, 0x98, 0x3F, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x08, 0xF8, 0x4E, 0x46, 0xC0, 0x3C, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x07, 0xF8,
  0x38, 0x71, 0x80, 0x06, 0x00, 0x10, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x20, 0x18, 0xF3, 0xE1, 0xFE, 0x00, 0x0C, 0x02, 0x01, 0x80, 0x60, 0xFF,
  0xCC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE4, 0x1F, 0x00, 0x38, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18,
  0xC0, 0x38, 0xC0, 0x78, 0xC0, 0xD8, 0x73, 0x98, 0x7F, 0x10, 0xC0, 0x0F,
  0x80, 0x1B, 0x00, 0x66, 0x01, 0xCC, 0x03, 0x18, 0x0C, 0x10, 0x18, 0x30,
  0x60, 0x60, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x06, 0x70, 0x04, 0xC0,
  0x0B, 0x00, 0x16, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x30, 0x0F, 0x80,
  0xE0, 0x1B, 0x01, 0xC0, 0x66, 0x06, 0x80, 0xCC, 0x0D, 0x03, 0x18, 0x33,
  0x06, 0x30, 0x66, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x18, 0xE1, 0x8C, 0x31,
  0x83, 0x18, 0x63, 0x06, 0x60, 0xCC, 0x04, 0xC1, 0x98, 0x0B, 0x03, 0x60,
  0x16, 0x02, 0xC0, 0x28, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x00,
  0x0C, 0x01, 0xC1, 0x80, 0xC0, 0x60, 0x60, 0x18, 0x38, 0x03, 0x1C, 0x00,
  0xC6, 0x00, 0x1B, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x36,
  0x00, 0x1D, 0x80, 0x06, 0x30, 0x03, 0x0C, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0x60, 0x0C, 0x38, 0x03, 0x00, 0x03, 0x00, 0x38, 0x18, 0x01, 0x80, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x80, 0xC0, 0x06, 0x06, 0x00,
  0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x01, 0x18,
  0x00, 0x08, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x40, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xDE, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xF1, 0xFF, 0xE0,
  0x00, 0xF0, 0x1E, 0x03, 0x80, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x1C, 0x07, 0x80, 0xE0, 0x07, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x1F, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x07, 0x80, 0xF0,
  0x00, 0x1E, 0x01, 0x7F, 0x81, 0xC1, 0xFF, 0x80, 0x3C,
};

const GFXglyph NotoSans_LightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 24, 8, 1, -24 },
  { 22, 9, 9, 12, 4, -24 },
  { 33, 21, 24, 21, 1, -24 },
  { 96, 17, 28, 19, 1, -26 },
  { 156, 22, 25, 27, 3, -25 },
  { 225, 21, 25, 23, 1, -25 },
  { 291, 3, 9, 7, 4, -24 },
  { 295, 11, 29, 9, 1, -24 },
  { 335, 10, 29, 9, -2, -24 },
  { 372, 15, 15, 18, 4, -26 },
  { 401, 16, 16, 19, 2, -20 },
  { 433, 6, 8, 7, -2, -4 },
  { 439, 8, 2, 11, 1, -10 },
  { 441, 3, 3, 8, 1, -3 },
  { 443, 16, 24, 11, -2, -24 },
  { 491, 16, 25, 19, 2, -25 },
  { 541, 9, 24, 19, 5, -24 },
  { 568, 18, 25, 19, 0, -25 },
  { 625, 17, 25, 19, 1, -25 },
  { 679, 18, 24, 19, 0, -24 },
  { 733, 17, 24, 19, 1, -24 },
  { 784, 17, 25, 19, 2, -25 },
  { 838, 16, 24, 19, 3, -24 },
  { 886, 16, 25, 19, 2, -25 },
  { 936, 16, 25, 19, 2, -25 },
  { 986, 6, 18, 8, 1, -18 },
  { 1000, 9, 22, 8, -2, -18 },
  { 1025, 16, 16, 19, 2, -20 },
  { 1057, 15, 8, 19, 3, -16 },
  { 1072, 16, 16, 19, 2, -20 },
  { 1104, 12, 25, 14, 3, -25 },
  { 1142, 26, 27, 29, 2, -24 },
  { 1230, 19, 24, 19, -2, -24 },
  { 1287, 18, 24, 20, 2, -24 },
  { 1341, 19, 25, 20, 3, -25 },
  { 1401, 20, 24, 23, 2, -24 },
  { 1461, 17, 24, 18, 2, -24 },
  { 1512, 17, 24, 16, 2, -24 },
  { 1563, 20, 25, 23, 3, -25 },
  { 1626, 21, 24, 23, 2, -24 },
  { 1689, 12, 24, 10, 0, -24 },
  { 1725, 15, 30, 9, -6, -24 },
  { 1782, 20, 24, 19, 2, -24 },
  { 1842, 12, 24, 16, 2, -24 },
  { 1878, 26, 24, 28, 2, -24 },
  { 1956, 22, 24, 24, 2, -24 },
  { 2022, 20, 25, 24, 3, -25 },
  { 2085, 17, 24, 19, 2, -24 },
  { 2136, 20, 31, 24, 3, -25 },
  { 2214, 17, 24, 19, 2, -24 },
  { 2265, 16, 25, 17, 1, -25 },
  { 2315, 17, 24, 17, 3, -24 },
  { 2366, 21, 24, 23, 3, -24 },
  { 2429, 18, 24, 19, 3, -24 },
  { 2483, 27, 24, 29, 4, -24 },
  { 2564, 22, 24, 17, -2, -24 },
  { 2630, 17, 24, 17, 3, -24 },
  { 2681, 19, 24, 18, 0, -24 },
  { 2738, 13, 29, 10, 0, -24 },
  { 2786, 6, 24, 11, 3, -24 },
  { 2804, 12, 29, 10, -2, -24 },
  { 2848, 17, 15, 19, 1, -24 },
  { 2880, 13, 2, 13, -3, 3 },
  { 2884, 5, 5, 9, 5, -26 },
  { 2888, 16, 18, 19, 2, -18 },
  { 2924, 17, 26, 20, 1, -26 },
  { 2980, 14, 18, 15, 2, -18 },
  { 3012, 18, 26, 20, 2, -26 },
  { 3071, 14, 18, 17, 2, -18 },
  { 3103, 19, 34, 10, -4, -26 },
  { 3184, 17, 26, 20, 1, -18 },
  { 3240, 16, 26, 19, 1, -26 },
  { 3292, 7, 25, 8, 1, -25 },
  { 3314, 13, 33, 8, -5, -25 },
  { 3368, 16, 26, 16, 1, -26 },
  { 3420, 7, 26, 8, 1, -26 },
  { 3443, 26, 18, 29, 1, -18 },
  { 3502, 16, 19, 19, 1, -19 },
  { 3540, 15, 18, 19, 2, -18 },
  { 3574, 19, 26, 20, -1, -18 },
  { 3636, 16, 26, 20, 2, -18 },
  { 3688, 13, 18, 13, 1, -18 },
  { 3718, 14, 18, 15, 0, -18 },
  { 3750, 10, 22, 11, 2, -22 },
  { 3778, 16, 18, 19, 2, -18 },
  { 3814, 15, 18, 15, 2, -18 },
  { 3848, 23, 18, 23, 2, -18 },
  { 3900, 18, 18, 16, -1, -18 },
  { 3941, 21, 26, 15, -4, -18 },
  { 4010, 15, 18, 15, 0, -18 },
  { 4044, 12, 29, 12, 1, -24 },
  { 4088, 2, 34, 18, 9, -26 },
  { 4097, 12, 29, 12, -1, -24 },
  { 4141, 16, 4, 19, 2, -14 },
};

const GFXfont NotoSans_LightItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_LIGHTITALIC34PT7B_H_
