#ifndef _NOTOSANS_LIGHTITALIC55PT7B_H_
#define _NOTOSANS_LIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x01, 0xE0, 0x04, 0x00, 0x3C, 0x1C, 0xE0, 0x73, 0x83, 0xCE,
  0x0E, 0x38, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0C, 0x70, 0x71, 0x81, 0xC6,
  0x07, 0x38, 0x18, 0xE0, 0x63, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0x80, 0x38, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xF0, 0xC1, 0xC0, 0x78, 0x38, 0x08, 0x0E, 0x07,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x0F, 0x0C, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0E, 0xF8,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x30, 0x78, 0x00, 0x06, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x70,
  0x00, 0x18, 0x1E, 0x00, 0x07, 0x03, 0x82, 0x00, 0xE0, 0xF0, 0x70, 0x18,
  0x7C, 0x0F, 0xFB, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x70, 0x3F, 0xF8, 0x00, 0x1C, 0x0F, 0x07, 0x00,
  0x07, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x70, 0x0E, 0x00, 0x38, 0x0E, 0x01,
  0xC0, 0x0E, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0C,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x03, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x30, 0x03, 0x83,
  0x80, 0x06, 0x00, 0x70, 0x70, 0x00, 0xC0, 0x1C, 0x1C, 0x3F, 0x18, 0x03,
  0x87, 0x0F, 0xF3, 0x00, 0x61, 0xC3, 0xFF, 0x70, 0x1C, 0x38, 0xE0, 0xFE,
  0x07, 0x0E, 0x38, 0x0F, 0xE1, 0xE3, 0x86, 0x01, 0xDF, 0xF8, 0xE1, 0xC0,
  0x39, 0xFE, 0x1C, 0x38, 0x03, 0x0F, 0x07, 0x0E, 0x00, 0xE0, 0x01, 0xC1,
  0xC0, 0x1C, 0x00, 0x70, 0x38, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x70, 0x03,
  0x81, 0xC0, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x03, 0x80,
  0x70, 0x1C, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0x70, 0x38, 0x00, 0x1C, 0x3C, 0x07, 0x00, 0x03, 0xFF, 0x03, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x70,
  0xF8, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x3E, 0x07, 0x00, 0x0E, 0x3C, 0x03, 0xC0, 0x0E, 0x3C,
  0x00, 0xF0, 0x07, 0x1C, 0x00, 0x38, 0x07, 0x1E, 0x00, 0x1E, 0x03, 0x8E,
  0x00, 0x07, 0x83, 0x8F, 0x00, 0x01, 0xC3, 0xC7, 0x00, 0x00, 0x73, 0xC3,
  0x80, 0x00, 0x3F, 0xC1, 0xC0, 0x00, 0x0F, 0xC0, 0xE0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x03, 0xDC,
  0x07, 0xC0, 0x07, 0xC7, 0x01, 0xF8, 0x1F, 0x83, 0xC0, 0x7F, 0xFF, 0x80,
  0xF0, 0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0xE3,
  0x8E, 0x39, 0xC7, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x00, 0x00, 0x07, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0x78, 0x0C, 0x00, 0xFE, 0x0C, 0x00,
  0x1F, 0x1C, 0x00, 0x07, 0xD8, 0x01, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x78, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x8E, 0x00,
  0x07, 0x06, 0x00, 0x0E, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x3C, 0x03, 0x80,
  0x18, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x83,
  0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3B, 0xDF, 0xF7, 0x90, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x1E,
  0x00, 0x0F, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x78, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0E, 0x3C, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1C,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x00, 0xE0, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x07, 0xC3, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0xC0, 0xF7, 0x0F, 0xB8, 0x7C,
  0xE7, 0xC3, 0xBE, 0x0E, 0xE0, 0x79, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xE0,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x06, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xC0, 0x7C, 0x01, 0xE0, 0x01,
  0xE0, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x08, 0x00, 0x03,
  0xE0, 0xE0, 0x00, 0x7C, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1E,
  0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78,
  0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x07, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xE0,
  0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x73, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x80,
  0x00, 0x78, 0x0E, 0x00, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFC, 0x01, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x7F, 0xE0, 0x1E, 0x7F, 0xFC, 0x07, 0x3E, 0x1F, 0x81, 0xDC, 0x00,
  0xF0, 0x7E, 0x00, 0x1C, 0x3F, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xE3, 0xC0,
  0x00, 0x38, 0xF0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0xC3, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0x80,
  0x07, 0x80, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0,
  0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x3C, 0x07, 0x00, 0x07, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xF0,
  0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x07,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xC0,
  0x78, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x3C, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0xF8, 0x70, 0x00, 0x3E, 0x1E, 0x00, 0x3B, 0x83, 0xC0, 0x1D, 0xC0,
  0x7F, 0xFE, 0x70, 0x0F, 0xFF, 0x1C, 0x00, 0xFF, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x38, 0x1F, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x1F, 0x03, 0xC0, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x81,
  0xE0, 0xF8, 0x1E, 0x02, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xE0, 0x3E, 0x10, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x3F, 0xE0, 0x0E, 0x1C, 0x00, 0x3F, 0xFE, 0x01, 0x87, 0x00, 0x3E, 0x0F,
  0x80, 0x73, 0x80, 0x1E, 0x00, 0xE0, 0x1C, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x30, 0x07, 0x80, 0x1C, 0x01, 0xDC, 0x01, 0xC0, 0x07, 0x00, 0x77, 0x00,
  0xE0, 0x01, 0x80, 0x1D, 0x80, 0x30, 0x00, 0xE0, 0x07, 0xE0, 0x1C, 0x00,
  0x38, 0x01, 0xB8, 0x07, 0x00, 0x0E, 0x00, 0xEE, 0x01, 0x80, 0x07, 0x00,
  0x3B, 0x80, 0xE0, 0x01, 0xC0, 0x0E, 0xE0, 0x38, 0x00, 0x70, 0x07, 0x38,
  0x0E, 0x00, 0x3C, 0x01, 0xCE, 0x03, 0x80, 0x0F, 0x00, 0xF3, 0x80, 0xE0,
  0x07, 0xC0, 0x38, 0xE0, 0x1C, 0x03, 0xF0, 0x1C, 0x38, 0x07, 0x01, 0xDC,
  0x0F, 0x0E, 0x01, 0xF1, 0xE3, 0x8F, 0x81, 0xC0, 0x3F, 0xF0, 0xFF, 0x80,
  0x70, 0x03, 0xF0, 0x1F, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x10, 0x00, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x00, 0xE0,
  0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0x80,
  0x03, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x78, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x1F,
  0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xE0, 0x01, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x78, 0x1C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC1, 0xC0, 0x01, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFE, 0x01,
  0xE0, 0x07, 0xE0, 0x00, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x30, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xC0, 0x03, 0xF0, 0x01, 0xC0, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x07, 0xC0,
  0x70, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x7E, 0x00, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x70, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0xC3, 0x80, 0x03, 0xFF, 0xE3, 0xC0, 0x01, 0xFF, 0xF1, 0xE0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x38, 0x03, 0xE0,
  0x00, 0x1C, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0E,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x10, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x0F, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x07, 0xC0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x0E, 0x7E, 0x00, 0x00, 0x0E, 0xFE, 0x00, 0x00, 0x0F, 0xEE, 0x00, 0x00,
  0x1F, 0x87, 0x00, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x07, 0x60, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xB8, 0x00,
  0x00, 0x3B, 0x80, 0x77, 0x00, 0x00, 0x0F, 0x70, 0x0E, 0x60, 0x00, 0x01,
  0xCE, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x00, 0x0E, 0x70,
  0x0F, 0x38, 0x00, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x38,
  0xE0, 0x00, 0x1C, 0x78, 0x07, 0x0C, 0x00, 0x07, 0x8E, 0x00, 0xE1, 0xC0,
  0x00, 0xE1, 0xC0, 0x3C, 0x38, 0x00, 0x38, 0x38, 0x07, 0x07, 0x00, 0x07,
  0x07, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xE0, 0x1C, 0x1C, 0x00, 0x38, 0x38,
  0x03, 0x83, 0x80, 0x0E, 0x07, 0x00, 0xE0, 0x30, 0x03, 0xC0, 0xE0, 0x1C,
  0x07, 0x00, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xC1, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x38, 0x03, 0x80, 0x78, 0x03, 0x8E, 0x00, 0x70, 0x0E,
  0x00, 0x71, 0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x70, 0x03, 0xC0, 0x38, 0x01,
  0xCE, 0x00, 0x70, 0x07, 0x00, 0x1B, 0x80, 0x0E, 0x01, 0xE0, 0x03, 0xE0,
  0x01, 0xC0, 0x38, 0x00, 0x7C, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x07, 0x00, 0xF8, 0x00,
  0x00, 0xE0, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x0D,
  0xC0, 0x00, 0x0E, 0x01, 0xDE, 0x00, 0x01, 0xE0, 0x1C, 0xE0, 0x00, 0x1C,
  0x01, 0xCE, 0x00, 0x01, 0xC0, 0x1C, 0x70, 0x00, 0x1C, 0x03, 0xC7, 0x00,
  0x01, 0xC0, 0x38, 0x78, 0x00, 0x3C, 0x03, 0x83, 0x80, 0x03, 0x80, 0x38,
  0x38, 0x00, 0x38, 0x03, 0x81, 0xC0, 0x03, 0x80, 0x78, 0x1C, 0x00, 0x38,
  0x07, 0x01, 0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x07, 0x80, 0xE0, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0xE0,
  0x0E, 0x00, 0x1C, 0x0E, 0x01, 0xC0, 0x01, 0xC1, 0xE0, 0x1C, 0x00, 0x1E,
  0x1C, 0x01, 0xC0, 0x00, 0xE1, 0xC0, 0x1C, 0x00, 0x0E, 0x1C, 0x03, 0xC0,
  0x00, 0x71, 0xC0, 0x38, 0x00, 0x07, 0x3C, 0x03, 0x80, 0x00, 0x7B, 0x80,
  0x38, 0x00, 0x03, 0xB8, 0x03, 0x80, 0x00, 0x3B, 0x80, 0x78, 0x00, 0x01,
  0xF8, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x1C, 0x00, 0x7C, 0x01, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x7C, 0x0E, 0x00, 0x0F, 0x80, 0xE0, 0x03,
  0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x1C, 0x00, 0x7C, 0x01, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0xF0, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x70, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x38, 0x00, 0x70, 0x03, 0x80, 0x07, 0x80, 0x78, 0x00,
  0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x00, 0x04, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x40, 0x00, 0x3C, 0x0C, 0x00, 0x1F, 0x81, 0xFC,
  0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE7, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x1B, 0x00, 0x01, 0xC7,
  0x00, 0x03, 0xB0, 0x00, 0x3C, 0x70, 0x00, 0x3B, 0x00, 0x03, 0x87, 0x00,
  0x07, 0x30, 0x00, 0x38, 0x70, 0x00, 0x73, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x38, 0x00, 0x70, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x38,
  0x00, 0xE0, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x07, 0x00, 0x38, 0x38, 0x01,
  0xC0, 0x70, 0x03, 0x83, 0x80, 0x3C, 0x07, 0x00, 0x70, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x00, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x38, 0x1E, 0x00, 0x70, 0x38, 0x01,
  0x81, 0xC0, 0x07, 0x03, 0x80, 0x18, 0x3C, 0x00, 0x38, 0x70, 0x01, 0x83,
  0x80, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00,
  0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x03,
  0x9C, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x01,
  0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x07,
  0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E,
  0x70, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x0E,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x0F, 0x06, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x0E,
  0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x07, 0x00, 0x06, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x06,
  0x03, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF8, 0x70, 0x1F, 0xFF, 0x1C, 0x0F,
  0x81, 0xE7, 0x07, 0xC0, 0x19, 0x83, 0xC0, 0x07, 0xE0, 0xE0, 0x00, 0xF8,
  0x78, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x71, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x8E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x1F,
  0x0E, 0x00, 0x07, 0xC3, 0x80, 0x03, 0x60, 0xF0, 0x01, 0xF8, 0x1C, 0x00,
  0xEE, 0x07, 0x80, 0x73, 0x80, 0xF8, 0x78, 0xE0, 0x3F, 0xFC, 0x30, 0x03,
  0xFC, 0x1C, 0x00, 0x10, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x0F, 0x80, 0x07, 0x0F, 0xFC, 0x01, 0xE3, 0xFF, 0xC0, 0x38, 0xF0, 0x7C,
  0x07, 0x38, 0x03, 0x80, 0xEC, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x07, 0xE0,
  0x00, 0xE0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78,
  0x70, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x07, 0xC0, 0x01, 0xE0, 0xDC,
  0x00, 0x78, 0x39, 0xC0, 0x1E, 0x07, 0x3E, 0x1F, 0x80, 0xE3, 0xFF, 0xE0,
  0x18, 0x1F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFC, 0x07, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x04, 0x07, 0xC0,
  0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x0E, 0x00, 0x3F, 0xF0,
  0xF0, 0x07, 0xFF, 0xC7, 0x00, 0x7C, 0x07, 0x38, 0x07, 0xC0, 0x1D, 0xC0,
  0x78, 0x00, 0x6E, 0x03, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3E, 0x07, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x1F, 0x01, 0xC0, 0x01, 0xF8, 0x0F, 0x00, 0x0D, 0xC0,
  0x38, 0x01, 0xCE, 0x01, 0xE0, 0x1C, 0xE0, 0x07, 0xC3, 0xC7, 0x00, 0x3F,
  0xFC, 0x38, 0x00, 0x7F, 0x81, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0x83, 0xE0, 0x7C, 0x01,
  0xC0, 0xF0, 0x03, 0x83, 0x80, 0x07, 0x8F, 0x00, 0x0E, 0x1C, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x00, 0x1F, 0x0E,
  0x03, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x01, 0x80, 0xF8, 0x1F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xC1, 0xC0, 0x1F, 0xFF,
  0x0C, 0x01, 0xF0, 0x1C, 0x60, 0x1F, 0x00, 0x77, 0x01, 0xE0, 0x01, 0xB8,
  0x0E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0xF8, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x7C, 0x07, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x77, 0x00, 0xE0, 0x07, 0x70,
  0x07, 0x80, 0x73, 0x80, 0x1F, 0x0F, 0x1C, 0x00, 0xFF, 0xF0, 0xE0, 0x01,
  0xFE, 0x07, 0x00, 0x01, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x02, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x00, 0xE1, 0xFF, 0x80,
  0x78, 0xFF, 0xF0, 0x1C, 0x78, 0x1E, 0x07, 0x38, 0x03, 0x81, 0xDC, 0x00,
  0xF0, 0x7E, 0x00, 0x1C, 0x3F, 0x00, 0x07, 0x0F, 0x80, 0x01, 0xC3, 0xC0,
  0x00, 0x70, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x0F, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x40, 0xE0, 0x01,
  0xE0, 0x78, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x03,
  0x81, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x1E, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x77, 0xF0, 0x00, 0x1B, 0x9C,
  0x00, 0x0F, 0xC7, 0x80, 0x03, 0xE0, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x38,
  0x07, 0x00, 0x1E, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x03,
  0x80, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0xC1, 0xFF, 0x00, 0xFF, 0xC0, 0x70, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1C, 0xF0, 0x7C, 0x38, 0x1E, 0x07, 0x30, 0x07, 0x1C,
  0x03, 0xC1, 0xD8, 0x01, 0xCE, 0x00, 0x70, 0x6C, 0x00, 0x77, 0x00, 0x1C,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xC3, 0xC0,
  0x01, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC0, 0x00,
  0xE1, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC3, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC0, 0x00, 0xE1,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x00, 0x80, 0xFC, 0x00, 0xC1, 0xFF, 0xC0, 0x70, 0xFF, 0xF8, 0x1C,
  0x78, 0x3E, 0x07, 0x38, 0x03, 0xC1, 0xDC, 0x00, 0xF0, 0x7E, 0x00, 0x1C,
  0x3F, 0x00, 0x07, 0x0F, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x7E, 0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x1C, 0x38, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x79, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x3C,
  0x0F, 0x00, 0x7C, 0x03, 0xE0, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0x83, 0xFF, 0x00,
  0x0E, 0x1F, 0xFE, 0x00, 0x38, 0xF0, 0x7C, 0x00, 0xE7, 0x00, 0x70, 0x03,
  0xB8, 0x01, 0xE0, 0x0D, 0x80, 0x03, 0x80, 0x7E, 0x00, 0x0E, 0x01, 0xF0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x70, 0x0F, 0x80,
  0x03, 0xC0, 0x3F, 0x00, 0x1E, 0x01, 0xCE, 0x00, 0xF0, 0x07, 0x3E, 0x1F,
  0x80, 0x1C, 0x7F, 0xFC, 0x00, 0x70, 0x7F, 0xC0, 0x01, 0xC0, 0x20, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xFC, 0x1C, 0x07, 0xFF, 0xC3, 0x01, 0xF0, 0x1C, 0x60,
  0x7C, 0x01, 0xDC, 0x1E, 0x00, 0x1B, 0x83, 0x80, 0x01, 0xF0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x78, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x78,
  0x38, 0x00, 0x1F, 0x07, 0x00, 0x07, 0xE0, 0xF0, 0x01, 0xDC, 0x0E, 0x00,
  0x77, 0x81, 0xE0, 0x1C, 0xE0, 0x1F, 0x0F, 0x1C, 0x03, 0xFF, 0xC3, 0x80,
  0x1F, 0xE0, 0xF0, 0x00, 0x40, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x18, 0x3F, 0x81, 0xC3, 0xFC, 0x0E, 0x3C, 0x00, 0x73,
  0x80, 0x03, 0xB8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x04, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x8C, 0x00, 0x3C, 0x3F, 0x03, 0xE0,
  0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x60, 0x7F, 0xE0, 0x3F, 0xE0, 0x02, 0x00, 0x0F,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0F,
  0x1E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x1F, 0x0E, 0x00,
  0x0D, 0x83, 0x80, 0x07, 0xE0, 0xF0, 0x03, 0xB8, 0x1C, 0x01, 0xCE, 0x07,
  0xC3, 0xE3, 0x80, 0xFF, 0xF0, 0xC0, 0x1F, 0xF0, 0x30, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x3C, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x03,
  0x80, 0x70, 0x07, 0x80, 0x38, 0x07, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x1D, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x80,
  0x03, 0xB8, 0x00, 0x7C, 0x00, 0x39, 0xC0, 0x03, 0x60, 0x01, 0xCE, 0x00,
  0x3B, 0x00, 0x1C, 0x70, 0x01, 0xD8, 0x00, 0xE3, 0x80, 0x1C, 0xC0, 0x0F,
  0x1E, 0x00, 0xE6, 0x00, 0x70, 0x70, 0x0E, 0x38, 0x07, 0x83, 0x80, 0x71,
  0xC0, 0x38, 0x1C, 0x07, 0x0E, 0x03, 0xC0, 0xE0, 0x38, 0x70, 0x1C, 0x07,
  0x03, 0x83, 0x81, 0xE0, 0x38, 0x1C, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0xE0,
  0xF0, 0x0E, 0x0E, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x38, 0x38, 0x03, 0x87,
  0x01, 0xC3, 0x80, 0x1C, 0x70, 0x06, 0x1C, 0x00, 0xE3, 0x80, 0x31, 0xC0,
  0x07, 0x38, 0x01, 0x8E, 0x00, 0x39, 0xC0, 0x0E, 0xE0, 0x01, 0xDC, 0x00,
  0x77, 0x00, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x76, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x0F,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x78, 0x00, 0x38, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0x9F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x5F, 0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x3F, 0x00, 0x3F, 0xFE, 0x80, 0x03,
  0xFE, 0x00, 0x00, 0x0C, 0x00,
};

const GFXglyph NotoSans_LightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 13, 40, 13, 1, -39 },
  { 66, 14, 14, 19, 6, -39 },
  { 91, 33, 39, 35, 2, -39 },
  { 252, 27, 45, 30, 2, -42 },
  { 404, 35, 41, 43, 5, -40 },
  { 584, 33, 41, 37, 2, -40 },
  { 754, 6, 14, 11, 6, -39 },
  { 765, 17, 48, 15, 2, -39 },
  { 867, 17, 48, 15, -4, -39 },
  { 969, 24, 24, 30, 6, -42 },
  { 1041, 26, 26, 31, 4, -32 },
  { 1126, 9, 13, 12, -2, -6 },
  { 1141, 13, 3, 17, 2, -16 },
  { 1146, 5, 6, 13, 1, -5 },
  { 1150, 25, 39, 18, -2, -39 },
  { 1272, 26, 41, 30, 3, -40 },
  { 1406, 14, 39, 30, 9, -39 },
  { 1475, 28, 40, 30, 0, -40 },
  { 1615, 28, 41, 30, 1, -40 },
  { 1759, 28, 39, 30, 1, -39 },
  { 1896, 28, 40, 30, 2, -39 },
  { 2036, 26, 41, 30, 4, -40 },
  { 2170, 26, 39, 30, 5, -39 },
  { 2297, 27, 41, 30, 3, -40 },
  { 2436, 26, 41, 30, 3, -40 },
  { 2570, 10, 31, 13, 1, -30 },
  { 2609, 14, 37, 13, -3, -30 },
  { 2674, 26, 26, 31, 4, -33 },
  { 2759, 25, 13, 31, 4, -26 },
  { 2800, 26, 26, 31, 4, -33 },
  { 2885, 20, 41, 23, 4, -40 },
  { 2988, 42, 44, 46, 3, -39 },
  { 3219, 31, 39, 31, -3, -39 },
  { 3371, 29, 39, 33, 3, -39 },
  { 3513, 31, 41, 33, 4, -40 },
  { 3672, 32, 39, 37, 3, -39 },
  { 3828, 28, 39, 29, 3, -39 },
  { 3965, 28, 39, 27, 3, -39 },
  { 4102, 33, 41, 38, 4, -40 },
  { 4272, 34, 39, 37, 3, -39 },
  { 4438, 19, 39, 17, 0, -39 },
  { 4531, 23, 49, 14, -9, -39 },
  { 4672, 32, 39, 30, 3, -39 },
  { 4828, 20, 39, 27, 3, -39 },
  { 4926, 43, 39, 45, 2, -39 },
  { 5136, 36, 39, 38, 2, -39 },
  { 5312, 34, 41, 40, 4, -40 },
  { 5487, 28, 39, 31, 3, -39 },
  { 5624, 34, 49, 40, 4, -40 },
  { 5833, 28, 39, 31, 3, -39 },
  { 5970, 27, 41, 28, 1, -40 },
  { 6109, 27, 39, 27, 5, -39 },
  { 6241, 33, 40, 38, 5, -39 },
  { 6406, 29, 39, 30, 5, -39 },
  { 6548, 44, 39, 46, 6, -39 },
  { 6763, 35, 39, 28, -3, -39 },
  { 6934, 27, 39, 27, 5, -39 },
  { 7066, 32, 39, 29, -1, -39 },
  { 7222, 21, 48, 16, -1, -39 },
  { 7348, 9, 39, 18, 6, -39 },
  { 7392, 21, 48, 16, -4, -39 },
  { 7518, 27, 25, 31, 2, -40 },
  { 7603, 22, 3, 21, -5, 5 },
  { 7612, 8, 9, 14, 8, -42 },
  { 7621, 26, 31, 31, 3, -30 },
  { 7722, 27, 43, 32, 2, -42 },
  { 7868, 22, 31, 25, 3, -30 },
  { 7954, 29, 43, 32, 3, -42 },
  { 8110, 23, 31, 27, 3, -30 },
  { 8200, 31, 55, 16, -7, -42 },
  { 8414, 29, 43, 32, 1, -30 },
  { 8570, 26, 42, 31, 2, -42 },
  { 8707, 11, 40, 13, 2, -40 },
  { 8762, 20, 53, 13, -7, -40 },
  { 8895, 26, 42, 26, 2, -42 },
  { 9032, 12, 42, 13, 2, -42 },
  { 9095, 42, 30, 47, 2, -30 },
  { 9253, 26, 30, 31, 2, -30 },
  { 9351, 25, 31, 31, 3, -30 },
  { 9448, 30, 43, 32, -1, -30 },
  { 9610, 27, 43, 32, 3, -30 },
  { 9756, 21, 30, 21, 2, -30 },
  { 9835, 22, 31, 24, 0, -30 },
  { 9921, 16, 37, 18, 3, -36 },
  { 9995, 26, 30, 31, 3, -29 },
  { 10093, 24, 29, 24, 3, -29 },
  { 10180, 37, 29, 38, 3, -29 },
  { 10315, 29, 29, 26, -2, -29 },
  { 10421, 33, 42, 24, -6, -29 },
  { 10595, 25, 29, 24, -1, -29 },
  { 10686, 21, 48, 19, 1, -39 },
  { 10812, 3, 55, 30, 15, -42 },
  { 10833, 20, 48, 19, -2, -39 },
  { 10953, 26, 6, 31, 4, -22 },
};

const GFXfont NotoSans_LightItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_LIGHTITALIC55PT7B_H_
