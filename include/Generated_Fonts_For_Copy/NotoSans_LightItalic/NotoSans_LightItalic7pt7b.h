#ifndef _NOTOSANS_LIGHTITALIC7PT7B_H_
#define _NOTOSANS_LIGHTITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xE0, 0x37, 0x5E, 0x60, 0x34, 0x25, 0x60, 0xDE, 0xB5,
  0xB0, 0x72, 0x9B, 0x6F, 0x00, 0xC0, 0x5A, 0xA0, 0x55, 0xA0, 0xCF, 0x00,
  0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x29, 0x48, 0x79, 0x99, 0xE0, 0xD5, 0x80,
  0x71, 0x24, 0xE0, 0x71, 0x61, 0xE0, 0x12, 0x6F, 0x20, 0x74, 0x21, 0xE0,
  0x74, 0xB9, 0xE0, 0xE9, 0x48, 0x75, 0x69, 0xE0, 0x79, 0x52, 0xE0, 0x90,
  0x98, 0x71, 0x80, 0xE0, 0xC7, 0x00, 0xDA, 0x80, 0x39, 0x5B, 0x75, 0xA9,
  0xC0, 0x26, 0x69, 0x90, 0x75, 0x69, 0xE0, 0xF2, 0x4E, 0x75, 0x59, 0xE0,
  0x74, 0x68, 0xE0, 0x74, 0x68, 0x80, 0xF8, 0xAA, 0xE0, 0x4A, 0x5D, 0x29,
  0x00, 0x56, 0x80, 0x24, 0xA5, 0x80, 0x56, 0x4A, 0x90, 0x49, 0x4E, 0x45,
  0x25, 0x6E, 0xA8, 0x4A, 0x5B, 0x69, 0x00, 0xF9, 0x99, 0xE0, 0x75, 0x78,
  0x80, 0xF9, 0x99, 0xA6, 0x75, 0x6A, 0x90, 0x78, 0x42, 0xE0, 0xEA, 0x48,
  0x99, 0x9A, 0xE0, 0xB7, 0x48, 0xAF, 0x7B, 0x29, 0x00, 0x56, 0x46, 0xA0,
  0xBA, 0x48, 0x72, 0x44, 0xE0, 0x6A, 0x49, 0x00, 0xF8, 0x24, 0x95, 0x80,
  0x26, 0x90, 0xE0, 0x80, 0x79, 0x9E, 0x46, 0x99, 0xE0, 0x72, 0x70, 0x17,
  0x99, 0xE0, 0x77, 0x70, 0x36, 0x24, 0x44, 0x80, 0x79, 0x9E, 0x2C, 0x46,
  0x99, 0xA0, 0x5A, 0x80, 0x25, 0x24, 0xA0, 0x45, 0xAC, 0xA0, 0x5A, 0x80,
  0x6A, 0x5A, 0x6A, 0x69, 0x9A, 0x69, 0x9E, 0x69, 0x9E, 0x88, 0x79, 0x9E,
  0x22, 0x72, 0x40, 0x71, 0xF0, 0x7A, 0xC0, 0x59, 0x9E, 0xB7, 0x20, 0xAD,
  0x5D, 0x20, 0xA9, 0x50, 0x55, 0x62, 0x48, 0x65, 0x60, 0x69, 0x49, 0x80,
  0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_LightItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 2, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 4, 5, 5, 1, -5 },
  { 13, 5, 5, 5, 0, -5 },
  { 17, 1, 2, 1, 1, -5 },
  { 18, 2, 6, 2, 0, -5 },
  { 20, 2, 6, 2, 0, -5 },
  { 22, 3, 3, 4, 1, -5 },
  { 24, 3, 3, 4, 1, -4 },
  { 26, 1, 2, 2, 0, -1 },
  { 27, 2, 1, 2, 0, -2 },
  { 28, 1, 1, 2, 0, -1 },
  { 29, 3, 5, 2, 0, -5 },
  { 31, 4, 5, 4, 0, -5 },
  { 34, 2, 5, 4, 1, -5 },
  { 36, 4, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 3, 5, 4, 1, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 4, 5, 4, 0, -5 },
  { 59, 1, 4, 2, 0, -4 },
  { 60, 1, 5, 2, 0, -4 },
  { 61, 3, 3, 4, 1, -4 },
  { 63, 3, 1, 4, 1, -3 },
  { 64, 3, 3, 4, 1, -4 },
  { 66, 2, 5, 3, 1, -5 },
  { 68, 6, 6, 6, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 3, 5, 4, 1, -5 },
  { 81, 4, 5, 5, 0, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 4, 5, 3, 0, -5 },
  { 90, 4, 5, 5, 1, -5 },
  { 93, 5, 5, 5, 0, -5 },
  { 97, 2, 5, 2, 0, -5 },
  { 99, 3, 6, 2, -1, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 3, 5, 3, 0, -5 },
  { 107, 6, 5, 6, 0, -5 },
  { 111, 5, 5, 5, 0, -5 },
  { 115, 4, 5, 5, 1, -5 },
  { 118, 4, 5, 4, 0, -5 },
  { 121, 4, 6, 5, 1, -5 },
  { 124, 4, 5, 4, 0, -5 },
  { 127, 4, 5, 4, 0, -5 },
  { 130, 3, 5, 3, 1, -5 },
  { 132, 4, 5, 5, 1, -5 },
  { 135, 3, 5, 4, 1, -5 },
  { 137, 5, 5, 6, 1, -5 },
  { 141, 4, 5, 4, 0, -5 },
  { 144, 3, 5, 3, 1, -5 },
  { 146, 4, 5, 4, 0, -5 },
  { 149, 3, 6, 2, 0, -5 },
  { 152, 1, 5, 2, 1, -5 },
  { 153, 3, 6, 2, -1, -5 },
  { 156, 4, 3, 4, 0, -5 },
  { 158, 3, 1, 3, -1, 0 },
  { 159, 1, 1, 2, 1, -5 },
  { 160, 4, 4, 4, 0, -4 },
  { 162, 4, 5, 4, 0, -5 },
  { 165, 3, 4, 3, 0, -4 },
  { 167, 4, 5, 4, 0, -5 },
  { 170, 3, 4, 3, 0, -4 },
  { 172, 4, 7, 2, -1, -5 },
  { 176, 4, 6, 4, 0, -4 },
  { 179, 4, 5, 4, 0, -5 },
  { 182, 2, 5, 2, 0, -5 },
  { 184, 3, 7, 2, -1, -5 },
  { 187, 4, 5, 3, 0, -5 },
  { 190, 2, 5, 2, 0, -5 },
  { 192, 6, 4, 6, 0, -4 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 4, 4, 4, 0, -4 },
  { 199, 4, 6, 4, 0, -4 },
  { 202, 4, 6, 4, 0, -4 },
  { 205, 3, 4, 3, 0, -4 },
  { 207, 3, 4, 3, 0, -4 },
  { 209, 2, 5, 2, 0, -5 },
  { 211, 4, 4, 4, 0, -4 },
  { 213, 3, 4, 3, 0, -4 },
  { 215, 5, 4, 5, 0, -4 },
  { 218, 3, 4, 3, 0, -4 },
  { 220, 4, 6, 3, -1, -4 },
  { 223, 3, 4, 3, 0, -4 },
  { 225, 3, 6, 2, 0, -5 },
  { 228, 1, 7, 4, 2, -5 },
  { 229, 2, 6, 2, 0, -5 },
  { 231, 3, 1, 4, 1, -3 },
};

const GFXfont NotoSans_LightItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_LIGHTITALIC7PT7B_H_
