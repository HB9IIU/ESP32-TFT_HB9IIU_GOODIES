#ifndef _NOTOSANS_LIGHTITALIC49PT7B_H_
#define _NOTOSANS_LIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x1F, 0x03,
  0xC0, 0x10, 0x00, 0x3C, 0x39, 0xC1, 0xCE, 0x0C, 0x70, 0x63, 0x07, 0x18,
  0x39, 0xC1, 0x8E, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x30, 0xC1, 0x8C, 0x0C,
  0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x70, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x80, 0x38, 0x06, 0x00, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x03, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x00, 0x18, 0x07, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x38, 0x06, 0x00, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0xE0, 0x18, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x7E, 0xDF, 0x81, 0xE1, 0x83, 0x07, 0x87, 0x00, 0x0E, 0x0C,
  0x00, 0x38, 0x18, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x60, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x00, 0x03, 0x86, 0x00, 0x07, 0x8C, 0x00, 0x07, 0xD8, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0x7C, 0x00,
  0x0E, 0x3C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0xC0, 0x03, 0x81, 0x80, 0x06, 0x07, 0x00, 0x0C, 0x1E, 0x20, 0x18,
  0x78, 0x78, 0x33, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x0F, 0xF8, 0x00, 0x18, 0x0E,
  0x1C, 0x00, 0x30, 0x1C, 0x0C, 0x00, 0x70, 0x38, 0x0C, 0x00, 0xE0, 0x30,
  0x0C, 0x00, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60,
  0x0C, 0x07, 0x00, 0x60, 0x0C, 0x06, 0x00, 0xE0, 0x0C, 0x0E, 0x00, 0xE0,
  0x1C, 0x1C, 0x00, 0xE0, 0x1C, 0x38, 0x00, 0xE0, 0x18, 0x30, 0x00, 0xE0,
  0x18, 0x71, 0xFC, 0xE0, 0x38, 0xE3, 0xFE, 0xE0, 0x31, 0xC7, 0x0E, 0xE0,
  0x71, 0x8E, 0x07, 0x70, 0xE3, 0x8C, 0x07, 0x7F, 0xC7, 0x1C, 0x07, 0x3F,
  0x8E, 0x18, 0x07, 0x00, 0x0C, 0x38, 0x07, 0x00, 0x1C, 0x38, 0x07, 0x00,
  0x38, 0x30, 0x07, 0x00, 0x70, 0x30, 0x06, 0x00, 0x60, 0x30, 0x06, 0x00,
  0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x00, 0x70, 0x1C, 0x07, 0x00, 0x70, 0x18, 0x0E, 0x00, 0x30, 0x38, 0x0C,
  0x00, 0x38, 0x70, 0x18, 0x00, 0x3F, 0xE0, 0x38, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x06,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x3E, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xE3, 0x80, 0x01, 0x0E, 0x07, 0x00, 0x38, 0x70, 0x0E,
  0x00, 0xE3, 0x80, 0x38, 0x07, 0x1C, 0x00, 0x70, 0x1C, 0x70, 0x00, 0xE0,
  0xE3, 0x80, 0x03, 0xC7, 0x0E, 0x00, 0x07, 0x3C, 0x38, 0x00, 0x0E, 0xE0,
  0xE0, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x1F, 0xC0, 0x78, 0x01, 0xF7, 0x80, 0xF0, 0x1F, 0x0E, 0x01, 0xFF,
  0xF8, 0x1C, 0x03, 0xFF, 0x00, 0x38, 0x3C, 0xE3, 0x8E, 0x30, 0xC7, 0x1C,
  0x61, 0x86, 0x18, 0xC0, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x60, 0x18, 0x03, 0xC0, 0xC0, 0x1F,
  0x86, 0x00, 0x1F, 0x60, 0x00, 0x3F, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xC0,
  0x70, 0x1B, 0x00, 0x03, 0x98, 0x00, 0x38, 0xE0, 0x03, 0x83, 0x00, 0x3C,
  0x1C, 0x03, 0xC0, 0xE0, 0x0C, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x38,
  0x38, 0x30, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x77, 0xFF,
  0xE2, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0,
  0x0F, 0x83, 0xC0, 0x3C, 0x03, 0xC0, 0xF0, 0x03, 0x81, 0xC0, 0x07, 0x07,
  0x00, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x37, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x38,
  0x07, 0x80, 0x78, 0x3E, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x38, 0x07, 0xC0, 0x7C, 0x0F, 0xE1, 0xF7, 0x1E, 0x3B, 0xE1, 0xDC, 0x1C,
  0x40, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x0C, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7C, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x10,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC1, 0x80,
  0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x30, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x86, 0x00, 0x03, 0x87, 0x00, 0x03,
  0x83, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0x60, 0x03,
  0x80, 0x70, 0x03, 0xC0, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x01,
  0xC0, 0x0E, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC1,
  0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x80,
  0x03, 0xC0, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3E, 0x02, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x38, 0xFF, 0xC0, 0x33,
  0xFF, 0xE0, 0x77, 0x00, 0xF0, 0x7E, 0x00, 0x70, 0x7C, 0x00, 0x38, 0x78,
  0x00, 0x38, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x70, 0x60, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x38,
  0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x0E, 0x03, 0xC0, 0x07, 0x03, 0x80,
  0x07, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x03, 0x00, 0x07, 0x03, 0x00,
  0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xE0,
  0x78, 0x00, 0xF1, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xE3, 0xC0, 0x0F, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x38, 0x00,
  0x78, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x60, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x1F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xE0,
  0x78, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x18, 0x00, 0x07, 0x18, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x3E, 0x0E, 0x00, 0x7E, 0x0F, 0x00,
  0xEC, 0x07, 0xFF, 0xDC, 0x03, 0xFF, 0x1C, 0x00, 0xFC, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0xC0, 0x7E, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0x03, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0xF8, 0x7C, 0x3C, 0x04, 0x00, 0x00, 0x20, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xFF, 0x0F, 0x03, 0xC4, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x01, 0x87, 0x00, 0x1F, 0xE0, 0x0C,
  0x30, 0x03, 0xFF, 0xC0, 0x73, 0x80, 0x3C, 0x0E, 0x03, 0x98, 0x03, 0x80,
  0x70, 0x1D, 0xC0, 0x38, 0x03, 0x80, 0xEC, 0x03, 0x80, 0x18, 0x07, 0x60,
  0x38, 0x01, 0xC0, 0x3F, 0x01, 0xC0, 0x0E, 0x01, 0xF8, 0x0C, 0x00, 0x60,
  0x0F, 0x80, 0xE0, 0x03, 0x00, 0x6C, 0x07, 0x00, 0x38, 0x03, 0x60, 0x30,
  0x01, 0xC0, 0x3B, 0x01, 0x80, 0x0C, 0x01, 0xD8, 0x0C, 0x00, 0xE0, 0x1C,
  0xC0, 0x70, 0x0F, 0x00, 0xE6, 0x03, 0x80, 0x78, 0x0E, 0x30, 0x1C, 0x06,
  0xE0, 0xE1, 0xC0, 0x7D, 0xE3, 0x9E, 0x0E, 0x01, 0xFE, 0x1F, 0xE0, 0x30,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80,
  0x18, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0xC0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0xE0, 0x03, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x0F,
  0x01, 0x80, 0x07, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x38, 0x00, 0xF0, 0x06, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x07,
  0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x00, 0x20, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0x80,
  0x1F, 0x80, 0x1C, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x0F, 0x03, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x01,
  0xC0, 0x01, 0xF0, 0x0E, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xE0, 0x00,
  0x60, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x0F, 0xFF, 0x38, 0x00, 0x7F, 0xF1, 0xC0, 0x03, 0xFF, 0x8E, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x1C, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x01, 0x80, 0x60, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x78,
  0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x78, 0x03, 0x80, 0x07, 0x80, 0x1C,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x07,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x18, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x18,
  0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0E, 0xFC, 0x00, 0x00, 0x7E, 0xE0,
  0x00, 0x03, 0xE3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x03, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x6C, 0x00, 0x00, 0x3F, 0x01, 0xB0, 0x00, 0x01, 0xD8, 0x0E, 0xC0,
  0x00, 0x07, 0xE0, 0x3B, 0x80, 0x00, 0x3B, 0x80, 0xEE, 0x00, 0x00, 0xCE,
  0x03, 0xB8, 0x00, 0x07, 0x38, 0x0C, 0x60, 0x00, 0x38, 0xC0, 0x71, 0x80,
  0x00, 0xE7, 0x01, 0xC6, 0x00, 0x07, 0x1C, 0x07, 0x1C, 0x00, 0x1C, 0x70,
  0x18, 0x70, 0x00, 0xE1, 0xC0, 0x61, 0xC0, 0x03, 0x0E, 0x03, 0x87, 0x00,
  0x1C, 0x38, 0x0E, 0x0C, 0x00, 0xE0, 0xE0, 0x38, 0x30, 0x03, 0x83, 0x80,
  0xC0, 0xC0, 0x1C, 0x0C, 0x07, 0x03, 0x80, 0x70, 0x70, 0x1C, 0x0E, 0x03,
  0x81, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x06,
  0x01, 0x83, 0x80, 0x60, 0x38, 0x06, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x70,
  0x0E, 0x03, 0x80, 0x71, 0x80, 0x38, 0x0E, 0x01, 0xCE, 0x00, 0xE0, 0x30,
  0x07, 0x30, 0x03, 0x01, 0xC0, 0x0D, 0xC0, 0x1C, 0x07, 0x00, 0x3E, 0x00,
  0x70, 0x1C, 0x00, 0xF8, 0x01, 0xC0, 0x60, 0x03, 0xC0, 0x07, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x06, 0x01, 0xF0, 0x00,
  0x0E, 0x01, 0xF0, 0x00, 0x0E, 0x03, 0xB8, 0x00, 0x0E, 0x03, 0xB8, 0x00,
  0x0C, 0x03, 0x98, 0x00, 0x0C, 0x03, 0x1C, 0x00, 0x1C, 0x03, 0x1C, 0x00,
  0x1C, 0x07, 0x0E, 0x00, 0x1C, 0x07, 0x0E, 0x00, 0x18, 0x07, 0x06, 0x00,
  0x38, 0x07, 0x07, 0x00, 0x38, 0x06, 0x07, 0x00, 0x38, 0x0E, 0x03, 0x80,
  0x38, 0x0E, 0x03, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x01, 0xC0,
  0x70, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0xE0, 0x70, 0x1C, 0x00, 0xE0,
  0x60, 0x1C, 0x00, 0x60, 0xE0, 0x18, 0x00, 0x70, 0xE0, 0x38, 0x00, 0x70,
  0xE0, 0x38, 0x00, 0x38, 0xC0, 0x38, 0x00, 0x38, 0xC0, 0x38, 0x00, 0x19,
  0xC0, 0x30, 0x00, 0x1D, 0xC0, 0x70, 0x00, 0x1D, 0xC0, 0x70, 0x00, 0x0F,
  0x80, 0x70, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x07, 0x80, 0x60, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x1E, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x70, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x00, 0xE0,
  0x38, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x03,
  0x80, 0x1F, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x1E, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x07,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x18, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0,
  0x60, 0x00, 0x70, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x00, 0x70,
  0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x38, 0x18, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xFF, 0x01, 0xF8, 0x1F, 0x03, 0xC0, 0x02, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x80, 0x03, 0xE0, 0xF0, 0x0F, 0xC0, 0xFF,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x86, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x70, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x03,
  0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x01, 0xC0,
  0x03, 0x80, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x07,
  0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xC0, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x3B, 0x80, 0x01, 0xE0, 0x00, 0x77, 0x00,
  0x07, 0xC0, 0x01, 0xCE, 0x00, 0x0D, 0x80, 0x03, 0x9C, 0x00, 0x3B, 0x00,
  0x0E, 0x38, 0x00, 0x66, 0x00, 0x1C, 0x70, 0x01, 0xCC, 0x00, 0x38, 0xE0,
  0x03, 0x98, 0x00, 0xE1, 0xC0, 0x0E, 0x30, 0x01, 0xC3, 0x80, 0x1C, 0x60,
  0x07, 0x07, 0x00, 0x70, 0xC0, 0x0E, 0x0E, 0x00, 0xE1, 0x80, 0x38, 0x1C,
  0x01, 0x83, 0x80, 0x70, 0x38, 0x07, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x1C, 0x06, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x01,
  0x81, 0xC0, 0x70, 0x38, 0x03, 0x03, 0x00, 0xE0, 0xE0, 0x06, 0x0E, 0x01,
  0xC1, 0xC0, 0x0C, 0x18, 0x03, 0x87, 0x00, 0x18, 0x70, 0x03, 0x0E, 0x00,
  0x30, 0xE0, 0x06, 0x38, 0x00, 0x63, 0x80, 0x0C, 0x70, 0x00, 0xE7, 0x00,
  0x18, 0xC0, 0x01, 0xDC, 0x00, 0x33, 0x80, 0x03, 0xB8, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0xDC, 0x00, 0x0D, 0xC0, 0x01, 0xB8, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x38, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x18, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x70,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xE0, 0xE0, 0xE0, 0x60,
  0x60, 0x70, 0x70, 0x70, 0x70, 0x30, 0x30, 0x30, 0x38, 0x38, 0x38, 0x18,
  0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06,
  0x06, 0x06, 0x07, 0x07, 0x07, 0x03, 0x03, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xD8, 0x00, 0x03, 0xB8, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x70,
  0x60, 0x00, 0xE0, 0xC0, 0x03, 0x81, 0xC0, 0x06, 0x01, 0x80, 0x1C, 0x03,
  0x00, 0x30, 0x07, 0x00, 0xE0, 0x06, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x0C,
  0x1C, 0x00, 0x18, 0x30, 0x00, 0x38, 0xE0, 0x00, 0x33, 0x80, 0x00, 0x77,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1,
  0xE1, 0xC1, 0xC3, 0x83, 0x83, 0x03, 0x00, 0x06, 0x00, 0x00, 0x7F, 0x83,
  0x01, 0xFF, 0xC7, 0x03, 0xE0, 0xE6, 0x07, 0x80, 0x76, 0x0F, 0x00, 0x36,
  0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18,
  0x70, 0x00, 0x38, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0x60, 0x01, 0xF0, 0x70, 0x01, 0xF0,
  0x70, 0x03, 0x60, 0x78, 0x06, 0x60, 0x3C, 0x1C, 0x60, 0x1F, 0xF8, 0xE0,
  0x0F, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x10, 0x00, 0x70, 0xFF, 0x00, 0x31, 0xFF, 0xC0, 0x39, 0xC0, 0xF0, 0x1D,
  0xC0, 0x3C, 0x0F, 0xC0, 0x0E, 0x06, 0xC0, 0x07, 0x03, 0xC0, 0x01, 0x83,
  0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x30, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0xE0, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x70, 0x7C, 0x00, 0x78, 0x3B, 0x00,
  0x78, 0x19, 0xC0, 0xF8, 0x0C, 0x7F, 0xF8, 0x0E, 0x1F, 0xF0, 0x00, 0x00,
  0x06, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x06, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x07, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x10, 0x0E, 0x00, 0x3F, 0xE1, 0x80,
  0x1F, 0xFE, 0x70, 0x07, 0xC0, 0xEE, 0x01, 0xE0, 0x0D, 0xC0, 0x78, 0x00,
  0xF8, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0,
  0x18, 0x00, 0x3C, 0x03, 0x80, 0x0D, 0x80, 0x70, 0x03, 0x70, 0x0F, 0x00,
  0xEE, 0x00, 0xF0, 0x79, 0xC0, 0x0F, 0xFC, 0x30, 0x00, 0xFF, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x7C, 0x1E, 0x0F, 0x00,
  0xE0, 0xE0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0xE7, 0x00,
  0x0E, 0x70, 0x01, 0xC6, 0x00, 0x78, 0xE0, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x08,
  0x3C, 0x07, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xC0, 0x80, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x40, 0x0F, 0xF8,
  0x60, 0x0F, 0xFF, 0x18, 0x07, 0xC0, 0xE6, 0x03, 0xC0, 0x1B, 0x81, 0xE0,
  0x03, 0xE0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x30,
  0x00, 0x78, 0x0E, 0x00, 0x36, 0x03, 0x80, 0x1B, 0x80, 0xF0, 0x0E, 0xE0,
  0x1E, 0x0F, 0x30, 0x03, 0xFF, 0x0C, 0x00, 0x7F, 0x87, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x08, 0x00, 0x38, 0x03,
  0x80, 0x3C, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x03, 0x87,
  0xF8, 0x03, 0x1F, 0xFE, 0x07, 0x3C, 0x1E, 0x07, 0x70, 0x0F, 0x07, 0xE0,
  0x07, 0x06, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00,
  0x07, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x30, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0x00, 0x40, 0x3C, 0x07, 0x80, 0xF0, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x01, 0x03, 0x80, 0x0E,
  0x03, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x07, 0x00, 0x70, 0x07, 0x01, 0xE0,
  0x07, 0x03, 0xC0, 0x06, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x0E, 0x1E, 0x00,
  0x0E, 0x3C, 0x00, 0x0C, 0x78, 0x00, 0x0C, 0xF0, 0x00, 0x1D, 0xF8, 0x00,
  0x1F, 0xB8, 0x00, 0x1F, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x0E, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x01, 0x00, 0x0C,
  0x1F, 0xC0, 0x3F, 0xC0, 0x31, 0xFF, 0x83, 0xFF, 0x81, 0xCE, 0x0F, 0x1E,
  0x0F, 0x07, 0x70, 0x1C, 0xE0, 0x1C, 0x1F, 0x00, 0x33, 0x00, 0x70, 0x6C,
  0x00, 0xD8, 0x01, 0xC1, 0xE0, 0x03, 0xC0, 0x07, 0x0F, 0x00, 0x0F, 0x00,
  0x1C, 0x3C, 0x00, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xE0, 0x01, 0xC3, 0x80,
  0x07, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x70, 0x00,
  0xE1, 0xC0, 0x01, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0xE0, 0x00, 0xC3, 0x80, 0x03, 0x80, 0x07,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x00, 0x70, 0xC0, 0x01,
  0xC0, 0x01, 0x87, 0x00, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x70, 0x00, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x07, 0xFC, 0x03, 0x1F, 0xFE,
  0x07, 0x3C, 0x1E, 0x07, 0x70, 0x0F, 0x07, 0xE0, 0x07, 0x06, 0xC0, 0x07,
  0x07, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xF0, 0x3C, 0x0F,
  0x00, 0x78, 0x78, 0x00, 0xE3, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00,
  0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0xEC, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03,
  0x87, 0x00, 0x1E, 0x1E, 0x00, 0xF0, 0x3C, 0x0F, 0x80, 0x7F, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x18, 0x3F, 0xC0, 0x03, 0x1F,
  0xFC, 0x00, 0xE7, 0x83, 0xC0, 0x1D, 0xC0, 0x3C, 0x03, 0xF0, 0x03, 0x80,
  0x6C, 0x00, 0x70, 0x0F, 0x00, 0x06, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x30, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x70, 0x1E, 0x00, 0x1C, 0x07, 0xC0, 0x07, 0x80, 0xEC, 0x01, 0xE0,
  0x1D, 0xC0, 0xF8, 0x03, 0x9F, 0xFE, 0x00, 0x60, 0xFF, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x80, 0x3F, 0xE1, 0x80, 0x7F, 0xF8,
  0xC0, 0x7C, 0x0E, 0x60, 0x78, 0x03, 0x70, 0x78, 0x00, 0xF8, 0x38, 0x00,
  0x78, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x06, 0x00, 0x0F, 0x03, 0x80, 0x0D, 0x81,
  0xC0, 0x0D, 0xC0, 0xF0, 0x0E, 0xE0, 0x3C, 0x1E, 0x70, 0x0F, 0xFC, 0x30,
  0x03, 0xFC, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x60, 0xFC, 0x0C, 0x7F,
  0x83, 0x9E, 0x00, 0x77, 0x00, 0x0F, 0xC0, 0x01, 0xB0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x78, 0x06, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x88, 0x00, 0x70, 0xF0, 0x1F,
  0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0xFF, 0xBF, 0xFF, 0x8E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x04, 0x1F, 0xF0, 0x1F, 0xE0, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x61, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x60, 0x00, 0x71, 0xC0,
  0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x18, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xC3, 0x80, 0x07,
  0x87, 0x00, 0x0F, 0x0E, 0x00, 0x3E, 0x1C, 0x00, 0xDC, 0x38, 0x03, 0x30,
  0x78, 0x1C, 0x60, 0x7F, 0xF0, 0xC0, 0x7F, 0xC3, 0x80, 0xE0, 0x00, 0x1D,
  0x80, 0x00, 0xE7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0,
  0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x30, 0x03, 0x80, 0xC0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x03,
  0x81, 0xC0, 0x06, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x61, 0xC0, 0x01, 0xC6,
  0x00, 0x07, 0x38, 0x00, 0x1C, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xD8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x0E, 0xE0, 0x07, 0xC0,
  0x0E, 0xE0, 0x0F, 0xC0, 0x1C, 0xE0, 0x0D, 0xC0, 0x1C, 0xE0, 0x1D, 0xC0,
  0x38, 0xE0, 0x19, 0xC0, 0x38, 0xE0, 0x38, 0xC0, 0x70, 0xE0, 0x30, 0xC0,
  0x70, 0xE0, 0x70, 0xC0, 0xE0, 0xE0, 0x60, 0xC0, 0xE0, 0xE0, 0xE0, 0xC0,
  0xC0, 0xE0, 0xC0, 0xC1, 0xC0, 0xE1, 0xC0, 0xE1, 0xC0, 0x61, 0x80, 0xE3,
  0x80, 0x63, 0x80, 0xE3, 0x80, 0x63, 0x00, 0xE7, 0x00, 0x67, 0x00, 0xE7,
  0x00, 0x66, 0x00, 0xEE, 0x00, 0x6E, 0x00, 0xEE, 0x00, 0x6C, 0x00, 0x6C,
  0x00, 0x6C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x01, 0xE0,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x00,
  0xE0, 0x03, 0x80, 0x38, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x01, 0xC0, 0x38,
  0x00, 0x30, 0x3C, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x06, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x60, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0,
  0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x01, 0xFC,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x05,
  0xFF, 0x80, 0x1F, 0x3F, 0xC1, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF0,
};

const GFXglyph NotoSans_LightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 36, 12, 1, -35 },
  { 51, 13, 13, 17, 5, -35 },
  { 73, 29, 35, 31, 2, -35 },
  { 200, 23, 40, 27, 2, -37 },
  { 315, 32, 36, 38, 4, -35 },
  { 459, 30, 36, 33, 2, -36 },
  { 594, 6, 13, 10, 5, -35 },
  { 604, 15, 43, 13, 2, -35 },
  { 685, 14, 43, 13, -3, -35 },
  { 761, 21, 21, 27, 6, -37 },
  { 817, 22, 23, 28, 4, -29 },
  { 881, 8, 12, 11, -2, -6 },
  { 893, 12, 3, 15, 2, -15 },
  { 898, 5, 5, 11, 1, -4 },
  { 902, 22, 35, 16, -2, -35 },
  { 999, 23, 36, 27, 3, -36 },
  { 1103, 13, 35, 27, 8, -35 },
  { 1160, 25, 35, 27, 0, -35 },
  { 1270, 25, 35, 27, 1, -35 },
  { 1380, 25, 35, 27, 1, -35 },
  { 1490, 24, 35, 27, 2, -35 },
  { 1595, 24, 36, 27, 3, -36 },
  { 1703, 23, 35, 27, 5, -35 },
  { 1804, 24, 36, 27, 2, -36 },
  { 1912, 24, 35, 27, 2, -35 },
  { 2017, 9, 28, 11, 1, -27 },
  { 2049, 12, 33, 11, -2, -27 },
  { 2099, 22, 23, 28, 4, -29 },
  { 2163, 22, 12, 28, 4, -23 },
  { 2196, 22, 23, 28, 4, -29 },
  { 2260, 17, 36, 20, 4, -35 },
  { 2337, 37, 39, 41, 3, -35 },
  { 2518, 28, 35, 27, -3, -35 },
  { 2641, 27, 35, 29, 2, -35 },
  { 2760, 27, 35, 29, 4, -35 },
  { 2879, 29, 35, 33, 2, -35 },
  { 3006, 25, 35, 26, 2, -35 },
  { 3116, 25, 35, 24, 2, -35 },
  { 3226, 29, 35, 34, 4, -35 },
  { 3353, 31, 35, 33, 2, -35 },
  { 3489, 17, 35, 15, 0, -35 },
  { 3564, 21, 44, 12, -8, -35 },
  { 3680, 29, 35, 27, 2, -35 },
  { 3807, 18, 35, 24, 2, -35 },
  { 3886, 38, 35, 40, 2, -35 },
  { 4053, 32, 35, 34, 2, -35 },
  { 4193, 29, 36, 35, 4, -36 },
  { 4324, 26, 35, 28, 2, -35 },
  { 4438, 29, 44, 35, 4, -36 },
  { 4598, 26, 35, 28, 2, -35 },
  { 4712, 24, 35, 25, 1, -35 },
  { 4817, 24, 35, 24, 5, -35 },
  { 4922, 30, 35, 34, 4, -35 },
  { 5054, 26, 35, 27, 5, -35 },
  { 5168, 39, 35, 41, 6, -35 },
  { 5339, 32, 35, 25, -3, -35 },
  { 5479, 24, 35, 24, 5, -35 },
  { 5584, 28, 35, 26, 0, -35 },
  { 5707, 18, 43, 15, 0, -35 },
  { 5804, 8, 35, 16, 5, -35 },
  { 5839, 19, 43, 15, -4, -35 },
  { 5942, 23, 22, 27, 2, -35 },
  { 6006, 19, 2, 19, -4, 5 },
  { 6011, 7, 8, 12, 7, -38 },
  { 6018, 24, 27, 27, 2, -27 },
  { 6099, 25, 37, 28, 1, -37 },
  { 6215, 20, 27, 22, 3, -27 },
  { 6283, 27, 37, 28, 2, -37 },
  { 6408, 20, 27, 24, 3, -27 },
  { 6476, 27, 49, 14, -6, -37 },
  { 6642, 26, 39, 28, 1, -27 },
  { 6769, 24, 37, 28, 1, -37 },
  { 6880, 11, 36, 11, 1, -36 },
  { 6930, 19, 48, 11, -7, -36 },
  { 7044, 24, 37, 23, 1, -37 },
  { 7155, 11, 37, 11, 1, -37 },
  { 7206, 38, 27, 42, 1, -27 },
  { 7335, 24, 27, 28, 1, -27 },
  { 7416, 22, 27, 28, 3, -27 },
  { 7491, 27, 39, 28, -1, -27 },
  { 7623, 25, 39, 28, 2, -27 },
  { 7745, 19, 27, 19, 1, -27 },
  { 7810, 20, 27, 21, 0, -27 },
  { 7878, 15, 32, 16, 2, -32 },
  { 7938, 23, 26, 28, 3, -26 },
  { 8013, 22, 26, 22, 2, -26 },
  { 8085, 32, 26, 34, 3, -26 },
  { 8189, 26, 26, 23, -2, -26 },
  { 8274, 29, 38, 22, -5, -26 },
  { 8412, 22, 26, 22, -1, -26 },
  { 8484, 18, 43, 17, 1, -35 },
  { 8581, 3, 49, 27, 13, -37 },
  { 8600, 18, 43, 17, -2, -35 },
  { 8697, 22, 5, 28, 4, -20 },
};

const GFXfont NotoSans_LightItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_LIGHTITALIC49PT7B_H_
