#ifndef _NOTOSANS_LIGHTITALIC24PT7B_H_
#define _NOTOSANS_LIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC4, 0x23, 0x18, 0x84, 0x23, 0x10, 0x80, 0x00, 0x18, 0xC0,
  0x4F, 0x28, 0xA2, 0x8A, 0x40, 0x03, 0x18, 0x08, 0x40, 0x21, 0x01, 0x8C,
  0x04, 0x21, 0xFF, 0xF0, 0xC2, 0x02, 0x10, 0x08, 0x40, 0x21, 0x01, 0x0C,
  0x3F, 0xFE, 0x10, 0x80, 0xC2, 0x02, 0x10, 0x08, 0x40, 0x61, 0x00, 0x01,
  0x80, 0x20, 0x3F, 0x8C, 0x93, 0x30, 0x44, 0x08, 0x81, 0x90, 0x1E, 0x00,
  0xE0, 0x16, 0x02, 0x60, 0x44, 0x08, 0x82, 0x27, 0x5C, 0x7E, 0x01, 0x00,
  0x60, 0x00, 0x3C, 0x06, 0x62, 0x0C, 0x42, 0x08, 0x42, 0x10, 0x82, 0x20,
  0x82, 0x60, 0x86, 0x40, 0x84, 0x9E, 0x8D, 0x22, 0x7B, 0x63, 0x02, 0x43,
  0x04, 0x42, 0x08, 0x42, 0x18, 0xC2, 0x10, 0xC6, 0x20, 0x44, 0x40, 0x78,
  0x07, 0xE0, 0x30, 0x80, 0x83, 0x02, 0x08, 0x08, 0x20, 0x21, 0x00, 0xD8,
  0x01, 0x80, 0x1A, 0x00, 0xCC, 0x14, 0x18, 0xF0, 0x22, 0x80, 0xD2, 0x01,
  0xCC, 0x06, 0x18, 0x64, 0x3F, 0x18, 0x7A, 0xA0, 0x06, 0x18, 0x20, 0x83,
  0x04, 0x18, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x81,
  0x02, 0x06, 0x00, 0x04, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03,
  0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x60, 0xC0,
  0x06, 0x01, 0x08, 0x43, 0x90, 0x39, 0xC3, 0xF1, 0x41, 0x90, 0xC2, 0x00,
  0xC0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x00, 0x32, 0x26, 0x48, 0xFC, 0xF0, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x20, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x00, 0x07, 0xC0,
  0x86, 0x10, 0x23, 0x03, 0x20, 0x36, 0x03, 0x60, 0x34, 0x03, 0x40, 0x24,
  0x02, 0xC0, 0x2C, 0x06, 0x40, 0x44, 0x0C, 0x40, 0x86, 0x10, 0x3E, 0x00,
  0x0C, 0xD6, 0xF2, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x30, 0x82, 0x18,
  0x60, 0x07, 0xE0, 0xC3, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0xFF, 0xE0, 0x0F, 0xC3, 0x06, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x78, 0x1F, 0x00, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC8, 0x18, 0xFE, 0x00, 0x00, 0x30, 0x03, 0x80, 0x34, 0x01, 0x60,
  0x12, 0x01, 0x10, 0x10, 0x81, 0x8C, 0x18, 0x61, 0x82, 0x18, 0x10, 0xFF,
  0xFF, 0xFF, 0x80, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0F, 0xF0, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x03, 0xF8, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC8, 0x18, 0xFE, 0x00, 0x07,
  0xE1, 0x80, 0x40, 0x10, 0x06, 0x00, 0x80, 0x11, 0x86, 0xFC, 0xA0, 0xD8,
  0x1A, 0x01, 0x40, 0x68, 0x0D, 0x01, 0x20, 0x66, 0x18, 0x7E, 0x00, 0x7F,
  0xE0, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x00, 0x07,
  0xE1, 0x82, 0x10, 0x31, 0x03, 0x10, 0x31, 0x02, 0x08, 0xC0, 0x78, 0x0F,
  0x03, 0x08, 0x60, 0x4C, 0x04, 0xC0, 0x6C, 0x04, 0xC0, 0xC6, 0x18, 0x3F,
  0x00, 0x0F, 0xC1, 0x86, 0x30, 0x22, 0x02, 0x60, 0x36, 0x03, 0x60, 0x26,
  0x06, 0x20, 0xE3, 0xF6, 0x04, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x70, 0xFC, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x0C, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x08, 0x61, 0x04, 0x20, 0x00, 0x60,
  0x38, 0x1C, 0x0C, 0x06, 0x01, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18,
  0x00, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x70, 0x30, 0x38, 0x1C,
  0x02, 0x00, 0x00, 0x7E, 0x21, 0x80, 0x40, 0x30, 0x10, 0x08, 0x08, 0x18,
  0x18, 0x18, 0x08, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x60, 0x60, 0x30, 0x02, 0x0C, 0x00, 0x63, 0x00, 0x04, 0x41,
  0xF8, 0x98, 0x43, 0x1A, 0x10, 0x43, 0x46, 0x08, 0x58, 0x81, 0x0B, 0x10,
  0x61, 0x62, 0x08, 0x6C, 0x43, 0x18, 0x8F, 0x9E, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x01, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x60, 0x07,
  0x00, 0x28, 0x03, 0x40, 0x12, 0x01, 0x98, 0x08, 0xC0, 0xC6, 0x04, 0x10,
  0x40, 0x87, 0xFC, 0x20, 0x23, 0x01, 0x90, 0x0D, 0x80, 0x68, 0x01, 0xC0,
  0x08, 0x0F, 0xE0, 0xC1, 0x86, 0x06, 0x20, 0x11, 0x00, 0x88, 0x0C, 0xC0,
  0xC7, 0xFC, 0x3F, 0xC1, 0x01, 0x18, 0x0C, 0xC0, 0x64, 0x03, 0x20, 0x19,
  0x01, 0x98, 0x38, 0xFF, 0x00, 0x07, 0xF8, 0x60, 0x46, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x08, 0x1F, 0xC0, 0x0F, 0xE0, 0x60,
  0xC1, 0x81, 0x84, 0x03, 0x10, 0x04, 0x40, 0x13, 0x00, 0x4C, 0x01, 0x20,
  0x04, 0x80, 0x36, 0x00, 0xD8, 0x02, 0x40, 0x19, 0x00, 0xC4, 0x06, 0x30,
  0xF0, 0xFF, 0x00, 0x0F, 0xF1, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x03, 0xFC, 0x3F, 0xC2, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xFF, 0x80, 0x0F, 0xF1, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xC2, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0xFC, 0x30, 0x31, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC1, 0xFA, 0x07,
  0xE8, 0x01, 0xA0, 0x04, 0xC0, 0x13, 0x00, 0xC6, 0x03, 0x0C, 0x18, 0x1F,
  0xE0, 0x08, 0x02, 0x30, 0x04, 0x60, 0x18, 0x80, 0x31, 0x00, 0x42, 0x00,
  0x8C, 0x01, 0x1F, 0xFE, 0x3F, 0xFC, 0x40, 0x11, 0x80, 0x23, 0x00, 0xC4,
  0x01, 0x88, 0x02, 0x10, 0x04, 0x60, 0x08, 0xC0, 0x30, 0x1F, 0x04, 0x04,
  0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30,
  0x20, 0xF8, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0xF8, 0x00, 0x08, 0x0C, 0x60, 0x61, 0x83, 0x04, 0x10,
  0x10, 0x80, 0x44, 0x03, 0x60, 0x0B, 0x80, 0x3A, 0x00, 0xCC, 0x06, 0x30,
  0x18, 0x40, 0x41, 0x81, 0x02, 0x04, 0x0C, 0x30, 0x10, 0xC0, 0x60, 0x08,
  0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C,
  0x04, 0x02, 0x01, 0x01, 0x80, 0xFF, 0x80, 0x0C, 0x00, 0xE3, 0x80, 0x18,
  0x50, 0x05, 0x0A, 0x01, 0xA1, 0x40, 0x2C, 0x6C, 0x0D, 0x8D, 0x81, 0x21,
  0x10, 0x64, 0x22, 0x08, 0x84, 0x42, 0x31, 0x88, 0xC6, 0x31, 0x10, 0x84,
  0x36, 0x10, 0x86, 0x86, 0x10, 0x70, 0xC6, 0x0C, 0x10, 0xC1, 0x02, 0x00,
  0x08, 0x03, 0x1C, 0x02, 0x14, 0x02, 0x16, 0x06, 0x12, 0x06, 0x32, 0x04,
  0x33, 0x04, 0x21, 0x04, 0x21, 0x8C, 0x20, 0x8C, 0x60, 0x88, 0x60, 0xC8,
  0x40, 0x48, 0x40, 0x78, 0x40, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0x07, 0xF0,
  0x70, 0x63, 0x00, 0xC8, 0x03, 0x60, 0x05, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0xC0, 0x1B, 0x00, 0x66, 0x03,
  0x0C, 0x38, 0x1F, 0x80, 0x0F, 0xE0, 0xC1, 0x86, 0x04, 0x20, 0x21, 0x01,
  0x88, 0x08, 0xC0, 0x46, 0x06, 0x20, 0xE1, 0xFC, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x70, 0x63,
  0x00, 0xC8, 0x03, 0x60, 0x05, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x02, 0xC0, 0x1B, 0x00, 0x66, 0x03, 0x1C, 0x38,
  0x1F, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x0F, 0xE0, 0xC1,
  0x86, 0x04, 0x20, 0x21, 0x01, 0x88, 0x08, 0xC0, 0xC4, 0x0C, 0x3F, 0xC1,
  0xF8, 0x18, 0x40, 0xC3, 0x04, 0x08, 0x20, 0x61, 0x03, 0x18, 0x08, 0xC0,
  0x60, 0x07, 0xF0, 0xC1, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x04, 0x00, 0xCC,
  0x18, 0x7F, 0x00, 0xFF, 0xF0, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x00, 0x30, 0x06, 0x60, 0x08, 0x80, 0x11, 0x00,
  0x62, 0x00, 0xCC, 0x01, 0x18, 0x02, 0x20, 0x04, 0x40, 0x19, 0x80, 0x33,
  0x00, 0x44, 0x00, 0x88, 0x03, 0x18, 0x04, 0x30, 0x18, 0x30, 0x60, 0x3F,
  0x80, 0xC0, 0x1A, 0x00, 0x90, 0x0C, 0x80, 0x44, 0x06, 0x20, 0x21, 0x82,
  0x0C, 0x30, 0x61, 0x01, 0x18, 0x08, 0x80, 0x4C, 0x02, 0x40, 0x16, 0x00,
  0xA0, 0x07, 0x00, 0x30, 0x00, 0x80, 0xC0, 0x70, 0x18, 0x0A, 0x07, 0x03,
  0x40, 0xA0, 0x48, 0x14, 0x19, 0x04, 0x82, 0x20, 0x90, 0x44, 0x23, 0x18,
  0x84, 0x62, 0x19, 0x0C, 0xC3, 0x21, 0x90, 0x6C, 0x16, 0x0D, 0x02, 0x81,
  0xE0, 0x50, 0x38, 0x0C, 0x03, 0x01, 0x80, 0x40, 0x20, 0x00, 0x08, 0x06,
  0x18, 0x18, 0x10, 0x60, 0x30, 0x80, 0x22, 0x00, 0x4C, 0x00, 0xF0, 0x00,
  0xC0, 0x03, 0x80, 0x05, 0x00, 0x12, 0x00, 0x66, 0x01, 0x84, 0x06, 0x0C,
  0x08, 0x18, 0x20, 0x10, 0xC0, 0x30, 0xC0, 0x34, 0x06, 0x40, 0x46, 0x0C,
  0x21, 0x82, 0x10, 0x22, 0x03, 0x60, 0x14, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x00, 0x0F, 0xFC, 0x40, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0xFF, 0xE0, 0x0F, 0x84, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30,
  0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10,
  0x0F, 0x80, 0xC2, 0x10, 0x84, 0x30, 0x84, 0x21, 0x08, 0x61, 0x08, 0x42,
  0x18, 0x0F, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x0F,
  0x80, 0x03, 0x00, 0xE0, 0x14, 0x04, 0x40, 0x88, 0x21, 0x8C, 0x11, 0x02,
  0x60, 0x78, 0x04, 0xFF, 0xFF, 0xC0, 0x99, 0x80, 0x0F, 0x11, 0x8A, 0x30,
  0x66, 0x06, 0x40, 0x64, 0x06, 0xC0, 0x4C, 0x04, 0xC0, 0xCC, 0x0C, 0xC1,
  0xC4, 0x28, 0x3C, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x3C, 0x2C, 0x62, 0x82, 0x30, 0x22, 0x03, 0x60, 0x24, 0x02, 0x40, 0x24,
  0x06, 0xC0, 0x4C, 0x0C, 0xA1, 0x89, 0xF0, 0x0F, 0xC6, 0x13, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x84, 0x3F, 0x00,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x07, 0xC8, 0x63, 0xC6,
  0x0E, 0x60, 0x62, 0x01, 0x10, 0x19, 0x80, 0xCC, 0x04, 0x60, 0x23, 0x03,
  0x18, 0x28, 0x42, 0xC1, 0xE4, 0x00, 0x07, 0x86, 0x33, 0x04, 0x81, 0x40,
  0xD0, 0xEF, 0xE3, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x82, 0x3F, 0x00, 0x00,
  0x78, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x07, 0xF0, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x02, 0xC0,
  0x1C, 0x00, 0x0F, 0x91, 0x8D, 0x30, 0x76, 0x06, 0x40, 0x24, 0x06, 0xC0,
  0x6C, 0x04, 0xC0, 0x4C, 0x0C, 0xC1, 0x44, 0x2C, 0x3C, 0x80, 0x08, 0x00,
  0x80, 0x18, 0x03, 0x0C, 0xE0, 0x78, 0x00, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x67, 0x8B, 0x19, 0x41, 0x30, 0x24, 0x05, 0x81, 0xA0, 0x34,
  0x04, 0x80, 0xB0, 0x16, 0x06, 0x80, 0xD0, 0x10, 0x08, 0xC4, 0x00, 0x18,
  0xC4, 0x21, 0x18, 0x84, 0x23, 0x18, 0x84, 0x00, 0x00, 0x80, 0xC0, 0x40,
  0x00, 0x00, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20,
  0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x83, 0xC1, 0x80, 0x18,
  0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0xCC, 0x31, 0x0C, 0x23, 0x04,
  0xC1, 0xB0, 0x2E, 0x06, 0x40, 0x8C, 0x30, 0x86, 0x18, 0x81, 0x10, 0x30,
  0x18, 0xC4, 0x21, 0x18, 0xC4, 0x21, 0x18, 0x84, 0x23, 0x18, 0x84, 0x00,
  0x33, 0x87, 0x8B, 0x33, 0x32, 0x85, 0x04, 0xC1, 0x81, 0x20, 0x60, 0x58,
  0x10, 0x36, 0x04, 0x0D, 0x03, 0x02, 0x40, 0xC0, 0xB0, 0x20, 0x2C, 0x08,
  0x1A, 0x02, 0x06, 0x81, 0x81, 0x00, 0x33, 0xC5, 0x8C, 0xA0, 0x98, 0x16,
  0x02, 0xC0, 0xD8, 0x1A, 0x02, 0x40, 0x58, 0x0B, 0x03, 0x40, 0x68, 0x08,
  0x0F, 0x83, 0x18, 0xC1, 0xB0, 0x14, 0x02, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x09, 0x03, 0x30, 0xC3, 0xF0, 0x19, 0xE0, 0xB1, 0x85, 0x04, 0x30,
  0x21, 0x01, 0x98, 0x08, 0x80, 0x44, 0x02, 0x20, 0x33, 0x01, 0x18, 0x18,
  0xA1, 0x84, 0xF8, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x00, 0x0F, 0x91, 0x8D, 0x30, 0x76, 0x06, 0x40, 0x24, 0x06, 0xC0, 0x6C,
  0x04, 0xC0, 0x4C, 0x0C, 0xC1, 0xC4, 0x2C, 0x3C, 0x80, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x33, 0x97, 0x0A, 0x06, 0x02, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x00, 0x0F, 0x8C, 0x32,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x12, 0x0C,
  0xFE, 0x00, 0x10, 0x20, 0x47, 0xF3, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02,
  0x0C, 0x18, 0x30, 0x3C, 0x30, 0x32, 0x03, 0x20, 0x22, 0x02, 0x60, 0x26,
  0x06, 0x40, 0x44, 0x04, 0xC0, 0xCC, 0x0C, 0xC1, 0xC4, 0x28, 0x7C, 0x80,
  0xC0, 0x78, 0x1B, 0x02, 0x20, 0xC4, 0x10, 0x86, 0x10, 0x82, 0x30, 0x64,
  0x0D, 0x80, 0xA0, 0x18, 0x03, 0x00, 0xC1, 0x81, 0xC1, 0x83, 0xC3, 0x82,
  0x42, 0x86, 0x46, 0x84, 0x44, 0x8C, 0x4C, 0x88, 0x48, 0xD8, 0x58, 0xD0,
  0x50, 0xD0, 0x50, 0x70, 0x60, 0x60, 0x60, 0x60, 0x18, 0x18, 0x41, 0x82,
  0x18, 0x19, 0x80, 0x48, 0x03, 0x80, 0x08, 0x00, 0xE0, 0x0D, 0x00, 0xCC,
  0x0C, 0x20, 0xC1, 0x8C, 0x04, 0x00, 0x0C, 0x06, 0x18, 0x08, 0x10, 0x20,
  0x20, 0xC0, 0x41, 0x00, 0x86, 0x01, 0x88, 0x03, 0x30, 0x06, 0x40, 0x05,
  0x80, 0x0A, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x01, 0x30, 0x03, 0xC0, 0x00, 0x1F, 0xE4, 0x18, 0x02, 0x00, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x60, 0x0F, 0xF0,
  0x03, 0x83, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x18, 0x18, 0x38,
  0x06, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x07, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0x00, 0xC0, 0x40, 0x20,
  0x10, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xE0, 0xC0, 0xC0, 0x40, 0x20, 0x10,
  0x18, 0x08, 0x04, 0x0E, 0x0C, 0x00, 0x70, 0x39, 0xCE, 0x0F, 0x00,
};

const GFXglyph NotoSans_LightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 17, 6, 1, -17 },
  { 12, 6, 6, 8, 3, -17 },
  { 17, 14, 17, 15, 1, -17 },
  { 47, 11, 19, 13, 1, -18 },
  { 74, 16, 17, 19, 2, -17 },
  { 108, 14, 17, 16, 1, -17 },
  { 138, 2, 6, 5, 3, -17 },
  { 140, 7, 21, 6, 1, -17 },
  { 159, 8, 21, 6, -2, -17 },
  { 180, 10, 10, 13, 3, -18 },
  { 193, 11, 11, 14, 2, -14 },
  { 209, 4, 6, 5, -1, -3 },
  { 212, 6, 1, 8, 1, -7 },
  { 213, 2, 2, 6, 1, -2 },
  { 214, 11, 17, 8, -1, -17 },
  { 238, 12, 17, 13, 1, -17 },
  { 264, 6, 17, 13, 4, -17 },
  { 277, 12, 17, 13, 0, -17 },
  { 303, 12, 17, 13, 1, -17 },
  { 329, 13, 17, 13, 0, -17 },
  { 357, 12, 17, 13, 1, -17 },
  { 383, 11, 17, 13, 2, -17 },
  { 407, 11, 17, 13, 2, -17 },
  { 431, 12, 17, 13, 1, -17 },
  { 457, 12, 17, 13, 1, -17 },
  { 483, 4, 13, 6, 1, -13 },
  { 490, 6, 16, 6, -1, -13 },
  { 502, 11, 11, 14, 2, -14 },
  { 518, 11, 6, 14, 2, -11 },
  { 527, 11, 11, 14, 2, -14 },
  { 543, 9, 17, 10, 2, -17 },
  { 563, 19, 19, 20, 1, -17 },
  { 609, 13, 17, 13, -1, -17 },
  { 637, 13, 17, 14, 1, -17 },
  { 665, 13, 17, 14, 2, -17 },
  { 693, 14, 17, 16, 1, -17 },
  { 723, 12, 17, 13, 1, -17 },
  { 749, 12, 17, 12, 1, -17 },
  { 775, 14, 17, 16, 2, -17 },
  { 805, 15, 17, 16, 1, -17 },
  { 837, 8, 17, 7, 0, -17 },
  { 854, 10, 21, 6, -4, -17 },
  { 881, 14, 17, 13, 1, -17 },
  { 911, 9, 17, 12, 1, -17 },
  { 931, 19, 17, 20, 1, -17 },
  { 972, 16, 17, 17, 1, -17 },
  { 1006, 14, 17, 17, 2, -17 },
  { 1036, 13, 17, 14, 1, -17 },
  { 1064, 14, 21, 17, 2, -17 },
  { 1101, 13, 17, 14, 1, -17 },
  { 1129, 12, 17, 12, 0, -17 },
  { 1155, 12, 17, 12, 2, -17 },
  { 1181, 15, 17, 16, 2, -17 },
  { 1213, 13, 17, 13, 2, -17 },
  { 1241, 19, 17, 20, 3, -17 },
  { 1282, 15, 17, 12, -1, -17 },
  { 1314, 12, 17, 12, 2, -17 },
  { 1340, 14, 17, 13, 0, -17 },
  { 1370, 9, 21, 7, 0, -17 },
  { 1394, 5, 17, 8, 2, -17 },
  { 1405, 9, 21, 7, -2, -17 },
  { 1429, 11, 10, 13, 1, -17 },
  { 1443, 9, 2, 9, -2, 2 },
  { 1446, 3, 3, 6, 4, -18 },
  { 1448, 12, 13, 13, 1, -13 },
  { 1468, 12, 18, 14, 1, -18 },
  { 1495, 10, 13, 11, 1, -13 },
  { 1512, 13, 18, 14, 1, -18 },
  { 1542, 10, 13, 12, 1, -13 },
  { 1559, 13, 24, 7, -3, -18 },
  { 1598, 12, 19, 14, 1, -13 },
  { 1627, 11, 18, 14, 1, -18 },
  { 1652, 5, 18, 6, 1, -18 },
  { 1664, 9, 24, 6, -3, -18 },
  { 1691, 11, 18, 11, 1, -18 },
  { 1716, 5, 18, 6, 1, -18 },
  { 1728, 18, 13, 21, 1, -13 },
  { 1758, 11, 13, 14, 1, -13 },
  { 1776, 11, 13, 14, 1, -13 },
  { 1794, 13, 19, 14, 0, -13 },
  { 1825, 12, 19, 14, 1, -13 },
  { 1854, 9, 13, 9, 1, -13 },
  { 1869, 10, 13, 10, 0, -13 },
  { 1886, 7, 16, 8, 1, -16 },
  { 1900, 12, 13, 14, 1, -13 },
  { 1920, 11, 13, 11, 1, -13 },
  { 1938, 16, 13, 16, 1, -13 },
  { 1964, 13, 13, 11, -1, -13 },
  { 1986, 15, 19, 11, -3, -13 },
  { 2022, 11, 13, 11, 0, -13 },
  { 2040, 9, 21, 8, 0, -17 },
  { 2064, 2, 24, 13, 6, -18 },
  { 2070, 9, 21, 8, -1, -17 },
  { 2094, 11, 3, 14, 2, -10 },
};

const GFXfont NotoSans_LightItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_LIGHTITALIC24PT7B_H_
