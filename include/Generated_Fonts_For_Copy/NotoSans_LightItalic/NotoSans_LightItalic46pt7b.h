#ifndef _NOTOSANS_LIGHTITALIC46PT7B_H_
#define _NOTOSANS_LIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x10, 0x00, 0x38, 0x73, 0x87, 0x30,
  0x67, 0x06, 0x70, 0xE7, 0x0E, 0x60, 0xC6, 0x0C, 0x60, 0xCC, 0x0C, 0xC1,
  0x8C, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x0E,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF0, 0x06, 0x03, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x0C,
  0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x38, 0x0C, 0x00, 0x06,
  0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x3E,
  0x67, 0x81, 0xE1, 0x82, 0x07, 0x0E, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0,
  0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x60, 0x00, 0xE1, 0x80, 0x01,
  0xC6, 0x00, 0x03, 0xD8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x37, 0xC0, 0x00, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x18, 0x38,
  0x00, 0x60, 0x60, 0x01, 0x83, 0x80, 0x06, 0x0E, 0x00, 0x30, 0x30, 0x00,
  0xC1, 0xC3, 0x03, 0x1E, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x3F, 0xC0, 0x01, 0x81, 0xC3,
  0x80, 0x0C, 0x0E, 0x06, 0x00, 0x70, 0x30, 0x18, 0x03, 0x81, 0xC0, 0x60,
  0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x18, 0x1C,
  0x03, 0x80, 0x60, 0x60, 0x0C, 0x01, 0x83, 0x80, 0x30, 0x0E, 0x1C, 0x00,
  0xC0, 0x30, 0x60, 0x03, 0x00, 0xC3, 0x0F, 0x8C, 0x07, 0x1C, 0xFF, 0x30,
  0x18, 0xE7, 0x8E, 0xE0, 0xE3, 0x18, 0x1B, 0x87, 0x18, 0xE0, 0x77, 0xF8,
  0xE3, 0x01, 0xCF, 0xC7, 0x1C, 0x07, 0x00, 0x18, 0x60, 0x1C, 0x00, 0xC1,
  0x80, 0x60, 0x07, 0x06, 0x01, 0x80, 0x38, 0x38, 0x06, 0x00, 0xC0, 0xE0,
  0x18, 0x06, 0x03, 0x00, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x30, 0x0C,
  0x06, 0x00, 0xC0, 0x70, 0x30, 0x03, 0x81, 0x81, 0xC0, 0x06, 0x0C, 0x0E,
  0x00, 0x1F, 0xF0, 0x70, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00,
  0x18, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x06, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xD8, 0x00, 0x00, 0xF9,
  0xC0, 0x01, 0x1E, 0x0E, 0x00, 0x63, 0x80, 0x70, 0x0E, 0x70, 0x07, 0x01,
  0xC7, 0x00, 0x38, 0x1C, 0xE0, 0x01, 0xC3, 0x8E, 0x00, 0x0E, 0x70, 0xE0,
  0x00, 0xE7, 0x0C, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0xFC, 0x07, 0x00, 0x1C, 0xE0, 0x78, 0x07, 0x87, 0x03,
  0xFF, 0xF0, 0x70, 0x0F, 0xFC, 0x03, 0x80, 0x39, 0xCC, 0xE7, 0x39, 0x8C,
  0x66, 0x31, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x06,
  0x03, 0x00, 0xF8, 0x30, 0x03, 0xC2, 0x00, 0x0F, 0x60, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xB0, 0x00, 0x73, 0x00, 0x0E, 0x18,
  0x01, 0xC1, 0x80, 0x38, 0x1C, 0x03, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x60,
  0xC0, 0x7F, 0xF7, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x40, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0xF8, 0x3C, 0x07, 0x00, 0xE0, 0x70,
  0x03, 0x87, 0x00, 0x1C, 0x30, 0x00, 0xE3, 0x80, 0x03, 0x18, 0x00, 0x19,
  0xC0, 0x00, 0xCE, 0x00, 0x06, 0x60, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00,
  0x0D, 0x80, 0x00, 0xEC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x6E, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01,
  0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0,
  0x07, 0x07, 0x00, 0x78, 0x38, 0x07, 0x80, 0xE0, 0x78, 0x03, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x7C, 0x0F, 0xE0, 0xF7, 0x1E,
  0x33, 0xE1, 0x8C, 0x1C, 0x40, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0xF8, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x80, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0x80, 0xF0, 0x3C, 0x00, 0xE0,
  0x20, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x10,
  0x00, 0x3C, 0x3C, 0x01, 0xF0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x30, 0x00, 0x07, 0x18,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x03, 0x83,
  0x00, 0x03, 0x81, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0x70, 0x03, 0x80, 0x30, 0x03, 0x80, 0x18, 0x03, 0x80, 0x1C, 0x01, 0x80,
  0x0E, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x03, 0x01, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x9F, 0x80, 0x03,
  0xFF, 0xE0, 0x0F, 0x87, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x10, 0x00, 0x70, 0x38, 0x03, 0xC0,
  0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xC0, 0x40, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC3, 0xFC, 0x07, 0x3F, 0xFC, 0x1D,
  0xC0, 0x70, 0x6C, 0x00, 0xE1, 0xE0, 0x03, 0x8F, 0x00, 0x07, 0x3C, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0xE0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x18, 0x00, 0x70, 0x70,
  0x03, 0xC1, 0xC0, 0x1E, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0x81,
  0xE0, 0x1E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x1C, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0x3C, 0x3C, 0x00, 0x3D, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0x8F, 0x00, 0x3C, 0x0F, 0x01, 0xE0,
  0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x70, 0x00,
  0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03,
  0x87, 0x00, 0x0E, 0x0F, 0x00, 0x38, 0x0F, 0x01, 0xF0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x3E, 0x0F, 0x01,
  0xE0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x00, 0x61, 0xC0, 0x01, 0xC7, 0x00,
  0x07, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03, 0xC7, 0x00, 0x1E, 0x1C,
  0x00, 0xD8, 0x38, 0x07, 0xE0, 0xFF, 0xF3, 0x80, 0xFF, 0x8C, 0x00, 0x60,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x08, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x07,
  0x0F, 0x0F, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x40,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0xFC, 0x78, 0x1E, 0x20, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xE1,
  0xC0, 0x01, 0x00, 0x1C, 0x70, 0x03, 0xFF, 0x81, 0x8C, 0x01, 0xFB, 0xE0,
  0x33, 0x80, 0x70, 0x0C, 0x06, 0x60, 0x1C, 0x03, 0x80, 0xCC, 0x07, 0x00,
  0x70, 0x1B, 0x80, 0xC0, 0x0C, 0x03, 0x60, 0x38, 0x01, 0x80, 0x6C, 0x06,
  0x00, 0x70, 0x0D, 0x80, 0xC0, 0x0C, 0x01, 0xB0, 0x38, 0x01, 0x80, 0x7E,
  0x07, 0x00, 0x70, 0x0D, 0xC0, 0xE0, 0x0E, 0x01, 0xB8, 0x1C, 0x03, 0xC0,
  0x73, 0x03, 0x80, 0x78, 0x1C, 0x60, 0x70, 0x1B, 0x03, 0x0C, 0x07, 0x0E,
  0x61, 0xE1, 0x80, 0x7F, 0x8F, 0xF0, 0x38, 0x07, 0xC0, 0xFC, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x10,
  0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x03, 0x83,
  0x00, 0x01, 0x81, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x01, 0x87,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x73, 0x80, 0x00, 0x39, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x70, 0x01, 0xE0, 0x38,
  0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x38, 0x07, 0xE0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x03,
  0x81, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x87, 0x00, 0x07, 0x83, 0x80, 0x07, 0x81, 0x80, 0x3F, 0x81, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x3F, 0x01, 0xE0, 0x3C, 0x00, 0x20, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x01, 0xC0, 0x0F, 0x80, 0x38, 0x00, 0x78, 0x07, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x38, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x1C, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x06, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x1E,
  0x07, 0x00, 0x07, 0x80, 0xE0, 0x07, 0xE0, 0x18, 0x0F, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0xF0,
  0x00, 0x60, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0x9C, 0x00, 0x7F,
  0xE3, 0x00, 0x0F, 0xFC, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x0E, 0x30, 0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x06, 0x07, 0x80,
  0x01, 0xC0, 0x78, 0x00, 0x38, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x81, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x38,
  0x06, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x78, 0x00, 0xC0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x67, 0xC0, 0x00, 0x0D,
  0xD8, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x36, 0x03, 0x60, 0x00, 0x07, 0xE0, 0x37, 0x00, 0x00, 0x6E, 0x03,
  0x70, 0x00, 0x0E, 0xE0, 0x73, 0x00, 0x01, 0xCC, 0x07, 0x30, 0x00, 0x1D,
  0xC0, 0x73, 0x00, 0x03, 0x9C, 0x06, 0x30, 0x00, 0x31, 0xC0, 0x63, 0x00,
  0x07, 0x18, 0x0E, 0x38, 0x00, 0x61, 0x80, 0xE3, 0x80, 0x0E, 0x38, 0x0E,
  0x18, 0x01, 0xC3, 0x80, 0xC1, 0x80, 0x1C, 0x38, 0x0C, 0x18, 0x03, 0x83,
  0x01, 0xC1, 0x80, 0x30, 0x30, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0,
  0x60, 0x70, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC1, 0xC0, 0x60, 0x38,
  0x0C, 0x18, 0x06, 0x03, 0x80, 0xC3, 0x80, 0xE0, 0x30, 0x0C, 0x30, 0x0E,
  0x03, 0x00, 0xE7, 0x00, 0xE0, 0x70, 0x0E, 0x60, 0x0C, 0x07, 0x00, 0x6E,
  0x01, 0xC0, 0x70, 0x07, 0xC0, 0x1C, 0x06, 0x00, 0x78, 0x01, 0xC0, 0x60,
  0x07, 0x80, 0x18, 0x0E, 0x00, 0x70, 0x01, 0x80, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x01,
  0x80, 0xF8, 0x00, 0x0E, 0x03, 0x60, 0x00, 0x38, 0x0D, 0xC0, 0x00, 0xE0,
  0x33, 0x00, 0x03, 0x01, 0xCE, 0x00, 0x0C, 0x07, 0x38, 0x00, 0x70, 0x1C,
  0x60, 0x01, 0xC0, 0x61, 0xC0, 0x07, 0x01, 0x83, 0x00, 0x18, 0x0E, 0x0E,
  0x00, 0x60, 0x38, 0x38, 0x03, 0x80, 0xE0, 0x60, 0x0E, 0x03, 0x01, 0xC0,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x0E, 0x03, 0x01, 0xC0, 0x38, 0x1C,
  0x07, 0x00, 0x60, 0x70, 0x18, 0x01, 0xC1, 0x80, 0xE0, 0x03, 0x06, 0x03,
  0x80, 0x0E, 0x38, 0x0E, 0x00, 0x38, 0xE0, 0x30, 0x00, 0x63, 0x80, 0xC0,
  0x01, 0xCC, 0x07, 0x00, 0x03, 0x30, 0x1C, 0x00, 0x0E, 0xC0, 0x70, 0x00,
  0x3F, 0x01, 0x80, 0x00, 0x7C, 0x06, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C,
  0x38, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x07, 0xC0,
  0x7C, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x0E,
  0x03, 0x80, 0x06, 0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x3C, 0x0C, 0x00, 0xF8,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xC0, 0x7C, 0x01, 0xE0,
  0x03, 0xC0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x07, 0x80,
  0x01, 0xC0, 0x78, 0x00, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x07, 0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x1E, 0x0E, 0x00, 0x3C, 0x0C, 0x00, 0x78, 0x0C, 0x0F, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x1C, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x30, 0x01,
  0xC0, 0x70, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00,
  0x60, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xC0, 0xF0, 0x1E, 0x00, 0x20, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x10, 0x00, 0x78,
  0x38, 0x03, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C,
  0x1C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x18, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x30, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x70, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x30, 0xE0, 0x00, 0x70, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x60, 0x01,
  0xC0, 0x60, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x1C,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x38, 0x00, 0x38, 0x30, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x19, 0xC0,
  0x00, 0x1B, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F,
  0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0xC0, 0x01, 0xE0,
  0x00, 0xE6, 0x00, 0x1F, 0x00, 0x0E, 0x30, 0x00, 0xD8, 0x00, 0x71, 0x80,
  0x0E, 0xC0, 0x03, 0x0C, 0x00, 0x67, 0x00, 0x38, 0x60, 0x07, 0x38, 0x01,
  0x83, 0x00, 0x39, 0xC0, 0x1C, 0x18, 0x01, 0x8E, 0x00, 0xC0, 0xC0, 0x1C,
  0x70, 0x0E, 0x06, 0x00, 0xC3, 0x80, 0x70, 0x30, 0x0E, 0x0C, 0x07, 0x01,
  0xC0, 0x60, 0x60, 0x38, 0x0E, 0x07, 0x03, 0x01, 0x80, 0x70, 0x30, 0x18,
  0x1C, 0x03, 0x83, 0x80, 0xC0, 0xC0, 0x1C, 0x18, 0x06, 0x0E, 0x00, 0xE1,
  0xC0, 0x30, 0x60, 0x07, 0x0C, 0x01, 0x87, 0x00, 0x38, 0xE0, 0x0C, 0x30,
  0x01, 0xC6, 0x00, 0x63, 0x80, 0x0E, 0x70, 0x03, 0x1C, 0x00, 0x73, 0x00,
  0x1C, 0xC0, 0x01, 0xB8, 0x00, 0xEE, 0x00, 0x0D, 0xC0, 0x07, 0x60, 0x00,
  0x6C, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0,
  0x07, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0xE0, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x30, 0x03, 0x80, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0xC0,
  0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC3, 0x00, 0x07, 0x06, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x1C, 0x00, 0x60, 0x70, 0x00, 0xC0, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x8E, 0x00, 0x03, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xC0, 0xC0, 0xE0, 0xE0,
  0xE0, 0x60, 0x60, 0x60, 0x70, 0x70, 0x70, 0x30, 0x30, 0x30, 0x38, 0x38,
  0x38, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E,
  0x0E, 0x06, 0x06, 0x06, 0x07, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x77, 0x00, 0x01, 0x8C, 0x00, 0x0E,
  0x30, 0x00, 0x30, 0x60, 0x01, 0xC1, 0x80, 0x0E, 0x07, 0x00, 0x30, 0x0C,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0x60, 0x38, 0x01, 0x81, 0xC0, 0x07, 0x06,
  0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0xB8, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0x87, 0x0C, 0x38, 0x60, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xFE, 0x30, 0x3E, 0x3C, 0xC1, 0xE0, 0x37, 0x0F,
  0x00, 0x7C, 0x78, 0x01, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x71,
  0x80, 0x01, 0xCE, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80,
  0x07, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0xF0, 0x70, 0x06, 0xC1, 0xC0, 0x33,
  0x03, 0x83, 0x8C, 0x0F, 0xFC, 0x70, 0x1F, 0xE1, 0x80, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x1F, 0x80, 0x38, 0xFF, 0x80, 0x73, 0xCF, 0x80, 0xCE,
  0x03, 0x81, 0xB0, 0x07, 0x07, 0xC0, 0x07, 0x0F, 0x00, 0x0E, 0x1E, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x1F,
  0x00, 0x3C, 0x36, 0x00, 0xF0, 0x67, 0x03, 0xC0, 0xC7, 0xFF, 0x03, 0x87,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x0F, 0xC7, 0x83, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x80, 0xFF, 0xF0, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x83,
  0x80, 0x3F, 0xF1, 0xC0, 0x3E, 0x3C, 0xC0, 0x3C, 0x07, 0x60, 0x38, 0x01,
  0xB0, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x1F, 0x01,
  0xC0, 0x1F, 0x80, 0xE0, 0x1D, 0x80, 0x38, 0x1C, 0xC0, 0x1F, 0xFC, 0x60,
  0x07, 0xF8, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x7E, 0x78, 0x3C,
  0x07, 0x1E, 0x00, 0xC7, 0x00, 0x33, 0x80, 0x0D, 0xC0, 0x07, 0x70, 0x01,
  0xD8, 0x00, 0xEE, 0x00, 0xF3, 0x9F, 0xF8, 0xFF, 0xF8, 0x3F, 0xC0, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x47, 0x80, 0x60, 0xFF, 0xF8, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x08, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x02, 0x3C, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xC3, 0x01, 0xF1, 0xE6, 0x03, 0xC0, 0x76, 0x07, 0x80, 0x36, 0x0F, 0x00,
  0x1E, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x70, 0x00, 0xF0, 0x70, 0x01, 0xF0, 0x38, 0x03, 0x70, 0x38, 0x07,
  0x60, 0x1C, 0x0E, 0x60, 0x1F, 0xFC, 0xE0, 0x0F, 0xF0, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x80, 0x0F, 0x00, 0xF8, 0x7E,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x7E, 0x01, 0xC7, 0xFE, 0x07, 0x3C, 0x78, 0x19, 0xC0, 0x70, 0x6C, 0x01,
  0xC3, 0xE0, 0x03, 0x0F, 0x00, 0x0C, 0x3C, 0x00, 0x30, 0xE0, 0x00, 0xC3,
  0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0x86, 0x00,
  0x0E, 0x18, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0C,
  0x30, 0x00, 0x70, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x18, 0x70,
  0x00, 0x61, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x70, 0x1C,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x00, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x23, 0xC0, 0x1F, 0xC0,
  0x0F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x41, 0xC0, 0x0E,
  0x07, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0xE0, 0x0E,
  0x07, 0x00, 0x38, 0x38, 0x00, 0xC1, 0xC0, 0x03, 0x0E, 0x00, 0x1C, 0x70,
  0x00, 0x73, 0x80, 0x01, 0x9F, 0x00, 0x06, 0xCC, 0x00, 0x1E, 0x38, 0x00,
  0xF0, 0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x30, 0x0E, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x03, 0x81, 0x80, 0x0E,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x71, 0xFE, 0x07, 0xFC, 0x06, 0x3C, 0xF0,
  0xF3, 0xE0, 0x66, 0x03, 0x9C, 0x0E, 0x06, 0xC0, 0x3B, 0x80, 0x70, 0x78,
  0x01, 0xB0, 0x07, 0x0F, 0x00, 0x1E, 0x00, 0x70, 0xF0, 0x01, 0xC0, 0x07,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0xE0, 0x03, 0x80, 0x06, 0x1C, 0x00, 0x38,
  0x00, 0x61, 0xC0, 0x03, 0x00, 0x0E, 0x1C, 0x00, 0x30, 0x00, 0xE1, 0x80,
  0x07, 0x00, 0x0E, 0x18, 0x00, 0x70, 0x00, 0xC3, 0x80, 0x07, 0x00, 0x0C,
  0x38, 0x00, 0x60, 0x01, 0xC3, 0x80, 0x06, 0x00, 0x1C, 0x30, 0x00, 0xE0,
  0x01, 0xC3, 0x00, 0x0E, 0x00, 0x18, 0x70, 0x00, 0xC0, 0x03, 0x87, 0x00,
  0x0C, 0x00, 0x38, 0x70, 0x01, 0xC0, 0x03, 0x86, 0x00, 0x1C, 0x00, 0x30,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x07, 0xE0, 0x1C, 0x7F, 0xE0, 0x63,
  0xEF, 0xC1, 0x9C, 0x07, 0x06, 0xC0, 0x1C, 0x3E, 0x00, 0x30, 0xF8, 0x00,
  0xC3, 0xC0, 0x03, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xC7,
  0x00, 0x07, 0x1C, 0x00, 0x18, 0x70, 0x00, 0xE1, 0x80, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xC3, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0x70, 0x00, 0x71, 0xC0, 0x01, 0x87, 0x00, 0x0E, 0x18, 0x00, 0x38, 0xE0,
  0x00, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0x3E, 0x01, 0xE0,
  0x1C, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0x8E, 0x00, 0x06,
  0x38, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x06, 0x60,
  0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x33, 0x80, 0x01, 0xC6, 0x00, 0x07, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xC0,
  0xE0, 0x0F, 0x03, 0xC0, 0x78, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0xE3, 0xFE, 0x00, 0x63, 0xCF, 0x80, 0x33, 0x80, 0xE0,
  0x1B, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x07, 0x80, 0x07,
  0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0,
  0x03, 0x81, 0xF0, 0x03, 0xC0, 0xF8, 0x03, 0xC0, 0x67, 0x03, 0xC0, 0x31,
  0xFF, 0xC0, 0x18, 0x7F, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x0C, 0x0F, 0x8F,
  0x30, 0x3C, 0x07, 0x60, 0xF0, 0x06, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0F,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3,
  0x80, 0x01, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x38, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x87, 0x00,
  0x1F, 0x07, 0x00, 0x7E, 0x0E, 0x01, 0xD8, 0x0E, 0x07, 0x30, 0x1F, 0xFC,
  0xE0, 0x1F, 0xE1, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0xC1, 0xC7, 0xF0, 0x63, 0xF8, 0x19, 0xC0, 0x06, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xFC, 0x1F, 0x1F, 0x07, 0x80, 0x20, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x71, 0x00,
  0x1E, 0x38, 0x07, 0x87, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x61, 0x80, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x30, 0xE0, 0x00, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C,
  0x70, 0x00, 0x71, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x38, 0xE0,
  0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xC0, 0x03,
  0xC3, 0x00, 0x0F, 0x0C, 0x00, 0x7C, 0x30, 0x03, 0x60, 0xE0, 0x19, 0x83,
  0xC1, 0xC6, 0x07, 0xFE, 0x38, 0x0F, 0xF0, 0xC0, 0xE0, 0x00, 0x76, 0x00,
  0x0E, 0x60, 0x00, 0xE6, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x38, 0x70,
  0x03, 0x87, 0x00, 0x70, 0x70, 0x06, 0x03, 0x00, 0xE0, 0x30, 0x1C, 0x03,
  0x01, 0xC0, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x70, 0x03, 0x86, 0x00,
  0x18, 0xE0, 0x01, 0x8C, 0x00, 0x19, 0xC0, 0x01, 0x98, 0x00, 0x1B, 0x80,
  0x01, 0xB0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0xEC, 0x00, 0xF0, 0x03, 0xB0, 0x07, 0xC0, 0x0C, 0xC0,
  0x1B, 0x80, 0x73, 0x00, 0xEE, 0x01, 0x8C, 0x03, 0x38, 0x0E, 0x38, 0x1C,
  0xE0, 0x30, 0xE0, 0x63, 0x81, 0xC3, 0x83, 0x86, 0x07, 0x0E, 0x0C, 0x18,
  0x38, 0x38, 0x70, 0x60, 0xE0, 0xE1, 0x81, 0x87, 0x03, 0x8E, 0x06, 0x1C,
  0x0E, 0x30, 0x18, 0xE0, 0x39, 0xC0, 0x63, 0x80, 0xE6, 0x01, 0x8C, 0x03,
  0x98, 0x06, 0x70, 0x06, 0xE0, 0x1D, 0x80, 0x1B, 0x00, 0x7E, 0x00, 0x7C,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x07, 0x80, 0xC0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x18, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x33, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC1, 0xC0, 0x01, 0xC0,
  0x60, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x01, 0x81, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x38,
  0x03, 0x00, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00, 0x60, 0x0C, 0x00,
  0x0C, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x87, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x07, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x04, 0xFF, 0x80, 0x1F, 0xBF, 0xC1, 0xF0,
  0x0F, 0xFE, 0x80, 0x0F, 0xF0,
};

const GFXglyph NotoSans_LightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 34, 11, 1, -33 },
  { 44, 12, 12, 16, 5, -33 },
  { 62, 27, 33, 29, 2, -33 },
  { 174, 22, 38, 25, 2, -35 },
  { 279, 30, 34, 36, 4, -33 },
  { 407, 28, 33, 31, 2, -33 },
  { 523, 5, 12, 9, 5, -33 },
  { 531, 14, 40, 12, 2, -33 },
  { 601, 14, 40, 12, -3, -33 },
  { 671, 20, 20, 25, 5, -35 },
  { 721, 22, 22, 26, 3, -27 },
  { 782, 8, 11, 10, -2, -5 },
  { 793, 12, 3, 14, 1, -14 },
  { 798, 4, 5, 11, 1, -4 },
  { 801, 21, 33, 15, -2, -33 },
  { 888, 21, 33, 25, 3, -33 },
  { 975, 13, 33, 25, 7, -33 },
  { 1029, 24, 33, 25, 0, -33 },
  { 1128, 23, 33, 25, 1, -33 },
  { 1223, 25, 33, 25, 0, -33 },
  { 1327, 23, 33, 25, 2, -33 },
  { 1422, 22, 33, 25, 3, -33 },
  { 1513, 21, 33, 25, 5, -33 },
  { 1600, 23, 33, 25, 2, -33 },
  { 1695, 22, 33, 25, 2, -33 },
  { 1786, 8, 26, 11, 1, -25 },
  { 1812, 11, 31, 11, -2, -25 },
  { 1855, 22, 21, 26, 3, -27 },
  { 1913, 22, 12, 26, 3, -22 },
  { 1946, 22, 21, 26, 3, -27 },
  { 2004, 16, 34, 19, 4, -33 },
  { 2072, 35, 37, 39, 2, -33 },
  { 2234, 25, 33, 26, -2, -33 },
  { 2338, 25, 33, 28, 2, -33 },
  { 2442, 25, 33, 27, 4, -33 },
  { 2546, 27, 33, 31, 2, -33 },
  { 2658, 24, 33, 24, 2, -33 },
  { 2757, 24, 33, 22, 2, -33 },
  { 2856, 27, 33, 31, 4, -33 },
  { 2968, 29, 33, 31, 2, -33 },
  { 3088, 16, 33, 14, 0, -33 },
  { 3154, 20, 41, 12, -8, -33 },
  { 3257, 27, 33, 25, 2, -33 },
  { 3369, 17, 33, 22, 2, -33 },
  { 3440, 36, 33, 38, 2, -33 },
  { 3589, 30, 33, 32, 2, -33 },
  { 3713, 27, 33, 33, 4, -33 },
  { 3825, 24, 33, 26, 2, -33 },
  { 3924, 27, 41, 33, 4, -33 },
  { 4063, 24, 33, 26, 2, -33 },
  { 4162, 23, 33, 23, 1, -33 },
  { 4257, 23, 33, 23, 4, -33 },
  { 4352, 28, 33, 32, 4, -33 },
  { 4468, 24, 33, 25, 5, -33 },
  { 4567, 37, 33, 39, 5, -33 },
  { 4720, 30, 33, 23, -3, -33 },
  { 4844, 23, 33, 23, 4, -33 },
  { 4939, 26, 33, 25, 0, -33 },
  { 5047, 17, 40, 14, 0, -33 },
  { 5132, 8, 33, 15, 5, -33 },
  { 5165, 17, 40, 14, -3, -33 },
  { 5250, 22, 20, 26, 2, -33 },
  { 5305, 18, 2, 18, -4, 5 },
  { 5310, 6, 7, 12, 7, -35 },
  { 5316, 22, 25, 26, 2, -25 },
  { 5385, 23, 35, 26, 1, -35 },
  { 5486, 19, 25, 21, 2, -25 },
  { 5546, 25, 35, 26, 2, -35 },
  { 5656, 18, 25, 23, 3, -25 },
  { 5713, 26, 46, 13, -6, -35 },
  { 5863, 24, 36, 26, 1, -25 },
  { 5971, 22, 35, 26, 1, -35 },
  { 6068, 10, 34, 11, 1, -34 },
  { 6111, 17, 45, 11, -6, -34 },
  { 6207, 22, 35, 21, 1, -35 },
  { 6304, 10, 35, 11, 1, -35 },
  { 6348, 36, 25, 40, 1, -25 },
  { 6461, 22, 25, 26, 1, -25 },
  { 6530, 22, 25, 26, 2, -25 },
  { 6599, 25, 36, 26, -1, -25 },
  { 6712, 23, 36, 26, 2, -25 },
  { 6816, 18, 25, 18, 1, -25 },
  { 6873, 19, 25, 20, 0, -25 },
  { 6933, 14, 30, 15, 2, -30 },
  { 6986, 22, 24, 26, 3, -24 },
  { 7052, 20, 24, 20, 2, -24 },
  { 7112, 30, 24, 32, 3, -24 },
  { 7202, 25, 24, 22, -2, -24 },
  { 7277, 27, 35, 20, -5, -24 },
  { 7396, 21, 24, 20, -1, -24 },
  { 7459, 17, 40, 16, 1, -33 },
  { 7544, 3, 46, 25, 12, -35 },
  { 7562, 17, 40, 16, -2, -33 },
  { 7647, 22, 5, 26, 3, -19 },
};

const GFXfont NotoSans_LightItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_LIGHTITALIC46PT7B_H_
