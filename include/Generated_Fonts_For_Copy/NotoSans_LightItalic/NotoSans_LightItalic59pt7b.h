#ifndef _NOTOSANS_LIGHTITALIC59PT7B_H_
#define _NOTOSANS_LIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x10, 0x00, 0x1E,
  0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1C, 0x38,
  0x1C, 0x38, 0x1C, 0x30, 0x1C, 0x70, 0x18, 0x70, 0x38, 0x70, 0x38, 0x60,
  0x38, 0x60, 0x30, 0xE0, 0x30, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF1, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFC, 0xE3, 0xE0, 0x1E, 0x0E,
  0x06, 0x03, 0xC0, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x70, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x83, 0x80, 0x00, 0x7C, 0x30, 0x00,
  0x03, 0xE3, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0E, 0x7C,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0xC0, 0xF0, 0x00,
  0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x18, 0x0F, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x1E, 0x08,
  0x03, 0x87, 0xC0, 0xF0, 0x31, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xC0,
  0x7F, 0xF0, 0x00, 0x0E, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x0E, 0x03, 0x80,
  0x03, 0xC0, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0xF0, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x07, 0x07, 0x80, 0x03, 0x80,
  0x1C, 0x1C, 0x0E, 0x0E, 0x00, 0xE0, 0xE1, 0xFF, 0x38, 0x03, 0x87, 0x0F,
  0xFE, 0xE0, 0x1E, 0x1C, 0x78, 0x3B, 0x80, 0x70, 0xE3, 0xC0, 0xFF, 0x03,
  0x87, 0x0E, 0x01, 0xDE, 0x1E, 0x3C, 0x70, 0x07, 0x7F, 0xF0, 0xE1, 0xC0,
  0x1C, 0xFF, 0x07, 0x0F, 0x00, 0x70, 0x70, 0x38, 0x38, 0x01, 0xC0, 0x01,
  0xE0, 0xE0, 0x07, 0x00, 0x07, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x78, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0x1C, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x70,
  0x0E, 0x00, 0x03, 0xC7, 0x80, 0x70, 0x00, 0x0F, 0xFC, 0x03, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1C, 0x1F, 0x00, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF9,
  0xC0, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0xF0, 0x00, 0xE0,
  0xF0, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x01, 0xC3, 0xC0, 0x03, 0xC0,
  0x3C, 0x78, 0x00, 0x1E, 0x03, 0x87, 0x00, 0x00, 0xE0, 0x78, 0x70, 0x00,
  0x0F, 0x0F, 0x07, 0x00, 0x00, 0x78, 0xE0, 0xF0, 0x00, 0x03, 0xDC, 0x0F,
  0x00, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x7F, 0x80, 0x7C, 0x00,
  0x1F, 0x3C, 0x03, 0xE0, 0x03, 0xE1, 0xE0, 0x1F, 0xC3, 0xF8, 0x1E, 0x00,
  0xFF, 0xFF, 0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0x80, 0x03, 0x00, 0x00,
  0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x86,
  0x0C, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01,
  0x00, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0xFC, 0x0C, 0x00, 0x3F, 0x06, 0x00,
  0x07, 0xE3, 0x00, 0x00, 0x7D, 0x80, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x01, 0xF0, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC3,
  0x00, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x03, 0xE0, 0x38, 0x03, 0xE0,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x20, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x77, 0xFF, 0xFF, 0x20, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00,
  0x70, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F,
  0x01, 0xFE, 0x03, 0xEE, 0x0F, 0xCE, 0x1F, 0x1E, 0x7E, 0x1E, 0xF8, 0x1C,
  0x70, 0x1C, 0x40, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x08, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x00, 0xF8,
  0x03, 0x80, 0x01, 0xE0, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x0C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x80, 0xFF,
  0x83, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x02, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x02, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x0F, 0xC0, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x03,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC1, 0xFF,
  0x00, 0x38, 0x7F, 0xF8, 0x03, 0x9F, 0xFF, 0xE0, 0x7B, 0xC0, 0x3E, 0x07,
  0x70, 0x00, 0xF0, 0x7E, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x78, 0xF8, 0x00,
  0x03, 0x8F, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0xCF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xE0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x78, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xC1, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x0F, 0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x6E, 0x0F, 0x00, 0x1F, 0xE0, 0x7C, 0x07, 0xDC, 0x07, 0xFF,
  0xF1, 0xC0, 0x1F, 0xFE, 0x3C, 0x00, 0x7F, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x08, 0x00, 0xFC, 0x00, 0xFC, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x81, 0xF0, 0x7C,
  0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0,
  0x40, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xF0, 0x7E, 0x1F,
  0xC3, 0x80, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0x07,
  0x00, 0x0F, 0xFF, 0xE0, 0x1C, 0x70, 0x00, 0xFC, 0x7E, 0x00, 0xE3, 0x80,
  0x1F, 0x00, 0x70, 0x07, 0x3C, 0x01, 0xE0, 0x03, 0x80, 0x39, 0xC0, 0x0E,
  0x00, 0x3C, 0x01, 0xCE, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0xE0, 0x0F, 0x00,
  0x0E, 0x00, 0x77, 0x00, 0x70, 0x00, 0x70, 0x03, 0xB8, 0x07, 0x80, 0x07,
  0x00, 0x1D, 0xC0, 0x38, 0x00, 0x38, 0x00, 0xFE, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x77, 0x00, 0xE0, 0x00, 0xE0, 0x03,
  0xB8, 0x07, 0x00, 0x07, 0x00, 0x3D, 0xC0, 0x38, 0x00, 0x78, 0x01, 0xCE,
  0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x70, 0x0E, 0x00, 0x3E, 0x00, 0xE3, 0x80,
  0x38, 0x03, 0xF0, 0x0F, 0x1E, 0x01, 0xC0, 0x3B, 0x80, 0xF0, 0x70, 0x0F,
  0x03, 0x8E, 0x1F, 0x03, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x1C, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0xE0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00,
  0xF8, 0x07, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x7F, 0x80, 0x0E, 0x00, 0x07,
  0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0x00, 0x3F, 0x00,
  0x06, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x70, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x7C,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x00,
  0x7C, 0x07, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x38, 0x00,
  0x01, 0xF0, 0x07, 0x00, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x3C,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xE1, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x3F, 0x00, 0x00, 0x20, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xF3, 0x80,
  0x00, 0xFF, 0xF8, 0xE0, 0x00, 0x3F, 0xFE, 0x38, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x80,
  0x00, 0x1C, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07,
  0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x79, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x07, 0xC0, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x00, 0x1C, 0x7C, 0x00, 0x00, 0x07, 0xBF, 0x80, 0x00, 0x00,
  0xFF, 0x78, 0x00, 0x00, 0x1F, 0xCF, 0x00, 0x00, 0x03, 0xF0, 0xE0, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x1D, 0xC0, 0x00, 0x00, 0xF7,
  0x00, 0x73, 0x80, 0x00, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0x00, 0x1E, 0xF0,
  0x07, 0x38, 0x00, 0x00, 0x73, 0xC0, 0x3C, 0xE0, 0x00, 0x03, 0xCE, 0x00,
  0xE3, 0x80, 0x00, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0x00, 0x70, 0xE0, 0x0E,
  0x38, 0x00, 0x03, 0xC7, 0x80, 0x78, 0x70, 0x00, 0x0E, 0x1E, 0x01, 0xE1,
  0xC0, 0x00, 0x78, 0x70, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x1C, 0x1C,
  0x00, 0x0E, 0x0F, 0x00, 0x70, 0x70, 0x00, 0x38, 0x3C, 0x03, 0xC1, 0xC0,
  0x01, 0xC0, 0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x38, 0x0E, 0x00,
  0x38, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x78, 0x03, 0x80, 0xE0, 0x07,
  0x01, 0xE0, 0x1E, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x3C, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x07, 0x80, 0x38,
  0x03, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x80,
  0x38, 0x01, 0xC3, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x1C, 0x00, 0x78, 0x07,
  0x80, 0x0E, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x3B, 0x80, 0x07, 0x00, 0x70,
  0x00, 0xFE, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0x00, 0x03,
  0x80, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x07, 0x70,
  0x00, 0x01, 0xE0, 0x1D, 0xE0, 0x00, 0x07, 0x00, 0x73, 0x80, 0x00, 0x1C,
  0x01, 0xCE, 0x00, 0x00, 0x70, 0x07, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x70,
  0x00, 0x0F, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x03, 0x83, 0x80, 0x00, 0xE0,
  0x0E, 0x0E, 0x00, 0x03, 0x80, 0x78, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x70,
  0x00, 0x70, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x0E, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x70, 0x00, 0x70,
  0x1C, 0x01, 0xC0, 0x01, 0xE0, 0x70, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x3C,
  0x00, 0x0E, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x3C, 0x03, 0x80, 0x00, 0x70,
  0xE0, 0x0E, 0x00, 0x01, 0xE3, 0x80, 0x38, 0x00, 0x03, 0x8E, 0x01, 0xE0,
  0x00, 0x0E, 0x78, 0x07, 0x80, 0x00, 0x3D, 0xC0, 0x1C, 0x00, 0x00, 0x77,
  0x00, 0x70, 0x00, 0x01, 0xFC, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0x00,
  0x00, 0x0F, 0xC0, 0x38, 0x00, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xFC, 0x00, 0xE0,
  0x00, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x1C,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00,
  0x07, 0xC0, 0x38, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x38, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xE0,
  0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1F,
  0x03, 0xC0, 0x01, 0xF8, 0x0F, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78,
  0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xE0,
  0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xC0, 0x07, 0x80, 0xF8, 0x00,
  0x08, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x82, 0x00, 0x00, 0xF8,
  0x1C, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xB8, 0x00, 0x0F,
  0x38, 0x00, 0x07, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x39, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xC7, 0x00, 0x07, 0x07, 0x80, 0x07, 0x8E, 0x00, 0x1E, 0x0F,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0x80, 0x70,
  0x03, 0x81, 0xC0, 0x0F, 0x00, 0xE0, 0x0F, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1C, 0x07, 0x00, 0x78, 0x03, 0x80, 0x78, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x38, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x78, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0x73, 0xC0, 0x00,
  0xE7, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xCE, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x03, 0x70, 0x00, 0x0E,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1E,
  0x01, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x38, 0x07, 0x80, 0x01, 0xC0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0,
  0x70, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03,
  0xC3, 0x00, 0x00, 0x38, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x1C,
  0x00, 0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x0C, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x70, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0xF0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x07, 0x00, 0xFF, 0xFC, 0x70, 0x1F, 0x81,
  0xC7, 0x03, 0xE0, 0x0E, 0x70, 0x78, 0x00, 0x6E, 0x0F, 0x00, 0x07, 0xE0,
  0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C,
  0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x3E, 0x0F, 0x00, 0x07, 0xE0, 0x70, 0x00, 0xEE, 0x07, 0x80, 0x1C,
  0xE0, 0x7C, 0x07, 0x8C, 0x03, 0xF1, 0xF1, 0xC0, 0x1F, 0xFE, 0x1C, 0x00,
  0xFF, 0x81, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x0F, 0x0F,
  0xFE, 0x00, 0x70, 0xFF, 0xF8, 0x03, 0x8F, 0x03, 0xE0, 0x1C, 0xE0, 0x0F,
  0x01, 0xEE, 0x00, 0x3C, 0x0E, 0xE0, 0x00, 0xE0, 0x7E, 0x00, 0x07, 0x03,
  0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x1E, 0x0E, 0xC0, 0x01, 0xE0, 0x76, 0x00, 0x1E, 0x07,
  0x3C, 0x03, 0xE0, 0x38, 0xF8, 0x7E, 0x01, 0xC3, 0xFF, 0xE0, 0x0E, 0x0F,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xF8, 0x06, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x20, 0x1F, 0xC3, 0xE0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x0F, 0xE0, 0x38, 0x00, 0x3F, 0xF8, 0x78, 0x00, 0xFF, 0xFC,
  0x78, 0x01, 0xF8, 0x1E, 0x70, 0x03, 0xE0, 0x06, 0x70, 0x07, 0x80, 0x03,
  0x70, 0x0F, 0x00, 0x03, 0x70, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x70, 0x00, 0xEE,
  0x00, 0x78, 0x01, 0xCE, 0x00, 0x7C, 0x03, 0x8E, 0x00, 0x3F, 0x1F, 0x0E,
  0x00, 0x1F, 0xFE, 0x0E, 0x00, 0x0F, 0xF8, 0x1C, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x01, 0xF8,
  0x1E, 0x03, 0xE0, 0x0F, 0x07, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x0F, 0x00,
  0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0x38, 0x00,
  0x1E, 0x38, 0x00, 0x3C, 0x78, 0x01, 0xF8, 0x70, 0x1F, 0xF0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x30, 0x1F, 0xC1, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x5C, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x01, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x70, 0x07, 0xFF, 0xE1, 0xC0,
  0x3F, 0x03, 0xCE, 0x01, 0xF0, 0x03, 0xB8, 0x0F, 0x00, 0x06, 0xE0, 0x78,
  0x00, 0x1B, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x81, 0xE0, 0x00,
  0xFE, 0x03, 0x80, 0x07, 0x70, 0x0F, 0x00, 0x39, 0xC0, 0x3E, 0x01, 0xC7,
  0x00, 0x7E, 0x3E, 0x3C, 0x00, 0xFF, 0xF0, 0xF0, 0x01, 0xFF, 0x03, 0x80,
  0x00, 0x40, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x02, 0x00, 0x07,
  0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0x03, 0xC3, 0xFF, 0x80, 0x38, 0x7F,
  0xFC, 0x03, 0x8F, 0x03, 0xE0, 0x39, 0xC0, 0x1E, 0x07, 0xB8, 0x00, 0xF0,
  0x77, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x70, 0x7C, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x70, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x07,
  0x80, 0x38, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x07,
  0x00, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x1C, 0xFC, 0x00, 0x01, 0xDF, 0xE0, 0x00, 0x1F, 0xCE,
  0x00, 0x01, 0xF8, 0xF0, 0x00, 0x3E, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x38, 0x03, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xF0,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1C,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xE1, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0x3C,
  0x0F, 0x07, 0x81, 0xE0, 0x3B, 0xC0, 0x3C, 0x70, 0x07, 0x83, 0x98, 0x00,
  0xE7, 0x00, 0x3C, 0x1D, 0x80, 0x07, 0x70, 0x00, 0xE0, 0xF8, 0x00, 0x3B,
  0x00, 0x07, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xC3, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x87, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x87, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x03, 0x80, 0xFF, 0x00, 0x38, 0x3F, 0xF8,
  0x03, 0x87, 0xFF, 0xC0, 0x38, 0xF0, 0x3E, 0x03, 0x9C, 0x01, 0xF0, 0x73,
  0x80, 0x0F, 0x07, 0x70, 0x00, 0xF0, 0x7E, 0x00, 0x07, 0x07, 0xC0, 0x00,
  0x70, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x38, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x3E,
  0x00, 0x78, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x8F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x7F, 0xF0, 0x00, 0x70, 0xFF,
  0xF8, 0x00, 0x71, 0xE0, 0x7C, 0x00, 0x73, 0x80, 0x3C, 0x00, 0xE7, 0x00,
  0x1E, 0x00, 0xEE, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x70, 0x0F, 0x80, 0x00, 0xF0, 0x0E, 0xC0, 0x01,
  0xE0, 0x0E, 0xC0, 0x03, 0xC0, 0x0E, 0xF0, 0x0F, 0xC0, 0x1E, 0x7C, 0x3F,
  0x80, 0x1C, 0x3F, 0xFE, 0x00, 0x1C, 0x1F, 0xF8, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xC1,
  0xC0, 0x3F, 0xFF, 0x0E, 0x03, 0xF0, 0x3C, 0xE0, 0x3E, 0x00, 0x67, 0x03,
  0xC0, 0x03, 0xB8, 0x3C, 0x00, 0x0D, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x3C, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07,
  0xC3, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3F, 0x07,
  0x80, 0x03, 0xF8, 0x1C, 0x00, 0x3B, 0x80, 0xF0, 0x03, 0x9C, 0x07, 0xC0,
  0x38, 0xE0, 0x1F, 0x8F, 0x8F, 0x00, 0x7F, 0xF8, 0x78, 0x01, 0xFF, 0x03,
  0x80, 0x00, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x0E, 0x0F, 0xF0, 0x38, 0x7F,
  0xC0, 0xE3, 0xC1, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3E, 0x01, 0xE0, 0xF8, 0x00, 0x41, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x84, 0x00, 0x0F, 0x0C, 0x00, 0x3C, 0x1F, 0x83, 0xF8, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0xC7, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x38, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x7E, 0x0F,
  0x00, 0x0E, 0xE0, 0x70, 0x01, 0xCE, 0x07, 0x80, 0x78, 0xE0, 0x7F, 0x3F,
  0x1C, 0x03, 0xFF, 0xE1, 0xC0, 0x0F, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x3C, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x07, 0x80, 0x0F, 0x01,
  0xE0, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x38,
  0x00, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0,
  0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x38, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0x00, 0x1C, 0xF0, 0x00, 0xFC, 0x00,
  0x3C, 0x70, 0x00, 0xFC, 0x00, 0x38, 0x70, 0x01, 0xDC, 0x00, 0x78, 0x70,
  0x01, 0xDC, 0x00, 0x70, 0x70, 0x03, 0x9C, 0x00, 0xF0, 0x70, 0x03, 0x9C,
  0x00, 0xE0, 0x70, 0x07, 0x1C, 0x01, 0xE0, 0x70, 0x07, 0x1C, 0x01, 0xC0,
  0x70, 0x0E, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x0E, 0x03, 0xC0, 0x70, 0x1C,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x0E, 0x07, 0x80, 0x70, 0x38, 0x0E, 0x07,
  0x00, 0x70, 0x38, 0x0E, 0x0F, 0x00, 0x70, 0x70, 0x0E, 0x0E, 0x00, 0x70,
  0x70, 0x0E, 0x1E, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x00, 0x78, 0xE0, 0x0E,
  0x3C, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x00, 0x79, 0xC0, 0x0E, 0x78, 0x00,
  0x3B, 0x80, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x0E, 0x70, 0x00, 0x3F, 0x00,
  0x06, 0xE0, 0x00, 0x3F, 0x00, 0x06, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0xF0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x13, 0xFF, 0xC0, 0x03, 0x7F, 0xFF, 0x00, 0x7F, 0x01,
  0xFF, 0x3F, 0xC0, 0x03, 0xFF, 0xC8, 0x00, 0x0F, 0xF8,
};

const GFXglyph NotoSans_LightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 13, 43, 14, 2, -42 },
  { 71, 16, 15, 21, 6, -42 },
  { 101, 36, 42, 37, 2, -42 },
  { 290, 28, 48, 33, 3, -45 },
  { 458, 38, 44, 46, 5, -43 },
  { 667, 36, 44, 40, 2, -43 },
  { 865, 7, 15, 12, 6, -42 },
  { 879, 18, 51, 16, 2, -42 },
  { 994, 18, 51, 16, -4, -42 },
  { 1109, 25, 26, 32, 7, -45 },
  { 1191, 28, 28, 34, 4, -35 },
  { 1289, 10, 15, 13, -3, -7 },
  { 1308, 14, 3, 18, 2, -17 },
  { 1314, 5, 6, 14, 2, -5 },
  { 1318, 28, 42, 20, -3, -42 },
  { 1465, 27, 44, 33, 4, -43 },
  { 1614, 16, 42, 33, 9, -42 },
  { 1698, 31, 43, 33, 0, -43 },
  { 1865, 30, 44, 33, 1, -43 },
  { 2030, 30, 42, 33, 1, -42 },
  { 2188, 30, 43, 33, 2, -42 },
  { 2350, 28, 44, 33, 4, -43 },
  { 2504, 27, 42, 33, 6, -42 },
  { 2646, 29, 44, 33, 3, -43 },
  { 2806, 28, 44, 33, 3, -43 },
  { 2960, 10, 33, 14, 2, -32 },
  { 3002, 15, 40, 14, -3, -32 },
  { 3077, 28, 28, 34, 4, -35 },
  { 3175, 28, 15, 34, 4, -28 },
  { 3228, 28, 28, 34, 4, -35 },
  { 3326, 21, 44, 25, 5, -43 },
  { 3442, 45, 47, 50, 3, -42 },
  { 3707, 33, 42, 33, -3, -42 },
  { 3881, 32, 42, 35, 3, -42 },
  { 4049, 32, 44, 35, 5, -43 },
  { 4225, 35, 42, 40, 3, -42 },
  { 4409, 30, 42, 31, 3, -42 },
  { 4567, 30, 42, 28, 3, -42 },
  { 4725, 34, 44, 40, 5, -43 },
  { 4912, 37, 42, 40, 3, -42 },
  { 5107, 21, 42, 18, 0, -42 },
  { 5218, 25, 53, 15, -10, -42 },
  { 5384, 35, 42, 33, 3, -42 },
  { 5568, 22, 42, 29, 3, -42 },
  { 5684, 46, 42, 49, 3, -42 },
  { 5926, 38, 42, 41, 3, -42 },
  { 6126, 35, 44, 42, 5, -43 },
  { 6319, 30, 42, 33, 3, -42 },
  { 6477, 35, 53, 42, 5, -43 },
  { 6709, 30, 42, 34, 3, -42 },
  { 6867, 29, 44, 30, 1, -43 },
  { 7027, 29, 42, 29, 5, -42 },
  { 7180, 36, 43, 40, 5, -42 },
  { 7374, 31, 42, 32, 6, -42 },
  { 7537, 47, 42, 50, 7, -42 },
  { 7784, 38, 42, 30, -3, -42 },
  { 7984, 29, 42, 29, 6, -42 },
  { 8137, 35, 42, 32, -1, -42 },
  { 8321, 23, 51, 18, -1, -42 },
  { 8468, 10, 42, 20, 6, -42 },
  { 8521, 22, 51, 18, -4, -42 },
  { 8662, 28, 26, 33, 3, -42 },
  { 8753, 23, 3, 23, -5, 6 },
  { 8762, 8, 9, 15, 9, -45 },
  { 8771, 28, 33, 33, 3, -32 },
  { 8887, 29, 46, 34, 2, -45 },
  { 9054, 24, 33, 27, 3, -32 },
  { 9153, 32, 46, 34, 3, -45 },
  { 9337, 24, 33, 29, 3, -32 },
  { 9436, 32, 59, 17, -7, -45 },
  { 9672, 30, 46, 34, 2, -32 },
  { 9845, 28, 45, 33, 2, -45 },
  { 10003, 12, 43, 14, 2, -43 },
  { 10068, 22, 57, 14, -8, -43 },
  { 10225, 28, 45, 28, 2, -45 },
  { 10383, 13, 45, 14, 2, -45 },
  { 10457, 45, 32, 51, 2, -32 },
  { 10637, 28, 32, 33, 2, -32 },
  { 10749, 27, 33, 33, 3, -32 },
  { 10861, 32, 46, 34, -1, -32 },
  { 11045, 29, 46, 34, 3, -32 },
  { 11212, 22, 32, 23, 2, -32 },
  { 11300, 23, 33, 25, 1, -32 },
  { 11395, 17, 40, 19, 3, -39 },
  { 11480, 28, 32, 33, 3, -31 },
  { 11592, 26, 31, 26, 3, -31 },
  { 11693, 40, 31, 41, 3, -31 },
  { 11848, 31, 31, 28, -2, -31 },
  { 11969, 35, 45, 26, -6, -31 },
  { 12166, 27, 31, 26, -1, -31 },
  { 12271, 22, 51, 20, 1, -42 },
  { 12412, 3, 59, 32, 16, -45 },
  { 12435, 22, 51, 20, -3, -42 },
  { 12576, 28, 6, 34, 4, -24 },
};

const GFXfont NotoSans_LightItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_LIGHTITALIC59PT7B_H_
