#ifndef _NOTOSANS_LIGHTITALIC47PT7B_H_
#define _NOTOSANS_LIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x00,
  0x80, 0x00, 0x38, 0x73, 0x87, 0x38, 0x73, 0x07, 0x30, 0x67, 0x06, 0x70,
  0xE6, 0x0E, 0x60, 0xC6, 0x0C, 0x60, 0xCC, 0x0C, 0xC1, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C,
  0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x06, 0x01, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x38, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x07, 0x00,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x18, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xF1, 0x83, 0x07, 0x06, 0x00, 0x18, 0x18,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x30, 0x00,
  0xE0, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x98, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xCF, 0x00, 0x03, 0x0E,
  0x00, 0x0C, 0x18, 0x00, 0x70, 0x70, 0x01, 0x81, 0xC0, 0x06, 0x06, 0x00,
  0x18, 0x18, 0x00, 0x60, 0xE0, 0x03, 0x87, 0x0C, 0x0C, 0x78, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x38, 0x3F, 0xC0, 0x00, 0xC1, 0xE3, 0x80, 0x06, 0x07, 0x06, 0x00, 0x38,
  0x38, 0x1C, 0x01, 0xC0, 0xC0, 0x70, 0x06, 0x07, 0x01, 0xC0, 0x30, 0x18,
  0x07, 0x01, 0xC0, 0x60, 0x1C, 0x0E, 0x03, 0x80, 0x70, 0x30, 0x0E, 0x01,
  0x81, 0x80, 0x30, 0x06, 0x0E, 0x00, 0xC0, 0x18, 0x70, 0x03, 0x00, 0xE1,
  0x81, 0x0C, 0x03, 0x0C, 0x3F, 0xB0, 0x1C, 0x71, 0xFE, 0xC0, 0x63, 0x8E,
  0x1F, 0x83, 0x8C, 0x70, 0x37, 0x1C, 0x71, 0x80, 0xDF, 0xE3, 0x8E, 0x03,
  0x1E, 0x1C, 0x30, 0x0C, 0x00, 0x61, 0xC0, 0x30, 0x03, 0x87, 0x00, 0xC0,
  0x1C, 0x18, 0x03, 0x00, 0x60, 0x60, 0x1C, 0x03, 0x01, 0x80, 0x70, 0x1C,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x06, 0x03, 0x00, 0xE0, 0x38, 0x18, 0x01,
  0x80, 0xC0, 0xE0, 0x06, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x18, 0x00, 0x3F,
  0xC0, 0xC0, 0x00, 0xFE, 0x04, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0xE0, 0x1C, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00,
  0xC0, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x0F, 0x0E, 0x00, 0x71, 0xE0, 0xF0, 0x07, 0x38, 0x07, 0x00, 0xE7, 0x00,
  0x38, 0x0E, 0x70, 0x01, 0xC1, 0xCE, 0x00, 0x1C, 0x18, 0xE0, 0x00, 0xE3,
  0x8E, 0x00, 0x07, 0x70, 0xE0, 0x00, 0x7E, 0x0E, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x3C, 0x0E, 0x00, 0x0F, 0xE0, 0x70, 0x01, 0xEE, 0x07, 0xC0, 0x78,
  0x70, 0x3F, 0xFF, 0x03, 0x80, 0xFF, 0xC0, 0x3C, 0x39, 0xCE, 0x63, 0x39,
  0xCC, 0x63, 0x19, 0x8C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x20, 0x18, 0x01, 0xC0, 0xC0, 0x1F,
  0x86, 0x00, 0x1F, 0x30, 0x00, 0x3F, 0x07, 0xC0, 0x3F, 0xFE, 0x01, 0xE7,
  0xF0, 0x1B, 0x00, 0x01, 0xDC, 0x00, 0x1C, 0x60, 0x01, 0xC3, 0x00, 0x1C,
  0x0C, 0x01, 0xC0, 0x60, 0x04, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38,
  0x30, 0x70, 0x60, 0xC0, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x20,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x1F, 0x1F, 0x00, 0xF0, 0x1E, 0x07, 0x80, 0x38,
  0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0xE0,
  0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00,
  0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x6E,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00,
  0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0x70, 0xE0, 0x03, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x70, 0x0F,
  0x07, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x18, 0x03, 0xC0,
  0x7E, 0x07, 0xE0, 0xFF, 0x0F, 0x39, 0xF1, 0xDE, 0x0E, 0x60, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFE,
  0x7E, 0x01, 0xE0, 0x0E, 0x00, 0x80, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x7C, 0x07, 0xC0, 0x1E, 0x03, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x80, 0x01, 0xE0, 0xF0, 0x07, 0xC0, 0xFF, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xEC, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x1C,
  0x18, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0x30, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0x60, 0x1C, 0x00, 0x60, 0x38, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0C, 0x03, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x20, 0x00, 0xF0, 0x70, 0x07, 0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFC, 0x30, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x07, 0xC0, 0x0C, 0x7F, 0xE0, 0x39, 0xF7, 0xE0, 0x76, 0x00,
  0xE0, 0xF8, 0x00, 0xE1, 0xE0, 0x01, 0xC7, 0x80, 0x03, 0x8F, 0x00, 0x03,
  0x1C, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71,
  0xC0, 0x00, 0xE3, 0x80, 0x01, 0x87, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x0E,
  0x00, 0x38, 0x1E, 0x00, 0xE0, 0x1E, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xE0, 0x03, 0xE3, 0xF0, 0x0E, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x38, 0x1E,
  0x00, 0x3C, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00,
  0x1E, 0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x0E, 0x07, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80,
  0x00, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x1E, 0x00,
  0x78, 0x1E, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xC0, 0x07, 0xC7, 0xC0, 0x1E, 0x01, 0xC0, 0x70, 0x03,
  0x81, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0C,
  0x30, 0x00, 0x1C, 0x60, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xC7,
  0x00, 0x03, 0x86, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x7C, 0x3C,
  0x01, 0xF8, 0x3C, 0x0F, 0x60, 0x3F, 0xF9, 0xC0, 0x3F, 0xC3, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x40, 0x3E, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0x83, 0xC3, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x83, 0xC1, 0xE0, 0xF0, 0x10, 0x00, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x1F, 0xFE, 0x1F, 0x8F, 0x84, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x0F, 0xE0, 0x1C, 0xE0,
  0x0F, 0xFF, 0x01, 0x98, 0x03, 0xC0, 0xE0, 0x37, 0x00, 0xE0, 0x1C, 0x06,
  0xC0, 0x38, 0x03, 0x00, 0xD8, 0x0E, 0x00, 0x60, 0x1F, 0x01, 0x80, 0x1C,
  0x03, 0xE0, 0x70, 0x03, 0x00, 0x78, 0x0C, 0x00, 0x60, 0x0F, 0x01, 0x80,
  0x1C, 0x03, 0xE0, 0x30, 0x03, 0x80, 0x6C, 0x0E, 0x00, 0x60, 0x0D, 0x81,
  0xC0, 0x1C, 0x03, 0xB0, 0x38, 0x03, 0x80, 0x66, 0x03, 0x00, 0xF0, 0x1C,
  0xC0, 0x60, 0x36, 0x07, 0x18, 0x0F, 0x1E, 0xE3, 0xC3, 0x80, 0xFF, 0x0F,
  0xF0, 0x70, 0x0F, 0xC0, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x10, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x30, 0x00,
  0x03, 0x8C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x0C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0,
  0x18, 0x00, 0x70, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x38, 0x00, 0x30,
  0x1C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x06, 0x00,
  0x3C, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0C,
  0x00, 0x07, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x38,
  0x1C, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x03,
  0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xC0,
  0x07, 0x80, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x0F, 0x81, 0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xF9,
  0xF8, 0x07, 0xC0, 0x06, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x18, 0x01, 0xF0, 0x03, 0x80, 0x07, 0x80,
  0x38, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x18,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x78, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x07,
  0x00, 0x07, 0x80, 0x70, 0x03, 0xF0, 0x06, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x40, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x01, 0xFE, 0x7F, 0x80, 0xF8, 0x00, 0x70, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x7F, 0xF3, 0x80, 0x0F, 0xFE, 0x70, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0F, 0x80,
  0x03, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0x02, 0x78, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x01,
  0xC0, 0x03, 0xC0, 0x18, 0x00, 0x78, 0x03, 0x80, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x03, 0x80, 0x3C, 0x00, 0x30, 0x07, 0x80, 0x03, 0x00, 0xE0, 0x00,
  0x70, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x70, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x0E, 0xF8, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x1F, 0x1C, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x07, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x18, 0x00, 0x30,
  0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x03, 0x60, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xB8,
  0x0C, 0xC0, 0x00, 0x1D, 0x80, 0x66, 0x00, 0x01, 0xCC, 0x07, 0x30, 0x00,
  0x0E, 0xE0, 0x39, 0x80, 0x00, 0xE7, 0x01, 0xCE, 0x00, 0x06, 0x38, 0x0E,
  0x70, 0x00, 0x71, 0x80, 0x63, 0x80, 0x03, 0x1C, 0x07, 0x0C, 0x00, 0x38,
  0xE0, 0x38, 0x60, 0x03, 0x87, 0x01, 0xC3, 0x00, 0x18, 0x38, 0x0C, 0x18,
  0x01, 0xC1, 0x80, 0x60, 0xE0, 0x0C, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0xE0,
  0x38, 0x18, 0x06, 0x07, 0x01, 0xC0, 0xC0, 0x70, 0x30, 0x0C, 0x06, 0x07,
  0x01, 0x80, 0x60, 0x30, 0x30, 0x1C, 0x07, 0x01, 0xC3, 0x80, 0xE0, 0x38,
  0x0E, 0x18, 0x07, 0x01, 0xC0, 0x71, 0xC0, 0x30, 0x0C, 0x01, 0x9C, 0x03,
  0x80, 0xE0, 0x0C, 0xE0, 0x1C, 0x07, 0x00, 0x6E, 0x00, 0xE0, 0x38, 0x03,
  0x60, 0x07, 0x01, 0xC0, 0x1F, 0x00, 0x30, 0x0C, 0x00, 0xF0, 0x03, 0x80,
  0xE0, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x30, 0x1E, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x07, 0x03, 0xF0, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0x60, 0x33, 0x00, 0x01,
  0x80, 0xCE, 0x00, 0x0E, 0x07, 0x38, 0x00, 0x38, 0x1C, 0x70, 0x00, 0xE0,
  0x71, 0xC0, 0x03, 0x01, 0x83, 0x00, 0x1C, 0x06, 0x0E, 0x00, 0x70, 0x38,
  0x38, 0x01, 0xC0, 0xE0, 0x70, 0x07, 0x03, 0x81, 0xC0, 0x18, 0x0C, 0x03,
  0x00, 0xE0, 0x30, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0x70,
  0x30, 0x1C, 0x01, 0xC0, 0xC0, 0x60, 0x03, 0x07, 0x01, 0x80, 0x0E, 0x1C,
  0x0E, 0x00, 0x38, 0x70, 0x38, 0x00, 0x71, 0x80, 0xE0, 0x01, 0xC6, 0x03,
  0x00, 0x03, 0x38, 0x1C, 0x00, 0x0E, 0xE0, 0x70, 0x00, 0x3B, 0x81, 0xC0,
  0x00, 0x7C, 0x07, 0x00, 0x01, 0xF0, 0x18, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x1E, 0x00, 0x78, 0x03, 0x80, 0x03, 0xC0,
  0x70, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x03,
  0x80, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x01, 0x80, 0x3E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x03,
  0x80, 0x07, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x07, 0x00, 0x03, 0x07,
  0x00, 0x03, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x0C, 0x01, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x1E, 0x00,
  0x78, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x01,
  0xF0, 0x1F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x30, 0x07, 0xC0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x83, 0x80, 0x01, 0x81, 0xC0, 0x00,
  0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x38, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x60,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0C,
  0x00, 0x30, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x01,
  0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFB, 0xF8, 0x1E, 0x00,
  0x20, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x20, 0x00, 0xF0, 0x78, 0x07, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x07, 0x00,
  0x07, 0x80, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x70, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x30, 0x07, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x0E,
  0x00, 0x30, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xC0,
  0x00, 0x19, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1D, 0x80, 0x01, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x80, 0x03,
  0x98, 0x00, 0x3E, 0x00, 0x0E, 0x60, 0x00, 0xD8, 0x00, 0x71, 0x80, 0x03,
  0x60, 0x01, 0xC6, 0x00, 0x1D, 0x80, 0x06, 0x18, 0x00, 0x66, 0x00, 0x38,
  0x60, 0x03, 0x98, 0x00, 0xC1, 0x80, 0x0C, 0x60, 0x07, 0x07, 0x00, 0x71,
  0x80, 0x1C, 0x1C, 0x01, 0x86, 0x00, 0xE0, 0x70, 0x0E, 0x18, 0x03, 0x81,
  0xC0, 0x30, 0x60, 0x1C, 0x07, 0x01, 0xC1, 0x80, 0x70, 0x1C, 0x06, 0x07,
  0x01, 0x80, 0x70, 0x38, 0x1C, 0x0E, 0x01, 0xC0, 0xC0, 0x70, 0x30, 0x07,
  0x07, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x1C,
  0x38, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0xC7, 0x00, 0x0C,
  0x70, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x00, 0xCE, 0x00, 0x33,
  0x80, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x0D, 0xC0, 0x03, 0x70, 0x00, 0x36,
  0x00, 0x0D, 0x80, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x3C, 0x30, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x1C, 0x03,
  0x80, 0x0C, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x06, 0x38, 0x00, 0x07, 0x30, 0x00, 0x07, 0x70, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0xC0, 0xE0,
  0xE0, 0x60, 0x60, 0x60, 0x60, 0x70, 0x70, 0x30, 0x30, 0x30, 0x30, 0x38,
  0x38, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0E,
  0x0E, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x07, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x33,
  0x00, 0x01, 0xCC, 0x00, 0x06, 0x38, 0x00, 0x38, 0x60, 0x01, 0xC1, 0x80,
  0x07, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x18,
  0x01, 0x80, 0xE0, 0x07, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x38, 0xE0, 0x00,
  0x63, 0x00, 0x01, 0x9C, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE3, 0x87, 0x0C, 0x38, 0x70, 0xC1, 0x00, 0x7F, 0x06, 0x03,
  0xFF, 0x9C, 0x0F, 0x03, 0x30, 0x38, 0x03, 0x60, 0xE0, 0x06, 0xC3, 0x80,
  0x07, 0x87, 0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x0C, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3,
  0x80, 0x07, 0x83, 0x00, 0x1F, 0x07, 0x00, 0x6E, 0x0E, 0x01, 0xD8, 0x0E,
  0x07, 0x30, 0x1F, 0xFC, 0x60, 0x0F, 0xE1, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x0F, 0xF0, 0x07, 0x1F, 0xF8, 0x07,
  0x38, 0x3C, 0x07, 0x60, 0x1E, 0x06, 0xC0, 0x0E, 0x07, 0x80, 0x0E, 0x0F,
  0x00, 0x06, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x1C,
  0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18,
  0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x38, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0x70, 0x76, 0x00, 0xE0, 0x67,
  0x03, 0xC0, 0x63, 0xFF, 0x80, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x1F,
  0xFE, 0x03, 0xC0, 0x20, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3E, 0x03, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x03,
  0xFE, 0x18, 0x01, 0xFF, 0xCE, 0x00, 0xF0, 0x3B, 0x80, 0x70, 0x06, 0xE0,
  0x38, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x7C,
  0x06, 0x00, 0x1E, 0x01, 0xC0, 0x0D, 0x80, 0x70, 0x0E, 0xE0, 0x0E, 0x07,
  0x38, 0x03, 0xFF, 0x8C, 0x00, 0x3F, 0x83, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0xF8, 0x1E, 0x07, 0x07, 0x00, 0x71, 0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00,
  0x3B, 0x80, 0x06, 0x70, 0x01, 0xCC, 0x00, 0xF3, 0x80, 0x7C, 0x7F, 0xFF,
  0x0F, 0xFF, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x02,
  0x0F, 0x01, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x8C, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x21, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x87, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0x00, 0xFF, 0xE3, 0x01,
  0xE0, 0x73, 0x03, 0x80, 0x37, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70,
  0x00, 0xF0, 0x30, 0x00, 0xF0, 0x38, 0x01, 0xB0, 0x38, 0x07, 0x70, 0x1C,
  0x0E, 0x70, 0x1F, 0xFC, 0x60, 0x07, 0xF0, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x80, 0x07, 0x00, 0xF0, 0x1E, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x7F, 0x80, 0x71, 0xFF, 0xC0, 0xE7, 0x03, 0x81, 0xD8, 0x03,
  0x83, 0x60, 0x07, 0x07, 0x80, 0x0E, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38,
  0x70, 0x00, 0x70, 0xE0, 0x00, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x30, 0xE0, 0x00, 0xE1, 0xC0,
  0x01, 0xC3, 0x80, 0x03, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0x80, 0x01, 0x87, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x00, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x23, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x70, 0x03, 0x80, 0xE0, 0x0E,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0xE0, 0x06, 0x03, 0x80, 0x1C, 0x0E, 0x00,
  0x38, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xC3, 0x80, 0x03, 0x9E, 0x00, 0x07,
  0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x38, 0x00, 0x3C, 0x70, 0x00, 0xF0,
  0x70, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x06, 0x01, 0xC0, 0x0C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x07,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x70, 0x00, 0x03, 0x0F, 0xE0, 0x1F, 0xC0, 0x38,
  0xFF, 0x83, 0xFF, 0x01, 0xDC, 0x0E, 0x38, 0x3C, 0x0C, 0xC0, 0x73, 0x80,
  0xE0, 0x6C, 0x01, 0xB8, 0x03, 0x83, 0xC0, 0x0D, 0x80, 0x1C, 0x3C, 0x00,
  0x78, 0x00, 0xE1, 0xE0, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x70, 0x00, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0x00, 0xE1, 0xC0, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x60,
  0x01, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x00,
  0xE1, 0xC0, 0x03, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x60, 0x01,
  0xC0, 0x03, 0x87, 0x00, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x00, 0xE1,
  0xC0, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x00, 0x70, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x06, 0x1F, 0xF0, 0x1C, 0x7F, 0xF0, 0x39,
  0xC1, 0xE0, 0x66, 0x00, 0xE0, 0xD8, 0x01, 0xC3, 0xE0, 0x03, 0x87, 0x80,
  0x07, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0C,
  0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC7,
  0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x60,
  0x00, 0x61, 0xC0, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3C,
  0x0F, 0x01, 0xC0, 0x1E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x01,
  0xCE, 0x00, 0x07, 0x38, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x39, 0x80, 0x00, 0xC6, 0x00, 0x07, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0xE0, 0xE0, 0x0F, 0x03, 0xE0, 0x78, 0x07, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0xC3, 0xFC, 0x00, 0x71, 0xFF, 0x80, 0x1C, 0xE0, 0xF0,
  0x06, 0x60, 0x1E, 0x01, 0xB0, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x3C, 0x00,
  0x18, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x70,
  0x00, 0x18, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0,
  0x60, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x1C, 0x07, 0x60,
  0x0E, 0x01, 0xDC, 0x0F, 0x00, 0x63, 0xFF, 0x80, 0x18, 0x7F, 0x80, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x86, 0x03, 0xFF, 0x8C, 0x0F, 0x03, 0x98, 0x38, 0x03, 0x70, 0xE0,
  0x03, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03,
  0x8C, 0x00, 0x07, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xF1,
  0xC0, 0x01, 0xE3, 0x80, 0x07, 0xC3, 0x00, 0x0F, 0x07, 0x00, 0x36, 0x0E,
  0x01, 0xDC, 0x0E, 0x07, 0x38, 0x1F, 0xFC, 0x60, 0x0F, 0xE0, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x03, 0x0F, 0xC1, 0xC7, 0xF0,
  0x73, 0x80, 0x19, 0x80, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1E, 0x03, 0x87,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x71, 0x00, 0x0E, 0x38, 0x07, 0x87, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x07, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x06, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0C, 0x30, 0x00, 0x31,
  0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x61, 0x80,
  0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0x00, 0x07,
  0x0C, 0x00, 0x3C, 0x30, 0x01, 0xF0, 0xC0, 0x0F, 0xC3, 0x80, 0x76, 0x0F,
  0x03, 0x98, 0x1F, 0xFC, 0x60, 0x3F, 0xC1, 0x80, 0xE0, 0x00, 0x3B, 0x00,
  0x03, 0x98, 0x00, 0x1C, 0xC0, 0x01, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x01, 0x80, 0x38, 0x0C, 0x03,
  0x80, 0x60, 0x18, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07,
  0x0E, 0x00, 0x18, 0x70, 0x00, 0xC7, 0x00, 0x06, 0x38, 0x00, 0x33, 0x80,
  0x01, 0xD8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x3B, 0x00, 0x1E,
  0x00, 0x76, 0x00, 0x6C, 0x01, 0xCC, 0x00, 0xD8, 0x03, 0x9C, 0x03, 0x30,
  0x06, 0x38, 0x06, 0x60, 0x1C, 0x70, 0x1C, 0xC0, 0x30, 0xE0, 0x31, 0x80,
  0xE1, 0xC0, 0xE3, 0x01, 0x83, 0x81, 0x86, 0x07, 0x07, 0x07, 0x0C, 0x0E,
  0x0E, 0x0C, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x70, 0x38, 0x60, 0x71, 0xC0,
  0x71, 0xC0, 0xE3, 0x80, 0xE3, 0x01, 0xCE, 0x00, 0xCE, 0x01, 0x9C, 0x01,
  0x98, 0x03, 0x30, 0x03, 0x70, 0x06, 0xE0, 0x06, 0xC0, 0x0D, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x80, 0xC0, 0x03, 0x80, 0x70, 0x03,
  0x80, 0x18, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x03, 0x80, 0x01, 0xC3,
  0x80, 0x00, 0xE3, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xD8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0xE0, 0x60, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0xF0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x1C,
  0x00, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x60, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x70, 0x1C,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x38, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x05,
  0xFF, 0xC0, 0x1F, 0x07, 0xE3, 0xF0, 0x07, 0xFE, 0x80, 0x03, 0xE0,
};

const GFXglyph NotoSans_LightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 35, 11, 1, -34 },
  { 50, 12, 13, 17, 5, -34 },
  { 70, 28, 34, 30, 2, -34 },
  { 189, 22, 39, 26, 2, -36 },
  { 297, 30, 35, 37, 4, -34 },
  { 429, 28, 34, 32, 2, -34 },
  { 548, 5, 13, 9, 5, -34 },
  { 557, 14, 41, 13, 2, -34 },
  { 629, 14, 41, 13, -3, -34 },
  { 701, 21, 21, 25, 5, -36 },
  { 757, 22, 23, 27, 3, -28 },
  { 821, 8, 11, 10, -2, -5 },
  { 832, 12, 3, 15, 1, -14 },
  { 837, 4, 5, 11, 1, -4 },
  { 840, 22, 34, 16, -2, -34 },
  { 934, 22, 34, 26, 3, -34 },
  { 1028, 13, 34, 26, 7, -34 },
  { 1084, 24, 34, 26, 0, -34 },
  { 1186, 24, 34, 26, 1, -34 },
  { 1288, 24, 34, 26, 1, -34 },
  { 1390, 23, 34, 26, 2, -34 },
  { 1488, 23, 34, 26, 3, -34 },
  { 1586, 21, 34, 26, 5, -34 },
  { 1676, 23, 34, 26, 2, -34 },
  { 1774, 23, 34, 26, 2, -34 },
  { 1872, 9, 26, 11, 1, -25 },
  { 1902, 12, 31, 11, -2, -25 },
  { 1949, 22, 22, 27, 3, -28 },
  { 2010, 21, 11, 27, 4, -22 },
  { 2039, 22, 22, 27, 3, -28 },
  { 2100, 17, 35, 20, 4, -34 },
  { 2175, 35, 37, 40, 3, -33 },
  { 2337, 26, 34, 26, -2, -34 },
  { 2448, 26, 34, 28, 2, -34 },
  { 2559, 26, 34, 28, 4, -34 },
  { 2670, 28, 34, 32, 2, -34 },
  { 2789, 24, 34, 25, 2, -34 },
  { 2891, 24, 34, 23, 2, -34 },
  { 2993, 27, 34, 32, 4, -34 },
  { 3108, 30, 34, 32, 2, -34 },
  { 3236, 16, 34, 14, 0, -34 },
  { 3304, 20, 43, 12, -8, -34 },
  { 3412, 28, 34, 26, 2, -34 },
  { 3531, 18, 34, 23, 2, -34 },
  { 3608, 37, 34, 39, 2, -34 },
  { 3766, 30, 34, 32, 2, -34 },
  { 3894, 28, 34, 34, 4, -34 },
  { 4013, 24, 34, 26, 2, -34 },
  { 4115, 28, 42, 34, 4, -34 },
  { 4262, 25, 34, 27, 2, -34 },
  { 4369, 23, 34, 24, 1, -34 },
  { 4467, 23, 34, 23, 4, -34 },
  { 4565, 28, 34, 32, 4, -34 },
  { 4684, 24, 34, 26, 5, -34 },
  { 4786, 38, 34, 40, 5, -34 },
  { 4948, 31, 34, 24, -3, -34 },
  { 5080, 24, 34, 23, 4, -34 },
  { 5182, 27, 34, 25, 0, -34 },
  { 5297, 17, 41, 14, 0, -34 },
  { 5385, 8, 34, 16, 5, -34 },
  { 5419, 17, 41, 14, -3, -34 },
  { 5507, 22, 21, 26, 2, -34 },
  { 5565, 18, 2, 18, -4, 5 },
  { 5570, 6, 8, 12, 7, -36 },
  { 5576, 23, 25, 26, 2, -25 },
  { 5648, 24, 36, 27, 1, -36 },
  { 5756, 20, 25, 21, 2, -25 },
  { 5819, 26, 36, 27, 2, -36 },
  { 5936, 19, 25, 23, 3, -25 },
  { 5996, 26, 47, 14, -6, -36 },
  { 6149, 24, 36, 27, 1, -25 },
  { 6257, 23, 36, 27, 1, -36 },
  { 6361, 10, 34, 11, 1, -34 },
  { 6404, 17, 45, 11, -6, -34 },
  { 6500, 23, 36, 22, 1, -36 },
  { 6604, 11, 36, 11, 1, -36 },
  { 6654, 37, 25, 40, 1, -25 },
  { 6770, 23, 26, 27, 1, -26 },
  { 6845, 22, 25, 27, 2, -25 },
  { 6914, 26, 36, 27, -1, -25 },
  { 7031, 23, 36, 27, 2, -25 },
  { 7135, 18, 25, 18, 1, -25 },
  { 7192, 19, 25, 20, 0, -25 },
  { 7252, 14, 31, 15, 2, -31 },
  { 7307, 22, 25, 27, 3, -25 },
  { 7376, 21, 25, 21, 2, -25 },
  { 7442, 31, 25, 32, 3, -25 },
  { 7539, 25, 25, 22, -2, -25 },
  { 7618, 28, 36, 21, -5, -25 },
  { 7744, 22, 25, 21, -1, -25 },
  { 7813, 17, 41, 16, 1, -34 },
  { 7901, 2, 47, 26, 13, -36 },
  { 7913, 17, 41, 16, -2, -34 },
  { 8001, 22, 5, 27, 3, -19 },
};

const GFXfont NotoSans_LightItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_LIGHTITALIC47PT7B_H_
