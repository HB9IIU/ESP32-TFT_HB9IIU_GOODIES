#ifndef _NOTOSANS_LIGHTITALIC29PT7B_H_
#define _NOTOSANS_LIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x20, 0x86,
  0x18, 0x00, 0x04, 0x30, 0xC0, 0x63, 0x62, 0x62, 0x46, 0x46, 0x44, 0xC4,
  0x84, 0x00, 0x82, 0x00, 0x20, 0x80, 0x18, 0x60, 0x04, 0x18, 0x01, 0x04,
  0x00, 0xC1, 0x00, 0x30, 0xC4, 0xFF, 0xFE, 0x02, 0x08, 0x01, 0x86, 0x00,
  0x41, 0x80, 0x10, 0x40, 0x0C, 0x10, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x60,
  0x80, 0x18, 0x60, 0x04, 0x18, 0x01, 0x04, 0x00, 0xC1, 0x00, 0x20, 0xC0,
  0x00, 0x00, 0x60, 0x01, 0x00, 0x0E, 0x01, 0xFF, 0x0C, 0xC4, 0x62, 0x01,
  0x08, 0x04, 0x20, 0x11, 0x80, 0x66, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x0C, 0xC0, 0x21, 0x00, 0x84, 0x02, 0x10, 0x08, 0xC8, 0x66, 0x3F, 0xF0,
  0x0C, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x43, 0x20, 0x10,
  0xC6, 0x06, 0x30, 0x41, 0x86, 0x08, 0x20, 0x83, 0x08, 0x10, 0x63, 0x06,
  0x08, 0xC0, 0xC1, 0x11, 0x98, 0x64, 0xFD, 0x09, 0xB1, 0xB7, 0x64, 0x13,
  0x89, 0x82, 0x03, 0x30, 0x40, 0xC4, 0x08, 0x30, 0x83, 0x04, 0x10, 0x61,
  0x82, 0x08, 0x60, 0x43, 0x18, 0x0C, 0xC6, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0xE6, 0x00, 0x60, 0xC0, 0x10, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x41,
  0x80, 0x18, 0xC0, 0x06, 0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x62, 0x03,
  0x30, 0xC1, 0x98, 0x18, 0x6C, 0x03, 0x33, 0x00, 0xD8, 0xC0, 0x1C, 0x30,
  0x07, 0x06, 0x03, 0x41, 0xC3, 0x98, 0x3F, 0x83, 0x00, 0x6D, 0xA4, 0xB4,
  0x01, 0x81, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x18,
  0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x01, 0x00, 0xC0, 0x60, 0x10, 0x00, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06,
  0x02, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x86, 0x0F, 0x20, 0x0F, 0x0C, 0x0F, 0xE1,
  0xE0, 0x19, 0x01, 0x88, 0x18, 0x60, 0x41, 0x80, 0x08, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xC0, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x39,
  0x88, 0xC4, 0x62, 0x00, 0xFF, 0xFC, 0x7C, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x7B, 0x86, 0x06, 0x30,
  0x33, 0x00, 0x90, 0x05, 0x80, 0x2C, 0x01, 0x40, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0A, 0x00, 0xD0, 0x06, 0xC0, 0x66, 0x03, 0x30,
  0x30, 0xC3, 0x03, 0xF0, 0x00, 0x01, 0x07, 0x1F, 0x3B, 0xE2, 0x42, 0x06,
  0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x10,
  0x10, 0x30, 0x01, 0xF0, 0x0F, 0xF8, 0x30, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x03, 0xF0, 0x3C, 0xE1, 0x80, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x38, 0x07, 0x80,
  0xFC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC8, 0x07, 0x38, 0x38, 0x7F, 0x80, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xA0, 0x06, 0x40, 0x19, 0x80, 0x23, 0x00, 0xC4, 0x03, 0x08,
  0x0C, 0x30, 0x30, 0x60, 0xC0, 0xC3, 0x01, 0x0C, 0x02, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x07,
  0xFE, 0x0F, 0xF8, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x11, 0x00, 0x7F, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x62, 0x01, 0x87, 0x0E,
  0x07, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x30, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x67, 0xC1, 0x3F, 0x8F, 0x03, 0x38, 0x0C,
  0xC0, 0x13, 0x00, 0x4C, 0x01, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x84, 0x06,
  0x1C, 0x70, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x70, 0x30, 0x30, 0x60, 0x20, 0x80,
  0x63, 0x00, 0x82, 0x03, 0x06, 0x0C, 0x06, 0x30, 0x07, 0xC0, 0x1F, 0x00,
  0xE3, 0x03, 0x03, 0x0C, 0x03, 0x10, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80,
  0x31, 0x80, 0xC1, 0x87, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x1D, 0xE0, 0xC1,
  0x86, 0x03, 0x30, 0x0C, 0xC0, 0x32, 0x00, 0xC8, 0x03, 0x20, 0x0C, 0xC0,
  0x73, 0x01, 0xC6, 0x1A, 0x0F, 0xD8, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0x20, 0xE0, 0xFE, 0x00, 0x11, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x23, 0x18, 0x04, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x30, 0x60, 0x83, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x00, 0x1F,
  0x0F, 0x79, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x00, 0x30, 0x06,
  0x03, 0x00, 0x0C, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x62, 0x03, 0xE0, 0x98,
  0x39, 0xC3, 0x41, 0x83, 0x0F, 0x0C, 0x08, 0x38, 0x20, 0x20, 0xE1, 0x81,
  0x82, 0x86, 0x04, 0x0A, 0x18, 0x10, 0x68, 0x60, 0xC1, 0x21, 0x87, 0x0C,
  0x83, 0x76, 0xE3, 0x07, 0x0E, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x08, 0x00, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x05, 0x00, 0x06, 0x80, 0x02, 0x40, 0x03, 0x30, 0x01,
  0x18, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xC0, 0x80, 0x60, 0x40,
  0x7F, 0xF0, 0x3F, 0xF8, 0x30, 0x0C, 0x10, 0x06, 0x18, 0x03, 0x18, 0x00,
  0x8C, 0x00, 0x4C, 0x00, 0x2E, 0x00, 0x18, 0x07, 0xF0, 0x0F, 0xFE, 0x0C,
  0x06, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x03, 0x18, 0x06, 0x18,
  0x0E, 0x1F, 0xF8, 0x1F, 0xF0, 0x30, 0x18, 0x30, 0x0C, 0x30, 0x04, 0x20,
  0x06, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x41, 0xF0, 0xFF,
  0xC0, 0x00, 0xFE, 0x03, 0xFF, 0x06, 0x01, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1C, 0x38, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xFE, 0x03,
  0x01, 0x81, 0x80, 0x60, 0xC0, 0x18, 0x40, 0x0C, 0x60, 0x06, 0x30, 0x01,
  0x18, 0x00, 0x88, 0x00, 0x44, 0x00, 0x26, 0x00, 0x33, 0x00, 0x19, 0x80,
  0x0C, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x06, 0x30, 0x06, 0x18, 0x0E, 0x08,
  0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xF0, 0x7F,
  0xC1, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xFC,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x7F, 0xE1, 0xFF, 0x83, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xFE, 0x01, 0xFF, 0xC1, 0x80, 0x21, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x1F, 0xD8,
  0x0F, 0xEC, 0x00, 0x36, 0x00, 0x13, 0x00, 0x09, 0x80, 0x0C, 0x60, 0x06,
  0x30, 0x03, 0x0C, 0x01, 0x03, 0x83, 0x80, 0xFF, 0x80, 0x04, 0x00, 0x61,
  0x80, 0x08, 0x30, 0x01, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x10, 0x01, 0x86,
  0x00, 0x20, 0xC0, 0x04, 0x18, 0x01, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x18,
  0x00, 0x83, 0x00, 0x30, 0x60, 0x06, 0x08, 0x00, 0xC3, 0x00, 0x18, 0x60,
  0x02, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x20, 0x03, 0x0C, 0x00, 0x40, 0x0F,
  0xC1, 0xE0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0xFC, 0x00, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x8E, 0x0F, 0x80, 0x04, 0x01, 0xC3, 0x00, 0xC0, 0xC0, 0x60,
  0x30, 0x30, 0x0C, 0x18, 0x02, 0x0C, 0x01, 0x86, 0x00, 0x63, 0x00, 0x19,
  0x80, 0x04, 0xC0, 0x01, 0x58, 0x00, 0xE6, 0x00, 0x30, 0xC0, 0x0C, 0x30,
  0x02, 0x04, 0x01, 0x81, 0x80, 0x60, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0x60, 0xC0, 0x18, 0x00, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFE, 0x06, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x78, 0x01, 0xA0, 0xB0, 0x03,
  0xC1, 0x60, 0x0D, 0x86, 0x40, 0x13, 0x0C, 0x80, 0x64, 0x19, 0x00, 0x98,
  0x22, 0x03, 0x30, 0x46, 0x0C, 0x61, 0x8C, 0x10, 0xC3, 0x18, 0x61, 0x06,
  0x10, 0x86, 0x08, 0x23, 0x0C, 0x30, 0x44, 0x18, 0x60, 0x98, 0x20, 0xC1,
  0xE0, 0x41, 0x03, 0x81, 0x82, 0x07, 0x03, 0x0C, 0x04, 0x06, 0x00, 0x04,
  0x00, 0x61, 0xC0, 0x0C, 0x38, 0x01, 0x87, 0x80, 0x20, 0xB0, 0x04, 0x12,
  0x01, 0x86, 0x60, 0x30, 0xC4, 0x06, 0x18, 0xC0, 0x82, 0x18, 0x30, 0x41,
  0x06, 0x18, 0x30, 0xC3, 0x02, 0x10, 0x60, 0x62, 0x08, 0x0C, 0xC3, 0x00,
  0x98, 0x60, 0x1B, 0x0C, 0x01, 0x41, 0x00, 0x38, 0x20, 0x07, 0x0C, 0x00,
  0x60, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xE0, 0x30, 0x60, 0x06, 0x18, 0x01,
  0x8C, 0x00, 0x32, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x0C, 0x60, 0x03, 0x18, 0x01, 0x83, 0x00, 0xC0, 0x70, 0xE0, 0x0F, 0xF0,
  0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x30, 0x38, 0x60, 0x30, 0xC0, 0x61, 0x00,
  0x46, 0x00, 0x8C, 0x03, 0x18, 0x06, 0x20, 0x18, 0x40, 0xE1, 0xFF, 0x83,
  0xE0, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xE0, 0x30,
  0x60, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x32, 0x00, 0x0D, 0x80, 0x03, 0x60,
  0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x02, 0xC0, 0x01, 0xB0, 0x00,
  0x6C, 0x00, 0x1B, 0x00, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x83, 0x00, 0xC0,
  0x70, 0xE0, 0x0F, 0xE0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x30, 0x38, 0x60, 0x30,
  0xC0, 0x21, 0x00, 0x46, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x20, 0x18, 0x43,
  0xE1, 0xFF, 0x03, 0x0C, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x10, 0x60, 0x30,
  0xC0, 0x61, 0x80, 0x42, 0x00, 0xCC, 0x01, 0x80, 0x03, 0xF0, 0x3F, 0xF1,
  0xC0, 0x46, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x30, 0x70, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x02, 0x10, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x18, 0xC0, 0x06, 0x20, 0x01, 0x08, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C,
  0x18, 0x03, 0x06, 0x01, 0x80, 0xE1, 0xC0, 0x1F, 0xE0, 0x00, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x36, 0x00, 0x4C, 0x01, 0x98, 0x02, 0x10, 0x0C, 0x20,
  0x10, 0x40, 0x60, 0xC1, 0x81, 0x83, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x60,
  0x08, 0xC0, 0x13, 0x00, 0x24, 0x00, 0x58, 0x00, 0xA0, 0x01, 0xC0, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x06, 0xC0, 0x38, 0x06, 0x40,
  0x28, 0x0C, 0x40, 0x68, 0x0C, 0x40, 0x48, 0x18, 0x40, 0xC8, 0x18, 0x40,
  0x88, 0x10, 0x41, 0x88, 0x30, 0x41, 0x08, 0x20, 0x43, 0x08, 0x60, 0x42,
  0x08, 0x60, 0x66, 0x0C, 0xC0, 0x66, 0x0C, 0xC0, 0x6C, 0x0D, 0x80, 0x6C,
  0x0D, 0x80, 0x68, 0x0D, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x60, 0x04, 0x00, 0x06, 0x00, 0x60, 0x40, 0x18, 0x0C, 0x06,
  0x00, 0x80, 0x80, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x23, 0x00, 0x06, 0xC0,
  0x00, 0xD0, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1B, 0x00,
  0x06, 0x20, 0x00, 0x86, 0x00, 0x30, 0xC0, 0x0C, 0x08, 0x03, 0x01, 0x80,
  0xC0, 0x30, 0x10, 0x03, 0x0E, 0x00, 0x60, 0x80, 0x0F, 0x00, 0x6C, 0x01,
  0x90, 0x0C, 0x60, 0x61, 0x81, 0x06, 0x0C, 0x08, 0x60, 0x31, 0x00, 0xCC,
  0x01, 0x60, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0x87, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0xF8, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xFC, 0x1F, 0x00, 0xC6, 0x30, 0x84, 0x21, 0x8C, 0x61, 0x08,
  0x43, 0x18, 0xC2, 0x10, 0x86, 0x31, 0x80, 0x07, 0xE0, 0xFC, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0xFC, 0x1F, 0x80, 0x00, 0x80, 0x06, 0x00, 0x34,
  0x00, 0x90, 0x06, 0x60, 0x10, 0x80, 0xC2, 0x02, 0x0C, 0x18, 0x10, 0xC0,
  0x62, 0x00, 0x98, 0x02, 0xC0, 0x0C, 0xFF, 0xF0, 0xC6, 0x23, 0x01, 0x80,
  0x3F, 0x91, 0xC3, 0x46, 0x07, 0x30, 0x1D, 0x80, 0x66, 0x01, 0x98, 0x06,
  0x40, 0x1B, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0x40, 0x71, 0x83, 0xC7, 0x1A,
  0x0F, 0x88, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x8E, 0x06, 0xFE, 0x16, 0x18, 0x70, 0x33, 0x80, 0xCC, 0x03, 0x30,
  0x0C, 0x80, 0x36, 0x00, 0xD8, 0x03, 0x60, 0x09, 0x80, 0x66, 0x03, 0x38,
  0x0C, 0xD8, 0xE2, 0x3F, 0x00, 0x03, 0xC3, 0xFC, 0xE0, 0x38, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0x1C, 0x21, 0xFC, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x01, 0x86, 0x0F, 0xE6, 0x1C, 0x14, 0x18, 0x14, 0x30,
  0x0C, 0x60, 0x0C, 0x60, 0x08, 0x60, 0x08, 0x40, 0x18, 0xC0, 0x18, 0xC0,
  0x18, 0xC0, 0x30, 0x40, 0x70, 0x60, 0xF0, 0x71, 0xB0, 0x3F, 0x30, 0x03,
  0x81, 0xFC, 0xE1, 0x98, 0x16, 0x02, 0x80, 0xF0, 0x36, 0xFC, 0xFE, 0x10,
  0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x18, 0x21, 0xFC, 0x00, 0x1F, 0x00,
  0x39, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x44, 0x03,
  0xF8, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x1F, 0xCC, 0x70,
  0x50, 0xC0, 0xA3, 0x00, 0xCC, 0x01, 0x98, 0x02, 0x30, 0x04, 0x40, 0x19,
  0x80, 0x33, 0x00, 0x66, 0x01, 0x84, 0x07, 0x0C, 0x1E, 0x1C, 0x6C, 0x1F,
  0x98, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x08, 0x0C, 0x1F, 0xF0,
  0x1F, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x8E, 0x06, 0xFE, 0x16, 0x18, 0x70, 0x33, 0x80, 0xCC, 0x03,
  0x30, 0x08, 0x80, 0x26, 0x01, 0x98, 0x06, 0x60, 0x19, 0x00, 0x44, 0x03,
  0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC0, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x84,
  0x10, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x02, 0xE0, 0x78,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x46, 0x06, 0x10, 0x30, 0x41, 0x83, 0x08, 0x0C, 0xC0, 0x26, 0x00,
  0xB8, 0x07, 0xA0, 0x1C, 0xC0, 0x63, 0x01, 0x06, 0x04, 0x18, 0x30, 0x30,
  0xC0, 0xC3, 0x01, 0x80, 0x0C, 0x30, 0xC2, 0x08, 0x61, 0x86, 0x10, 0x43,
  0x0C, 0x30, 0x86, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x00, 0x08, 0xE0, 0x70,
  0x4F, 0xC7, 0xE1, 0x61, 0xB0, 0xC7, 0x07, 0x83, 0x38, 0x1C, 0x04, 0xC0,
  0x60, 0x33, 0x01, 0x80, 0xC8, 0x06, 0x03, 0x60, 0x10, 0x09, 0x80, 0xC0,
  0x26, 0x03, 0x01, 0x90, 0x0C, 0x06, 0x40, 0x20, 0x1B, 0x00, 0x80, 0x4C,
  0x06, 0x01, 0x30, 0x18, 0x0C, 0x08, 0xE0, 0x4F, 0xE1, 0x61, 0xCF, 0x03,
  0x38, 0x0C, 0xC0, 0x33, 0x00, 0x88, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01,
  0x98, 0x04, 0x40, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0x03, 0x80, 0xFF,
  0x0E, 0x0C, 0xC0, 0x26, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xA0, 0x0D, 0x00, 0x6C, 0x06, 0x60, 0x31, 0x87, 0x07, 0xE0, 0x02,
  0x38, 0x04, 0xFE, 0x05, 0x86, 0x07, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x0C,
  0x03, 0x08, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x02, 0x18, 0x06, 0x18,
  0x0C, 0x38, 0x0C, 0x36, 0x38, 0x33, 0xF0, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x1F,
  0xCC, 0x70, 0x50, 0xC0, 0xA3, 0x00, 0xCC, 0x01, 0x98, 0x02, 0x30, 0x04,
  0x40, 0x19, 0x80, 0x33, 0x00, 0x66, 0x01, 0x84, 0x07, 0x0C, 0x1E, 0x1C,
  0x6C, 0x1F, 0x98, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x08, 0xE2, 0x7C, 0x58, 0x0E, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x07, 0xC1, 0xFF, 0x18, 0x13, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x0C,
  0xC1, 0x87, 0xF0, 0x0C, 0x04, 0x06, 0x03, 0x0F, 0xF8, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x31, 0x1F,
  0x00, 0x30, 0x09, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0x20, 0x0B, 0x00,
  0xD8, 0x06, 0xC0, 0x36, 0x03, 0x20, 0x19, 0x01, 0xC8, 0x1E, 0x61, 0xB1,
  0xF1, 0x00, 0xC0, 0x1A, 0x01, 0x90, 0x0C, 0xC0, 0xC6, 0x04, 0x30, 0x61,
  0x86, 0x04, 0x30, 0x23, 0x01, 0x18, 0x09, 0x80, 0x68, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x00, 0x80, 0xC0, 0x70, 0x38, 0x1A, 0x05, 0x03, 0x41, 0xA0,
  0xC8, 0x24, 0x19, 0x8C, 0xC6, 0x31, 0x18, 0xC6, 0x63, 0x30, 0xC8, 0x66,
  0x1B, 0x0C, 0x83, 0x61, 0xB0, 0x78, 0x14, 0x0F, 0x03, 0x81, 0xC0, 0x60,
  0x38, 0x0C, 0x00, 0x1C, 0x0E, 0x18, 0x18, 0x10, 0x60, 0x31, 0x80, 0x26,
  0x00, 0x78, 0x00, 0x60, 0x01, 0xC0, 0x02, 0x80, 0x0D, 0x80, 0x31, 0x00,
  0xC3, 0x03, 0x06, 0x0C, 0x06, 0x30, 0x0C, 0x00, 0x0C, 0x01, 0x82, 0x01,
  0x81, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x40, 0x30, 0x60, 0x08, 0x20, 0x04,
  0x30, 0x02, 0x30, 0x01, 0x98, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x0B, 0x80, 0x07, 0x80, 0x00, 0x1F, 0xF8, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0xFF, 0x00, 0x00, 0x40, 0xF0, 0x60,
  0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0xC0, 0xE0,
  0x38, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x38, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x04, 0x01, 0xC0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x01, 0xC0, 0x70, 0x20, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02,
  0x01, 0x80, 0xE0, 0xF0, 0x20, 0x00, 0x3C, 0x07, 0xFC, 0x38, 0x1F, 0x80,
};

const GFXglyph NotoSans_LightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 21, 7, 1, -21 },
  { 17, 8, 8, 10, 3, -21 },
  { 25, 18, 21, 18, 1, -21 },
  { 73, 14, 24, 16, 1, -22 },
  { 115, 19, 21, 23, 2, -21 },
  { 165, 18, 21, 20, 1, -21 },
  { 213, 3, 8, 6, 3, -21 },
  { 216, 9, 26, 8, 1, -21 },
  { 246, 9, 26, 8, -2, -21 },
  { 276, 13, 13, 16, 3, -22 },
  { 298, 14, 14, 17, 2, -17 },
  { 323, 5, 7, 6, -1, -3 },
  { 328, 7, 2, 9, 1, -9 },
  { 330, 2, 3, 7, 1, -3 },
  { 331, 13, 21, 10, -1, -21 },
  { 366, 13, 21, 16, 2, -21 },
  { 401, 8, 21, 16, 4, -21 },
  { 422, 15, 21, 16, 0, -21 },
  { 462, 14, 21, 16, 1, -21 },
  { 499, 15, 21, 16, 0, -21 },
  { 539, 15, 21, 16, 1, -21 },
  { 579, 14, 21, 16, 2, -21 },
  { 616, 13, 21, 16, 3, -21 },
  { 651, 15, 21, 16, 1, -21 },
  { 691, 14, 21, 16, 1, -21 },
  { 728, 5, 16, 7, 1, -16 },
  { 738, 7, 20, 7, -1, -16 },
  { 756, 14, 13, 17, 2, -17 },
  { 779, 14, 7, 17, 2, -14 },
  { 792, 14, 13, 17, 2, -17 },
  { 815, 11, 21, 12, 2, -21 },
  { 844, 22, 24, 24, 2, -21 },
  { 910, 17, 21, 16, -2, -21 },
  { 955, 16, 21, 17, 1, -21 },
  { 997, 16, 21, 17, 2, -21 },
  { 1039, 17, 21, 19, 1, -21 },
  { 1084, 15, 21, 15, 1, -21 },
  { 1124, 15, 21, 14, 1, -21 },
  { 1164, 17, 21, 20, 2, -21 },
  { 1209, 19, 21, 20, 1, -21 },
  { 1259, 10, 21, 9, 0, -21 },
  { 1286, 12, 26, 7, -5, -21 },
  { 1325, 18, 21, 16, 1, -21 },
  { 1373, 11, 21, 14, 1, -21 },
  { 1402, 23, 21, 24, 1, -21 },
  { 1463, 19, 21, 20, 1, -21 },
  { 1513, 18, 21, 21, 2, -21 },
  { 1561, 15, 21, 16, 1, -21 },
  { 1601, 18, 26, 21, 2, -21 },
  { 1660, 15, 21, 16, 1, -21 },
  { 1700, 14, 21, 15, 1, -21 },
  { 1737, 14, 21, 14, 3, -21 },
  { 1774, 18, 21, 20, 2, -21 },
  { 1822, 15, 21, 16, 3, -21 },
  { 1862, 24, 21, 24, 3, -21 },
  { 1925, 19, 21, 15, -2, -21 },
  { 1975, 14, 21, 14, 3, -21 },
  { 2012, 17, 21, 16, 0, -21 },
  { 2057, 11, 26, 9, 0, -21 },
  { 2093, 5, 21, 10, 3, -21 },
  { 2107, 11, 26, 9, -2, -21 },
  { 2143, 14, 13, 16, 1, -21 },
  { 2166, 12, 1, 11, -3, 3 },
  { 2168, 4, 4, 7, 4, -22 },
  { 2170, 14, 16, 16, 1, -16 },
  { 2198, 14, 22, 17, 1, -22 },
  { 2237, 11, 16, 13, 2, -16 },
  { 2259, 16, 22, 17, 1, -22 },
  { 2303, 11, 16, 14, 2, -16 },
  { 2325, 16, 29, 8, -4, -22 },
  { 2383, 15, 23, 17, 1, -16 },
  { 2427, 14, 22, 16, 1, -22 },
  { 2466, 6, 21, 7, 1, -21 },
  { 2482, 11, 28, 7, -4, -21 },
  { 2521, 14, 22, 14, 1, -22 },
  { 2560, 6, 22, 7, 1, -22 },
  { 2577, 22, 16, 25, 1, -16 },
  { 2621, 14, 16, 16, 1, -16 },
  { 2649, 13, 16, 16, 2, -16 },
  { 2675, 16, 23, 17, -1, -16 },
  { 2721, 15, 23, 17, 1, -16 },
  { 2765, 11, 16, 11, 1, -16 },
  { 2787, 12, 16, 12, 0, -16 },
  { 2811, 9, 19, 9, 1, -19 },
  { 2833, 13, 15, 16, 2, -15 },
  { 2858, 13, 15, 13, 1, -15 },
  { 2883, 19, 15, 20, 2, -15 },
  { 2919, 15, 15, 14, -1, -15 },
  { 2948, 17, 22, 13, -3, -15 },
  { 2995, 13, 15, 13, 0, -15 },
  { 3020, 10, 26, 10, 1, -21 },
  { 3053, 1, 29, 16, 8, -22 },
  { 3057, 10, 26, 10, -1, -21 },
  { 3090, 14, 3, 17, 2, -12 },
};

const GFXfont NotoSans_LightItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_LIGHTITALIC29PT7B_H_
