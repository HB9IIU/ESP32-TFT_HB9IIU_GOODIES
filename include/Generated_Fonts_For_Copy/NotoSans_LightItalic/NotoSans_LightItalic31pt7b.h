#ifndef _NOTOSANS_LIGHTITALIC31PT7B_H_
#define _NOTOSANS_LIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83,
  0x06, 0x08, 0x30, 0x00, 0x00, 0x02, 0x0E, 0x18, 0x00, 0x33, 0x63, 0x63,
  0x63, 0x42, 0x42, 0x46, 0xC4, 0x00, 0xC1, 0x80, 0x18, 0x20, 0x02, 0x0C,
  0x00, 0xC1, 0x80, 0x18, 0x20, 0x02, 0x04, 0x00, 0x41, 0x81, 0xFF, 0xFF,
  0x03, 0x04, 0x00, 0x41, 0x80, 0x18, 0x30, 0x03, 0x04, 0x00, 0x40, 0x80,
  0x08, 0x30, 0x3F, 0xFF, 0xE0, 0x60, 0x80, 0x08, 0x30, 0x03, 0x06, 0x00,
  0x60, 0x80, 0x08, 0x30, 0x01, 0x06, 0x00, 0x60, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x0F, 0xC0, 0x7F, 0xE1, 0x88, 0x46, 0x10, 0x0C,
  0x60, 0x18, 0xC0, 0x31, 0x00, 0x62, 0x00, 0x74, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x4E, 0x00, 0x8C, 0x01, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x11, 0x8C,
  0x27, 0x1F, 0xF8, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1F,
  0x00, 0x63, 0x10, 0x08, 0x61, 0x81, 0x84, 0x18, 0x30, 0xC1, 0x82, 0x0C,
  0x18, 0x60, 0x81, 0x0C, 0x08, 0x11, 0x80, 0x83, 0x10, 0x88, 0x33, 0x7E,
  0x86, 0x66, 0x2C, 0x4C, 0xC3, 0x7C, 0x88, 0x30, 0x19, 0x83, 0x03, 0x18,
  0x30, 0x61, 0x02, 0x04, 0x10, 0x20, 0xC1, 0x06, 0x18, 0x10, 0x43, 0x01,
  0x0C, 0x20, 0x19, 0x86, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x61, 0xC0, 0x18,
  0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30,
  0xC0, 0x03, 0x70, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0E, 0x60, 0x03, 0x86,
  0x06, 0xC0, 0xC1, 0x98, 0x0C, 0x26, 0x00, 0xCC, 0xC0, 0x1B, 0x18, 0x01,
  0xC3, 0x00, 0x38, 0x30, 0x0D, 0x87, 0x8F, 0x30, 0x3F, 0x83, 0x00, 0x36,
  0x66, 0x44, 0x4C, 0x01, 0xC0, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x02, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0xC0, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30, 0x00, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x0C, 0x20, 0x79, 0x00, 0x78, 0xE0, 0xFF, 0x0E, 0x00, 0xD8,
  0x0C, 0x41, 0xC3, 0x04, 0x18, 0x00, 0x60, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x19, 0x8C,
  0x66, 0x33, 0x10, 0xFF, 0x5F, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x38,
  0x61, 0xC0, 0xC6, 0x03, 0x30, 0x04, 0xC0, 0x16, 0x00, 0x58, 0x01, 0x60,
  0x05, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xB0,
  0x06, 0xC0, 0x1B, 0x00, 0xCC, 0x06, 0x18, 0x38, 0x71, 0xC0, 0xFC, 0x00,
  0x03, 0x0F, 0x1B, 0x72, 0xC6, 0x86, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x01, 0xFC,
  0x07, 0x0E, 0x04, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0x03, 0xF8, 0x3C, 0x18, 0x20, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0xE0, 0x1F, 0x00, 0x47, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x64, 0x01, 0x8F, 0x1E, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x02, 0x80, 0x03, 0x40, 0x03, 0x60, 0x03,
  0x30, 0x03, 0x18, 0x03, 0x08, 0x03, 0x0C, 0x03, 0x06, 0x01, 0x03, 0x01,
  0x81, 0x81, 0x80, 0x81, 0x80, 0xC1, 0x80, 0x62, 0xFF, 0xFE, 0x80, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x07,
  0xFF, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0x10, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x80, 0x30, 0xF1, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x61, 0xC0,
  0xDF, 0xE1, 0x60, 0xE7, 0x00, 0xCE, 0x01, 0x98, 0x01, 0x30, 0x02, 0x60,
  0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xC3, 0x03, 0x07, 0x9E, 0x03, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x03, 0xFC, 0x07, 0x0E, 0x0E, 0x06, 0x0C, 0x03,
  0x0C, 0x03, 0x0C, 0x02, 0x0C, 0x06, 0x0C, 0x0E, 0x06, 0x18, 0x03, 0x70,
  0x03, 0xC0, 0x0E, 0x70, 0x38, 0x38, 0x70, 0x18, 0x60, 0x0C, 0x40, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0x60, 0x18, 0x60, 0x18, 0x38, 0x70, 0x1F, 0xC0,
  0x03, 0xF8, 0x0C, 0x38, 0x30, 0x30, 0xC0, 0x31, 0x00, 0x66, 0x00, 0xCC,
  0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x1C, 0xC0, 0x38, 0xC1, 0xB0, 0xFE,
  0xC0, 0x61, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x0C, 0x38, 0x1F, 0xE0, 0x00, 0x18, 0xC6, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x1C, 0xC0, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0xC3, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0xF3, 0xE0, 0x0E, 0x00, 0xE0, 0x70, 0x00, 0x61, 0x80, 0x00,
  0xC2, 0x00, 0x00, 0xCC, 0x07, 0xC1, 0xB0, 0x3F, 0xC1, 0x60, 0xC1, 0x83,
  0x83, 0x03, 0x07, 0x0C, 0x04, 0x0E, 0x18, 0x18, 0x38, 0x20, 0x30, 0x70,
  0x40, 0x60, 0xE1, 0x81, 0x83, 0x41, 0x03, 0x06, 0x83, 0x0A, 0x19, 0x87,
  0xE7, 0xE3, 0x03, 0x87, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x40, 0x07, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x68, 0x00, 0x32, 0x00, 0x0C, 0x80,
  0x06, 0x30, 0x01, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x0C,
  0x04, 0x03, 0x01, 0x01, 0xFF, 0xE0, 0x60, 0x18, 0x30, 0x06, 0x18, 0x01,
  0x86, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x02, 0x60, 0x00, 0xB8, 0x00, 0x30,
  0x07, 0xFE, 0x03, 0x0F, 0x81, 0x00, 0xE1, 0x80, 0x30, 0xC0, 0x18, 0x60,
  0x0C, 0x30, 0x06, 0x30, 0x06, 0x18, 0x07, 0x0C, 0x0F, 0x07, 0xFC, 0x02,
  0x03, 0x83, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x0C, 0x60, 0x06, 0x20, 0x02,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x03, 0x87, 0xFF, 0x87, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0xF0, 0x60, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x3C, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0xC7, 0xE0, 0x10, 0x0E, 0x06, 0x00, 0xE0, 0xC0,
  0x0C, 0x18, 0x01, 0x82, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x0C, 0x60, 0x01, 0x88, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x31, 0x80, 0x0C, 0x20, 0x03, 0x8C, 0x00, 0xE1, 0x80, 0x38, 0x30, 0x1E,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x04, 0x1F, 0xF8, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xF0,
  0xFF, 0xF0, 0x07, 0xFF, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1F, 0xF8, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x78, 0x38, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x1F, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x62, 0x00, 0x08,
  0x60, 0x03, 0x0C, 0x00, 0x61, 0xC0, 0x0C, 0x1C, 0x01, 0x01, 0xE1, 0xE0,
  0x1F, 0xF8, 0x00, 0x06, 0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x30, 0xC0,
  0x02, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x04, 0x18,
  0x00, 0xC1, 0x80, 0x0C, 0x1F, 0xFF, 0xC1, 0x00, 0x0C, 0x30, 0x00, 0x83,
  0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x20, 0x01, 0x86, 0x00, 0x10,
  0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0x0F, 0xE0,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x03, 0x01, 0xF8, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x70, 0x3F,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0xE0, 0xC0, 0x30, 0x10, 0x0C, 0x06, 0x03,
  0x00, 0xC0, 0xC0, 0x18, 0x30, 0x02, 0x1C, 0x00, 0xC7, 0x00, 0x19, 0xC0,
  0x03, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x60, 0x03, 0x8C, 0x00, 0x60, 0xC0,
  0x0C, 0x18, 0x01, 0x81, 0x00, 0x20, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0x81,
  0xC0, 0x03, 0xC1, 0xA0, 0x01, 0x60, 0xD0, 0x01, 0xB0, 0x68, 0x01, 0x90,
  0x26, 0x00, 0xD8, 0x33, 0x00, 0xCC, 0x19, 0x80, 0x66, 0x0C, 0xC0, 0x62,
  0x06, 0x20, 0x23, 0x02, 0x10, 0x31, 0x83, 0x0C, 0x30, 0xC1, 0x86, 0x18,
  0x60, 0xC3, 0x18, 0x20, 0x61, 0x8C, 0x30, 0x20, 0x4C, 0x18, 0x30, 0x24,
  0x0C, 0x18, 0x16, 0x06, 0x0C, 0x0E, 0x02, 0x04, 0x07, 0x03, 0x06, 0x03,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x70, 0x03, 0x07, 0x00, 0x30, 0xD0, 0x03,
  0x0D, 0x80, 0x20, 0xD8, 0x06, 0x08, 0xC0, 0x61, 0x8C, 0x06, 0x18, 0x40,
  0x61, 0x86, 0x04, 0x18, 0x60, 0xC1, 0x03, 0x0C, 0x30, 0x30, 0xC3, 0x01,
  0x0C, 0x30, 0x18, 0x83, 0x01, 0x98, 0x20, 0x0D, 0x86, 0x00, 0xD8, 0x60,
  0x05, 0x06, 0x00, 0x70, 0x40, 0x07, 0x0C, 0x00, 0x30, 0x01, 0xFE, 0x00,
  0xF0, 0xF0, 0x38, 0x07, 0x0E, 0x00, 0x61, 0x80, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xB0, 0x00, 0x32, 0x00, 0x06, 0x60,
  0x01, 0x8C, 0x00, 0x31, 0xC0, 0x0C, 0x1C, 0x07, 0x01, 0xE3, 0xC0, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x06, 0x3E, 0x04, 0x07, 0x0C, 0x03, 0x0C, 0x01,
  0x0C, 0x01, 0x0C, 0x01, 0x18, 0x03, 0x18, 0x03, 0x18, 0x06, 0x18, 0x0E,
  0x1F, 0xF8, 0x3F, 0xE0, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0xF0, 0xF0, 0x38, 0x07, 0x0E, 0x00, 0x61, 0x80, 0x06, 0x60, 0x00,
  0xCC, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xB0, 0x00, 0x32, 0x00, 0x06,
  0x60, 0x01, 0x8C, 0x00, 0x31, 0xC0, 0x0C, 0x1C, 0x07, 0x01, 0xE3, 0xC0,
  0x1F, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0xFC, 0x06, 0x3E, 0x04, 0x03, 0x0C, 0x03, 0x0C,
  0x01, 0x0C, 0x01, 0x08, 0x01, 0x18, 0x03, 0x18, 0x03, 0x18, 0x06, 0x18,
  0x1C, 0x1F, 0xF0, 0x30, 0x60, 0x30, 0x60, 0x30, 0x30, 0x30, 0x30, 0x20,
  0x30, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x0C, 0xC0, 0x0C, 0x03,
  0xFC, 0x1E, 0x1C, 0x70, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC4, 0x03,
  0x8E, 0x1E, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x88, 0x00,
  0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x44, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x62, 0x00, 0x18, 0x80,
  0x06, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x80, 0x60, 0x78, 0xF0, 0x0F, 0xF0,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x04, 0x40, 0x0C, 0x40,
  0x18, 0x60, 0x18, 0x60, 0x30, 0x60, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0x20, 0xC0, 0x21, 0x80, 0x31, 0x80, 0x33, 0x00, 0x32, 0x00, 0x36,
  0x00, 0x34, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x18, 0x00, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x28, 0x06, 0x80, 0x68, 0x06, 0xC0, 0x68, 0x0C,
  0xC0, 0xC8, 0x0C, 0xC0, 0xC8, 0x08, 0xC1, 0x88, 0x18, 0xC1, 0x88, 0x18,
  0xC1, 0x08, 0x30, 0xC3, 0x0C, 0x30, 0xC2, 0x0C, 0x60, 0xC6, 0x0C, 0x60,
  0xC4, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xC8, 0x0C, 0x80, 0xD8, 0x0D, 0x80,
  0xD8, 0x0D, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x03, 0x00, 0x30, 0x30, 0x06, 0x01, 0x00, 0xC0, 0x18,
  0x18, 0x01, 0x83, 0x00, 0x08, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xD0, 0x00,
  0x19, 0x80, 0x03, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0xC0,
  0x18, 0x06, 0x03, 0x00, 0x60, 0x70, 0x02, 0x0E, 0x00, 0x30, 0xC0, 0x07,
  0x80, 0x19, 0x00, 0x63, 0x00, 0xC6, 0x03, 0x04, 0x0C, 0x0C, 0x18, 0x18,
  0x60, 0x31, 0x80, 0x23, 0x00, 0x6C, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0xC2, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x07, 0xE0, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0xC0, 0x1F, 0x83, 0xF0, 0x00, 0xC6, 0x10, 0x86, 0x31,
  0x8C, 0x21, 0x0C, 0x63, 0x18, 0x42, 0x18, 0xC6, 0x30, 0x84, 0x07, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x1F, 0x83, 0xF0, 0x00,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x19, 0x00, 0x23, 0x00, 0xC6, 0x03,
  0x04, 0x06, 0x0C, 0x18, 0x08, 0x20, 0x18, 0xC0, 0x31, 0x00, 0x26, 0x00,
  0x78, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xCC, 0x46, 0x30, 0x03, 0x80, 0x3F,
  0x91, 0x83, 0xCC, 0x07, 0x60, 0x1D, 0x80, 0x6C, 0x01, 0xB0, 0x06, 0xC0,
  0x1A, 0x00, 0x68, 0x03, 0x20, 0x0C, 0x80, 0x73, 0x01, 0xCC, 0x0B, 0x18,
  0xC8, 0x7E, 0x20, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x38, 0x19, 0xFC, 0x36, 0x18, 0x50, 0x18,
  0xC0, 0x33, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x90, 0x03, 0x20, 0x06, 0xC0,
  0x0D, 0x80, 0x33, 0x00, 0x66, 0x01, 0x9A, 0x06, 0x36, 0x3C, 0x47, 0xE0,
  0x03, 0xE0, 0xFF, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x0C,
  0x3F, 0x80, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x03, 0xC6, 0x0F, 0xE6, 0x18, 0x34, 0x30, 0x1C,
  0x60, 0x0C, 0x60, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18,
  0x80, 0x18, 0x80, 0x30, 0x80, 0x30, 0xC0, 0x70, 0xC0, 0xB0, 0xE3, 0x30,
  0x7E, 0x20, 0x03, 0xC0, 0xFF, 0x18, 0x33, 0x01, 0x60, 0x16, 0x03, 0xC0,
  0x7C, 0x1E, 0xFF, 0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0x0C, 0x3F, 0xC0, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x03, 0xFC, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x07, 0xF3, 0x0C, 0x1A, 0x18, 0x0A, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06,
  0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0x40, 0x18, 0x40, 0x18,
  0x60, 0x38, 0x60, 0x58, 0x71, 0x98, 0x3F, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0xC1, 0xC0, 0xFF, 0x80, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x38, 0x19, 0xFC, 0x36, 0x18, 0x50, 0x18, 0xC0, 0x33, 0x80, 0x66, 0x00,
  0xCC, 0x03, 0x18, 0x06, 0x20, 0x0C, 0xC0, 0x19, 0x80, 0x23, 0x00, 0xC4,
  0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x18, 0x04, 0x1C, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x82,
  0x0C, 0x18, 0x30, 0x00, 0x00, 0x20, 0x07, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x0F,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x01, 0x18, 0x1C, 0x30, 0x70, 0x61, 0x80, 0x86, 0x03,
  0x18, 0x06, 0x60, 0x0D, 0x80, 0x17, 0x80, 0x3B, 0x00, 0xE3, 0x01, 0x86,
  0x03, 0x06, 0x04, 0x0C, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x18, 0x06, 0x08,
  0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18,
  0x20, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0x00, 0xF0, 0x3C, 0x19, 0xF8,
  0xFE, 0x1A, 0x0D, 0x87, 0x14, 0x0F, 0x03, 0x18, 0x0E, 0x03, 0x38, 0x0C,
  0x03, 0x30, 0x0C, 0x03, 0x30, 0x0C, 0x02, 0x30, 0x08, 0x06, 0x20, 0x18,
  0x06, 0x60, 0x18, 0x06, 0x60, 0x18, 0x06, 0x60, 0x10, 0x0C, 0x40, 0x30,
  0x0C, 0xC0, 0x30, 0x0C, 0xC0, 0x30, 0x0C, 0xC0, 0x30, 0x08, 0x18, 0x70,
  0x33, 0xF8, 0x6C, 0x38, 0xA0, 0x31, 0x80, 0x67, 0x00, 0xCC, 0x01, 0x98,
  0x06, 0x30, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x46, 0x01, 0x88, 0x03,
  0x30, 0x06, 0x60, 0x0C, 0xC0, 0x30, 0x03, 0xC0, 0x3F, 0xC1, 0x83, 0x8C,
  0x06, 0x60, 0x0D, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xA0, 0x06, 0xC0, 0x1B, 0x00, 0xCC, 0x06, 0x1C, 0x70, 0x3F, 0x80,
  0x00, 0x1C, 0x03, 0x3F, 0x81, 0xB0, 0xC0, 0xA0, 0x30, 0x60, 0x18, 0x70,
  0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x84, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0xD0, 0x30, 0x6C, 0x78, 0x33, 0xF0,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x03, 0xC0, 0x1F, 0xCC, 0x60, 0xD1, 0x80, 0xA6, 0x01,
  0xCC, 0x01, 0xB0, 0x03, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x32, 0x00, 0x64,
  0x01, 0x88, 0x03, 0x18, 0x0E, 0x30, 0x2C, 0x31, 0x98, 0x7E, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xF1, 0x9F, 0x1B, 0x01, 0x40, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x00, 0x03, 0xC0, 0x7F, 0xC6, 0x04, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x32, 0x01, 0x9C, 0x38, 0x7F, 0x80, 0x18, 0x0C, 0x04, 0x06, 0x0F, 0xF9,
  0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x60, 0x31, 0x0F, 0x80, 0x30, 0x06, 0x60, 0x18, 0x80, 0x33, 0x00,
  0x66, 0x00, 0x8C, 0x03, 0x18, 0x06, 0x20, 0x0C, 0xC0, 0x19, 0x80, 0x63,
  0x00, 0xC6, 0x03, 0x8C, 0x07, 0x18, 0x16, 0x38, 0xC8, 0x3F, 0x10, 0x80,
  0x1E, 0x01, 0xB0, 0x09, 0x80, 0xCC, 0x0C, 0x60, 0x63, 0x06, 0x08, 0x30,
  0x43, 0x03, 0x18, 0x19, 0x80, 0xC8, 0x06, 0xC0, 0x34, 0x00, 0xE0, 0x06,
  0x00, 0xC0, 0x60, 0x3C, 0x0E, 0x02, 0xC0, 0xA0, 0x6C, 0x1A, 0x06, 0xC1,
  0x20, 0xCC, 0x32, 0x0C, 0xC2, 0x21, 0x8C, 0x63, 0x18, 0xC4, 0x33, 0x0C,
  0xC3, 0x30, 0xC8, 0x36, 0x0D, 0x83, 0x60, 0xD0, 0x34, 0x0F, 0x03, 0xC0,
  0xE0, 0x38, 0x06, 0x01, 0x80, 0x0C, 0x07, 0x0C, 0x0C, 0x06, 0x0C, 0x06,
  0x18, 0x03, 0x30, 0x03, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x06,
  0xC0, 0x06, 0x60, 0x0C, 0x60, 0x18, 0x20, 0x30, 0x30, 0x60, 0x10, 0xC0,
  0x18, 0x04, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x10, 0x18, 0x0C, 0x06, 0x06,
  0x01, 0x81, 0x80, 0x20, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00,
  0x33, 0x00, 0x0C, 0x80, 0x01, 0x60, 0x00, 0x50, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x3F, 0xF8, 0x00, 0xE0, 0x78,
  0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x0C, 0x0F, 0x01, 0xC0, 0x0C, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x07, 0x80, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0xF0, 0x02, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0xC0, 0xE0, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x1E, 0x03, 0x80, 0x00, 0x18, 0x02, 0xFE,
  0x0F, 0x07, 0xF4, 0x03, 0x80,
};

const GFXglyph NotoSans_LightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 22, 7, 1, -22 },
  { 21, 8, 8, 11, 3, -22 },
  { 29, 19, 22, 20, 1, -22 },
  { 82, 15, 26, 17, 1, -24 },
  { 131, 20, 22, 24, 3, -22 },
  { 186, 19, 22, 21, 1, -22 },
  { 239, 4, 8, 6, 3, -22 },
  { 243, 10, 27, 8, 1, -22 },
  { 277, 9, 27, 8, -2, -22 },
  { 308, 13, 14, 17, 4, -24 },
  { 331, 15, 14, 18, 2, -18 },
  { 358, 5, 8, 7, -1, -4 },
  { 363, 8, 1, 10, 1, -9 },
  { 364, 3, 3, 7, 1, -3 },
  { 366, 14, 22, 10, -1, -22 },
  { 405, 14, 22, 17, 2, -22 },
  { 444, 8, 22, 17, 5, -22 },
  { 466, 16, 22, 17, 0, -22 },
  { 510, 15, 22, 17, 1, -22 },
  { 552, 17, 22, 17, 0, -22 },
  { 599, 16, 22, 17, 1, -22 },
  { 643, 15, 22, 17, 2, -22 },
  { 685, 14, 22, 17, 3, -22 },
  { 724, 16, 22, 17, 1, -22 },
  { 768, 15, 22, 17, 1, -22 },
  { 810, 5, 17, 7, 1, -17 },
  { 821, 7, 21, 7, -1, -17 },
  { 840, 15, 15, 18, 2, -19 },
  { 869, 15, 8, 18, 2, -15 },
  { 884, 15, 15, 18, 2, -19 },
  { 913, 12, 22, 13, 2, -22 },
  { 946, 23, 25, 26, 2, -22 },
  { 1018, 18, 22, 17, -2, -22 },
  { 1068, 17, 22, 19, 1, -22 },
  { 1115, 18, 22, 18, 2, -22 },
  { 1165, 19, 22, 21, 1, -22 },
  { 1218, 16, 22, 16, 1, -22 },
  { 1262, 16, 22, 15, 1, -22 },
  { 1306, 19, 22, 21, 2, -22 },
  { 1359, 20, 22, 21, 1, -22 },
  { 1414, 11, 22, 9, 0, -22 },
  { 1445, 13, 28, 8, -5, -22 },
  { 1491, 19, 22, 17, 1, -22 },
  { 1544, 12, 22, 15, 1, -22 },
  { 1577, 25, 22, 26, 1, -22 },
  { 1646, 20, 22, 21, 1, -22 },
  { 1701, 19, 22, 22, 2, -22 },
  { 1754, 16, 22, 17, 1, -22 },
  { 1798, 19, 27, 22, 2, -22 },
  { 1863, 16, 22, 18, 1, -22 },
  { 1907, 15, 22, 16, 1, -22 },
  { 1949, 15, 22, 15, 3, -22 },
  { 1991, 18, 22, 21, 3, -22 },
  { 2041, 16, 22, 17, 3, -22 },
  { 2085, 24, 22, 26, 4, -22 },
  { 2151, 20, 22, 16, -2, -22 },
  { 2206, 15, 22, 15, 3, -22 },
  { 2248, 18, 22, 17, 0, -22 },
  { 2298, 11, 27, 9, 0, -22 },
  { 2336, 5, 22, 10, 3, -22 },
  { 2350, 11, 27, 9, -2, -22 },
  { 2388, 15, 14, 17, 1, -22 },
  { 2415, 12, 2, 12, -3, 3 },
  { 2418, 4, 5, 8, 5, -24 },
  { 2421, 14, 17, 17, 2, -17 },
  { 2451, 15, 24, 18, 1, -24 },
  { 2496, 12, 17, 14, 2, -17 },
  { 2522, 16, 24, 18, 2, -24 },
  { 2570, 12, 17, 15, 2, -17 },
  { 2596, 17, 31, 9, -4, -24 },
  { 2662, 16, 24, 18, 1, -17 },
  { 2710, 15, 24, 18, 1, -24 },
  { 2755, 7, 23, 7, 1, -23 },
  { 2776, 12, 30, 7, -4, -23 },
  { 2821, 15, 24, 14, 1, -24 },
  { 2866, 7, 24, 7, 1, -24 },
  { 2887, 24, 17, 27, 1, -17 },
  { 2938, 15, 17, 18, 1, -17 },
  { 2970, 14, 17, 17, 2, -17 },
  { 3000, 17, 24, 18, -1, -17 },
  { 3051, 15, 24, 18, 2, -17 },
  { 3096, 12, 17, 12, 1, -17 },
  { 3122, 13, 17, 13, 0, -17 },
  { 3150, 9, 20, 10, 2, -20 },
  { 3173, 15, 16, 18, 2, -16 },
  { 3203, 13, 16, 14, 2, -16 },
  { 3229, 20, 16, 21, 2, -16 },
  { 3269, 16, 16, 15, -1, -16 },
  { 3301, 18, 23, 14, -3, -16 },
  { 3353, 14, 16, 14, 0, -16 },
  { 3381, 11, 27, 11, 1, -22 },
  { 3419, 2, 31, 17, 8, -24 },
  { 3427, 11, 27, 11, -1, -22 },
  { 3465, 15, 4, 18, 2, -13 },
};

const GFXfont NotoSans_LightItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_LIGHTITALIC31PT7B_H_
