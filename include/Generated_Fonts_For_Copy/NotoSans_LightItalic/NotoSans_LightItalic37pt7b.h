#ifndef _NOTOSANS_LIGHTITALIC37PT7B_H_
#define _NOTOSANS_LIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C,
  0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0xE0, 0x71, 0xD8, 0x66, 0x19, 0x86, 0x61, 0x10, 0xCC, 0x33,
  0x0C, 0xC2, 0x00, 0x00, 0x30, 0x30, 0x00, 0x60, 0x40, 0x00, 0x81, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x08, 0x08, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x60, 0x1F, 0xFF, 0xFE, 0x41, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x10, 0x10, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0x00, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x18, 0x18, 0x00, 0x20, 0x20,
  0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x02, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x1F, 0xC0, 0x7F, 0xF8, 0x71, 0x8C, 0x70, 0x80, 0x30, 0xC0, 0x18,
  0x60, 0x0C, 0x30, 0x06, 0x10, 0x03, 0x08, 0x00, 0xEC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x9C, 0x00, 0xC7, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x10, 0x60, 0x18, 0x70, 0x0C, 0x31, 0x06, 0x70, 0xFF, 0xF0, 0x3F,
  0xE0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x07, 0x80,
  0x02, 0x0F, 0xC0, 0x0C, 0x18, 0xE0, 0x18, 0x30, 0x60, 0x18, 0x20, 0x60,
  0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x40, 0x60, 0xC0, 0xC0, 0x61,
  0x80, 0xC0, 0x43, 0x00, 0xC0, 0xC3, 0x00, 0xC0, 0xC6, 0x7C, 0xC0, 0x8C,
  0xFE, 0xC1, 0x99, 0xC3, 0x63, 0x19, 0x83, 0x7E, 0x33, 0x03, 0x1C, 0x63,
  0x03, 0x00, 0xC3, 0x03, 0x00, 0xC2, 0x03, 0x01, 0x86, 0x03, 0x03, 0x06,
  0x02, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x06, 0x0C, 0x18, 0x06,
  0x0C, 0x30, 0x03, 0x38, 0x70, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x18,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x03, 0x06, 0x00,
  0x06, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xCC, 0x00, 0x0E, 0x1C, 0x07, 0x38, 0x18, 0x0C, 0xE0, 0x18, 0x31, 0x80,
  0x18, 0x63, 0x00, 0x39, 0x8E, 0x00, 0x36, 0x1C, 0x00, 0x38, 0x18, 0x00,
  0x70, 0x30, 0x03, 0xE0, 0x70, 0x0E, 0x60, 0x7D, 0xF8, 0xE0, 0x7F, 0xC0,
  0xE0, 0x76, 0x66, 0x64, 0xCC, 0xC0, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x30, 0x0E, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x60, 0xC0, 0xF8, 0x80, 0x1C, 0x80, 0x07, 0xFF, 0x01, 0xFF,
  0x06, 0x80, 0x0E, 0xC0, 0x1C, 0x40, 0x38, 0x60, 0x70, 0x60, 0x20, 0x30,
  0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x0E, 0x38, 0x60, 0xC3, 0x06, 0x18, 0x30,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x38, 0x70, 0x18, 0x0E, 0x0E,
  0x01, 0x87, 0x00, 0x61, 0x80, 0x1C, 0xE0, 0x07, 0x30, 0x01, 0xCC, 0x00,
  0x77, 0x00, 0x1D, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x1B,
  0x80, 0x06, 0xE0, 0x03, 0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x1C, 0xE0,
  0x06, 0x38, 0x03, 0x86, 0x00, 0xC1, 0x80, 0x70, 0x70, 0x38, 0x0F, 0xFC,
  0x01, 0xFC, 0x00, 0x03, 0xC1, 0xE1, 0xF8, 0xE6, 0xF1, 0xB0, 0xE0, 0x30,
  0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0x07, 0x01, 0x80, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x78, 0x38,
  0x38, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x43, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x80,
  0x1C, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x18, 0xC0,
  0x03, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x30, 0x18,
  0x07, 0x03, 0x00, 0xE0, 0x30, 0x1C, 0x03, 0x01, 0x80, 0x30, 0x30, 0x07,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x01,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x3F,
  0xE0, 0x0F, 0xFE, 0x00, 0x80, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0x86, 0x00, 0xE0, 0xFD, 0xF8, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0x04, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xCF, 0xF0, 0x77, 0x1E, 0x1B, 0x01, 0xC7, 0x00, 0x31, 0xC0,
  0x0C, 0x60, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x03,
  0x18, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x30, 0x30, 0x1C, 0x0F, 0xBE, 0x00,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xC0, 0x78, 0x78, 0x18, 0x06, 0x0C, 0x01, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x07, 0x0C, 0x01, 0x83, 0x00, 0xE0, 0x60, 0x70, 0x0C,
  0x70, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xF3, 0x80, 0xE0, 0x70, 0x70, 0x0E,
  0x18, 0x01, 0x8C, 0x00, 0x73, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0xCC,
  0x00, 0x63, 0x80, 0x38, 0x70, 0x1C, 0x0F, 0xBE, 0x01, 0xFF, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0x01, 0xC1, 0xC1, 0x80, 0x61, 0x80, 0x18, 0xC0, 0x0C,
  0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0x66, 0x00,
  0x73, 0x00, 0x39, 0x80, 0x3C, 0x60, 0x7E, 0x3F, 0xF6, 0x07, 0xE3, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x0C, 0x3C, 0x70,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC3, 0x87, 0x00, 0x01, 0x80, 0xF0, 0x38, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x07, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x07,
  0x81, 0xFF, 0x1C, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xF3, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x21, 0x80, 0x7E, 0x03, 0x30,
  0x1F, 0xF8, 0x33, 0x03, 0x81, 0x83, 0x60, 0x60, 0x30, 0x36, 0x0E, 0x03,
  0x03, 0x40, 0xC0, 0x30, 0x3C, 0x08, 0x03, 0x03, 0xC1, 0x80, 0x60, 0x3C,
  0x18, 0x06, 0x02, 0xC1, 0x80, 0x60, 0x6C, 0x18, 0x0E, 0x06, 0xC1, 0x81,
  0xE0, 0xCC, 0x1C, 0x36, 0x18, 0xC0, 0xFE, 0x7F, 0x06, 0x07, 0xC3, 0xE0,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x07, 0x18, 0x00, 0x30,
  0xC0, 0x03, 0x86, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x30, 0x03,
  0x83, 0x80, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xC0,
  0x00, 0xCE, 0x00, 0x06, 0x60, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x07, 0xFF,
  0x80, 0x60, 0xFC, 0x06, 0x00, 0xE0, 0xE0, 0x06, 0x0C, 0x00, 0x70, 0xC0,
  0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x0C, 0x18,
  0x03, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0x80, 0x70, 0x30, 0x03, 0x83,
  0x00, 0x18, 0x30, 0x01, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x1C,
  0x60, 0x01, 0x86, 0x00, 0x38, 0xE0, 0x07, 0x0C, 0x00, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x01, 0xE0, 0x70, 0x78,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x01, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x18, 0x7F, 0x00, 0x60, 0x1E, 0x03, 0x80, 0x1C, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xE0, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x1C, 0x00, 0x18,
  0x60, 0x00, 0x71, 0x80, 0x01, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x31, 0xC0, 0x00,
  0xC6, 0x00, 0x07, 0x18, 0x00, 0x38, 0x60, 0x01, 0xC1, 0x80, 0x0E, 0x0E,
  0x00, 0x70, 0x30, 0x0F, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x1E, 0x07, 0x81,
  0xE0, 0x02, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x01, 0xFF, 0x30, 0x00, 0x1C, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xE0, 0x00,
  0xE1, 0x80, 0x03, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x3C, 0x01, 0xC0,
  0x7F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x38, 0x70, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83,
  0x00, 0x03, 0x06, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x70, 0xE0, 0x00, 0xC1, 0x80, 0x01,
  0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x30,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x80, 0x07, 0xF8, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x7D, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x8F, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x06, 0x00,
  0x3C, 0x18, 0x01, 0xC0, 0x60, 0x0E, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x00,
  0x30, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x63,
  0x80, 0x01, 0x9C, 0x00, 0x06, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xF3, 0x80,
  0x03, 0x86, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x30, 0x01, 0xC0, 0xE0, 0x06,
  0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00,
  0xE0, 0x30, 0x01, 0x80, 0xC0, 0x07, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xF0, 0xD8, 0x00, 0x1B, 0x0D, 0x80, 0x03, 0x60, 0xD8,
  0x00, 0x36, 0x0D, 0x80, 0x06, 0x60, 0xC8, 0x00, 0x66, 0x18, 0xC0, 0x0C,
  0xE1, 0x8C, 0x01, 0xCC, 0x18, 0xC0, 0x18, 0xC1, 0x8C, 0x03, 0x0C, 0x18,
  0xC0, 0x30, 0xC3, 0x0C, 0x06, 0x1C, 0x30, 0x60, 0x61, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x61, 0xC1, 0x87, 0x06, 0x18, 0x18, 0x60, 0x63, 0x03, 0x86,
  0x06, 0x30, 0x30, 0x60, 0x26, 0x03, 0x06, 0x03, 0x60, 0x30, 0xC0, 0x3C,
  0x07, 0x0C, 0x03, 0x80, 0x60, 0xC0, 0x38, 0x06, 0x0C, 0x03, 0x00, 0x60,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x06, 0x07, 0x80, 0x06, 0x0D, 0x80, 0x06,
  0x0D, 0x80, 0x0E, 0x0C, 0xC0, 0x0C, 0x0C, 0xC0, 0x0C, 0x0C, 0xE0, 0x0C,
  0x18, 0x60, 0x0C, 0x18, 0x60, 0x18, 0x18, 0x30, 0x18, 0x18, 0x30, 0x18,
  0x18, 0x38, 0x18, 0x30, 0x18, 0x18, 0x30, 0x18, 0x30, 0x30, 0x0C, 0x30,
  0x30, 0x0C, 0x30, 0x70, 0x0E, 0x30, 0x60, 0x06, 0x70, 0x60, 0x06, 0x60,
  0x60, 0x03, 0x60, 0x60, 0x03, 0x60, 0xC0, 0x03, 0xE0, 0xC0, 0x01, 0xE0,
  0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00,
  0x3C, 0x1E, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x38, 0x70, 0x00, 0x63, 0x80,
  0x01, 0xCC, 0x00, 0x03, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x6C, 0x00, 0x03, 0xB0, 0x00,
  0x0C, 0xE0, 0x00, 0x71, 0x80, 0x01, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x70,
  0x3C, 0x07, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0xC3, 0xF0, 0x18, 0x07, 0x07, 0x00, 0x60, 0xC0, 0x0E, 0x18, 0x00, 0xC3,
  0x00, 0x18, 0x60, 0x03, 0x1C, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x07, 0x0C,
  0x00, 0xC1, 0x80, 0x70, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3C, 0x1E, 0x01, 0xC0, 0x1C, 0x0E, 0x00,
  0x38, 0x70, 0x00, 0x63, 0x80, 0x01, 0xCC, 0x00, 0x03, 0x70, 0x00, 0x0D,
  0x80, 0x00, 0x36, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x6C, 0x00, 0x03, 0xB0, 0x00, 0x0C, 0xE0, 0x00, 0x31, 0x80, 0x01, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x70, 0x3C, 0x07, 0x80, 0x7F, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x80, 0x07, 0xFF, 0x00, 0xC3, 0xF0, 0x18,
  0x07, 0x07, 0x00, 0x60, 0xC0, 0x0E, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60,
  0x03, 0x1C, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x07, 0x0C, 0x01, 0xC1, 0x81,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0x81, 0x80, 0x30, 0x18, 0x0E, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x1C, 0x38, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x07, 0x18, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x7F,
  0xF0, 0x78, 0x3C, 0x38, 0x01, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x80, 0x3C, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x0E, 0x18, 0x00, 0x18, 0x70, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80,
  0x01, 0xC3, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x38, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x86, 0x00, 0x03,
  0x0C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0xE0, 0x00, 0x61,
  0x80, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x1C,
  0x00, 0x30, 0x18, 0x00, 0xE0, 0x38, 0x07, 0x80, 0x3F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x07, 0x60, 0x00, 0xCC,
  0x00, 0x39, 0x80, 0x06, 0x38, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0C, 0x0C,
  0x01, 0x81, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0xE0, 0x18,
  0x18, 0x01, 0x87, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x00, 0xC6, 0x00, 0x19,
  0x80, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x6C,
  0x00, 0x50, 0x03, 0xB8, 0x03, 0x40, 0x0C, 0x60, 0x0D, 0x00, 0x71, 0x80,
  0x66, 0x01, 0x86, 0x01, 0x98, 0x06, 0x18, 0x0C, 0x60, 0x30, 0x60, 0x31,
  0x80, 0xC1, 0x81, 0x86, 0x06, 0x06, 0x06, 0x18, 0x18, 0x18, 0x30, 0x60,
  0xE0, 0x60, 0xC1, 0x83, 0x01, 0x87, 0x06, 0x1C, 0x06, 0x18, 0x18, 0x60,
  0x18, 0xE0, 0x61, 0x80, 0x63, 0x01, 0x8C, 0x01, 0x8C, 0x06, 0x30, 0x06,
  0x60, 0x19, 0x80, 0x19, 0x80, 0x66, 0x00, 0x6C, 0x00, 0xB0, 0x01, 0xB0,
  0x02, 0xC0, 0x07, 0x80, 0x0B, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x80, 0x07, 0x01, 0x80, 0x0C,
  0x01, 0xC0, 0x18, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x33, 0x80, 0x00, 0x37, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x03, 0x00, 0x07, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0xEC, 0x00, 0x31, 0x80, 0x0E, 0x18, 0x01, 0x83, 0x00, 0x60,
  0x60, 0x1C, 0x0E, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x38, 0x03, 0x06, 0x00,
  0x31, 0x80, 0x06, 0x60, 0x00, 0xDC, 0x00, 0x1B, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0xC3, 0x0C, 0x30, 0x61, 0x86,
  0x18, 0x61, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x18, 0x61, 0x86, 0x18, 0x60,
  0xC3, 0x0C, 0x30, 0x01, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x07, 0xF0, 0x3F, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x19, 0x00, 0x18, 0xC0,
  0x0C, 0x60, 0x0C, 0x10, 0x06, 0x0C, 0x06, 0x02, 0x06, 0x01, 0x83, 0x00,
  0xC3, 0x00, 0x21, 0x80, 0x19, 0x80, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0xFF, 0xFC, 0xE1, 0x83, 0x06, 0x18, 0x30, 0x01, 0xF0, 0xC1, 0xFE, 0x20,
  0xE0, 0xD8, 0x70, 0x1E, 0x38, 0x03, 0x8C, 0x00, 0xE7, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x70, 0xE0, 0x3C, 0x18, 0x1B, 0x07,
  0xFC, 0xC0, 0xFC, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x3E,
  0x03, 0x3F, 0xE0, 0xD8, 0x38, 0x3C, 0x07, 0x1A, 0x00, 0xC7, 0x00, 0x31,
  0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x07, 0x30, 0x01, 0x9C, 0x00, 0x67, 0x00, 0x39, 0xC0, 0x0C, 0x70, 0x06,
  0x1E, 0x03, 0x8C, 0xF7, 0xC3, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xFC, 0x38,
  0x08, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x20, 0xFB, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0xF0, 0xC0, 0x7F, 0xCC, 0x0E, 0x0D,
  0xC1, 0xC0, 0x78, 0x38, 0x03, 0x83, 0x00, 0x38, 0x70, 0x03, 0x86, 0x00,
  0x38, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0,
  0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0E, 0x0C, 0x01, 0xE0, 0xE0, 0x36, 0x06,
  0x06, 0xC0, 0x7F, 0xCC, 0x03, 0xF8, 0xC0, 0x01, 0xF8, 0x0F, 0xF8, 0x38,
  0x38, 0xE0, 0x33, 0x80, 0x66, 0x00, 0xDC, 0x03, 0xB0, 0x0E, 0x60, 0x79,
  0xFF, 0xE3, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x10, 0xFB, 0xE0, 0xFF, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x60, 0x7F, 0xCC, 0x1C, 0x19, 0x87, 0x01, 0xE1, 0xC0, 0x1C, 0x30,
  0x03, 0x8E, 0x00, 0x71, 0x80, 0x0C, 0x70, 0x01, 0x8C, 0x00, 0x31, 0x80,
  0x06, 0x30, 0x01, 0xC6, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x01, 0xC3, 0x00,
  0x78, 0x70, 0x1B, 0x06, 0x06, 0xC0, 0xFF, 0x98, 0x0F, 0xE3, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x03, 0x01, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x3E, 0x03, 0x3F, 0xE0, 0xDC, 0x18, 0x3C, 0x07, 0x1A,
  0x00, 0xC7, 0x00, 0x31, 0xC0, 0x0C, 0x60, 0x07, 0x18, 0x01, 0x8E, 0x00,
  0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x0C, 0x60, 0x07, 0x18, 0x01, 0x8E, 0x00, 0x63, 0x00, 0x18, 0x03,
  0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60,
  0xE0, 0xC0, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x0F, 0xC0, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x01, 0xC3, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x1C, 0x18, 0x06, 0x0C,
  0x01, 0x86, 0x00, 0x63, 0x00, 0x19, 0x80, 0x0C, 0xE0, 0x03, 0x7C, 0x00,
  0xF3, 0x00, 0x30, 0xE0, 0x1C, 0x18, 0x06, 0x07, 0x01, 0x80, 0xC0, 0x60,
  0x38, 0x18, 0x06, 0x0E, 0x01, 0x83, 0x00, 0x30, 0x03, 0x03, 0x07, 0x06,
  0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18,
  0x18, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0,
  0x0C, 0x3E, 0x07, 0xC0, 0x67, 0xF8, 0x7F, 0x83, 0x60, 0xC6, 0x0C, 0x1E,
  0x07, 0x60, 0x71, 0xA0, 0x1E, 0x03, 0x8E, 0x00, 0xE0, 0x1C, 0x70, 0x06,
  0x00, 0xE3, 0x00, 0x70, 0x06, 0x18, 0x03, 0x00, 0x31, 0xC0, 0x18, 0x01,
  0x8C, 0x00, 0xC0, 0x0C, 0x60, 0x06, 0x00, 0xC3, 0x00, 0x70, 0x06, 0x38,
  0x03, 0x00, 0x31, 0x80, 0x18, 0x01, 0x8C, 0x00, 0xC0, 0x1C, 0x60, 0x06,
  0x00, 0xC3, 0x00, 0x60, 0x06, 0x38, 0x03, 0x00, 0x31, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x3F, 0x03, 0x3F, 0xE0, 0xDC, 0x18, 0x3C, 0x07, 0x1A, 0x00,
  0xC7, 0x00, 0x31, 0xC0, 0x1C, 0x60, 0x07, 0x38, 0x01, 0x8E, 0x00, 0x63,
  0x00, 0x18, 0xC0, 0x0E, 0x30, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x07, 0x18, 0x01, 0x8E, 0x00, 0x63, 0x00, 0x18, 0x01, 0xF8,
  0x03, 0xFF, 0x03, 0x81, 0xC3, 0x80, 0x63, 0x80, 0x39, 0x80, 0x0D, 0x80,
  0x06, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x36, 0x00, 0x1B, 0x00, 0x19, 0xC0, 0x0C, 0x60, 0x0C, 0x38, 0x0E,
  0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0x0F, 0x80, 0x33, 0xFE, 0x03, 0x60,
  0xE0, 0x3C, 0x07, 0x06, 0x80, 0x30, 0x70, 0x03, 0x07, 0x00, 0x30, 0x60,
  0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C,
  0x00, 0x61, 0xC0, 0x06, 0x1C, 0x00, 0xE1, 0xC0, 0x0C, 0x1C, 0x01, 0xC1,
  0xE0, 0x38, 0x3B, 0xDF, 0x03, 0x1F, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0xC1, 0xFF, 0x30, 0xE0,
  0xCC, 0x70, 0x1E, 0x38, 0x03, 0x8C, 0x00, 0xE7, 0x00, 0x39, 0x80, 0x0C,
  0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x06, 0x30,
  0x03, 0x8C, 0x00, 0xE3, 0x00, 0x78, 0xE0, 0x36, 0x18, 0x1B, 0x07, 0xFC,
  0xC0, 0xFE, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x3C, 0x33, 0xF0, 0xDC, 0x03, 0xC0, 0x1A, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0x03,
  0xF8, 0x1F, 0xFC, 0x70, 0x18, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x19, 0x00, 0x63, 0xEF, 0xC3, 0xFE,
  0x00, 0x04, 0x01, 0x80, 0x30, 0x0E, 0x03, 0xFF, 0xFF, 0xC6, 0x00, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3D, 0x83, 0xF0, 0x18, 0x00,
  0xC6, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x31, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x71, 0x80,
  0x18, 0xE0, 0x06, 0x30, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x78, 0xC0, 0x3C,
  0x38, 0x1B, 0x07, 0xBC, 0xC0, 0xFC, 0x30, 0xC0, 0x03, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x0C, 0xC0, 0x1C, 0x60, 0x18, 0x60, 0x38, 0x60, 0x30, 0x60,
  0x60, 0x60, 0x60, 0x60, 0xC0, 0x61, 0xC0, 0x71, 0x80, 0x33, 0x80, 0x33,
  0x00, 0x37, 0x00, 0x36, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xC0,
  0x18, 0x03, 0xE0, 0x0C, 0x01, 0xB0, 0x0F, 0x01, 0xD8, 0x05, 0x80, 0xCC,
  0x06, 0xC0, 0xE6, 0x03, 0x60, 0x63, 0x03, 0x30, 0x31, 0x81, 0x98, 0x30,
  0xE1, 0x8C, 0x18, 0x30, 0xC6, 0x18, 0x18, 0xC3, 0x0C, 0x0C, 0x61, 0x8C,
  0x06, 0x60, 0xC6, 0x03, 0x30, 0x27, 0x01, 0xB0, 0x13, 0x00, 0xD8, 0x0D,
  0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0xE0, 0xC0, 0x18, 0x18, 0x06, 0x01, 0x81, 0x80,
  0x30, 0x60, 0x07, 0x1C, 0x00, 0x67, 0x00, 0x0C, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x33, 0x00, 0x0E, 0x60, 0x03,
  0x86, 0x00, 0x60, 0xC0, 0x18, 0x0C, 0x06, 0x01, 0x81, 0x80, 0x18, 0x70,
  0x03, 0x00, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0,
  0x0C, 0x03, 0x80, 0x70, 0x06, 0x01, 0x80, 0x18, 0x0E, 0x00, 0x60, 0x30,
  0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0x60, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1F, 0xFF, 0x1F, 0xFF, 0x80, 0x00, 0x78, 0x07, 0x80, 0x70, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xF8, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x0F, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x7C, 0x03, 0x80, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x70, 0x0F,
  0x80, 0x38, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0xE0, 0x7F, 0xD0, 0x07, 0xC0,
};

const GFXglyph NotoSans_LightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 26, 9, 1, -26 },
  { 27, 10, 9, 13, 4, -26 },
  { 39, 23, 26, 23, 1, -26 },
  { 114, 17, 30, 20, 2, -28 },
  { 178, 24, 27, 29, 3, -27 },
  { 259, 23, 27, 25, 1, -27 },
  { 337, 4, 9, 7, 4, -26 },
  { 342, 12, 32, 10, 1, -26 },
  { 390, 12, 32, 10, -3, -26 },
  { 438, 16, 16, 20, 4, -28 },
  { 470, 17, 18, 21, 3, -22 },
  { 509, 7, 9, 8, -2, -4 },
  { 517, 9, 2, 12, 1, -11 },
  { 520, 3, 3, 9, 1, -3 },
  { 522, 17, 26, 12, -2, -26 },
  { 578, 18, 27, 20, 2, -27 },
  { 639, 10, 26, 20, 6, -26 },
  { 672, 19, 27, 20, 0, -27 },
  { 737, 18, 27, 20, 1, -27 },
  { 798, 20, 26, 20, 0, -26 },
  { 863, 19, 26, 20, 1, -26 },
  { 925, 18, 27, 20, 2, -27 },
  { 986, 17, 26, 20, 4, -26 },
  { 1042, 18, 27, 20, 2, -27 },
  { 1103, 17, 27, 20, 2, -27 },
  { 1161, 7, 20, 9, 1, -20 },
  { 1179, 10, 25, 9, -2, -20 },
  { 1211, 17, 17, 21, 3, -22 },
  { 1248, 17, 10, 21, 3, -18 },
  { 1270, 17, 17, 21, 3, -22 },
  { 1307, 13, 27, 15, 3, -27 },
  { 1351, 28, 29, 31, 2, -26 },
  { 1453, 21, 26, 21, -2, -26 },
  { 1522, 20, 26, 22, 2, -26 },
  { 1587, 20, 27, 22, 3, -27 },
  { 1655, 22, 26, 25, 2, -26 },
  { 1727, 19, 26, 19, 2, -26 },
  { 1789, 19, 26, 18, 2, -26 },
  { 1851, 22, 27, 25, 3, -27 },
  { 1926, 23, 26, 25, 2, -26 },
  { 2001, 13, 26, 11, 0, -26 },
  { 2044, 16, 33, 9, -6, -26 },
  { 2110, 22, 26, 20, 2, -26 },
  { 2182, 13, 26, 18, 2, -26 },
  { 2225, 28, 26, 30, 2, -26 },
  { 2316, 24, 26, 26, 2, -26 },
  { 2394, 22, 27, 27, 3, -27 },
  { 2469, 19, 26, 21, 2, -26 },
  { 2531, 22, 33, 27, 3, -27 },
  { 2622, 19, 26, 21, 2, -26 },
  { 2684, 18, 27, 19, 1, -27 },
  { 2745, 19, 26, 18, 3, -26 },
  { 2807, 23, 26, 25, 3, -26 },
  { 2882, 19, 26, 20, 4, -26 },
  { 2944, 30, 26, 31, 4, -26 },
  { 3042, 24, 26, 19, -2, -26 },
  { 3120, 19, 26, 18, 3, -26 },
  { 3182, 21, 26, 20, 0, -26 },
  { 3251, 14, 32, 11, 0, -26 },
  { 3307, 6, 26, 12, 4, -26 },
  { 3327, 14, 32, 11, -3, -26 },
  { 3383, 17, 17, 21, 2, -27 },
  { 3420, 14, 1, 14, -3, 4 },
  { 3422, 6, 6, 9, 5, -28 },
  { 3427, 18, 20, 21, 2, -20 },
  { 3472, 18, 28, 21, 1, -28 },
  { 3535, 15, 20, 17, 2, -20 },
  { 3573, 20, 28, 21, 2, -28 },
  { 3643, 15, 20, 18, 2, -20 },
  { 3681, 21, 37, 11, -5, -28 },
  { 3779, 19, 29, 21, 1, -20 },
  { 3848, 18, 28, 21, 1, -28 },
  { 3911, 8, 27, 9, 1, -27 },
  { 3938, 14, 36, 9, -5, -27 },
  { 4001, 18, 28, 17, 1, -28 },
  { 4064, 8, 28, 9, 1, -28 },
  { 4092, 29, 20, 32, 1, -20 },
  { 4165, 18, 20, 21, 1, -20 },
  { 4210, 17, 20, 21, 2, -20 },
  { 4253, 20, 29, 21, -1, -20 },
  { 4326, 18, 29, 21, 2, -20 },
  { 4392, 14, 20, 14, 1, -20 },
  { 4427, 15, 20, 16, 0, -20 },
  { 4465, 11, 24, 12, 2, -24 },
  { 4498, 18, 20, 21, 2, -20 },
  { 4543, 16, 20, 16, 2, -20 },
  { 4583, 25, 20, 25, 2, -20 },
  { 4646, 19, 20, 17, -1, -20 },
  { 4694, 22, 29, 16, -4, -20 },
  { 4774, 17, 20, 16, -1, -20 },
  { 4817, 13, 32, 13, 1, -26 },
  { 4869, 2, 37, 20, 10, -28 },
  { 4879, 14, 32, 13, -2, -26 },
  { 4935, 17, 4, 21, 3, -15 },
};

const GFXfont NotoSans_LightItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_LIGHTITALIC37PT7B_H_
