#ifndef _NOTOSANS_LIGHTITALIC72PT7B_H_
#define _NOTOSANS_LIGHTITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x1E, 0x03, 0xE3,
  0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F,
  0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x3C, 0x38,
  0x07, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0x70, 0xE0,
  0x1C, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0xF1, 0xFC, 0x01, 0xF8, 0x38, 0x06,
  0x00, 0xF8, 0x0E, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x3F, 0x9C, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xE3, 0xF0, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x00, 0x1C,
  0x0F, 0x80, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x1C, 0x03, 0xE0, 0x00, 0x07, 0x00, 0xF0, 0x20, 0x01, 0xC0, 0xFC,
  0x0F, 0x00, 0x70, 0x7E, 0x03, 0xFC, 0x3D, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0x80, 0x1F, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x07,
  0x80, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x3C, 0x0F, 0x07, 0xFC, 0x3C, 0x00, 0x78, 0x3C, 0x1F, 0xFC, 0x78,
  0x00, 0xE0, 0xF0, 0x7F, 0xFC, 0xF0, 0x03, 0xC1, 0xE1, 0xF0, 0x7D, 0xE0,
  0x0F, 0x07, 0x87, 0x80, 0x7B, 0xC0, 0x1E, 0x1E, 0x1F, 0x00, 0x73, 0xC0,
  0x78, 0x38, 0x3C, 0x00, 0xF7, 0xE3, 0xE0, 0xF0, 0xF0, 0x01, 0xE7, 0xFF,
  0x83, 0xC1, 0xE0, 0x03, 0xC7, 0xFE, 0x0F, 0x03, 0x80, 0x07, 0x87, 0xF0,
  0x1C, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x38, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x70, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0,
  0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x1E,
  0x00, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x3E, 0x00,
  0x07, 0xC3, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xC0, 0x07, 0x87, 0x80, 0x00, 0x7C, 0x01, 0xF1, 0xE0,
  0x00, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x0F, 0x80, 0x00,
  0x0F, 0x83, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x3C, 0x00, 0x00, 0x1F,
  0x1E, 0x07, 0x80, 0x00, 0x01, 0xF7, 0x80, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x1E, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x7E, 0x7C, 0x01, 0xF8, 0x00, 0x3F,
  0x87, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x78, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x80,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x8F, 0x1C,
  0x38, 0xF1, 0xE3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x40,
  0x00, 0xE0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0xFE,
  0x01, 0xC0, 0x00, 0x7F, 0x81, 0xC0, 0x00, 0x1F, 0xE1, 0xC0, 0x00, 0x03,
  0xF9, 0x80, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0C,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFE, 0x7D, 0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00,
  0x78, 0xF8, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0xFD, 0xE0, 0x1F, 0xBC, 0x07, 0xF3, 0xC0, 0xFC, 0x3C, 0x3F, 0x83,
  0xCF, 0xE0, 0x7C, 0x7C, 0x07, 0x87, 0x00, 0x78, 0x20, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x06, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xCF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x08, 0x00, 0x00,
  0x3E, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x3F, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x0F, 0x03,
  0xFF, 0xE0, 0x03, 0xC3, 0xFF, 0xFE, 0x00, 0xF1, 0xFF, 0xFF, 0xC0, 0x7D,
  0xF0, 0x03, 0xF0, 0x1E, 0xF8, 0x00, 0x3E, 0x07, 0xB8, 0x00, 0x07, 0xC1,
  0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xE8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x1F,
  0xC0, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xE0,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0xF0,
  0x00, 0x07, 0xF8, 0x1F, 0x00, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0xFB, 0xC0,
  0x3F, 0x80, 0x7E, 0x78, 0x03, 0xFF, 0xFF, 0x9F, 0x00, 0x1F, 0xFF, 0xC3,
  0xC0, 0x01, 0xFF, 0xE0, 0x78, 0x00, 0x01, 0x80, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xEF, 0xF8, 0x1E, 0x00, 0x3F, 0x06, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x1C, 0x1E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x38, 0x78, 0x00,
  0x3F, 0x00, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF3,
  0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x80, 0x01, 0xC0,
  0x03, 0xCE, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0xBC, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x0F, 0x78, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x1E, 0xE0, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x39, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x77,
  0x80, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xEF, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x03, 0xDE, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0xBC, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x0E, 0x78, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x79, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE3,
  0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xC7, 0x80, 0x3C, 0x00, 0x1F, 0x80,
  0x0F, 0x0F, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x00,
  0xEE, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x03, 0x9E, 0x03, 0xE0, 0x78, 0x00,
  0xF8, 0x1E, 0x3E, 0x0F, 0x80, 0x70, 0x01, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x7E, 0x00,
  0x3C, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F,
  0xE0, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x00, 0x0C, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x0C, 0x00, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x03,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x1E, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x00, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x08, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0xFF, 0xE3, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x3F, 0x00, 0x00,
  0x01, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x04, 0x01, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x7E,
  0x00, 0x00, 0x00, 0x1E, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xC7, 0xE0, 0x00,
  0x00, 0x00, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xDF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xCF, 0x00, 0x00, 0x00, 0x1F,
  0xF1, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x79, 0xC0, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xE0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0,
  0xF8, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0x70, 0x00, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x81, 0xE0,
  0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x1F,
  0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0x80, 0x38, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x03,
  0xC0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x78,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x0E, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0xF0, 0x01, 0xE7, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0x87, 0x80,
  0x00, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x01,
  0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x07,
  0x80, 0x00, 0x07, 0x87, 0x80, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0x80,
  0x0F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0x06, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x1E,
  0x7C, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x1E,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x07, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0xC0, 0x70, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x70, 0x03, 0xFF, 0xF8, 0x3C, 0x01, 0xFF, 0xFF, 0x0F, 0x00, 0xFC,
  0x01, 0xE3, 0x80, 0x7E, 0x00, 0x3C, 0xE0, 0x3E, 0x00, 0x07, 0x78, 0x1F,
  0x00, 0x00, 0xDE, 0x0F, 0x80, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x00, 0xFC,
  0x0F, 0x00, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x3B, 0xC0, 0xF8, 0x00, 0x1C,
  0xE0, 0x1F, 0x00, 0x0F, 0x38, 0x07, 0xC0, 0x07, 0x8E, 0x00, 0xFC, 0x07,
  0xC7, 0x80, 0x1F, 0xFF, 0xC1, 0xE0, 0x03, 0xFF, 0xE0, 0x70, 0x00, 0x7F,
  0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xF0, 0x00,
  0x0F, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x7F, 0xFF, 0x00, 0x0F, 0x0F, 0xFF,
  0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x80, 0x1E, 0x78, 0x00, 0x7C, 0x01, 0xE7,
  0x00, 0x03, 0xC0, 0x1E, 0xE0, 0x00, 0x3E, 0x01, 0xDC, 0x00, 0x01, 0xE0,
  0x3F, 0x80, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3B, 0x80, 0x00, 0x7C, 0x07,
  0xBC, 0x00, 0x1F, 0x80, 0x79, 0xE0, 0x03, 0xF0, 0x07, 0x0F, 0x00, 0xFE,
  0x00, 0x70, 0xFF, 0xFF, 0xC0, 0x0F, 0x07, 0xFF, 0xF0, 0x00, 0xF0, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0,
  0x03, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x80, 0x3F, 0x80, 0x3C, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xFE, 0x01, 0xE0, 0x00, 0x3F, 0xFE, 0x07, 0x80, 0x03, 0xFF,
  0xFC, 0x3E, 0x00, 0x1F, 0xFF, 0xF8, 0xF0, 0x00, 0xFC, 0x00, 0xF3, 0xC0,
  0x07, 0xE0, 0x01, 0xCF, 0x00, 0x3E, 0x00, 0x03, 0xBC, 0x01, 0xF0, 0x00,
  0x0E, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0x00,
  0x00, 0x77, 0x80, 0x3E, 0x00, 0x01, 0xDC, 0x00, 0xF8, 0x00, 0x0E, 0xF0,
  0x01, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0xC0,
  0x7C, 0x3C, 0x00, 0x1F, 0xFF, 0xE0, 0xE0, 0x00, 0x3F, 0xFF, 0x03, 0x80,
  0x00, 0x7F, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xE0, 0x1F, 0x00, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0,
  0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0x78, 0x00, 0x3F, 0xC3,
  0xC0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x9E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x01, 0xC0, 0x03, 0xFF, 0xFC,
  0x1E, 0x00, 0x3F, 0xFF, 0xF0, 0xE0, 0x03, 0xF0, 0x03, 0xC7, 0x00, 0x3F,
  0x00, 0x0E, 0x78, 0x03, 0xE0, 0x00, 0x3B, 0xC0, 0x3E, 0x00, 0x00, 0xDE,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0x07, 0x78, 0x07, 0xC0,
  0x00, 0x7B, 0x80, 0x3E, 0x00, 0x07, 0xBC, 0x00, 0xF8, 0x00, 0x79, 0xE0,
  0x07, 0xC0, 0x07, 0x8F, 0x00, 0x1F, 0x80, 0xF8, 0x78, 0x00, 0x7F, 0xFF,
  0x87, 0x80, 0x01, 0xFF, 0xF8, 0x3C, 0x00, 0x07, 0xFF, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xF8, 0x00, 0x1E, 0x03, 0xFF,
  0xC0, 0x03, 0xC1, 0xFF, 0xFC, 0x00, 0x78, 0x7F, 0xFF, 0xC0, 0x1E, 0x3F,
  0x00, 0xFC, 0x03, 0xCF, 0x80, 0x0F, 0x80, 0x79, 0xC0, 0x00, 0xF0, 0x0F,
  0x70, 0x00, 0x1E, 0x01, 0xDC, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x0C, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0xF1, 0xFC, 0x00, 0x00, 0x3C, 0xFF,
  0x00, 0x00, 0x0F, 0x7B, 0xE0, 0x00, 0x03, 0xFC, 0x78, 0x00, 0x00, 0xFE,
  0x1F, 0x00, 0x00, 0x7F, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xE1,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xE3, 0xE0, 0x3F, 0x07, 0x80, 0x7E,
  0x01, 0xE7, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x01, 0xEF, 0x00, 0x0F, 0x1C,
  0x00, 0x1E, 0x01, 0xEE, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x01, 0xDC, 0x00,
  0x07, 0x70, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x1E, 0x07, 0xFF, 0xC0, 0x03, 0xC1, 0xFF, 0xFC, 0x00,
  0x70, 0xFF, 0xFF, 0xC0, 0x1E, 0x3F, 0x00, 0xFC, 0x03, 0xCF, 0x80, 0x0F,
  0x80, 0x7B, 0xC0, 0x00, 0xF0, 0x0F, 0x70, 0x00, 0x1F, 0x01, 0xFC, 0x00,
  0x03, 0xE0, 0x7F, 0x00, 0x00, 0x7C, 0x0F, 0xE0, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3C, 0x0F, 0xC0, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3D, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3C, 0x07, 0xFF, 0x00, 0x00, 0x70, 0x3F, 0xFF,
  0x80, 0x00, 0xE0, 0xFF, 0xFF, 0x80, 0x03, 0xC7, 0xC0, 0x1F, 0x00, 0x07,
  0x9F, 0x00, 0x1F, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x00, 0x1E, 0xE0, 0x00,
  0x3E, 0x00, 0x3B, 0x80, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x01,
  0xF8, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0x70,
  0x00, 0x0F, 0x80, 0x1E, 0xF0, 0x00, 0x7E, 0x00, 0x3C, 0xF0, 0x01, 0xF8,
  0x00, 0x78, 0xF0, 0x0F, 0xE0, 0x00, 0xF1, 0xFF, 0xFF, 0x80, 0x01, 0xE1,
  0xFF, 0xFE, 0x00, 0x07, 0x80, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0x07, 0x80, 0x3F, 0xFF, 0xF0,
  0xE0, 0x0F, 0xC0, 0x1F, 0x1C, 0x03, 0xF0, 0x00, 0xE7, 0x80, 0xF8, 0x00,
  0x0E, 0xF0, 0x3E, 0x00, 0x01, 0xDE, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x1F, 0x81, 0xE0, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x01, 0xDE, 0x07, 0xC0,
  0x00, 0x7B, 0x80, 0xF8, 0x00, 0x1E, 0xF0, 0x0F, 0x80, 0x07, 0x9E, 0x01,
  0xF0, 0x01, 0xE3, 0xC0, 0x1F, 0x80, 0xF8, 0x78, 0x01, 0xFF, 0xFE, 0x1E,
  0x00, 0x1F, 0xFF, 0x83, 0xC0, 0x01, 0xFF, 0xC0, 0x78, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x0F, 0x03, 0xFE, 0x00, 0xE0, 0xFF, 0xE0, 0x0E,
  0x1F, 0xFE, 0x01, 0xE3, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0xE0, 0x7E,
  0x00, 0x02, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x08, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x08, 0x07, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x1F, 0x83, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xF0, 0x3C, 0x00,
  0x01, 0xFC, 0x0F, 0x00, 0x00, 0xEF, 0x03, 0xE0, 0x00, 0x7B, 0xC0, 0xF8,
  0x00, 0x3C, 0xE0, 0x1F, 0x00, 0x3E, 0x38, 0x07, 0xE0, 0x3F, 0x1E, 0x00,
  0xFF, 0xFF, 0x87, 0x80, 0x1F, 0xFF, 0x81, 0xE0, 0x03, 0xFF, 0x80, 0x70,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0,
  0x1E, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3D,
  0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x79,
  0xE0, 0x01, 0xF0, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF1,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xE1,
  0xE0, 0x03, 0xC0, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xC1,
  0xE0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0xE0, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0xE0, 0x1F, 0x00, 0x78, 0x0F, 0x00,
  0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0x79, 0xE0, 0x00,
  0x73, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x80, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x80,
  0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x02, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x4F,
  0xFF, 0xE0, 0x00, 0x37, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x01, 0xFF, 0xFF, 0xB0, 0x00, 0x1F, 0xFF, 0xC8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0x00,
};

const GFXglyph NotoSans_LightItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 16, 52, 17, 2, -51 },
  { 105, 19, 18, 25, 8, -51 },
  { 148, 44, 51, 45, 2, -51 },
  { 429, 34, 59, 40, 3, -55 },
  { 680, 47, 53, 56, 6, -52 },
  { 992, 43, 53, 49, 3, -52 },
  { 1277, 7, 18, 14, 8, -51 },
  { 1293, 21, 62, 19, 3, -51 },
  { 1456, 22, 62, 19, -5, -51 },
  { 1627, 32, 32, 39, 8, -55 },
  { 1755, 34, 34, 41, 5, -42 },
  { 1900, 12, 17, 16, -3, -8 },
  { 1926, 18, 4, 23, 2, -21 },
  { 1935, 6, 7, 17, 2, -6 },
  { 1941, 33, 51, 24, -3, -51 },
  { 2152, 34, 53, 40, 4, -52 },
  { 2378, 20, 51, 40, 11, -51 },
  { 2506, 37, 52, 40, 0, -52 },
  { 2747, 36, 53, 40, 2, -52 },
  { 2986, 37, 52, 40, 1, -52 },
  { 3227, 36, 52, 40, 3, -51 },
  { 3461, 34, 53, 40, 5, -52 },
  { 3687, 33, 51, 40, 7, -51 },
  { 3898, 36, 53, 40, 3, -52 },
  { 4137, 35, 53, 40, 3, -52 },
  { 4369, 13, 40, 17, 2, -39 },
  { 4434, 18, 48, 17, -3, -39 },
  { 4542, 34, 34, 41, 5, -43 },
  { 4687, 34, 18, 41, 5, -34 },
  { 4764, 34, 34, 41, 5, -43 },
  { 4909, 26, 53, 30, 6, -52 },
  { 5082, 55, 57, 61, 4, -51 },
  { 5474, 40, 51, 40, -4, -51 },
  { 5729, 39, 51, 43, 3, -51 },
  { 5978, 40, 53, 43, 6, -52 },
  { 6243, 43, 51, 48, 3, -51 },
  { 6518, 37, 51, 38, 3, -51 },
  { 6754, 37, 51, 35, 3, -51 },
  { 6990, 42, 53, 49, 6, -52 },
  { 7269, 46, 51, 49, 3, -51 },
  { 7563, 25, 51, 22, 0, -51 },
  { 7723, 31, 64, 18, -12, -51 },
  { 7971, 43, 51, 40, 3, -51 },
  { 8246, 27, 51, 35, 3, -51 },
  { 8419, 56, 51, 59, 3, -51 },
  { 8776, 47, 51, 50, 3, -51 },
  { 9076, 43, 53, 52, 6, -52 },
  { 9361, 38, 51, 41, 3, -51 },
  { 9604, 43, 64, 52, 6, -52 },
  { 9948, 38, 51, 41, 3, -51 },
  { 10191, 36, 53, 36, 1, -52 },
  { 10430, 35, 51, 36, 7, -51 },
  { 10654, 44, 52, 49, 6, -51 },
  { 10940, 38, 51, 39, 7, -51 },
  { 11183, 58, 51, 61, 8, -51 },
  { 11553, 46, 51, 37, -4, -51 },
  { 11847, 35, 51, 36, 7, -51 },
  { 12071, 42, 51, 39, -1, -51 },
  { 12339, 28, 62, 21, -1, -51 },
  { 12556, 13, 51, 24, 7, -51 },
  { 12639, 27, 62, 21, -5, -51 },
  { 12849, 34, 32, 40, 3, -52 },
  { 12985, 28, 4, 28, -6, 7 },
  { 12999, 10, 11, 18, 11, -55 },
  { 13013, 34, 40, 40, 4, -39 },
  { 13183, 36, 56, 41, 2, -55 },
  { 13435, 29, 40, 33, 4, -39 },
  { 13580, 38, 56, 41, 4, -55 },
  { 13846, 29, 40, 36, 4, -39 },
  { 13991, 40, 72, 21, -9, -55 },
  { 14351, 37, 56, 41, 2, -39 },
  { 14610, 35, 55, 41, 2, -55 },
  { 14851, 16, 52, 17, 2, -52 },
  { 14955, 28, 69, 17, -10, -52 },
  { 15197, 34, 55, 34, 2, -55 },
  { 15431, 16, 55, 17, 2, -55 },
  { 15541, 56, 39, 62, 2, -39 },
  { 15814, 35, 39, 41, 2, -39 },
  { 15985, 33, 40, 41, 4, -39 },
  { 16150, 39, 56, 41, -1, -39 },
  { 16423, 35, 56, 41, 4, -39 },
  { 16668, 28, 39, 28, 2, -39 },
  { 16805, 28, 40, 31, 1, -39 },
  { 16945, 21, 48, 23, 4, -47 },
  { 17071, 34, 39, 41, 4, -38 },
  { 17237, 31, 38, 32, 4, -38 },
  { 17385, 48, 38, 49, 4, -38 },
  { 17613, 38, 38, 34, -3, -38 },
  { 17794, 42, 55, 32, -7, -38 },
  { 18083, 33, 38, 32, -1, -38 },
  { 18240, 27, 62, 24, 1, -51 },
  { 18450, 3, 72, 39, 20, -55 },
  { 18477, 26, 62, 24, -3, -51 },
  { 18679, 34, 8, 41, 5, -29 },
};

const GFXfont NotoSans_LightItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_LIGHTITALIC72PT7B_H_
