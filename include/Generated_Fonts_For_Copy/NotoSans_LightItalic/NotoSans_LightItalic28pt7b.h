#ifndef _NOTOSANS_LIGHTITALIC28PT7B_H_
#define _NOTOSANS_LIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x08, 0x21, 0x86,
  0x00, 0x00, 0x0C, 0x30, 0x62, 0xCD, 0x1A, 0x24, 0x58, 0xA3, 0x00, 0x01,
  0x86, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x20, 0x80, 0x30, 0xC0, 0x10, 0x40,
  0xFF, 0xFE, 0x0C, 0x30, 0x06, 0x10, 0x02, 0x08, 0x01, 0x04, 0x01, 0x86,
  0x00, 0x82, 0x07, 0xFF, 0xF0, 0x61, 0x80, 0x30, 0xC0, 0x10, 0x40, 0x08,
  0x20, 0x0C, 0x30, 0x04, 0x10, 0x00, 0x00, 0x40, 0x01, 0x00, 0x3F, 0x03,
  0xFF, 0x18, 0x80, 0x42, 0x01, 0x18, 0x04, 0x60, 0x19, 0x00, 0x74, 0x00,
  0x70, 0x00, 0xF0, 0x02, 0x60, 0x08, 0xC0, 0x23, 0x00, 0x8C, 0x06, 0x22,
  0x11, 0x8F, 0xFC, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x00, 0x1F,
  0x00, 0xC6, 0x20, 0x20, 0x86, 0x0C, 0x30, 0xC3, 0x04, 0x18, 0x40, 0x82,
  0x18, 0x30, 0x46, 0x06, 0x08, 0x80, 0xC3, 0x27, 0xD8, 0x4D, 0x99, 0x1B,
  0x21, 0x3E, 0x4C, 0x30, 0x11, 0x04, 0x06, 0x20, 0x81, 0x8C, 0x10, 0x21,
  0x86, 0x08, 0x30, 0xC3, 0x06, 0x10, 0xC0, 0x46, 0x30, 0x0F, 0x80, 0x03,
  0xF0, 0x03, 0x8C, 0x01, 0x02, 0x01, 0x81, 0x80, 0xC0, 0x80, 0x60, 0xC0,
  0x10, 0xC0, 0x0C, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x60, 0x06, 0x18,
  0x36, 0x0C, 0x36, 0x03, 0x13, 0x00, 0xD9, 0x80, 0x38, 0xC0, 0x18, 0x60,
  0x1E, 0x1C, 0x39, 0x87, 0xF0, 0xE0, 0x6D, 0x25, 0xA0, 0x03, 0x02, 0x04,
  0x0C, 0x18, 0x10, 0x30, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30,
  0x18, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x81, 0x80, 0x81, 0xC0,
  0x03, 0x00, 0x30, 0x83, 0x0E, 0x20, 0x72, 0x00, 0xFF, 0x06, 0x00, 0xA0,
  0x31, 0x06, 0x10, 0x21, 0x80, 0x08, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x7F, 0xFF, 0xFF, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x00, 0x33, 0x26, 0x4C, 0x80, 0xFE, 0xF0, 0x00, 0x18,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x61, 0x86, 0x04,
  0x60, 0x32, 0x01, 0xB0, 0x0D, 0x80, 0x68, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x05, 0x00, 0x28, 0x03, 0x40, 0x1A, 0x00, 0x90, 0x0C, 0xC0, 0x46, 0x06,
  0x18, 0xE0, 0x7C, 0x00, 0x03, 0x0F, 0x1A, 0x72, 0xC6, 0x06, 0x06, 0x04,
  0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30,
  0x03, 0xF8, 0x1E, 0x38, 0x10, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xF0, 0x78, 0xE1, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x60, 0x3E, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x8C, 0x1C, 0x3F,
  0xE0, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x60, 0x04, 0xC0, 0x19,
  0x00, 0x62, 0x01, 0x8C, 0x06, 0x18, 0x18, 0x20, 0x60, 0x41, 0x81, 0x82,
  0x03, 0x08, 0x06, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x07, 0xFC, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x3F, 0xC0, 0x43, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x8C, 0x1C,
  0x1F, 0xE0, 0x01, 0xF8, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x4F, 0xC6, 0x83, 0x38, 0x0D, 0x80, 0x6C, 0x03, 0x60,
  0x1A, 0x00, 0xD8, 0x04, 0xC0, 0x66, 0x06, 0x18, 0x70, 0x7E, 0x00, 0xFF,
  0xF8, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x18, 0x60,
  0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x30, 0x80, 0x83, 0x0C, 0x06, 0xE0,
  0x0E, 0x01, 0xCC, 0x0C, 0x18, 0x60, 0x31, 0x00, 0x4C, 0x01, 0x30, 0x04,
  0xC0, 0x31, 0x80, 0xC7, 0x0E, 0x07, 0xE0, 0x07, 0xE0, 0x38, 0xC1, 0x81,
  0x84, 0x02, 0x30, 0x0C, 0x80, 0x32, 0x00, 0xC8, 0x03, 0x20, 0x18, 0xC0,
  0x63, 0x87, 0x87, 0xF6, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x08, 0x38, 0x3F, 0x80, 0x19, 0xC4, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x06, 0x1C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x06, 0x18, 0x30, 0x41, 0x82, 0x00, 0x00, 0x08, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xE0, 0x0C, 0x00, 0x00, 0x3F, 0x98, 0x70, 0x0C, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x30, 0x08, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x3E, 0x01,
  0x80, 0x18, 0x18, 0x00, 0x41, 0x00, 0x03, 0x10, 0x00, 0x09, 0x81, 0xF8,
  0x68, 0x30, 0x43, 0xC3, 0x06, 0x1C, 0x10, 0x30, 0xE1, 0x81, 0x07, 0x08,
  0x08, 0x28, 0x40, 0xC1, 0x42, 0x06, 0x1A, 0x10, 0x71, 0x90, 0xC4, 0x98,
  0x83, 0xC7, 0x86, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x40, 0x07, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x02, 0xC0, 0x0C, 0x80, 0x11, 0x00, 0x62, 0x00, 0x84, 0x03, 0x0C,
  0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0xFF, 0xC3, 0x00, 0x84, 0x01, 0x18,
  0x03, 0x60, 0x06, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x10, 0x0F, 0xF8, 0x18,
  0x78, 0x30, 0x18, 0x40, 0x10, 0x80, 0x23, 0x00, 0x46, 0x01, 0x8C, 0x06,
  0x10, 0x38, 0x7F, 0xC0, 0xC0, 0xE1, 0x80, 0x43, 0x00, 0xC4, 0x01, 0x98,
  0x03, 0x30, 0x06, 0x60, 0x18, 0x80, 0x71, 0x07, 0xC7, 0xFE, 0x00, 0x01,
  0xFF, 0x07, 0x86, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3C,
  0x30, 0x0F, 0xF0, 0x0F, 0xF0, 0x06, 0x3E, 0x03, 0x01, 0x81, 0x00, 0x60,
  0x80, 0x30, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x10, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0x66, 0x00, 0x22, 0x00, 0x31, 0x00, 0x19, 0x80, 0x18, 0xC0,
  0x1C, 0x60, 0x1C, 0x20, 0x1C, 0x10, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xFE,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x7F, 0xE0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x87, 0xFE, 0x00,
  0x0F, 0xFE, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xFF, 0xC1, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xFF, 0x83, 0xC3, 0x83, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x1F, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x10, 0x80, 0x08,
  0x60, 0x0C, 0x38, 0x06, 0x0E, 0x0F, 0x01, 0xFE, 0x00, 0x0C, 0x00, 0xC3,
  0x00, 0x30, 0xC0, 0x0C, 0x20, 0x02, 0x08, 0x01, 0x86, 0x00, 0x61, 0x80,
  0x18, 0x60, 0x04, 0x10, 0x01, 0x0F, 0xFF, 0xC3, 0x00, 0x30, 0xC0, 0x0C,
  0x30, 0x02, 0x08, 0x00, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x10,
  0x01, 0x04, 0x00, 0x43, 0x00, 0x30, 0x0F, 0xC0, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x03, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x06, 0x09, 0xC0, 0xF8, 0x00, 0x0C, 0x03, 0x86,
  0x03, 0x03, 0x03, 0x01, 0x03, 0x00, 0x83, 0x00, 0xC3, 0x00, 0x63, 0x00,
  0x33, 0x00, 0x13, 0x00, 0x1B, 0x80, 0x0E, 0x60, 0x06, 0x30, 0x02, 0x0C,
  0x01, 0x06, 0x01, 0x81, 0x00, 0xC0, 0xC0, 0x60, 0x20, 0x20, 0x18, 0x10,
  0x0C, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0xFF, 0xE0, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xA0, 0x03, 0xC2, 0x80, 0x0A, 0x0A, 0x00, 0x78, 0x6C, 0x03,
  0x61, 0xB0, 0x09, 0x84, 0xC0, 0x64, 0x11, 0x01, 0x10, 0xC4, 0x0C, 0xC3,
  0x10, 0x23, 0x0C, 0x61, 0x8C, 0x21, 0x8C, 0x20, 0x86, 0x20, 0x86, 0x09,
  0x86, 0x18, 0x24, 0x18, 0x60, 0xB0, 0x61, 0x02, 0x81, 0x04, 0x0C, 0x04,
  0x30, 0x30, 0x30, 0x0C, 0x00, 0x43, 0x80, 0x30, 0xE0, 0x0C, 0x28, 0x03,
  0x0B, 0x00, 0x86, 0x40, 0x21, 0x98, 0x18, 0x46, 0x06, 0x10, 0x81, 0x8C,
  0x30, 0x43, 0x04, 0x10, 0xC1, 0x8C, 0x20, 0x63, 0x08, 0x0C, 0xC6, 0x03,
  0x21, 0x80, 0x48, 0x60, 0x1E, 0x10, 0x07, 0x84, 0x00, 0xC3, 0x00, 0x30,
  0x03, 0xFC, 0x03, 0x87, 0x03, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x19, 0x00,
  0x0D, 0x80, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x16, 0x00, 0x1B, 0x00, 0x0C, 0x80, 0x0C, 0x60, 0x0E,
  0x38, 0x0E, 0x0E, 0x1E, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x18, 0xF0, 0x30,
  0x30, 0x40, 0x30, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x02, 0x10, 0x0C,
  0x60, 0x30, 0xFF, 0xC1, 0xFC, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFC, 0x03,
  0x87, 0x03, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x19, 0x00, 0x0D, 0x80, 0x06,
  0xC0, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x16, 0x00, 0x1B, 0x00, 0x0C, 0x80, 0x0C, 0x60, 0x0E, 0x38, 0x0E, 0x0E,
  0x1E, 0x01, 0xFC, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0F, 0xF0, 0x18, 0xF8, 0x30, 0x30, 0x40, 0x30, 0x80,
  0x63, 0x00, 0xC6, 0x01, 0x8C, 0x02, 0x10, 0x0C, 0x60, 0x70, 0xFF, 0x81,
  0x86, 0x03, 0x0C, 0x04, 0x08, 0x18, 0x18, 0x30, 0x30, 0x60, 0x30, 0x80,
  0x61, 0x00, 0xC6, 0x00, 0xC0, 0x07, 0xF8, 0x70, 0xC6, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x60, 0x07, 0x30, 0x71,
  0xFE, 0x00, 0xFF, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x8C, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x33, 0x00, 0x11, 0x80, 0x08,
  0xC0, 0x0C, 0x40, 0x06, 0x60, 0x03, 0x30, 0x01, 0x18, 0x01, 0x88, 0x00,
  0xC4, 0x00, 0x66, 0x00, 0x23, 0x00, 0x31, 0x80, 0x18, 0x40, 0x18, 0x30,
  0x0C, 0x0C, 0x1C, 0x03, 0xF8, 0x00, 0x80, 0x07, 0x80, 0x1B, 0x00, 0x66,
  0x00, 0xCC, 0x03, 0x18, 0x06, 0x10, 0x18, 0x20, 0x30, 0x40, 0xC0, 0x81,
  0x01, 0x86, 0x03, 0x08, 0x06, 0x30, 0x0C, 0x40, 0x19, 0x80, 0x12, 0x00,
  0x2C, 0x00, 0x50, 0x00, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x07, 0x80,
  0x60, 0x1B, 0x01, 0xC0, 0x36, 0x03, 0x80, 0xCC, 0x05, 0x81, 0x88, 0x1B,
  0x02, 0x10, 0x26, 0x0C, 0x20, 0xCC, 0x10, 0x41, 0x18, 0x60, 0x86, 0x30,
  0x81, 0x08, 0x63, 0x02, 0x30, 0x44, 0x04, 0x40, 0x98, 0x09, 0x81, 0x30,
  0x12, 0x02, 0x40, 0x2C, 0x05, 0x80, 0x50, 0x0A, 0x00, 0xA0, 0x1C, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x80, 0x60, 0x30,
  0x10, 0x04, 0x0C, 0x01, 0x86, 0x00, 0x63, 0x00, 0x09, 0x80, 0x03, 0x40,
  0x00, 0xF0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x06, 0x80, 0x03, 0x30, 0x00,
  0x84, 0x00, 0x61, 0x80, 0x30, 0x60, 0x18, 0x08, 0x0C, 0x03, 0x02, 0x00,
  0xC3, 0x80, 0x18, 0x80, 0x1F, 0x00, 0x4C, 0x03, 0x10, 0x18, 0x40, 0x41,
  0x83, 0x06, 0x18, 0x08, 0xC0, 0x33, 0x00, 0xD8, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xC1, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0xE0,
  0x86, 0x31, 0x84, 0x21, 0x0C, 0x63, 0x08, 0x42, 0x18, 0xC6, 0x10, 0x84,
  0x30, 0x07, 0xE0, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x07, 0xE0, 0x01, 0x80,
  0x06, 0x00, 0x3C, 0x01, 0x90, 0x04, 0x40, 0x30, 0x80, 0x82, 0x06, 0x0C,
  0x30, 0x10, 0x80, 0x46, 0x01, 0xB0, 0x03, 0xFF, 0xE0, 0xC6, 0x21, 0x07,
  0xCC, 0x31, 0xB1, 0x83, 0x8C, 0x06, 0x20, 0x19, 0x80, 0x66, 0x01, 0x90,
  0x04, 0xC0, 0x33, 0x00, 0xCC, 0x07, 0x30, 0x18, 0x60, 0xA1, 0x84, 0x83,
  0xE6, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x1F, 0x05, 0xCE, 0x34, 0x18, 0xE0, 0x23, 0x00, 0xCC, 0x03, 0x20,
  0x0D, 0x80, 0x26, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0xCE, 0x06, 0x34,
  0x30, 0x8F, 0x80, 0x07, 0xF0, 0xE3, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x0C,
  0x1F, 0x80, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x81, 0xF3, 0x06, 0x36, 0x18, 0x1C, 0x60, 0x30, 0x80, 0x63, 0x00,
  0xC6, 0x01, 0x88, 0x03, 0x30, 0x04, 0x60, 0x18, 0xC0, 0x31, 0x80, 0xE1,
  0x82, 0xC3, 0x0D, 0x03, 0xE2, 0x00, 0x0F, 0xC3, 0x1C, 0xC1, 0xB0, 0x34,
  0x07, 0x81, 0xB0, 0xE7, 0xF0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00,
  0xC3, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x01, 0xFC, 0x04, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x07, 0xC4, 0x31, 0xB1,
  0x81, 0xCC, 0x06, 0x20, 0x19, 0x80, 0x66, 0x01, 0x90, 0x06, 0xC0, 0x13,
  0x00, 0xCC, 0x03, 0x30, 0x1C, 0x60, 0xB1, 0x86, 0x83, 0xE6, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x20, 0x60, 0xFF, 0x00, 0xF0, 0x00, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x47, 0xC2, 0xE7,
  0x34, 0x19, 0xC0, 0x4C, 0x02, 0x60, 0x32, 0x01, 0xB0, 0x0D, 0x80, 0x4C,
  0x02, 0x40, 0x32, 0x01, 0xB0, 0x0D, 0x80, 0x4C, 0x06, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x61, 0x0C, 0x30, 0xC2, 0x08, 0x61, 0x86, 0x10, 0x43, 0x0C,
  0x30, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x1F,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x62, 0x06, 0x30, 0x61, 0x86, 0x0C, 0x60, 0x44, 0x02, 0x40,
  0x3F, 0x01, 0xC8, 0x0C, 0x60, 0x41, 0x02, 0x0C, 0x30, 0x21, 0x81, 0x8C,
  0x06, 0x00, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x08, 0x21,
  0x86, 0x18, 0x41, 0x0C, 0x30, 0xC0, 0x11, 0xE1, 0xF0, 0xB9, 0x98, 0xCF,
  0x05, 0x82, 0x70, 0x28, 0x13, 0x01, 0x80, 0x98, 0x0C, 0x04, 0x80, 0xC0,
  0x6C, 0x06, 0x03, 0x60, 0x30, 0x1B, 0x01, 0x00, 0x90, 0x08, 0x04, 0x80,
  0xC0, 0x6C, 0x06, 0x03, 0x60, 0x30, 0x1B, 0x01, 0x00, 0x80, 0x11, 0xF0,
  0xB9, 0xCD, 0x06, 0x70, 0x13, 0x00, 0x98, 0x0C, 0x80, 0x6C, 0x03, 0x60,
  0x13, 0x01, 0x90, 0x0C, 0x80, 0x6C, 0x03, 0x60, 0x13, 0x01, 0x80, 0x07,
  0xE0, 0x73, 0x86, 0x06, 0x60, 0x36, 0x00, 0xB0, 0x05, 0x00, 0x28, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x04, 0x80, 0x66, 0x06, 0x18, 0x60, 0x7E, 0x00,
  0x04, 0x7C, 0x05, 0xCE, 0x0D, 0x06, 0x0E, 0x02, 0x0C, 0x03, 0x0C, 0x03,
  0x08, 0x03, 0x18, 0x02, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x0C,
  0x38, 0x18, 0x34, 0x30, 0x33, 0xE0, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x07, 0xC4, 0x31, 0xB1,
  0x81, 0xCC, 0x06, 0x20, 0x19, 0x80, 0x66, 0x01, 0x90, 0x06, 0xC0, 0x13,
  0x00, 0xCC, 0x03, 0x30, 0x1C, 0x60, 0xB1, 0x86, 0x83, 0xE6, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x11,
  0xE2, 0xE4, 0xD0, 0x1C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x0F, 0xE3, 0x0C, 0xC0,
  0x18, 0x03, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x0D, 0x83, 0x1F, 0xC0, 0x08, 0x04, 0x06, 0x0F, 0xF9, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x60,
  0x3E, 0x00, 0x20, 0x1B, 0x00, 0xD8, 0x04, 0xC0, 0x24, 0x03, 0x20, 0x1B,
  0x00, 0xD8, 0x04, 0xC0, 0x64, 0x03, 0x20, 0x19, 0x01, 0xC8, 0x14, 0x63,
  0x21, 0xF3, 0x00, 0xC0, 0x1A, 0x01, 0x90, 0x08, 0x80, 0xC6, 0x0C, 0x30,
  0x61, 0x86, 0x0C, 0x30, 0x23, 0x01, 0x10, 0x09, 0x80, 0x48, 0x02, 0xC0,
  0x1C, 0x00, 0xE0, 0x00, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x14, 0x1A, 0x0D,
  0x06, 0x82, 0x43, 0x21, 0x90, 0xC8, 0x44, 0x22, 0x31, 0x18, 0xC8, 0x44,
  0x36, 0x13, 0x0D, 0x04, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0C,
  0x06, 0x00, 0x18, 0x06, 0x18, 0x18, 0x30, 0x60, 0x21, 0x80, 0x66, 0x00,
  0x58, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x09, 0x00, 0x33, 0x00, 0xC2,
  0x03, 0x06, 0x0C, 0x04, 0x30, 0x0C, 0x00, 0x0C, 0x01, 0x82, 0x01, 0x81,
  0x00, 0x80, 0x80, 0xC0, 0x60, 0x40, 0x30, 0x60, 0x18, 0x60, 0x04, 0x30,
  0x02, 0x30, 0x01, 0x10, 0x00, 0xD8, 0x00, 0x68, 0x00, 0x3C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x0F, 0x80, 0x07, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xFF, 0xC0, 0x01, 0xC0, 0xE0, 0x60, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x03, 0xC0, 0xE0, 0x08, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x03, 0xC0, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0x80, 0x30, 0x07, 0x01, 0xC0, 0xC0, 0x60, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x03, 0x03, 0x80, 0x7E, 0x0C, 0x1F,
  0xE0, 0x18,
};

const GFXglyph NotoSans_LightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 20, 7, 1, -20 },
  { 16, 7, 7, 10, 3, -20 },
  { 23, 17, 20, 18, 1, -20 },
  { 66, 14, 23, 15, 1, -21 },
  { 107, 19, 20, 22, 2, -20 },
  { 155, 17, 20, 19, 1, -20 },
  { 198, 3, 7, 5, 3, -20 },
  { 201, 8, 24, 7, 1, -20 },
  { 225, 9, 24, 7, -2, -20 },
  { 252, 12, 12, 15, 3, -21 },
  { 270, 13, 13, 16, 2, -16 },
  { 292, 4, 7, 6, -1, -3 },
  { 296, 7, 1, 9, 1, -8 },
  { 297, 2, 2, 7, 1, -2 },
  { 298, 13, 20, 9, -1, -20 },
  { 331, 13, 20, 15, 2, -20 },
  { 364, 8, 20, 15, 4, -20 },
  { 384, 15, 20, 15, 0, -20 },
  { 422, 14, 20, 15, 1, -20 },
  { 457, 15, 20, 15, 0, -20 },
  { 495, 14, 20, 15, 1, -20 },
  { 530, 13, 20, 15, 2, -20 },
  { 563, 13, 20, 15, 3, -20 },
  { 596, 14, 20, 15, 1, -20 },
  { 631, 14, 20, 15, 1, -20 },
  { 666, 5, 15, 7, 1, -15 },
  { 676, 7, 19, 7, -1, -15 },
  { 693, 13, 13, 16, 2, -17 },
  { 715, 13, 7, 16, 2, -13 },
  { 727, 13, 13, 16, 2, -17 },
  { 749, 10, 20, 12, 2, -20 },
  { 774, 21, 23, 24, 2, -20 },
  { 835, 15, 20, 16, -1, -20 },
  { 873, 15, 20, 17, 1, -20 },
  { 911, 16, 20, 17, 2, -20 },
  { 951, 17, 20, 19, 1, -20 },
  { 994, 15, 20, 15, 1, -20 },
  { 1032, 15, 20, 14, 1, -20 },
  { 1070, 17, 20, 19, 2, -20 },
  { 1113, 18, 20, 19, 1, -20 },
  { 1158, 10, 20, 8, 0, -20 },
  { 1183, 12, 25, 7, -5, -20 },
  { 1221, 17, 20, 15, 1, -20 },
  { 1264, 11, 20, 14, 1, -20 },
  { 1292, 22, 20, 23, 1, -20 },
  { 1347, 18, 20, 19, 1, -20 },
  { 1392, 17, 20, 20, 2, -20 },
  { 1435, 15, 20, 16, 1, -20 },
  { 1473, 17, 25, 20, 2, -20 },
  { 1527, 15, 20, 16, 1, -20 },
  { 1565, 13, 20, 14, 1, -20 },
  { 1598, 13, 20, 14, 3, -20 },
  { 1631, 17, 20, 19, 2, -20 },
  { 1674, 15, 20, 15, 3, -20 },
  { 1712, 23, 20, 24, 3, -20 },
  { 1770, 18, 20, 14, -2, -20 },
  { 1815, 14, 20, 14, 3, -20 },
  { 1850, 16, 20, 15, 0, -20 },
  { 1890, 10, 24, 8, 0, -20 },
  { 1920, 5, 20, 9, 3, -20 },
  { 1933, 11, 24, 8, -2, -20 },
  { 1966, 14, 12, 16, 1, -20 },
  { 1987, 11, 1, 11, -2, 3 },
  { 1989, 4, 4, 7, 4, -21 },
  { 1991, 14, 15, 16, 1, -15 },
  { 2018, 14, 21, 16, 1, -21 },
  { 2055, 12, 15, 13, 1, -15 },
  { 2078, 15, 21, 16, 1, -21 },
  { 2118, 11, 15, 14, 2, -15 },
  { 2139, 15, 28, 8, -3, -21 },
  { 2192, 14, 22, 16, 1, -15 },
  { 2231, 13, 21, 16, 1, -21 },
  { 2266, 6, 20, 7, 1, -20 },
  { 2281, 11, 27, 7, -4, -20 },
  { 2319, 13, 21, 13, 1, -21 },
  { 2354, 6, 21, 7, 1, -21 },
  { 2370, 21, 15, 24, 1, -15 },
  { 2410, 13, 15, 16, 1, -15 },
  { 2435, 13, 15, 16, 1, -15 },
  { 2460, 16, 22, 16, -1, -15 },
  { 2504, 14, 22, 16, 1, -15 },
  { 2543, 11, 15, 11, 1, -15 },
  { 2564, 11, 15, 12, 0, -15 },
  { 2585, 9, 18, 9, 1, -18 },
  { 2606, 13, 15, 16, 2, -15 },
  { 2631, 13, 15, 12, 1, -15 },
  { 2656, 18, 15, 19, 2, -15 },
  { 2690, 15, 15, 13, -1, -15 },
  { 2719, 17, 22, 12, -3, -15 },
  { 2766, 12, 15, 12, 0, -15 },
  { 2789, 10, 24, 9, 1, -20 },
  { 2819, 1, 28, 15, 8, -21 },
  { 2823, 10, 24, 9, -1, -20 },
  { 2853, 13, 3, 16, 2, -11 },
};

const GFXfont NotoSans_LightItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_LIGHTITALIC28PT7B_H_
