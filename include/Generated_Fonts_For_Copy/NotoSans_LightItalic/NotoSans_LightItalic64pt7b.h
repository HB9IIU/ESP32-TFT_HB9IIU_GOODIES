#ifndef _NOTOSANS_LIGHTITALIC64PT7B_H_
#define _NOTOSANS_LIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x06, 0x00, 0x00,
  0x1E, 0x07, 0x8E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xC0,
  0x70, 0xE0, 0x38, 0x70, 0x3C, 0x78, 0x1E, 0x38, 0x0E, 0x1C, 0x07, 0x0E,
  0x03, 0x87, 0x01, 0xC3, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xF8, 0xE3, 0xF0,
  0x1F, 0x07, 0x01, 0x80, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x30,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x87, 0x00, 0x00, 0x1F, 0x1C, 0x00,
  0x00, 0x3F, 0x70, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x3F, 0x00, 0x00,
  0x1C, 0x3E, 0x00, 0x00, 0x70, 0x7C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x07, 0x01, 0xE0, 0x80, 0x1C, 0x0F, 0x03, 0x80, 0x70, 0xF8, 0x0F,
  0xF9, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0x80, 0x3F, 0xFC, 0x00, 0x01, 0xC0, 0x1E, 0x07, 0x00,
  0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x38, 0x00, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x1E,
  0x00, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x01,
  0xC0, 0x07, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x00,
  0x70, 0x38, 0x00, 0x0F, 0x00, 0x38, 0x1C, 0x0F, 0xC3, 0xC0, 0x0E, 0x0F,
  0x0F, 0xF8, 0xF0, 0x07, 0x87, 0x87, 0xFF, 0x3C, 0x01, 0xC1, 0xC3, 0xC1,
  0xE7, 0x00, 0xF0, 0xE1, 0xE0, 0x39, 0xC0, 0x78, 0x78, 0xF0, 0x0F, 0x78,
  0x3C, 0x3C, 0x38, 0x03, 0xCF, 0xFF, 0x0E, 0x1E, 0x00, 0x73, 0xFF, 0x87,
  0x07, 0x00, 0x1C, 0x3F, 0x83, 0xC1, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0xF0,
  0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x3C,
  0x00, 0x1E, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x03,
  0x80, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x07,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x00,
  0x0E, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xE3, 0xE0, 0x0E, 0x00, 0x00, 0x7F,
  0xF0, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x7E,
  0x00, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x78, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0xF1, 0xF0, 0x07, 0x80, 0x03, 0x87, 0x80, 0x0F, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x00, 0x71, 0xE0, 0x00, 0x78, 0x03, 0xC7, 0x00,
  0x00, 0xF0, 0x1E, 0x3C, 0x00, 0x03, 0xE0, 0x70, 0xF0, 0x00, 0x07, 0x83,
  0xC3, 0x80, 0x00, 0x0F, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0xF0, 0x38, 0x00,
  0x00, 0x7F, 0x80, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0x80, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0xF8, 0x00,
  0x07, 0xDE, 0x01, 0xF0, 0x00, 0x3E, 0x3C, 0x03, 0xE0, 0x07, 0xF0, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xC0, 0x1F, 0xFF,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x38, 0xF1, 0xE3,
  0xC7, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00,
  0x78, 0x03, 0x00, 0x0F, 0xE0, 0x30, 0x00, 0x7F, 0x07, 0x00, 0x00, 0xFC,
  0x70, 0x00, 0x03, 0xF6, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0xF8, 0x1C,
  0x00, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x80, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07,
  0x80, 0xE0, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x33, 0xFF,
  0xFF, 0xFD, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x1F,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xB8, 0x3F, 0x3C, 0x3F, 0x1E, 0x7E, 0x0F,
  0x7E, 0x07, 0x1C, 0x07, 0x8C, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x40, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x01, 0xE0, 0x03, 0x80, 0x00, 0xF8, 0x01, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x80, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x01, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x80, 0x00, 0x07,
  0x80, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0x20, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x3F, 0xF0, 0x01, 0xE1, 0xFF, 0xF8, 0x03, 0xCF, 0xFF, 0xF8, 0x07, 0x3E,
  0x01, 0xF8, 0x1E, 0xF0, 0x00, 0xF0, 0x3F, 0x80, 0x00, 0xF0, 0x7E, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xF8, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x80, 0x00,
  0xF0, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x3E, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x03, 0xF0, 0xF0,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0xEE, 0x07, 0xC0, 0x0F, 0x78, 0x0F, 0xE3,
  0xF9, 0xE0, 0x1F, 0xFF, 0xC7, 0x00, 0x3F, 0xFC, 0x3C, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x08, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x7C,
  0x0F, 0x81, 0xF0, 0x7E, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xF8, 0x0F,
  0xC1, 0x80, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x1F, 0xFF, 0x80, 0x3C, 0x3C, 0x00, 0x3F, 0xFF, 0xE0,
  0x0E, 0x1C, 0x00, 0x3F, 0x01, 0xE0, 0x07, 0x1E, 0x00, 0x3E, 0x00, 0x70,
  0x03, 0x8E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xCF, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0xE7, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x73, 0x80, 0x1C, 0x00, 0x0E,
  0x00, 0x3B, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x1D, 0xE0, 0x0E, 0x00, 0x07,
  0x00, 0x0E, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x0F, 0x70, 0x07, 0x00, 0x01,
  0xC0, 0x07, 0xB8, 0x03, 0x80, 0x01, 0xE0, 0x03, 0x9C, 0x01, 0xC0, 0x00,
  0xE0, 0x01, 0xDE, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xEF, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0xE7, 0x80, 0x78, 0x00, 0x3C, 0x00, 0xF3, 0xC0, 0x1C, 0x00,
  0x3E, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0x3F, 0x00, 0x78, 0x70, 0x07, 0x00,
  0x1B, 0x80, 0x78, 0x38, 0x03, 0xC0, 0x1D, 0xC0, 0x7C, 0x1C, 0x01, 0xF0,
  0x3C, 0xF0, 0x7C, 0x0F, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x07, 0x80, 0x1F,
  0xFC, 0x1F, 0xF8, 0x01, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00,
  0x1F, 0x80, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x03,
  0xE0, 0x0E, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x01, 0xF8, 0x07, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x02, 0x00, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0xE0, 0x00, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00,
  0x7E, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x07,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x78, 0x01, 0xF8, 0x00, 0x00, 0x40, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xF8, 0xF0, 0x00, 0x0F,
  0xFF, 0xE3, 0xC0, 0x00, 0x3F, 0xFF, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x03,
  0x80, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0x00, 0x07, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x00, 0x38, 0x3E, 0x00, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x00, 0x1E, 0x7F, 0x00, 0x00, 0x00, 0x7B, 0xFC, 0x00, 0x00,
  0x01, 0xDE, 0x78, 0x00, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x00, 0x3F, 0x03,
  0x80, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0x70, 0x03, 0x9C, 0x00, 0x00, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0xC0, 0x1E,
  0x70, 0x00, 0x00, 0x3C, 0xF0, 0x07, 0x9C, 0x00, 0x00, 0x1E, 0x38, 0x01,
  0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x71, 0xE0, 0x00, 0x03, 0xC7, 0x80,
  0x1C, 0x38, 0x00, 0x00, 0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x70,
  0x03, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x38, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x70, 0x00, 0x38,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x07,
  0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x01,
  0xE0, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x70, 0x0F, 0x00, 0x38, 0x03, 0x80,
  0x3C, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03,
  0x80, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x1C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x0F, 0x00, 0x1E, 0x00, 0xF0,
  0x01, 0xC3, 0x80, 0x07, 0x00, 0x38, 0x00, 0x71, 0xE0, 0x03, 0xC0, 0x0E,
  0x00, 0x1C, 0x70, 0x00, 0xF0, 0x07, 0x80, 0x07, 0xBC, 0x00, 0x3C, 0x01,
  0xE0, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x70, 0x07, 0xF0,
  0x00, 0x00, 0x38, 0x03, 0xFC, 0x00, 0x00, 0x3C, 0x01, 0xDE, 0x00, 0x00,
  0x1E, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x00,
  0x78, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x78, 0x00, 0x03, 0xC0, 0x1C, 0x3C,
  0x00, 0x01, 0xE0, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x07, 0x80, 0x00,
  0x70, 0x07, 0x81, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0x00, 0x78, 0x03, 0x80, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x03,
  0xC0, 0x1C, 0x00, 0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x0F,
  0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x3C,
  0x00, 0x07, 0x83, 0xC0, 0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x0E, 0x00, 0x00,
  0xF0, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0xF0, 0x07, 0x80, 0x00, 0x1C, 0x78,
  0x03, 0x80, 0x00, 0x0F, 0x3C, 0x01, 0xC0, 0x00, 0x07, 0x9C, 0x01, 0xE0,
  0x00, 0x01, 0xEE, 0x00, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0x80, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x1C, 0x00, 0x00, 0x0F, 0xC0,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0x00, 0x07, 0xE0, 0x07, 0x80, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0x00, 0x07, 0xE0, 0x07, 0x80, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0x0E,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x77, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC7, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x87, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x07, 0x80, 0x07, 0x83, 0x80, 0x07,
  0x80, 0x78, 0x00, 0x70, 0x38, 0x00, 0x70, 0x07, 0x80, 0x0F, 0x03, 0x80,
  0x0F, 0x00, 0x78, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x03, 0x80, 0x3C, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x03, 0x80,
  0x78, 0x03, 0x80, 0x78, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x80, 0x03,
  0x80, 0xF0, 0x03, 0x80, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0F, 0x00,
  0x03, 0x81, 0xE0, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x78, 0x00,
  0x1C, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0xF0,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x0F, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0,
  0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x78,
  0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1C, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8,
  0xF8, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x1C, 0x00, 0xFF, 0xF8, 0x38,
  0x07, 0xFD, 0xF8, 0xE0, 0x1F, 0x80, 0x79, 0xC0, 0x7C, 0x00, 0x73, 0x80,
  0xF0, 0x00, 0x77, 0x03, 0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3F, 0x03, 0x80, 0x00, 0xFC,
  0x07, 0x80, 0x03, 0xB8, 0x0F, 0x00, 0x0E, 0x70, 0x1F, 0x00, 0x38, 0xE0,
  0x1F, 0x01, 0xE3, 0xC0, 0x1F, 0xFF, 0x87, 0x00, 0x1F, 0xFE, 0x0E, 0x00,
  0x1F, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0xF0, 0x3F, 0xE0, 0x01, 0xC1,
  0xFF, 0xF0, 0x03, 0x8F, 0xEF, 0xF0, 0x0F, 0x3E, 0x03, 0xF0, 0x1E, 0xF0,
  0x01, 0xE0, 0x39, 0xC0, 0x03, 0xC0, 0x77, 0x00, 0x03, 0xC0, 0xFC, 0x00,
  0x07, 0x83, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0E, 0x0F, 0x80, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x38, 0x7C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF0, 0xFC,
  0x00, 0x03, 0xC1, 0xF8, 0x00, 0x0F, 0x83, 0xB8, 0x00, 0x3E, 0x07, 0x38,
  0x00, 0xF8, 0x0E, 0x78, 0x03, 0xE0, 0x3C, 0x7F, 0xFF, 0x80, 0x70, 0x7F,
  0xFE, 0x00, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0x01,
  0xF8, 0x00, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x40, 0x7E, 0x00, 0x60, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x7F, 0xE0, 0x78, 0x00, 0x3F, 0xFF, 0x0E, 0x00, 0x1F, 0xF7,
  0xF3, 0xC0, 0x07, 0xE0, 0x0E, 0x78, 0x01, 0xF0, 0x00, 0xEF, 0x00, 0x7C,
  0x00, 0x0D, 0xC0, 0x0F, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x0E, 0x00, 0x01, 0xB8, 0x01, 0xE0,
  0x00, 0x7F, 0x00, 0x3C, 0x00, 0x1D, 0xE0, 0x07, 0xC0, 0x0F, 0x38, 0x00,
  0x7C, 0x03, 0xC7, 0x00, 0x07, 0xFF, 0xF0, 0xE0, 0x00, 0x7F, 0xF8, 0x1C,
  0x00, 0x07, 0xFE, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFD, 0xFC, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x38, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0xC7, 0x80, 0x07, 0xE3, 0xC0,
  0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x80, 0xFC, 0x00, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF8,
  0x30, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xC0, 0x07, 0xFF, 0xE1, 0xC0,
  0x0F, 0xFB, 0xF8, 0xE0, 0x0F, 0xC0, 0x1C, 0x70, 0x0F, 0x80, 0x07, 0x78,
  0x0F, 0x80, 0x01, 0xB8, 0x07, 0x80, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x01, 0xF8, 0x07, 0x00, 0x01, 0xDC, 0x03, 0xC0, 0x00, 0xFE, 0x01, 0xE0,
  0x01, 0xEF, 0x00, 0xF8, 0x01, 0xE7, 0x00, 0x3E, 0x01, 0xE3, 0x80, 0x0F,
  0xFF, 0xE3, 0xC0, 0x03, 0xFF, 0xC1, 0xE0, 0x00, 0xFF, 0xC0, 0xE0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x04, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0xF0, 0x3F, 0xF0, 0x01, 0xC1, 0xFF, 0xF0, 0x03, 0x87, 0xFF, 0xF0,
  0x0F, 0x3E, 0x01, 0xF0, 0x1E, 0xF0, 0x01, 0xE0, 0x39, 0xC0, 0x03, 0xC0,
  0x77, 0x00, 0x03, 0x80, 0xFC, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x1C, 0x0F, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x10, 0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x38, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xE3, 0xE0, 0x00, 0x03, 0x9F, 0xC0,
  0x00, 0x1E, 0xFF, 0x00, 0x00, 0x77, 0x1E, 0x00, 0x01, 0xF8, 0x78, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x70, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x38, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3C, 0xF0, 0x1F, 0x0F,
  0x00, 0xF0, 0x1C, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x0E, 0xE0, 0x01, 0xCF,
  0x00, 0x1E, 0x07, 0x60, 0x00, 0xF7, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0x83, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x81,
  0xFF, 0xC0, 0x07, 0x07, 0xFF, 0xC0, 0x0E, 0x3F, 0xFF, 0xC0, 0x3C, 0xF8,
  0x07, 0xC0, 0x7B, 0xC0, 0x07, 0x80, 0xE7, 0x00, 0x0F, 0x01, 0xDC, 0x00,
  0x0F, 0x07, 0xF0, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0xFE, 0x00, 0x03, 0x83,
  0xFF, 0xE0, 0x00, 0xE1, 0xFB, 0xFC, 0x00, 0x79, 0xF0, 0x1F, 0x80, 0x1C,
  0xF0, 0x01, 0xE0, 0x07, 0x38, 0x00, 0x78, 0x01, 0xDC, 0x00, 0x0F, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x1C,
  0x03, 0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x7C, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF0,
  0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0xE7, 0x00, 0x1F,
  0x00, 0x39, 0xE0, 0x0F, 0x80, 0x1E, 0x3F, 0xFF, 0xC0, 0x07, 0x87, 0xFF,
  0xE0, 0x01, 0xE0, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0x00, 0x3F, 0xFF, 0x0E, 0x00, 0xFF,
  0xBF, 0x8E, 0x01, 0xF8, 0x03, 0x8E, 0x03, 0xE0, 0x01, 0xDE, 0x07, 0xC0,
  0x00, 0xDC, 0x07, 0x80, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0xC0, 0x70, 0x00,
  0x0D, 0xC0, 0x78, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x3B, 0xC0, 0x7C, 0x00,
  0xF3, 0x80, 0x3E, 0x01, 0xE3, 0x80, 0x1F, 0xFF, 0xC7, 0x80, 0x0F, 0xFF,
  0x07, 0x80, 0x07, 0xFE, 0x07, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0xFF,
  0x01, 0xC3, 0xFF, 0x01, 0xC7, 0xFF, 0x03, 0xCF, 0x80, 0x03, 0x9E, 0x00,
  0x03, 0x9C, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x7F, 0xDF, 0xF0, 0x7C, 0x00, 0x70, 0x3C, 0x00, 0x08, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC2, 0x00, 0x03, 0xC1, 0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x0F,
  0x83, 0x80, 0x00, 0x7E, 0x0E, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x1D, 0xC0,
  0xF0, 0x00, 0xE7, 0x03, 0xC0, 0x07, 0x1C, 0x0F, 0x80, 0x7C, 0xF0, 0x1F,
  0xFF, 0xC3, 0x80, 0x3F, 0xFE, 0x0E, 0x00, 0x7F, 0xE0, 0x38, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x78,
  0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x3C,
  0x01, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xC0, 0x78,
  0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xF8, 0x00, 0x1E, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0x38, 0x00, 0x3B, 0x80, 0x03, 0xCE, 0x00, 0x0E,
  0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x38, 0x00, 0x78, 0xF0, 0x01, 0xCE, 0x00,
  0x3C, 0x3C, 0x00, 0xF3, 0x80, 0x0F, 0x0F, 0x00, 0x38, 0xE0, 0x07, 0x83,
  0xC0, 0x1E, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x0F, 0x00, 0xF0, 0x3C, 0x03,
  0xC3, 0xC0, 0x3C, 0x0F, 0x00, 0xE0, 0xF0, 0x0E, 0x03, 0xC0, 0x78, 0x1C,
  0x07, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x3C, 0x0F, 0x01, 0xC0, 0xF0,
  0x07, 0x03, 0x80, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x1C, 0x1E, 0x00, 0x70,
  0x70, 0x07, 0x07, 0x80, 0x1C, 0x3C, 0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x00,
  0x70, 0xF0, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x07, 0x9E,
  0x00, 0x1C, 0xF0, 0x01, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x7B, 0xC0, 0x01,
  0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x09, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0xE1, 0xFC, 0x00, 0x7F,
  0xFF, 0x40, 0x00, 0x7F, 0xF2, 0x00, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_LightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 14, 47, 15, 2, -46 },
  { 84, 17, 17, 22, 7, -46 },
  { 121, 39, 46, 40, 2, -46 },
  { 346, 30, 53, 35, 3, -49 },
  { 545, 42, 47, 50, 5, -46 },
  { 792, 38, 47, 43, 3, -46 },
  { 1016, 7, 17, 13, 7, -46 },
  { 1031, 20, 56, 17, 2, -46 },
  { 1171, 19, 56, 17, -4, -46 },
  { 1304, 28, 29, 35, 7, -49 },
  { 1406, 29, 31, 37, 5, -38 },
  { 1519, 11, 15, 14, -3, -7 },
  { 1540, 16, 3, 20, 2, -19 },
  { 1546, 5, 7, 15, 2, -6 },
  { 1551, 30, 46, 21, -3, -46 },
  { 1724, 30, 47, 35, 4, -46 },
  { 1901, 17, 46, 35, 10, -46 },
  { 1999, 33, 46, 35, 0, -46 },
  { 2189, 33, 47, 35, 1, -46 },
  { 2383, 33, 46, 35, 1, -46 },
  { 2573, 32, 47, 35, 2, -46 },
  { 2761, 31, 47, 35, 4, -46 },
  { 2944, 30, 46, 35, 6, -46 },
  { 3117, 31, 47, 35, 3, -46 },
  { 3300, 30, 47, 35, 3, -46 },
  { 3477, 11, 36, 15, 2, -35 },
  { 3527, 16, 43, 15, -3, -35 },
  { 3613, 29, 30, 37, 5, -38 },
  { 3722, 29, 16, 37, 5, -31 },
  { 3780, 29, 30, 37, 5, -38 },
  { 3889, 23, 47, 27, 5, -46 },
  { 4025, 49, 51, 54, 3, -45 },
  { 4338, 35, 46, 36, -3, -46 },
  { 4540, 34, 46, 38, 3, -46 },
  { 4736, 36, 47, 38, 5, -46 },
  { 4948, 38, 46, 43, 3, -46 },
  { 5167, 33, 46, 34, 3, -46 },
  { 5357, 33, 46, 31, 3, -46 },
  { 5547, 38, 47, 44, 5, -46 },
  { 5771, 41, 46, 44, 3, -46 },
  { 6007, 22, 46, 19, 0, -46 },
  { 6134, 26, 58, 16, -10, -46 },
  { 6323, 38, 46, 35, 3, -46 },
  { 6542, 24, 46, 31, 3, -46 },
  { 6680, 50, 46, 53, 3, -46 },
  { 6968, 41, 46, 44, 3, -46 },
  { 7204, 39, 47, 46, 5, -46 },
  { 7434, 33, 46, 36, 3, -46 },
  { 7624, 39, 57, 46, 5, -46 },
  { 7902, 33, 46, 36, 3, -46 },
  { 8092, 32, 47, 32, 1, -46 },
  { 8280, 31, 46, 32, 6, -46 },
  { 8459, 39, 47, 44, 5, -46 },
  { 8689, 34, 46, 35, 6, -46 },
  { 8885, 52, 46, 54, 7, -46 },
  { 9184, 42, 46, 33, -4, -46 },
  { 9426, 32, 46, 32, 6, -46 },
  { 9610, 38, 46, 34, -1, -46 },
  { 9829, 25, 56, 19, -1, -46 },
  { 10004, 10, 46, 21, 7, -46 },
  { 10062, 25, 56, 19, -5, -46 },
  { 10237, 30, 29, 36, 3, -46 },
  { 10346, 26, 3, 25, -6, 6 },
  { 10356, 9, 10, 16, 9, -49 },
  { 10368, 31, 36, 36, 3, -35 },
  { 10508, 31, 50, 37, 2, -49 },
  { 10702, 26, 36, 29, 3, -35 },
  { 10819, 35, 50, 37, 3, -49 },
  { 11038, 26, 36, 32, 4, -35 },
  { 11155, 35, 64, 19, -8, -49 },
  { 11435, 33, 50, 37, 2, -35 },
  { 11642, 31, 49, 36, 2, -49 },
  { 11832, 14, 47, 15, 2, -47 },
  { 11915, 25, 62, 15, -9, -47 },
  { 12109, 30, 49, 30, 2, -49 },
  { 12293, 14, 49, 15, 2, -49 },
  { 12379, 49, 35, 55, 2, -35 },
  { 12594, 31, 35, 36, 2, -35 },
  { 12730, 30, 36, 36, 3, -35 },
  { 12865, 34, 50, 37, -1, -35 },
  { 13078, 32, 50, 37, 3, -35 },
  { 13278, 24, 35, 25, 2, -35 },
  { 13383, 25, 36, 27, 1, -35 },
  { 13496, 19, 43, 21, 3, -42 },
  { 13599, 30, 35, 36, 4, -34 },
  { 13731, 28, 34, 28, 3, -34 },
  { 13850, 42, 34, 44, 4, -34 },
  { 14029, 33, 34, 30, -2, -34 },
  { 14170, 38, 49, 28, -7, -34 },
  { 14403, 29, 34, 28, -1, -34 },
  { 14527, 24, 56, 22, 1, -46 },
  { 14695, 3, 64, 35, 17, -49 },
  { 14719, 24, 56, 22, -3, -46 },
  { 14887, 29, 7, 37, 5, -26 },
};

const GFXfont NotoSans_LightItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_LIGHTITALIC64PT7B_H_
