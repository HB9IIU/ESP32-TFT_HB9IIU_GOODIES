#ifndef _NOTOSANS_LIGHTITALIC25PT7B_H_
#define _NOTOSANS_LIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x21, 0x18, 0xC4, 0x21, 0x18, 0xC4, 0x00, 0x00, 0xC6,
  0x00, 0x45, 0x3C, 0xF2, 0x8A, 0x28, 0x80, 0x01, 0x08, 0x06, 0x10, 0x08,
  0x60, 0x10, 0x80, 0x61, 0x00, 0x86, 0x1F, 0xFF, 0x82, 0x10, 0x08, 0x20,
  0x10, 0xC0, 0x21, 0x07, 0xFF, 0xEF, 0xFF, 0x82, 0x10, 0x04, 0x20, 0x10,
  0x40, 0x21, 0x80, 0x42, 0x00, 0x00, 0x80, 0x08, 0x07, 0xE0, 0xF7, 0x11,
  0x03, 0x10, 0x33, 0x03, 0x20, 0x1A, 0x00, 0xE0, 0x03, 0x80, 0x6C, 0x04,
  0x40, 0x44, 0x04, 0x40, 0x4C, 0xFF, 0x83, 0xE0, 0x08, 0x01, 0x80, 0x1E,
  0x02, 0x22, 0x04, 0x62, 0x0C, 0x42, 0x08, 0xC2, 0x10, 0xC2, 0x30, 0x82,
  0x60, 0x86, 0x4E, 0x84, 0x9B, 0xCD, 0xA1, 0x7B, 0x21, 0x02, 0x61, 0x04,
  0x41, 0x0C, 0x41, 0x08, 0x43, 0x10, 0x42, 0x20, 0x66, 0x60, 0x3C, 0x03,
  0xE0, 0x0C, 0x60, 0x30, 0xC0, 0x40, 0x80, 0x83, 0x01, 0x04, 0x03, 0x30,
  0x03, 0xC0, 0x0E, 0x00, 0x36, 0x01, 0x84, 0x1A, 0x04, 0x2C, 0x0C, 0xD0,
  0x0F, 0x20, 0x0C, 0x60, 0x38, 0x61, 0xD8, 0x7E, 0x18, 0x5F, 0xA8, 0x02,
  0x08, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x03, 0x02, 0x04, 0x0C, 0x00, 0x04, 0x06, 0x02, 0x02, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x0C,
  0x08, 0x10, 0x30, 0x20, 0xC0, 0x06, 0x00, 0xC2, 0x10, 0x62, 0x03, 0x40,
  0x1F, 0xC7, 0x01, 0xB0, 0x62, 0x08, 0x40, 0x0C, 0x00, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x33, 0x26, 0x48, 0xFC, 0xF0, 0x00, 0x20, 0x0C, 0x01, 0x00,
  0x60, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x00, 0x0F, 0x83, 0x18, 0xC1,
  0x90, 0x16, 0x02, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0,
  0x28, 0x05, 0x01, 0xA0, 0x26, 0x0C, 0xC3, 0x0F, 0xC0, 0x06, 0x38, 0xD7,
  0x68, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20,
  0xC0, 0x03, 0xE0, 0x71, 0x82, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x07, 0xFF, 0x00, 0x07, 0xC3, 0xC6, 0x10, 0x30,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x0C, 0x0F, 0x01, 0x38, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x81, 0x8F, 0xF0, 0x00, 0x18,
  0x01, 0xC0, 0x1C, 0x01, 0xA0, 0x19, 0x00, 0x98, 0x08, 0xC0, 0x84, 0x08,
  0x20, 0xC1, 0x0C, 0x18, 0xC0, 0xCF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x0F, 0xF0, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x30, 0x03, 0xF0, 0x31, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x0C, 0x81, 0x8F, 0xF0, 0x03, 0xF0, 0xE0, 0x18, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0xF8, 0xF0, 0xCC, 0x04, 0xC0, 0x48,
  0x04, 0x80, 0x48, 0x04, 0x80, 0xCC, 0x08, 0x63, 0x03, 0xE0, 0x7F, 0xF0,
  0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x07, 0xE0, 0xC3, 0x18, 0x11, 0x01, 0x10, 0x11, 0x03, 0x18, 0x20,
  0xCC, 0x07, 0x01, 0xD8, 0x30, 0xC4, 0x06, 0xC0, 0x2C, 0x02, 0xC0, 0x6C,
  0x04, 0x60, 0xC3, 0xF0, 0x07, 0xC1, 0xC6, 0x10, 0x33, 0x03, 0x20, 0x16,
  0x01, 0x60, 0x16, 0x03, 0x20, 0x73, 0x0F, 0x1F, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x87, 0x0F, 0xC0, 0x13, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xCC, 0x04, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x21,
  0x86, 0x10, 0x80, 0x00, 0x20, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x30,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x10, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x80, 0x40, 0x00, 0x3E, 0x31,
  0x80, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x78, 0xE0,
  0x18, 0x03, 0x04, 0x00, 0x21, 0x00, 0x06, 0x60, 0xFC, 0x48, 0x31, 0x0A,
  0x08, 0x21, 0x42, 0x04, 0x28, 0xC1, 0x87, 0x10, 0x20, 0xE2, 0x04, 0x3C,
  0x41, 0x85, 0x8C, 0x51, 0x90, 0xF3, 0xE2, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x10, 0x03, 0xFC, 0x00, 0x00, 0x20, 0x01, 0x80, 0x0F,
  0x00, 0x2C, 0x01, 0xB0, 0x04, 0x40, 0x31, 0x00, 0x84, 0x06, 0x10, 0x30,
  0x40, 0x81, 0x87, 0xFE, 0x10, 0x18, 0xC0, 0x22, 0x00, 0x98, 0x02, 0x40,
  0x0B, 0x00, 0x30, 0x0F, 0xE0, 0x21, 0xE1, 0x80, 0x86, 0x03, 0x10, 0x0C,
  0x40, 0x21, 0x01, 0x8C, 0x0C, 0x3F, 0xC0, 0x81, 0x82, 0x03, 0x08, 0x04,
  0x60, 0x11, 0x80, 0x44, 0x03, 0x10, 0x0C, 0xC1, 0xE3, 0xFE, 0x00, 0x03,
  0xF8, 0x3C, 0x31, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x20, 0x7F, 0x00, 0x0F, 0xC0, 0x11, 0xF0, 0x60,
  0x70, 0xC0, 0x61, 0x00, 0x62, 0x00, 0xC4, 0x01, 0x98, 0x03, 0x30, 0x06,
  0x40, 0x0C, 0x80, 0x19, 0x00, 0x26, 0x00, 0xCC, 0x03, 0x10, 0x04, 0x20,
  0x38, 0xC3, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x3F, 0xE1, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0xFF, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x03, 0xF8, 0x1E, 0x1C, 0x60, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x81, 0xFA,
  0x00, 0x24, 0x00, 0x4C, 0x01, 0x98, 0x03, 0x30, 0x04, 0x30, 0x08, 0x30,
  0x30, 0x3F, 0xC0, 0x08, 0x03, 0x08, 0x03, 0x18, 0x03, 0x18, 0x02, 0x10,
  0x02, 0x10, 0x06, 0x10, 0x06, 0x30, 0x04, 0x3F, 0xFC, 0x20, 0x04, 0x20,
  0x0C, 0x20, 0x0C, 0x60, 0x08, 0x60, 0x08, 0x40, 0x08, 0x40, 0x18, 0xC0,
  0x18, 0xC0, 0x10, 0x1F, 0x83, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10,
  0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x7C, 0x00,
  0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x0C, 0x3E, 0x04, 0x00, 0x08, 0x06, 0x10, 0x18, 0x60, 0x60, 0xC1,
  0x01, 0x04, 0x02, 0x30, 0x04, 0xC0, 0x1B, 0x00, 0x3E, 0x00, 0x76, 0x00,
  0x8C, 0x01, 0x08, 0x06, 0x18, 0x0C, 0x10, 0x10, 0x30, 0x20, 0x20, 0xC0,
  0x61, 0x80, 0x40, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x7F, 0xC0,
  0x0C, 0x00, 0x70, 0xC0, 0x06, 0x1C, 0x00, 0xA1, 0xC0, 0x1E, 0x16, 0x01,
  0x61, 0x60, 0x34, 0x12, 0x02, 0x43, 0x20, 0x64, 0x32, 0x04, 0xC2, 0x20,
  0x8C, 0x23, 0x18, 0x86, 0x31, 0x08, 0x61, 0x30, 0x84, 0x12, 0x18, 0x41,
  0x41, 0x84, 0x14, 0x10, 0xC1, 0x81, 0x0C, 0x18, 0x30, 0x08, 0x01, 0x0C,
  0x01, 0x1C, 0x03, 0x1E, 0x03, 0x12, 0x02, 0x12, 0x02, 0x13, 0x02, 0x31,
  0x06, 0x31, 0x86, 0x20, 0x84, 0x20, 0x84, 0x60, 0xCC, 0x60, 0x4C, 0x60,
  0x68, 0x40, 0x28, 0x40, 0x28, 0xC0, 0x38, 0xC0, 0x18, 0x03, 0xF0, 0x1C,
  0x70, 0x60, 0x31, 0x80, 0x36, 0x00, 0x6C, 0x00, 0xD0, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x2C, 0x00, 0xD8, 0x01, 0xB0,
  0x06, 0x30, 0x18, 0x30, 0x60, 0x3F, 0x80, 0x0F, 0xC0, 0x47, 0x86, 0x06,
  0x30, 0x31, 0x00, 0x88, 0x04, 0x40, 0x66, 0x02, 0x30, 0x31, 0xFF, 0x0F,
  0x80, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x03, 0xF0, 0x1C, 0x70, 0x60, 0x31, 0x80, 0x36, 0x00, 0x6C, 0x00,
  0xD0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x2C,
  0x00, 0xD8, 0x01, 0xB0, 0x06, 0x30, 0x18, 0x30, 0x60, 0x3F, 0x80, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x47, 0x86, 0x06,
  0x30, 0x31, 0x00, 0x88, 0x0C, 0x40, 0x66, 0x02, 0x30, 0x71, 0xFE, 0x08,
  0x60, 0x43, 0x06, 0x08, 0x30, 0x61, 0x01, 0x08, 0x08, 0xC0, 0x66, 0x01,
  0x00, 0x03, 0xF0, 0x70, 0xC6, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0xC1, 0xC3, 0xF8, 0x00, 0xFF, 0xF8, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x10, 0x02, 0x60, 0x04, 0xC0, 0x19, 0x00, 0x32, 0x00, 0x44, 0x00,
  0x98, 0x03, 0x30, 0x06, 0x40, 0x0C, 0x80, 0x11, 0x00, 0x26, 0x00, 0xCC,
  0x01, 0x98, 0x02, 0x30, 0x0C, 0x60, 0x30, 0x60, 0xC0, 0x7F, 0x00, 0xC0,
  0x0D, 0x00, 0x64, 0x01, 0x10, 0x0C, 0x40, 0x21, 0x81, 0x86, 0x04, 0x18,
  0x30, 0x60, 0x80, 0x86, 0x02, 0x10, 0x08, 0xC0, 0x22, 0x00, 0x90, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0x40, 0x00, 0x80, 0x60, 0x38, 0x06, 0x02,
  0x80, 0xA0, 0x68, 0x0A, 0x04, 0x81, 0xA0, 0xCC, 0x12, 0x0C, 0xC3, 0x20,
  0x8C, 0x22, 0x18, 0xC6, 0x21, 0x0C, 0x42, 0x30, 0xCC, 0x22, 0x0C, 0x82,
  0x60, 0xD8, 0x24, 0x05, 0x02, 0xC0, 0x70, 0x28, 0x06, 0x02, 0x80, 0x60,
  0x30, 0x04, 0x03, 0x00, 0x08, 0x03, 0x0C, 0x06, 0x04, 0x0C, 0x06, 0x18,
  0x02, 0x10, 0x02, 0x20, 0x03, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x04, 0xC0, 0x0C, 0x40, 0x18, 0x60, 0x30, 0x60, 0x20, 0x20,
  0x40, 0x30, 0xC0, 0x10, 0xC0, 0x1A, 0x01, 0x90, 0x18, 0xC0, 0x82, 0x0C,
  0x10, 0xC0, 0xC4, 0x06, 0x60, 0x16, 0x00, 0xA0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0x86, 0x02, 0x01, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0,
  0x40, 0x20, 0x30, 0x18, 0x08, 0x07, 0xC0, 0x88, 0x88, 0xCC, 0x44, 0x44,
  0x66, 0x22, 0x22, 0x33, 0x07, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x3E, 0x00, 0x03, 0x00, 0x30, 0x07,
  0x80, 0x48, 0x08, 0x81, 0x84, 0x10, 0x43, 0x06, 0x20, 0x24, 0x02, 0xC0,
  0x30, 0xFF, 0xFF, 0xE0, 0x99, 0x10, 0x03, 0x00, 0xF9, 0x18, 0x53, 0x07,
  0x60, 0x24, 0x02, 0x40, 0x2C, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0xCC, 0x14,
  0x63, 0x43, 0xCC, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x08,
  0x37, 0xE3, 0xC3, 0x30, 0x33, 0x01, 0x20, 0x16, 0x03, 0x60, 0x34, 0x03,
  0x40, 0x2C, 0x06, 0xE0, 0xCA, 0x18, 0x9F, 0x00, 0x01, 0x01, 0xFC, 0x60,
  0x18, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20,
  0x06, 0x08, 0x7E, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x08, 0x60, 0xFD, 0x06, 0x14, 0x30, 0x31, 0x80, 0xC4, 0x03, 0x10,
  0x08, 0xC0, 0x23, 0x01, 0x8C, 0x06, 0x30, 0x30, 0xC1, 0xC1, 0x8D, 0x03,
  0xC4, 0x00, 0x03, 0x01, 0xF8, 0x61, 0x18, 0x36, 0x04, 0x81, 0x91, 0xE7,
  0xF0, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x08, 0x7F, 0x00, 0x00, 0x7C,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0xFE, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x2C, 0x00, 0xE0, 0x00, 0x02, 0x08, 0x7E, 0x86, 0x14, 0x60,
  0x66, 0x03, 0x20, 0x19, 0x00, 0x98, 0x04, 0xC0, 0x66, 0x03, 0x30, 0x31,
  0x83, 0x86, 0x34, 0x1E, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x31,
  0xC1, 0xF8, 0x00, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x08,
  0x37, 0xE3, 0xC3, 0x30, 0x33, 0x03, 0x20, 0x36, 0x02, 0x60, 0x24, 0x06,
  0x40, 0x6C, 0x04, 0xC0, 0x4C, 0x04, 0x80, 0xC0, 0x18, 0xC0, 0x00, 0x18,
  0xC4, 0x21, 0x18, 0xC4, 0x23, 0x18, 0xC4, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20,
  0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0x82, 0xC1, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x01, 0x30, 0x63, 0x0C, 0x21,
  0x82, 0x30, 0x26, 0x06, 0xC0, 0x54, 0x06, 0x60, 0x42, 0x0C, 0x30, 0xC1,
  0x0C, 0x18, 0x81, 0x80, 0x08, 0xC6, 0x21, 0x08, 0xC6, 0x21, 0x08, 0xC6,
  0x21, 0x18, 0xC6, 0x20, 0x01, 0x01, 0x86, 0xF8, 0xF8, 0xA1, 0xA1, 0x98,
  0x18, 0x13, 0x03, 0x02, 0x40, 0xC0, 0xD8, 0x18, 0x1B, 0x02, 0x02, 0x40,
  0x40, 0x48, 0x08, 0x0B, 0x03, 0x03, 0x60, 0x60, 0x6C, 0x08, 0x09, 0x01,
  0x01, 0x00, 0x01, 0x83, 0x7E, 0x3C, 0x33, 0x83, 0x30, 0x32, 0x03, 0x60,
  0x26, 0x02, 0x40, 0x64, 0x06, 0xC0, 0x4C, 0x04, 0xC0, 0x48, 0x0C, 0x03,
  0x00, 0xFC, 0x18, 0x63, 0x03, 0x60, 0x34, 0x03, 0x40, 0x3C, 0x03, 0xC0,
  0x2C, 0x02, 0xC0, 0x64, 0x0C, 0x61, 0x83, 0xF0, 0x00, 0x40, 0xDF, 0x85,
  0x86, 0x38, 0x31, 0x80, 0x88, 0x04, 0xC0, 0x66, 0x03, 0x20, 0x19, 0x00,
  0x98, 0x0C, 0xE0, 0xC5, 0x0C, 0x27, 0xC1, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x00, 0x02, 0x08, 0x7E, 0x86, 0x14, 0x60, 0x66,
  0x03, 0x20, 0x19, 0x00, 0x98, 0x04, 0xC0, 0x66, 0x03, 0x30, 0x31, 0x83,
  0x86, 0x34, 0x1E, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x01, 0x9B, 0xCB, 0x07, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x30, 0x18, 0x0C, 0x04, 0x00, 0x02, 0x07, 0xF3, 0x00, 0x80, 0x20,
  0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x18, 0x06, 0x83, 0x3F, 0x80,
  0x18, 0x10, 0x10, 0xFF, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40,
  0xC0, 0xC0, 0xC0, 0x78, 0x30, 0x12, 0x01, 0x20, 0x32, 0x03, 0x60, 0x26,
  0x02, 0x40, 0x64, 0x06, 0x40, 0x4C, 0x0C, 0xC1, 0x44, 0x34, 0x7C, 0xC0,
  0xC0, 0x78, 0x09, 0x03, 0x20, 0x44, 0x10, 0x86, 0x18, 0x83, 0x30, 0x64,
  0x05, 0x80, 0xA0, 0x1C, 0x03, 0x00, 0xC0, 0x81, 0xE0, 0xE0, 0x90, 0x70,
  0xC8, 0x58, 0x44, 0x2C, 0x62, 0x22, 0x21, 0x11, 0x30, 0x90, 0x90, 0x48,
  0x58, 0x28, 0x28, 0x14, 0x14, 0x0C, 0x0E, 0x06, 0x06, 0x00, 0x18, 0x18,
  0x41, 0x83, 0x18, 0x09, 0x80, 0x78, 0x01, 0x80, 0x0C, 0x00, 0xA0, 0x0D,
  0x80, 0xC4, 0x0C, 0x30, 0xC0, 0x8C, 0x06, 0x00, 0x0C, 0x06, 0x08, 0x08,
  0x10, 0x30, 0x20, 0x40, 0x41, 0x80, 0xC6, 0x01, 0x88, 0x03, 0x30, 0x02,
  0x40, 0x05, 0x80, 0x0A, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x1F, 0xE0, 0x18, 0x02,
  0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x60,
  0x0F, 0xF8, 0x01, 0xC0, 0xC0, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x08, 0x06, 0x07, 0x03, 0x80, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x03,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x00, 0xE0, 0x70,
  0x40, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x03, 0x07, 0x00, 0x7C,
  0x30, 0xFC, 0x02, 0x00,
};

const GFXglyph NotoSans_LightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 18, 6, 1, -18 },
  { 13, 6, 7, 9, 3, -18 },
  { 19, 15, 18, 16, 1, -18 },
  { 53, 12, 20, 14, 1, -19 },
  { 83, 16, 18, 20, 2, -18 },
  { 119, 15, 18, 17, 1, -18 },
  { 153, 2, 7, 5, 3, -18 },
  { 155, 7, 22, 7, 1, -18 },
  { 175, 8, 22, 7, -2, -18 },
  { 197, 11, 11, 14, 3, -19 },
  { 213, 11, 12, 14, 2, -15 },
  { 230, 4, 6, 6, -1, -3 },
  { 233, 6, 1, 8, 1, -7 },
  { 234, 2, 2, 6, 1, -2 },
  { 235, 11, 18, 8, -1, -18 },
  { 260, 11, 18, 14, 2, -18 },
  { 285, 7, 18, 14, 4, -18 },
  { 301, 13, 18, 14, 0, -18 },
  { 331, 12, 18, 14, 1, -18 },
  { 358, 13, 18, 14, 0, -18 },
  { 388, 12, 18, 14, 1, -18 },
  { 415, 12, 18, 14, 2, -18 },
  { 442, 12, 18, 14, 2, -18 },
  { 469, 12, 18, 14, 1, -18 },
  { 496, 12, 18, 14, 1, -18 },
  { 523, 4, 14, 6, 1, -14 },
  { 530, 6, 17, 6, -1, -14 },
  { 543, 11, 12, 14, 2, -15 },
  { 560, 11, 6, 14, 2, -12 },
  { 569, 11, 12, 14, 2, -15 },
  { 586, 9, 18, 10, 2, -18 },
  { 607, 19, 20, 21, 1, -18 },
  { 655, 14, 18, 14, -1, -18 },
  { 687, 14, 18, 15, 1, -18 },
  { 719, 14, 18, 15, 2, -18 },
  { 751, 15, 18, 17, 1, -18 },
  { 785, 13, 18, 13, 1, -18 },
  { 815, 13, 18, 12, 1, -18 },
  { 845, 15, 18, 17, 2, -18 },
  { 879, 16, 18, 17, 1, -18 },
  { 915, 9, 18, 8, 0, -18 },
  { 936, 10, 23, 6, -4, -18 },
  { 965, 15, 18, 14, 1, -18 },
  { 999, 9, 18, 12, 1, -18 },
  { 1020, 20, 18, 21, 1, -18 },
  { 1065, 16, 18, 17, 1, -18 },
  { 1101, 15, 18, 18, 2, -18 },
  { 1135, 13, 18, 14, 1, -18 },
  { 1165, 15, 22, 18, 2, -18 },
  { 1207, 13, 18, 14, 1, -18 },
  { 1237, 13, 18, 13, 0, -18 },
  { 1267, 13, 18, 12, 2, -18 },
  { 1297, 15, 18, 17, 2, -18 },
  { 1331, 14, 18, 14, 2, -18 },
  { 1363, 20, 18, 21, 3, -18 },
  { 1408, 16, 18, 13, -1, -18 },
  { 1444, 13, 18, 12, 2, -18 },
  { 1474, 14, 18, 13, 0, -18 },
  { 1506, 9, 22, 7, 0, -18 },
  { 1531, 4, 18, 8, 3, -18 },
  { 1540, 10, 22, 7, -2, -18 },
  { 1568, 12, 11, 14, 1, -18 },
  { 1585, 10, 2, 10, -2, 2 },
  { 1588, 3, 4, 6, 4, -19 },
  { 1590, 12, 14, 14, 1, -14 },
  { 1611, 12, 19, 14, 1, -19 },
  { 1640, 11, 14, 11, 1, -14 },
  { 1660, 14, 19, 14, 1, -19 },
  { 1694, 11, 14, 12, 1, -14 },
  { 1714, 14, 25, 7, -3, -19 },
  { 1758, 13, 20, 14, 1, -14 },
  { 1791, 12, 19, 14, 1, -19 },
  { 1820, 5, 18, 6, 1, -18 },
  { 1832, 9, 24, 6, -3, -18 },
  { 1859, 12, 19, 12, 1, -19 },
  { 1888, 5, 19, 6, 1, -19 },
  { 1900, 19, 14, 21, 1, -14 },
  { 1934, 12, 14, 14, 1, -14 },
  { 1955, 12, 14, 14, 1, -14 },
  { 1976, 13, 20, 14, 0, -14 },
  { 2009, 13, 20, 14, 1, -14 },
  { 2042, 9, 14, 10, 1, -14 },
  { 2058, 10, 14, 11, 0, -14 },
  { 2076, 8, 16, 8, 1, -16 },
  { 2092, 12, 13, 14, 1, -13 },
  { 2112, 11, 13, 11, 1, -13 },
  { 2130, 17, 13, 17, 1, -13 },
  { 2158, 13, 13, 12, -1, -13 },
  { 2180, 15, 19, 11, -3, -13 },
  { 2216, 11, 13, 11, 0, -13 },
  { 2234, 10, 22, 8, 0, -18 },
  { 2262, 1, 25, 14, 7, -19 },
  { 2266, 9, 22, 8, -1, -18 },
  { 2291, 11, 3, 14, 2, -10 },
};

const GFXfont NotoSans_LightItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_LIGHTITALIC25PT7B_H_
