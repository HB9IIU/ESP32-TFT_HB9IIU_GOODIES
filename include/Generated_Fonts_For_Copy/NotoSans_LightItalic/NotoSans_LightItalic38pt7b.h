#ifndef _NOTOSANS_LIGHTITALIC38PT7B_H_
#define _NOTOSANS_LIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0xE0, 0x30, 0xCC, 0x77, 0x19, 0x86, 0x61, 0x98, 0x64,
  0x11, 0x0C, 0xC3, 0x30, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0x60, 0x20, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x02, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x40,
  0x01, 0x81, 0x80, 0x03, 0x03, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0,
  0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0x80, 0x80, 0x03, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x03, 0xFF, 0xC1, 0xEC,
  0xE0, 0xE3, 0x08, 0x70, 0xC0, 0x18, 0x20, 0x06, 0x18, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x1C, 0x60, 0x03, 0xD0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x23, 0x80, 0x08, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x10, 0x60, 0x0C, 0x38, 0x83, 0x3C, 0x3F, 0xFC, 0x03, 0xFC, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x01, 0x00, 0x01,
  0x07, 0xE0, 0x03, 0x07, 0x38, 0x03, 0x07, 0x0C, 0x01, 0x83, 0x06, 0x01,
  0x83, 0x03, 0x01, 0x81, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x60,
  0xC0, 0x60, 0x30, 0xC0, 0x30, 0x18, 0xC0, 0x18, 0x18, 0x61, 0x0C, 0x0C,
  0x67, 0xF6, 0x06, 0x67, 0x1B, 0x06, 0x63, 0x06, 0xC6, 0x33, 0x03, 0x7E,
  0x31, 0x81, 0x84, 0x31, 0x80, 0xC0, 0x38, 0xC0, 0x60, 0x18, 0x60, 0x30,
  0x18, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x08, 0x0C, 0x0C, 0x04, 0x0C,
  0x0C, 0x03, 0x06, 0x0C, 0x01, 0x86, 0x06, 0x00, 0xE7, 0x0E, 0x00, 0x3F,
  0x00, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x00, 0x1E, 0x78, 0x00, 0xE0, 0x60,
  0x03, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x06,
  0x01, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0xE0, 0x00, 0xEF, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x1C, 0x03, 0x38, 0x30, 0x0D,
  0x80, 0x60, 0x6E, 0x01, 0xC1, 0xB0, 0x03, 0x0C, 0xC0, 0x06, 0x63, 0x00,
  0x1F, 0x8C, 0x00, 0x3C, 0x30, 0x00, 0xE0, 0xC0, 0x07, 0xC3, 0x80, 0x73,
  0x87, 0xFF, 0x87, 0x07, 0xF8, 0x0E, 0x33, 0x76, 0x66, 0x44, 0xCC, 0x00,
  0x70, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x04,
  0x0C, 0x07, 0x86, 0x00, 0xF3, 0x00, 0x1F, 0x0F, 0x01, 0xFF, 0x81, 0xE0,
  0x01, 0xB0, 0x01, 0x8C, 0x01, 0x86, 0x03, 0xC3, 0x00, 0xC0, 0xC0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x0E, 0x38, 0x70, 0xC3, 0x86,
  0x18, 0x30, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x3F, 0x80, 0x3C, 0xF0, 0x1C, 0x0E, 0x0E, 0x01, 0xC3, 0x00, 0x31, 0xC0,
  0x0C, 0x60, 0x03, 0x38, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0D, 0xC0, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x07, 0xE0, 0x01, 0xB8,
  0x00, 0x6E, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0x38, 0x01, 0xC6, 0x00,
  0x61, 0x80, 0x38, 0x70, 0x1C, 0x0C, 0x0E, 0x03, 0xFF, 0x00, 0x3F, 0x80,
  0x01, 0xC0, 0xF0, 0xEC, 0x76, 0x79, 0xB8, 0x64, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0x00, 0x04,
  0x00, 0x07, 0xF8, 0x01, 0xF3, 0xC0, 0x38, 0x0E, 0x02, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x08, 0x00, 0x3F,
  0xE0, 0x1F, 0x1F, 0x07, 0x00, 0x60, 0x40, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x18, 0x03, 0xC3, 0xFF, 0xF0,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x36, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x03, 0x8C, 0x00,
  0x70, 0xC0, 0x06, 0x1C, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x03, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x81, 0xC0, 0x30, 0x38, 0x03, 0x03, 0x00, 0x30,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x07, 0xFE, 0x01, 0xF3, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0xC0, 0x1E, 0x1F, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xF0, 0x1F, 0x88, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x87, 0xC0, 0x67, 0xFC, 0x3B, 0x07, 0x8D,
  0x00, 0x63, 0x80, 0x1C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00,
  0x0C, 0xC0, 0x07, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x30, 0xE0, 0x1C,
  0x1C, 0x0E, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0x3C, 0x78,
  0x1C, 0x07, 0x0E, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x70, 0x60, 0x38, 0x1C, 0x1C, 0x03, 0x9C, 0x00, 0x3C,
  0x00, 0x7F, 0x80, 0x78, 0x70, 0x38, 0x0E, 0x1C, 0x01, 0xCE, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x1C, 0xE0,
  0x06, 0x1C, 0x07, 0x83, 0xEF, 0xC0, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x7F,
  0x80, 0x78, 0xF0, 0x38, 0x0E, 0x1C, 0x01, 0x86, 0x00, 0x63, 0x80, 0x1C,
  0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x07, 0x30,
  0x01, 0xCC, 0x00, 0xE3, 0x80, 0x78, 0x70, 0x76, 0x0F, 0xFB, 0x80, 0xF0,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x3C, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x04,
  0x1C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x87, 0x0E, 0x00, 0x00, 0x80, 0x70, 0x3C, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xC0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0xFF, 0x87, 0xCF, 0x08, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x38,
  0x07, 0xFC, 0x19, 0x80, 0xE0, 0xC0, 0xDC, 0x0E, 0x06, 0x06, 0xC0, 0xC0,
  0x30, 0x36, 0x06, 0x01, 0x81, 0xA0, 0x60, 0x18, 0x0F, 0x03, 0x00, 0xC0,
  0x78, 0x30, 0x06, 0x06, 0xC1, 0x80, 0x60, 0x36, 0x0C, 0x03, 0x01, 0xB0,
  0x60, 0x38, 0x19, 0x83, 0x01, 0x41, 0xCC, 0x0C, 0x1B, 0x1C, 0x70, 0x7F,
  0x9F, 0xC1, 0x80, 0xF0, 0x78, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x20, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x03, 0x1C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x18,
  0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x06, 0x01, 0xC0, 0x70,
  0x06, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0x80, 0x0C, 0x1C, 0x00, 0x60,
  0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xE6, 0x00, 0x03, 0x70, 0x00,
  0x1B, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x06,
  0x00, 0xE0, 0x60, 0x07, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x71, 0xC0, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x78,
  0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x38, 0x03, 0x83, 0x00, 0x1C, 0x30, 0x00,
  0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00,
  0x1C, 0x60, 0x01, 0x8E, 0x00, 0x38, 0xC0, 0x0F, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0x7E, 0x07, 0x80,
  0x20, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x08, 0x07, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x60, 0x1E,
  0x01, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0, 0x01, 0xC3,
  0x00, 0x07, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x80, 0x01, 0xCC, 0x00, 0x07,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0x60,
  0x00, 0x61, 0x80, 0x03, 0x86, 0x00, 0x3C, 0x38, 0x01, 0xE0, 0xC0, 0x3E,
  0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0xF0, 0x3F, 0xFE, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x81,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xE0, 0x1F,
  0xDF, 0xC0, 0xF0, 0x03, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xFF, 0xB0, 0x03,
  0xFC, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x1C,
  0xE0, 0x00, 0x63, 0x80, 0x01, 0x86, 0x00, 0x06, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xF0, 0x03, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0x00,
  0x03, 0x06, 0x00, 0x07, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00,
  0x06, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x0C, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x38, 0x00, 0x18, 0x30, 0x00, 0x38, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x70, 0x00, 0x70, 0x60, 0x00,
  0x70, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xC0, 0x00,
  0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x07, 0xF8, 0x0F, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x03,
  0xF0, 0x3F, 0xC0, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x87, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x07,
  0x00, 0x1C, 0x18, 0x00, 0xE0, 0x60, 0x07, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0x80, 0x30, 0x0C, 0x00, 0xC0, 0xE0, 0x03, 0x07, 0x00, 0x0C, 0x38, 0x00,
  0x71, 0xC0, 0x01, 0x8E, 0x00, 0x06, 0x70, 0x00, 0x1B, 0xC0, 0x00, 0x7B,
  0x80, 0x03, 0xC6, 0x00, 0x0E, 0x1C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xE0,
  0x03, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xE0, 0x38, 0x01, 0x80, 0xC0, 0x07, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3E, 0x0F, 0x00, 0x01, 0xF0, 0xD8, 0x00, 0x1B, 0x06, 0xC0, 0x00, 0xD8,
  0x33, 0x00, 0x0C, 0xC1, 0x98, 0x00, 0xE6, 0x0C, 0xC0, 0x06, 0x60, 0xE6,
  0x00, 0x63, 0x06, 0x30, 0x03, 0x18, 0x31, 0x80, 0x30, 0xC1, 0x84, 0x01,
  0x8E, 0x0C, 0x30, 0x18, 0x60, 0xC1, 0x81, 0xC3, 0x06, 0x0C, 0x0C, 0x18,
  0x30, 0x60, 0xC0, 0xC1, 0x83, 0x06, 0x0E, 0x1C, 0x18, 0x60, 0x60, 0xC0,
  0x63, 0x03, 0x06, 0x03, 0x30, 0x18, 0x30, 0x1B, 0x80, 0xC1, 0x80, 0xD8,
  0x0E, 0x1C, 0x07, 0x80, 0x60, 0xC0, 0x3C, 0x03, 0x06, 0x01, 0xC0, 0x18,
  0x30, 0x06, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x07, 0x80,
  0x03, 0x07, 0x80, 0x07, 0x0D, 0x80, 0x06, 0x0C, 0xC0, 0x06, 0x0C, 0xC0,
  0x06, 0x0C, 0xE0, 0x0E, 0x0C, 0x60, 0x0C, 0x1C, 0x60, 0x0C, 0x18, 0x30,
  0x0C, 0x18, 0x30, 0x0C, 0x18, 0x38, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x18,
  0x18, 0x30, 0x0C, 0x18, 0x30, 0x0C, 0x18, 0x30, 0x06, 0x38, 0x70, 0x06,
  0x30, 0x60, 0x07, 0x30, 0x60, 0x03, 0x30, 0x60, 0x03, 0x30, 0x60, 0x01,
  0xE0, 0xE0, 0x01, 0xE0, 0xC0, 0x01, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xCF, 0xC0, 0x3C, 0x03,
  0xC0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x87, 0x00, 0x03, 0x1C, 0x00, 0x07,
  0x30, 0x00, 0x0E, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x76, 0x00, 0x00, 0xCE, 0x00,
  0x03, 0x9C, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x38, 0x01,
  0xE0, 0x78, 0x07, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x18, 0x07, 0x03, 0x00, 0x70, 0xE0, 0x06, 0x1C, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x03,
  0x8C, 0x00, 0x61, 0x80, 0x38, 0x30, 0x1F, 0x0F, 0xFF, 0x81, 0xFF, 0x80,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xCF, 0xC0,
  0x3C, 0x03, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x87, 0x00, 0x03, 0x1C,
  0x00, 0x07, 0x30, 0x00, 0x0E, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x76, 0x00, 0x00,
  0xCE, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0x38, 0x01, 0xC0, 0x78, 0x07, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x18, 0x07,
  0x03, 0x00, 0x70, 0xE0, 0x06, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x03, 0x8C, 0x00, 0xE1, 0x80, 0x38,
  0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0x81, 0x80, 0x30, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x70, 0x38, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x1C, 0x18, 0x01, 0x87,
  0x00, 0x30, 0xC0, 0x07, 0x18, 0x00, 0x63, 0x00, 0x0E, 0x00, 0x00, 0x08,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x83, 0x80, 0x20, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x10, 0x07, 0x83,
  0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x38, 0xE0, 0x00, 0x71, 0x80, 0x00,
  0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x18,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC7, 0x00, 0x03, 0x8E,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x71, 0xC0,
  0x00, 0xE3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x1C, 0x00,
  0x18, 0x38, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x78, 0x07, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0xCC,
  0x00, 0x1C, 0xC0, 0x01, 0x8E, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x70,
  0x60, 0x06, 0x06, 0x00, 0xE0, 0x60, 0x0C, 0x06, 0x01, 0xC0, 0x60, 0x18,
  0x06, 0x03, 0x00, 0x70, 0x30, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x33, 0x80, 0x03, 0x30, 0x00, 0x37,
  0x00, 0x01, 0x60, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x19, 0x80, 0x1E, 0x00, 0x73,
  0x00, 0x3C, 0x00, 0xC6, 0x00, 0xD8, 0x03, 0x8C, 0x01, 0xB0, 0x06, 0x18,
  0x06, 0x60, 0x0C, 0x30, 0x0C, 0xC0, 0x30, 0x60, 0x39, 0x80, 0x60, 0xC0,
  0x63, 0x01, 0x81, 0x81, 0xC6, 0x03, 0x03, 0x03, 0x0C, 0x0E, 0x06, 0x06,
  0x08, 0x18, 0x0C, 0x18, 0x18, 0x70, 0x18, 0x30, 0x30, 0xC0, 0x30, 0xC0,
  0x61, 0x80, 0x61, 0x80, 0xC6, 0x00, 0xC6, 0x01, 0x8C, 0x01, 0x8C, 0x03,
  0x30, 0x03, 0x30, 0x06, 0x60, 0x06, 0x60, 0x0D, 0x80, 0x0D, 0x80, 0x1B,
  0x00, 0x1B, 0x00, 0x36, 0x00, 0x14, 0x00, 0x78, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x07,
  0x01, 0x80, 0x06, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x38,
  0x00, 0xE0, 0x70, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x33, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0xC7, 0x00, 0x01, 0x83, 0x00, 0x03, 0x03, 0x00, 0x07, 0x03, 0x80,
  0x0E, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x70, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0xC0, 0x01, 0xF0, 0x00, 0x6E, 0x00,
  0x39, 0x80, 0x1C, 0x60, 0x06, 0x18, 0x03, 0x07, 0x01, 0xC0, 0xC0, 0x60,
  0x30, 0x30, 0x0C, 0x1C, 0x01, 0x86, 0x00, 0x63, 0x00, 0x19, 0xC0, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFC,
  0x0F, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xC3, 0x0C, 0x10, 0x61,
  0x86, 0x18, 0x60, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x18, 0x61, 0x86, 0x18,
  0x60, 0xC3, 0x0C, 0x30, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x06, 0x60, 0x01, 0x98, 0x00, 0xC2, 0x00, 0x30, 0xC0, 0x18,
  0x30, 0x0E, 0x06, 0x03, 0x01, 0x81, 0x80, 0x60, 0x60, 0x0C, 0x30, 0x03,
  0x1C, 0x00, 0x46, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0xC7, 0x18, 0x63, 0x0C, 0x00, 0x60, 0x00, 0xFE, 0x30, 0x79,
  0xCC, 0x38, 0x1B, 0x18, 0x03, 0x8E, 0x00, 0xE3, 0x00, 0x39, 0xC0, 0x0E,
  0x60, 0x03, 0x98, 0x00, 0xCE, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x07, 0x30,
  0x01, 0x8C, 0x00, 0xE3, 0x00, 0x38, 0xC0, 0x1E, 0x38, 0x0D, 0x86, 0x06,
  0x41, 0xFF, 0x30, 0x3F, 0x8C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x0C, 0x01, 0x8F, 0xE0, 0x33, 0x8E, 0x06, 0xC0, 0xE0, 0xF0,
  0x0C, 0x3C, 0x01, 0xC7, 0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x1C, 0xE0, 0x03, 0x98, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x63, 0x80, 0x0C, 0x70, 0x03, 0x0F, 0x00, 0xE1, 0xB0, 0x38, 0x67, 0xBE,
  0x0C, 0x7F, 0x00, 0x00, 0x30, 0x07, 0xFC, 0x1E, 0x18, 0xF0, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x21, 0xF7, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x60, 0xE0, 0x3F, 0xCC, 0x07, 0x8E, 0xC0, 0xE0,
  0x6C, 0x18, 0x03, 0xC3, 0x80, 0x1C, 0x30, 0x01, 0x87, 0x00, 0x18, 0x60,
  0x01, 0x8E, 0x00, 0x18, 0xE0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0xE0, 0xC0, 0x1E, 0x0E, 0x03, 0x60,
  0x60, 0x66, 0x07, 0xFC, 0x60, 0x3F, 0x8C, 0x00, 0x00, 0x20, 0x03, 0xFC,
  0x07, 0x8E, 0x0E, 0x06, 0x18, 0x07, 0x38, 0x07, 0x30, 0x06, 0x70, 0x06,
  0x60, 0x1C, 0x60, 0xF8, 0xFF, 0xE0, 0xFC, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x08, 0x3F, 0xF8,
  0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x40, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x30, 0x10, 0x1F, 0xE2, 0x03,
  0xC7, 0x60, 0x70, 0x36, 0x0C, 0x01, 0xE1, 0xC0, 0x0E, 0x18, 0x00, 0xC3,
  0x80, 0x0C, 0x30, 0x00, 0xC7, 0x00, 0x0C, 0x70, 0x01, 0x86, 0x00, 0x18,
  0x60, 0x01, 0x86, 0x00, 0x38, 0x60, 0x03, 0x86, 0x00, 0x70, 0x60, 0x0F,
  0x07, 0x01, 0xB0, 0x30, 0x33, 0x03, 0xFE, 0x70, 0x1F, 0xC6, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x0C, 0x07, 0x80, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x0C, 0x03, 0x1F, 0xE0, 0xCE, 0x3C, 0x36, 0x03,
  0x0F, 0x00, 0xC7, 0x80, 0x31, 0xC0, 0x0C, 0x70, 0x03, 0x18, 0x00, 0xC6,
  0x00, 0x33, 0x80, 0x1C, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00,
  0x39, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x1C,
  0xC0, 0x06, 0x00, 0x03, 0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30,
  0x30, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x3F, 0x00, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x70, 0xC0,
  0x30, 0x30, 0x18, 0x0C, 0x0C, 0x07, 0x06, 0x01, 0x83, 0x00, 0x61, 0x80,
  0x19, 0xC0, 0x06, 0xE0, 0x03, 0x7C, 0x00, 0xFB, 0x00, 0x3C, 0xC0, 0x0C,
  0x18, 0x03, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x06, 0x01,
  0x83, 0x80, 0x70, 0xC0, 0x0E, 0x00, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06,
  0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18,
  0x38, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0x00,
  0x08, 0x00, 0x80, 0x63, 0xF8, 0x3F, 0x83, 0x39, 0xE3, 0x9E, 0x1B, 0x03,
  0x30, 0x30, 0xF0, 0x1B, 0x01, 0x8F, 0x00, 0xF0, 0x0C, 0x70, 0x07, 0x00,
  0x63, 0x80, 0x38, 0x03, 0x18, 0x01, 0x80, 0x18, 0xC0, 0x0C, 0x00, 0xCE,
  0x00, 0xE0, 0x0E, 0x60, 0x06, 0x00, 0x63, 0x00, 0x30, 0x03, 0x18, 0x01,
  0x80, 0x18, 0xC0, 0x0C, 0x00, 0xCE, 0x00, 0xC0, 0x0E, 0x60, 0x06, 0x00,
  0x63, 0x00, 0x30, 0x03, 0x18, 0x01, 0x80, 0x19, 0xC0, 0x1C, 0x01, 0xCC,
  0x00, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x1F, 0xE0, 0xCF, 0x3C, 0x36,
  0x07, 0x0F, 0x00, 0xC7, 0x80, 0x31, 0xC0, 0x0C, 0x70, 0x03, 0x18, 0x00,
  0xC6, 0x00, 0x73, 0x80, 0x1C, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x67,
  0x00, 0x39, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x80,
  0x1C, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x78, 0xF0, 0x70,
  0x0C, 0x18, 0x03, 0x8C, 0x00, 0x67, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01,
  0xF8, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xEC,
  0x00, 0x33, 0x00, 0x0C, 0xE0, 0x06, 0x18, 0x03, 0x87, 0x01, 0xC0, 0xFF,
  0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x18, 0xFE, 0x00, 0xCE, 0x38,
  0x06, 0xC0, 0xE0, 0x3C, 0x03, 0x03, 0xC0, 0x1C, 0x1C, 0x00, 0x60, 0xE0,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0xC3, 0x80, 0x0C, 0x1C, 0x00,
  0xC0, 0xF0, 0x0E, 0x06, 0xC0, 0xE0, 0x77, 0xBE, 0x03, 0x1F, 0xC0, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x20, 0x7F, 0x88, 0x1E, 0x3B, 0x07, 0x03, 0x61, 0x80, 0x3C, 0x70,
  0x07, 0x8C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x01, 0x9C, 0x00, 0x33, 0x80,
  0x0E, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0E, 0x30, 0x01, 0xC6, 0x00,
  0x70, 0xC0, 0x1E, 0x1C, 0x06, 0xC1, 0x81, 0x98, 0x3F, 0xE7, 0x03, 0xF8,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x18, 0xFC, 0x33, 0xD0, 0x6C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xFC, 0x3C, 0x78, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x33, 0x00, 0xE7, 0xFF, 0x87, 0xFC, 0x00, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x01, 0xC1, 0xFF, 0xFF, 0xF8, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x38, 0x07, 0xB0, 0x7E, 0x00, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x0C, 0xE0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0E,
  0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x1C, 0xE0, 0x07, 0x30,
  0x01, 0x8C, 0x00, 0xE3, 0x00, 0x78, 0xE0, 0x36, 0x38, 0x19, 0x07, 0xFC,
  0xC0, 0xFE, 0x30, 0xC0, 0x03, 0xE0, 0x03, 0xB0, 0x01, 0x9C, 0x01, 0x86,
  0x00, 0xC3, 0x00, 0xC1, 0x80, 0xE0, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x30,
  0x18, 0x38, 0x0E, 0x18, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xCC, 0x00, 0x6E,
  0x00, 0x36, 0x00, 0x1B, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x1C,
  0x01, 0xE0, 0x0E, 0x01, 0xF0, 0x0F, 0x00, 0xD8, 0x07, 0x80, 0xEC, 0x06,
  0xC0, 0x67, 0x03, 0x60, 0x73, 0x83, 0x30, 0x30, 0xC1, 0x98, 0x18, 0x61,
  0x86, 0x18, 0x30, 0xC3, 0x0C, 0x18, 0xC1, 0x8C, 0x0C, 0x60, 0xC6, 0x06,
  0x60, 0x66, 0x03, 0x30, 0x33, 0x01, 0xB0, 0x1B, 0x80, 0xD8, 0x0D, 0x80,
  0x78, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0xF0, 0x60, 0x0C, 0x07, 0x01, 0x80, 0x30, 0x30, 0x03,
  0x07, 0x00, 0x18, 0xE0, 0x01, 0x9C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0x71, 0x80,
  0x0E, 0x18, 0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0xE0, 0x60, 0x06,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x60,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00,
  0xC0, 0x60, 0x01, 0x81, 0xC0, 0x03, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x58, 0x00, 0x00, 0xB0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0,
  0x00, 0x3C, 0x03, 0xF0, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x01, 0xF0, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x01, 0xC0, 0x3F, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x79, 0xF8,
  0x70, 0x1F, 0xF0, 0x00, 0xE0,
};

const GFXglyph NotoSans_LightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 27, 9, 1, -27 },
  { 28, 10, 10, 13, 4, -27 },
  { 41, 23, 27, 24, 1, -27 },
  { 119, 18, 31, 21, 2, -29 },
  { 189, 25, 28, 30, 3, -28 },
  { 277, 22, 28, 26, 2, -28 },
  { 354, 4, 10, 7, 4, -27 },
  { 359, 12, 33, 10, 1, -27 },
  { 409, 12, 33, 10, -3, -27 },
  { 459, 17, 17, 21, 4, -29 },
  { 496, 17, 18, 22, 3, -22 },
  { 535, 7, 9, 8, -2, -4 },
  { 543, 10, 2, 12, 1, -11 },
  { 546, 3, 3, 9, 1, -3 },
  { 548, 18, 27, 13, -2, -27 },
  { 609, 18, 28, 21, 2, -28 },
  { 672, 10, 27, 21, 6, -27 },
  { 706, 20, 28, 21, 0, -28 },
  { 776, 19, 28, 21, 1, -28 },
  { 843, 20, 27, 21, 0, -27 },
  { 911, 19, 27, 21, 1, -27 },
  { 976, 18, 28, 21, 3, -28 },
  { 1039, 17, 27, 21, 4, -27 },
  { 1097, 18, 28, 21, 2, -28 },
  { 1160, 18, 28, 21, 2, -28 },
  { 1223, 7, 21, 9, 1, -21 },
  { 1242, 10, 26, 9, -2, -21 },
  { 1275, 17, 18, 22, 3, -23 },
  { 1314, 17, 9, 22, 3, -18 },
  { 1334, 17, 18, 22, 3, -23 },
  { 1373, 14, 28, 16, 3, -28 },
  { 1422, 29, 30, 32, 2, -27 },
  { 1531, 21, 27, 21, -2, -27 },
  { 1602, 20, 27, 23, 2, -27 },
  { 1670, 21, 28, 22, 3, -28 },
  { 1744, 22, 27, 26, 2, -27 },
  { 1819, 19, 27, 20, 2, -27 },
  { 1884, 19, 27, 18, 2, -27 },
  { 1949, 22, 28, 26, 3, -28 },
  { 2026, 24, 27, 26, 2, -27 },
  { 2107, 13, 27, 11, 0, -27 },
  { 2151, 16, 34, 10, -6, -27 },
  { 2219, 22, 27, 21, 2, -27 },
  { 2294, 14, 27, 18, 2, -27 },
  { 2342, 29, 27, 31, 2, -27 },
  { 2440, 24, 27, 26, 2, -27 },
  { 2521, 23, 28, 27, 3, -28 },
  { 2602, 19, 27, 21, 2, -27 },
  { 2667, 23, 34, 27, 3, -28 },
  { 2765, 19, 27, 22, 2, -27 },
  { 2830, 19, 28, 19, 1, -28 },
  { 2897, 19, 27, 19, 3, -27 },
  { 2962, 23, 27, 26, 3, -27 },
  { 3040, 20, 27, 21, 4, -27 },
  { 3108, 31, 27, 32, 4, -27 },
  { 3213, 24, 27, 19, -2, -27 },
  { 3294, 18, 27, 19, 4, -27 },
  { 3355, 22, 27, 20, 0, -27 },
  { 3430, 14, 33, 11, 0, -27 },
  { 3488, 6, 27, 13, 4, -27 },
  { 3509, 15, 33, 11, -3, -27 },
  { 3571, 18, 17, 21, 2, -27 },
  { 3610, 15, 2, 15, -3, 4 },
  { 3614, 5, 6, 10, 6, -29 },
  { 3618, 18, 21, 21, 2, -21 },
  { 3666, 19, 29, 22, 1, -29 },
  { 3735, 15, 21, 17, 2, -21 },
  { 3775, 20, 29, 22, 2, -29 },
  { 3848, 16, 21, 19, 2, -21 },
  { 3890, 21, 38, 11, -5, -29 },
  { 3990, 20, 30, 22, 1, -21 },
  { 4065, 18, 29, 22, 1, -29 },
  { 4131, 8, 28, 9, 1, -28 },
  { 4159, 14, 37, 9, -5, -28 },
  { 4224, 18, 29, 18, 1, -29 },
  { 4290, 8, 29, 9, 1, -29 },
  { 4319, 29, 21, 33, 1, -21 },
  { 4396, 18, 21, 22, 1, -21 },
  { 4444, 18, 21, 21, 2, -21 },
  { 4492, 21, 30, 22, -1, -21 },
  { 4571, 19, 30, 22, 2, -21 },
  { 4643, 15, 21, 15, 1, -21 },
  { 4683, 15, 21, 16, 0, -21 },
  { 4723, 11, 25, 12, 2, -25 },
  { 4758, 18, 20, 22, 2, -20 },
  { 4803, 17, 20, 17, 2, -20 },
  { 4846, 25, 20, 26, 2, -20 },
  { 4909, 20, 20, 18, -1, -20 },
  { 4959, 23, 29, 17, -4, -20 },
  { 5043, 18, 20, 17, -1, -20 },
  { 5088, 14, 33, 13, 1, -27 },
  { 5146, 2, 38, 21, 10, -29 },
  { 5156, 14, 33, 13, -2, -27 },
  { 5214, 17, 5, 22, 3, -16 },
};

const GFXfont NotoSans_LightItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_LIGHTITALIC38PT7B_H_
