#ifndef _NOTOSANS_LIGHTITALIC26PT7B_H_
#define _NOTOSANS_LIGHTITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC6, 0x31, 0x08, 0xC6, 0x31, 0x08, 0x46, 0x20, 0x00, 0x06,
  0x30, 0x66, 0x89, 0x16, 0x6C, 0xD1, 0x22, 0x00, 0x01, 0x04, 0x01, 0x08,
  0x03, 0x08, 0x02, 0x08, 0x02, 0x18, 0x02, 0x10, 0x7F, 0xFF, 0x04, 0x30,
  0x04, 0x20, 0x0C, 0x20, 0x08, 0x20, 0x08, 0x60, 0xFF, 0xFC, 0x10, 0x40,
  0x10, 0xC0, 0x10, 0x80, 0x30, 0x80, 0x20, 0x80, 0x21, 0x80, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x1F, 0xF1, 0x91, 0x08, 0x80, 0xC4, 0x06, 0x20, 0x13,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x26, 0x03, 0x30, 0x11, 0x80, 0x8C,
  0x84, 0xC7, 0xFC, 0x07, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x1C, 0x01,
  0x19, 0x01, 0x08, 0xC1, 0x88, 0x21, 0x84, 0x30, 0x86, 0x18, 0x83, 0x0C,
  0xC1, 0x04, 0x40, 0x82, 0x4F, 0x62, 0x4C, 0xDB, 0x6C, 0x26, 0x24, 0x10,
  0x22, 0x08, 0x31, 0x0C, 0x31, 0x86, 0x10, 0xC2, 0x10, 0x63, 0x18, 0x11,
  0x18, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x70, 0x0C, 0x10, 0x0C, 0x18, 0x08,
  0x10, 0x08, 0x10, 0x0C, 0x20, 0x04, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x31,
  0x03, 0x61, 0x82, 0x40, 0xC6, 0xC0, 0x6C, 0xC0, 0x38, 0xC0, 0x30, 0xC0,
  0x78, 0x61, 0xC8, 0x3F, 0x0C, 0x69, 0x6D, 0x20, 0x03, 0x06, 0x0C, 0x08,
  0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x04, 0x06, 0x02, 0x03, 0x03,
  0x03, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x04,
  0x0C, 0x08, 0x18, 0x30, 0x20, 0xC0, 0x02, 0x00, 0x40, 0x08, 0x63, 0x07,
  0x40, 0x3F, 0xC3, 0x08, 0xD0, 0x32, 0x0C, 0x61, 0x04, 0x00, 0x80, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x33, 0x26, 0x4C, 0xFF, 0xF0, 0xF0, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x00, 0x07, 0x80, 0xFE, 0x18, 0x63, 0x03, 0x60, 0x36,
  0x03, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x28, 0x02, 0x80, 0x68,
  0x06, 0x80, 0xC8, 0x0C, 0xC1, 0x86, 0x30, 0x3E, 0x00, 0x02, 0x1C, 0x7B,
  0x2C, 0x41, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30,
  0x40, 0x80, 0x01, 0xE0, 0x3F, 0x83, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0xBF, 0xF8, 0x03, 0xC0, 0xFF,
  0x84, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x01, 0xC0,
  0x78, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x46, 0x0E, 0x3F, 0xC0, 0x00, 0x08, 0x00, 0x60, 0x02, 0x80, 0x1E, 0x00,
  0xD8, 0x06, 0x40, 0x31, 0x01, 0x8C, 0x04, 0x30, 0x20, 0xC1, 0x02, 0x0C,
  0x08, 0x60, 0x63, 0xFF, 0xF0, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x07, 0xF8, 0x7F, 0xC2, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x3F, 0x81, 0x07, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0xC6, 0x0C, 0x1F, 0xC0, 0x01, 0xF0, 0x7B,
  0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x20, 0xDF, 0xCF, 0x0C,
  0xC0, 0x6C, 0x06, 0x80, 0x68, 0x06, 0x80, 0x68, 0x04, 0xC0, 0xC6, 0x38,
  0x3F, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x3B, 0x82, 0x06,
  0x30, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0x41, 0x8C, 0x07, 0xC0, 0x3C, 0x06,
  0x30, 0xC0, 0xC4, 0x02, 0x60, 0x13, 0x00, 0xD8, 0x04, 0x40, 0x63, 0x06,
  0x0F, 0xE0, 0x03, 0xC0, 0x7F, 0x06, 0x0C, 0x60, 0x22, 0x01, 0x10, 0x0D,
  0x80, 0x6C, 0x03, 0x20, 0x31, 0x83, 0x8E, 0x7C, 0x1E, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x01, 0x84, 0x38, 0x3F, 0x80, 0x33, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xCC, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x31, 0x86, 0x10, 0x80, 0x00, 0x10, 0x03, 0x00, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x06, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x00, 0x80, 0x00, 0x1E, 0x3F, 0x80, 0x60, 0x10, 0x08,
  0x04, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x02, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0xFF, 0x80, 0x30, 0x0C, 0x0C, 0x00, 0x61,
  0x80, 0x02, 0x10, 0x00, 0x32, 0x07, 0xE1, 0x61, 0x86, 0x14, 0x10, 0x61,
  0x42, 0x04, 0x14, 0x20, 0x41, 0xC6, 0x0C, 0x3C, 0x60, 0xC2, 0xC6, 0x18,
  0x64, 0x23, 0xCC, 0x43, 0xE7, 0x86, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x04, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x01, 0xC0, 0x05, 0x00,
  0x34, 0x00, 0x90, 0x06, 0x40, 0x11, 0x00, 0xC6, 0x02, 0x18, 0x18, 0x60,
  0xC0, 0x83, 0xFE, 0x1F, 0xF8, 0x40, 0x23, 0x00, 0xC8, 0x03, 0x60, 0x0F,
  0x00, 0x3C, 0x00, 0x40, 0x0F, 0x80, 0x3F, 0xE0, 0x80, 0xC6, 0x03, 0x18,
  0x04, 0x60, 0x11, 0x00, 0xC4, 0x06, 0x30, 0xF0, 0xFF, 0x03, 0x03, 0x08,
  0x06, 0x20, 0x19, 0x80, 0x66, 0x01, 0x90, 0x06, 0x40, 0x31, 0x07, 0x8F,
  0xF8, 0x00, 0x00, 0xF8, 0x1F, 0xF0, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xE0, 0x81, 0xFE, 0x00,
  0x0F, 0x80, 0x0F, 0xF8, 0x08, 0x1C, 0x18, 0x06, 0x18, 0x06, 0x18, 0x02,
  0x10, 0x02, 0x10, 0x03, 0x30, 0x03, 0x30, 0x02, 0x30, 0x02, 0x20, 0x06,
  0x20, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x18, 0x40, 0x70, 0x43, 0xC0,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC2, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0xFF, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F,
  0xC2, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0xFF, 0x0F, 0xF8, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x0F, 0xFC, 0x30, 0x08, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x03,
  0xF6, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0x30, 0x02, 0x20, 0x0C, 0x60, 0x18,
  0x70, 0x70, 0x7F, 0x80, 0x0C, 0x01, 0x84, 0x00, 0x82, 0x00, 0x43, 0x00,
  0x21, 0x80, 0x30, 0xC0, 0x18, 0x40, 0x08, 0x20, 0x04, 0x30, 0x06, 0x1F,
  0xFF, 0x0C, 0x01, 0x84, 0x00, 0x82, 0x00, 0x43, 0x00, 0x61, 0x80, 0x30,
  0x80, 0x18, 0x40, 0x08, 0x20, 0x04, 0x30, 0x06, 0x00, 0x0F, 0x83, 0x81,
  0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x60, 0x30, 0x18, 0x3E, 0x00, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40,
  0x18, 0x3E, 0x07, 0x00, 0x0C, 0x03, 0x08, 0x06, 0x08, 0x08, 0x18, 0x30,
  0x18, 0x60, 0x18, 0xC0, 0x11, 0x80, 0x13, 0x00, 0x36, 0x00, 0x3F, 0x00,
  0x3B, 0x00, 0x21, 0x80, 0x21, 0x80, 0x60, 0x80, 0x60, 0xC0, 0x40, 0x40,
  0x40, 0x60, 0x40, 0x20, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x0F, 0xFC, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0E,
  0x00, 0x51, 0xE0, 0x0F, 0x1A, 0x00, 0xB1, 0x20, 0x1A, 0x12, 0x01, 0x21,
  0x20, 0x26, 0x32, 0x06, 0x63, 0x30, 0x46, 0x23, 0x0C, 0x42, 0x10, 0x84,
  0x21, 0x18, 0xC6, 0x11, 0x0C, 0x61, 0x20, 0x84, 0x1E, 0x08, 0x41, 0xC0,
  0x8C, 0x1C, 0x18, 0xC0, 0x81, 0x80, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00,
  0x63, 0xC0, 0x21, 0xA0, 0x10, 0x98, 0x18, 0x44, 0x0C, 0x22, 0x04, 0x31,
  0x82, 0x18, 0x41, 0x08, 0x31, 0x84, 0x08, 0xC2, 0x04, 0x43, 0x03, 0x21,
  0x80, 0x90, 0x80, 0x78, 0x40, 0x1C, 0x60, 0x0C, 0x30, 0x06, 0x00, 0x01,
  0xE0, 0x07, 0xF8, 0x1C, 0x0C, 0x10, 0x06, 0x30, 0x02, 0x60, 0x03, 0x60,
  0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x0C, 0x40, 0x0C, 0x60, 0x18, 0x38, 0x70, 0x1F,
  0xC0, 0x0F, 0x80, 0x3F, 0xC0, 0x81, 0x86, 0x02, 0x18, 0x0C, 0x60, 0x31,
  0x00, 0xC4, 0x02, 0x30, 0x18, 0xC0, 0xC3, 0xFE, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0xF8, 0x1C, 0x0C, 0x10, 0x06, 0x30, 0x02, 0x60, 0x03, 0x60,
  0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x0C, 0x40, 0x0C, 0x60, 0x18, 0x38, 0x70, 0x1F,
  0xC0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x0F, 0x80, 0x3F,
  0xC0, 0x81, 0x86, 0x02, 0x18, 0x0C, 0x60, 0x31, 0x00, 0x84, 0x06, 0x30,
  0x18, 0xC3, 0xC3, 0xFC, 0x08, 0x20, 0x20, 0x81, 0x83, 0x06, 0x04, 0x10,
  0x18, 0x40, 0x61, 0x00, 0x8C, 0x03, 0x00, 0x01, 0xF0, 0x3F, 0xC3, 0x02,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x66, 0x0E,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x10, 0x03, 0x10,
  0x03, 0x30, 0x03, 0x30, 0x02, 0x30, 0x02, 0x20, 0x06, 0x20, 0x06, 0x60,
  0x04, 0x60, 0x04, 0x60, 0x0C, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x08, 0xC0,
  0x08, 0xC0, 0x18, 0xC0, 0x10, 0x40, 0x30, 0x70, 0xE0, 0x3F, 0x80, 0x80,
  0x0C, 0x00, 0xE0, 0x05, 0x00, 0x6C, 0x06, 0x60, 0x33, 0x03, 0x18, 0x18,
  0x41, 0x82, 0x08, 0x10, 0xC0, 0x84, 0x04, 0x60, 0x32, 0x01, 0xB0, 0x0D,
  0x00, 0x78, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x20, 0x1E, 0x03, 0x00, 0xB0,
  0x18, 0x0D, 0x81, 0xC0, 0x4C, 0x0A, 0x06, 0x60, 0xD0, 0x33, 0x04, 0xC1,
  0x18, 0x66, 0x18, 0xC2, 0x30, 0x86, 0x31, 0x8C, 0x31, 0x0C, 0x40, 0x98,
  0x26, 0x04, 0x81, 0x20, 0x2C, 0x0B, 0x01, 0x40, 0x50, 0x0A, 0x02, 0x80,
  0x70, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x0C, 0x02,
  0x04, 0x06, 0x06, 0x0C, 0x02, 0x18, 0x02, 0x10, 0x03, 0x20, 0x01, 0x60,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x02, 0xC0, 0x04, 0x40, 0x0C, 0x60,
  0x18, 0x20, 0x30, 0x20, 0x20, 0x30, 0x40, 0x10, 0xC0, 0x18, 0xC0, 0x0A,
  0x00, 0xD8, 0x0C, 0xC0, 0xC2, 0x04, 0x10, 0x60, 0xC6, 0x06, 0x20, 0x13,
  0x00, 0xB0, 0x07, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x23, 0xFF, 0x80, 0x07, 0xC3, 0xE0, 0xC0, 0x20, 0x08, 0x02,
  0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0F, 0x80, 0x88, 0x8C,
  0xC4, 0x44, 0x46, 0x62, 0x22, 0x23, 0x33, 0x10, 0x07, 0xC1, 0xF0, 0x0C,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x0F,
  0x80, 0x01, 0x00, 0x18, 0x00, 0xA0, 0x09, 0x00, 0xCC, 0x04, 0x20, 0x61,
  0x02, 0x0C, 0x30, 0x21, 0x01, 0x90, 0x05, 0x80, 0x30, 0xFF, 0xC0, 0xD9,
  0x90, 0x07, 0x88, 0xE2, 0xCC, 0x0C, 0x60, 0x66, 0x03, 0x30, 0x19, 0x00,
  0x98, 0x04, 0xC0, 0x66, 0x03, 0x30, 0x38, 0x83, 0x86, 0x34, 0x1F, 0x20,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x4F, 0x86,
  0xC6, 0x38, 0x11, 0x80, 0x8C, 0x06, 0x40, 0x36, 0x01, 0x30, 0x09, 0x00,
  0xC8, 0x06, 0x40, 0x67, 0x03, 0x2C, 0x71, 0x3F, 0x00, 0x07, 0xE3, 0x84,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x30, 0x07, 0x08, 0x7F, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x78, 0x87, 0x16, 0x30, 0x38, 0x80, 0xC6, 0x03,
  0x18, 0x0C, 0x40, 0x33, 0x00, 0xCC, 0x02, 0x30, 0x18, 0xC0, 0xE1, 0x03,
  0x86, 0x34, 0x0F, 0x90, 0x07, 0xC3, 0x8C, 0x41, 0x90, 0x36, 0x06, 0x81,
  0x9F, 0xE3, 0xC0, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x07, 0x08, 0x7F, 0x00,
  0x00, 0x3C, 0x01, 0x90, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x7F,
  0x02, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x03, 0xC0, 0x00, 0x07, 0x88,
  0xE2, 0x4C, 0x0E, 0x40, 0x66, 0x03, 0x30, 0x19, 0x00, 0xD8, 0x06, 0xC0,
  0x26, 0x03, 0x30, 0x38, 0x81, 0xC6, 0x34, 0x1F, 0x20, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x20, 0xC1, 0xFC, 0x00, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x13, 0xE3, 0x63, 0x38, 0x13, 0x01, 0x30, 0x12,
  0x03, 0x60, 0x36, 0x03, 0x40, 0x24, 0x02, 0x40, 0x6C, 0x06, 0xC0, 0x48,
  0x04, 0x08, 0xC0, 0x00, 0x08, 0xC6, 0x31, 0x08, 0xC6, 0x21, 0x08, 0xC6,
  0x20, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x40, 0x60, 0xE0, 0x00, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x33, 0x06, 0x30, 0xC2, 0x18, 0x23, 0x02, 0x60,
  0x6C, 0x07, 0x60, 0x66, 0x04, 0x30, 0x43, 0x0C, 0x10, 0xC1, 0x88, 0x0C,
  0x08, 0x46, 0x31, 0x88, 0x46, 0x31, 0x08, 0x46, 0x31, 0x08, 0x46, 0x31,
  0x00, 0x13, 0xC3, 0xE3, 0x66, 0x66, 0x38, 0x28, 0x33, 0x03, 0x03, 0x30,
  0x30, 0x32, 0x02, 0x03, 0x60, 0x20, 0x26, 0x06, 0x02, 0x40, 0x60, 0x64,
  0x04, 0x06, 0x40, 0x40, 0x4C, 0x04, 0x04, 0xC0, 0xC0, 0x48, 0x0C, 0x0C,
  0x13, 0xE3, 0x63, 0x38, 0x13, 0x01, 0x30, 0x12, 0x03, 0x60, 0x36, 0x03,
  0x40, 0x24, 0x02, 0xC0, 0x6C, 0x06, 0xC0, 0x48, 0x04, 0x07, 0xC1, 0xC6,
  0x30, 0x32, 0x01, 0x60, 0x14, 0x01, 0x40, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0x40, 0x66, 0x06, 0x71, 0xC1, 0xF0, 0x04, 0xF8, 0x1B, 0x18, 0x38, 0x10,
  0x60, 0x20, 0xC0, 0x61, 0x00, 0xC6, 0x01, 0x0C, 0x02, 0x10, 0x0C, 0x20,
  0x18, 0x40, 0x61, 0xC0, 0xC3, 0xC7, 0x04, 0xF8, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x00, 0x07, 0x88, 0xE2, 0x4C,
  0x0E, 0x40, 0x66, 0x03, 0x30, 0x19, 0x00, 0xD8, 0x06, 0xC0, 0x26, 0x03,
  0x30, 0x38, 0x81, 0xC6, 0x34, 0x1F, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x13, 0xCD, 0x83, 0x80, 0xC0, 0x30, 0x08,
  0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x00, 0x0F,
  0xE3, 0x08, 0xC0, 0x10, 0x03, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x10, 0x02, 0x00, 0xCC, 0x38, 0xFC, 0x00, 0x08, 0x18, 0x10, 0xFF, 0x30,
  0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x40, 0x78,
  0x30, 0x19, 0x80, 0xCC, 0x04, 0x40, 0x22, 0x03, 0x30, 0x19, 0x80, 0xC8,
  0x04, 0x40, 0x62, 0x03, 0x30, 0x39, 0x81, 0x86, 0x34, 0x1F, 0x20, 0xC0,
  0x3C, 0x06, 0x40, 0x44, 0x0C, 0x40, 0x84, 0x18, 0x63, 0x06, 0x30, 0x66,
  0x02, 0x40, 0x2C, 0x02, 0x80, 0x38, 0x03, 0x00, 0xC0, 0xC0, 0xD0, 0x30,
  0x24, 0x14, 0x19, 0x05, 0x04, 0x43, 0x43, 0x10, 0x90, 0x84, 0x64, 0x61,
  0x11, 0x10, 0x4C, 0x6C, 0x12, 0x1A, 0x05, 0x87, 0x81, 0x41, 0xC0, 0x70,
  0x70, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x20, 0x60, 0xC3, 0x01, 0x18, 0x06,
  0xC0, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x05, 0x80, 0x32, 0x01, 0x8C, 0x0C,
  0x30, 0x60, 0x43, 0x01, 0x80, 0x0C, 0x03, 0x0C, 0x06, 0x04, 0x04, 0x04,
  0x0C, 0x04, 0x08, 0x06, 0x18, 0x06, 0x10, 0x06, 0x30, 0x02, 0x20, 0x02,
  0x60, 0x02, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x0C,
  0x03, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0xFF, 0x00, 0x00, 0x40, 0xF0, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x81, 0x80, 0xF0, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x0C, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x07, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x30, 0x38, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x01, 0x83, 0x80, 0x30, 0x0F, 0xE1, 0x83, 0xE0,
};

const GFXglyph NotoSans_LightItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 19, 6, 1, -19 },
  { 13, 7, 7, 9, 3, -19 },
  { 20, 16, 19, 16, 1, -19 },
  { 58, 13, 22, 14, 1, -20 },
  { 94, 17, 19, 20, 2, -19 },
  { 135, 16, 19, 18, 1, -19 },
  { 173, 3, 7, 5, 3, -19 },
  { 176, 8, 23, 7, 1, -19 },
  { 199, 8, 23, 7, -2, -19 },
  { 222, 11, 12, 14, 3, -20 },
  { 239, 12, 12, 15, 2, -15 },
  { 257, 4, 6, 6, -1, -3 },
  { 260, 6, 2, 8, 1, -8 },
  { 262, 2, 2, 6, 1, -2 },
  { 263, 12, 19, 9, -1, -19 },
  { 292, 12, 19, 14, 2, -19 },
  { 321, 7, 19, 14, 4, -19 },
  { 338, 13, 19, 14, 0, -19 },
  { 369, 13, 19, 14, 1, -19 },
  { 400, 14, 19, 14, 0, -19 },
  { 434, 13, 19, 14, 1, -19 },
  { 465, 12, 19, 14, 2, -19 },
  { 494, 12, 19, 14, 3, -19 },
  { 523, 13, 19, 14, 1, -19 },
  { 554, 13, 19, 14, 1, -19 },
  { 585, 4, 14, 6, 1, -14 },
  { 592, 6, 17, 6, -1, -14 },
  { 605, 12, 13, 15, 2, -16 },
  { 625, 12, 6, 15, 2, -12 },
  { 634, 12, 13, 15, 2, -16 },
  { 654, 9, 19, 11, 2, -19 },
  { 676, 20, 20, 22, 1, -18 },
  { 726, 14, 19, 14, -1, -19 },
  { 760, 14, 19, 16, 1, -19 },
  { 794, 14, 19, 15, 2, -19 },
  { 828, 16, 19, 17, 1, -19 },
  { 866, 13, 19, 14, 1, -19 },
  { 897, 13, 19, 13, 1, -19 },
  { 928, 15, 19, 18, 2, -19 },
  { 964, 17, 19, 18, 1, -19 },
  { 1005, 9, 19, 8, 0, -19 },
  { 1027, 11, 24, 7, -4, -19 },
  { 1060, 16, 19, 14, 1, -19 },
  { 1098, 10, 19, 13, 1, -19 },
  { 1122, 20, 19, 21, 1, -19 },
  { 1170, 17, 19, 18, 1, -19 },
  { 1211, 16, 19, 19, 2, -19 },
  { 1249, 14, 19, 15, 1, -19 },
  { 1283, 16, 23, 19, 2, -19 },
  { 1329, 14, 19, 15, 1, -19 },
  { 1363, 13, 19, 13, 0, -19 },
  { 1394, 13, 19, 13, 2, -19 },
  { 1425, 16, 19, 18, 2, -19 },
  { 1463, 13, 19, 14, 3, -19 },
  { 1494, 21, 19, 22, 3, -19 },
  { 1544, 16, 19, 13, -1, -19 },
  { 1582, 13, 19, 13, 2, -19 },
  { 1613, 15, 19, 14, 0, -19 },
  { 1649, 10, 23, 8, 0, -19 },
  { 1678, 4, 19, 9, 3, -19 },
  { 1688, 10, 23, 8, -2, -19 },
  { 1717, 13, 12, 15, 1, -19 },
  { 1737, 10, 1, 10, -2, 3 },
  { 1739, 3, 4, 7, 4, -20 },
  { 1741, 13, 14, 15, 1, -14 },
  { 1764, 13, 20, 15, 1, -20 },
  { 1797, 11, 14, 12, 1, -14 },
  { 1817, 14, 20, 15, 1, -20 },
  { 1852, 11, 14, 13, 1, -14 },
  { 1872, 14, 26, 8, -3, -20 },
  { 1918, 13, 20, 15, 1, -14 },
  { 1951, 12, 20, 15, 1, -20 },
  { 1981, 5, 19, 6, 1, -19 },
  { 1993, 9, 25, 6, -3, -19 },
  { 2022, 12, 20, 12, 1, -20 },
  { 2052, 5, 20, 6, 1, -20 },
  { 2065, 20, 14, 22, 1, -14 },
  { 2100, 12, 14, 15, 1, -14 },
  { 2121, 12, 14, 15, 1, -14 },
  { 2142, 15, 20, 15, -1, -14 },
  { 2180, 13, 20, 15, 1, -14 },
  { 2213, 10, 14, 10, 1, -14 },
  { 2231, 11, 14, 11, 0, -14 },
  { 2251, 8, 17, 8, 1, -17 },
  { 2268, 13, 14, 15, 1, -14 },
  { 2291, 12, 14, 11, 1, -14 },
  { 2312, 18, 14, 18, 1, -14 },
  { 2344, 14, 14, 12, -1, -14 },
  { 2369, 16, 20, 11, -3, -14 },
  { 2409, 11, 14, 11, 0, -14 },
  { 2429, 10, 23, 9, 0, -19 },
  { 2458, 1, 26, 14, 7, -20 },
  { 2462, 9, 23, 9, -1, -19 },
  { 2488, 12, 3, 15, 2, -11 },
};

const GFXfont NotoSans_LightItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_LIGHTITALIC26PT7B_H_
