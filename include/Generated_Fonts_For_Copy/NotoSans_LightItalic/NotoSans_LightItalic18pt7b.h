#ifndef _NOTOSANS_LIGHTITALIC18PT7B_H_
#define _NOTOSANS_LIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x24, 0x04, 0xC0, 0x5A, 0xA5, 0x29, 0x00,
  0x08, 0x81, 0x10, 0x22, 0x04, 0x87, 0xFE, 0x22, 0x04, 0x81, 0x10, 0xFF,
  0x84, 0x41, 0x10, 0x22, 0x04, 0x40, 0x04, 0x04, 0x1F, 0x24, 0x48, 0x48,
  0x28, 0x1C, 0x0E, 0x12, 0x12, 0x16, 0xFC, 0x20, 0x20, 0x38, 0x34, 0x42,
  0x44, 0x44, 0x48, 0x45, 0x08, 0x96, 0x4A, 0x97, 0x51, 0x09, 0x10, 0x91,
  0x11, 0x12, 0x12, 0x41, 0xC0, 0x0F, 0x02, 0x20, 0x84, 0x10, 0x81, 0x20,
  0x38, 0x0E, 0x02, 0x23, 0x84, 0x50, 0x52, 0x04, 0x41, 0xC7, 0xCC, 0x5A,
  0x80, 0x08, 0x88, 0x44, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x08, 0x10,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x44, 0x22, 0x11, 0x10, 0x08, 0x08, 0x88,
  0x68, 0x1F, 0x28, 0x48, 0x44, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40,
  0x20, 0x10, 0x08, 0x00, 0x2D, 0x60, 0xF0, 0x70, 0x01, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x0C, 0x00, 0x1E,
  0x18, 0x88, 0x48, 0x14, 0x0A, 0x0A, 0x05, 0x02, 0x81, 0x41, 0xA0, 0x88,
  0x87, 0x80, 0x19, 0xB4, 0x21, 0x18, 0x84, 0x21, 0x10, 0x84, 0x00, 0x0F,
  0x08, 0x40, 0x20, 0x10, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x08,
  0x0F, 0xF0, 0x0F, 0x18, 0x40, 0x20, 0x10, 0x08, 0x08, 0x78, 0x02, 0x01,
  0x00, 0x80, 0x50, 0x67, 0xE0, 0x00, 0x80, 0x60, 0x28, 0x12, 0x09, 0x04,
  0x43, 0x10, 0x84, 0x41, 0x3F, 0xF0, 0x20, 0x08, 0x02, 0x00, 0x1F, 0x90,
  0x08, 0x04, 0x02, 0x03, 0xE0, 0x08, 0x06, 0x01, 0x00, 0x80, 0x90, 0xCF,
  0xC0, 0x07, 0x8C, 0x08, 0x04, 0x04, 0x02, 0xF1, 0x8D, 0x82, 0x81, 0x40,
  0xA0, 0x88, 0x47, 0xC0, 0xFF, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x30, 0x20, 0x40, 0x40, 0x80, 0x1F, 0x18, 0x88, 0x24, 0x12, 0x10, 0xB0,
  0x70, 0xC4, 0x83, 0x40, 0xA0, 0xD0, 0x47, 0xC0, 0x1E, 0x21, 0x41, 0x41,
  0x41, 0x41, 0x43, 0x3D, 0x03, 0x02, 0x06, 0x0C, 0xF8, 0x33, 0x00, 0x00,
  0x00, 0x4C, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x23, 0x11, 0x00, 0x00, 0x81,
  0x83, 0x06, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x30, 0x60, 0xC0,
  0x80, 0x00, 0x7C, 0x8C, 0x08, 0x10, 0x41, 0x84, 0x10, 0x40, 0x80, 0x02,
  0x0C, 0x00, 0x03, 0xC0, 0x30, 0xC3, 0x00, 0x88, 0x02, 0x47, 0xC6, 0x31,
  0x18, 0x84, 0x64, 0x22, 0x90, 0x8A, 0x46, 0x28, 0xE7, 0x10, 0x00, 0x40,
  0x00, 0xC3, 0x00, 0xF0, 0x00, 0x01, 0x00, 0xA0, 0x28, 0x12, 0x04, 0x82,
  0x20, 0x88, 0x42, 0x1F, 0x88, 0x16, 0x05, 0x01, 0x80, 0x40, 0x3F, 0x08,
  0x22, 0x0C, 0x82, 0x20, 0x90, 0x47, 0xE1, 0x04, 0x40, 0x90, 0x28, 0x12,
  0x0C, 0xFC, 0x00, 0x07, 0xC6, 0x13, 0x00, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x3F, 0x00, 0x3F, 0x08, 0x62, 0x04,
  0x81, 0x20, 0x50, 0x14, 0x05, 0x01, 0x40, 0x50, 0x28, 0x1A, 0x0C, 0xFC,
  0x00, 0x3F, 0x90, 0x08, 0x04, 0x02, 0x02, 0x09, 0xF8, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x0F, 0xE0, 0x3F, 0x90, 0x08, 0x04, 0x02, 0x02, 0x01, 0xF8,
  0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x00, 0x07, 0xC3, 0x04, 0xC0, 0x10,
  0x04, 0x00, 0x80, 0x10, 0xF6, 0x02, 0xC0, 0x48, 0x09, 0x02, 0x30, 0x43,
  0xF8, 0x30, 0x24, 0x04, 0x80, 0x90, 0x12, 0x04, 0x80, 0x9F, 0xF2, 0x02,
  0x40, 0x88, 0x12, 0x02, 0x40, 0x48, 0x18, 0x3C, 0x21, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x08, 0xF0, 0x01, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0xF0, 0x30, 0x64, 0x10,
  0x84, 0x11, 0x02, 0x40, 0xB0, 0x1E, 0x02, 0x40, 0x44, 0x08, 0x82, 0x08,
  0x41, 0x08, 0x10, 0x30, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20,
  0xFC, 0x30, 0x0C, 0xC0, 0x53, 0x01, 0x8A, 0x0A, 0x28, 0x29, 0x21, 0x24,
  0x85, 0x12, 0x24, 0x49, 0x11, 0x24, 0x48, 0x61, 0x21, 0x88, 0x84, 0x20,
  0x30, 0x26, 0x04, 0xC0, 0x94, 0x12, 0x82, 0x88, 0x91, 0x12, 0x32, 0x42,
  0x48, 0x52, 0x06, 0x40, 0xC8, 0x18, 0x0F, 0x82, 0x08, 0x80, 0xB0, 0x14,
  0x02, 0x80, 0x50, 0x0E, 0x01, 0xC0, 0x28, 0x09, 0x01, 0x30, 0xC3, 0xF0,
  0x3E, 0x10, 0xC8, 0x24, 0x12, 0x0A, 0x0D, 0x0C, 0xF8, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x00, 0x0F, 0x82, 0x08, 0x80, 0xB0, 0x14, 0x02, 0x80, 0x50,
  0x0E, 0x01, 0xC0, 0x28, 0x09, 0x01, 0x30, 0xC3, 0xF0, 0x0C, 0x00, 0x80,
  0x0C, 0x3E, 0x10, 0xC8, 0x24, 0x12, 0x0A, 0x0D, 0x1C, 0xF8, 0x44, 0x23,
  0x20, 0x90, 0x48, 0x10, 0x0F, 0x88, 0x48, 0x04, 0x02, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x00, 0x80, 0x40, 0x4F, 0xC0, 0xFF, 0x88, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x00, 0x40, 0x50,
  0x14, 0x05, 0x01, 0xC0, 0xE0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x12,
  0x08, 0x7C, 0x00, 0x80, 0xC0, 0xE0, 0x50, 0x48, 0x24, 0x21, 0x10, 0x90,
  0x48, 0x28, 0x14, 0x0C, 0x06, 0x00, 0x81, 0x07, 0x06, 0x0A, 0x0C, 0x24,
  0x28, 0x48, 0x51, 0x91, 0x22, 0x22, 0x44, 0x48, 0x90, 0x91, 0x20, 0xC2,
  0x81, 0x85, 0x02, 0x04, 0x04, 0x08, 0x00, 0x10, 0x30, 0x84, 0x08, 0x40,
  0x88, 0x05, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0A, 0x01, 0x10, 0x21, 0x04,
  0x08, 0xC0, 0x80, 0x81, 0xC1, 0xA0, 0x88, 0x84, 0xC2, 0x41, 0x40, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x00, 0x1F, 0xC0, 0x30, 0x08, 0x04, 0x02,
  0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00, 0xFF, 0x00, 0x1E,
  0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20,
  0x78, 0x92, 0x44, 0x92, 0x48, 0x92, 0x1E, 0x08, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x70, 0x08, 0x0C, 0x14, 0x22,
  0x22, 0x42, 0x41, 0x81, 0xFF, 0xA4, 0x1C, 0x91, 0x90, 0x48, 0x28, 0x14,
  0x12, 0x09, 0x04, 0x86, 0x3D, 0x00, 0x20, 0x20, 0x20, 0x20, 0x2E, 0x51,
  0x61, 0x41, 0x41, 0x81, 0x81, 0x82, 0xC2, 0xBC, 0x1E, 0x45, 0x02, 0x08,
  0x10, 0x20, 0x40, 0xC0, 0xF8, 0x00, 0x40, 0x20, 0x08, 0x02, 0x1C, 0x88,
  0xA4, 0x11, 0x04, 0x81, 0x20, 0x48, 0x22, 0x08, 0x86, 0x1E, 0x80, 0x1C,
  0x45, 0x0A, 0x18, 0xDE, 0x20, 0x40, 0xC0, 0xF8, 0x01, 0xC0, 0x80, 0x40,
  0x10, 0x1F, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x38, 0x00, 0x0E, 0x44, 0x52, 0x08, 0x82,
  0x40, 0x90, 0x24, 0x11, 0x04, 0x43, 0x0F, 0x40, 0x10, 0x08, 0x02, 0x3F,
  0x00, 0x20, 0x20, 0x20, 0x20, 0x2E, 0x51, 0x61, 0x41, 0x41, 0xC1, 0x82,
  0x82, 0x82, 0x82, 0x20, 0x14, 0x92, 0x52, 0x48, 0x04, 0x00, 0x01, 0x08,
  0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08, 0xC0, 0x20, 0x20, 0x20,
  0x20, 0x21, 0x42, 0x44, 0x48, 0x50, 0xB0, 0xC8, 0x88, 0x84, 0x84, 0x24,
  0x92, 0x92, 0x5A, 0x49, 0x00, 0x4E, 0x32, 0x92, 0x58, 0x62, 0x82, 0x14,
  0x20, 0xA1, 0x06, 0x08, 0x30, 0x43, 0x82, 0x14, 0x20, 0x80, 0x27, 0x14,
  0x4C, 0x24, 0x12, 0x0B, 0x05, 0x04, 0x82, 0x41, 0x60, 0x80, 0x1C, 0x23,
  0x41, 0xC1, 0x81, 0x81, 0x81, 0x82, 0xC6, 0x7C, 0x27, 0x14, 0x4C, 0x24,
  0x12, 0x09, 0x05, 0x02, 0x82, 0x61, 0x2F, 0x20, 0x10, 0x08, 0x04, 0x00,
  0x1C, 0x91, 0x50, 0x48, 0x28, 0x14, 0x0A, 0x09, 0x04, 0x86, 0x3D, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x4D, 0x46, 0x10, 0x41, 0x08, 0x20, 0x82, 0x00,
  0x1C, 0x45, 0x03, 0x03, 0x01, 0x01, 0x02, 0x05, 0xF0, 0x21, 0x3E, 0x84,
  0x21, 0x18, 0x84, 0x21, 0xC0, 0x40, 0xA0, 0x90, 0x48, 0x24, 0x14, 0x1A,
  0x09, 0x04, 0x86, 0x3D, 0x00, 0x81, 0x82, 0x82, 0x84, 0x88, 0x48, 0x50,
  0x50, 0x60, 0x60, 0x84, 0x18, 0x62, 0x8A, 0x28, 0xA6, 0x92, 0x49, 0x24,
  0xA2, 0x8A, 0x28, 0xC3, 0x0C, 0x30, 0x30, 0x44, 0x21, 0x10, 0x28, 0x0C,
  0x03, 0x01, 0x40, 0x48, 0x22, 0x30, 0x40, 0x10, 0x22, 0x08, 0x41, 0x08,
  0x40, 0x98, 0x12, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x01, 0xC0, 0x00, 0x3F, 0x02, 0x06, 0x04, 0x08, 0x10, 0x20, 0x60, 0x40,
  0xFC, 0x06, 0x10, 0x20, 0x81, 0x02, 0x04, 0x30, 0xE0, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x18, 0xFF, 0xFF, 0xC0, 0x18, 0x08, 0x10, 0x20, 0x81, 0x02,
  0x02, 0x0E, 0x10, 0x40, 0x81, 0x02, 0x08, 0x60, 0xF8, 0xC3, 0x80,
};

const GFXglyph NotoSans_LightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 13, 4, 0, -13 },
  { 8, 5, 5, 6, 2, -13 },
  { 12, 11, 13, 11, 1, -13 },
  { 30, 8, 15, 10, 1, -14 },
  { 45, 12, 13, 14, 1, -13 },
  { 65, 11, 13, 12, 1, -13 },
  { 83, 2, 5, 4, 2, -13 },
  { 85, 5, 16, 5, 1, -13 },
  { 95, 5, 16, 5, -1, -13 },
  { 105, 8, 8, 10, 2, -14 },
  { 113, 9, 9, 10, 1, -11 },
  { 124, 3, 4, 4, -1, -2 },
  { 126, 4, 1, 6, 1, -5 },
  { 127, 2, 2, 4, 0, -2 },
  { 128, 9, 13, 6, -1, -13 },
  { 143, 9, 13, 10, 1, -13 },
  { 158, 5, 13, 10, 3, -13 },
  { 167, 9, 13, 10, 0, -13 },
  { 182, 9, 13, 10, 0, -13 },
  { 197, 10, 13, 10, 0, -13 },
  { 214, 9, 13, 10, 1, -13 },
  { 229, 9, 13, 10, 1, -13 },
  { 244, 8, 13, 10, 2, -13 },
  { 257, 9, 13, 10, 1, -13 },
  { 272, 8, 13, 10, 1, -13 },
  { 285, 4, 10, 4, 0, -10 },
  { 290, 5, 12, 4, -1, -10 },
  { 298, 9, 9, 10, 1, -11 },
  { 309, 9, 5, 10, 1, -9 },
  { 315, 9, 9, 10, 1, -11 },
  { 326, 7, 13, 8, 1, -13 },
  { 338, 14, 15, 15, 1, -13 },
  { 365, 10, 13, 10, -1, -13 },
  { 382, 10, 13, 11, 1, -13 },
  { 399, 10, 13, 11, 1, -13 },
  { 416, 10, 13, 12, 1, -13 },
  { 433, 9, 13, 9, 1, -13 },
  { 448, 9, 13, 9, 1, -13 },
  { 463, 11, 13, 12, 1, -13 },
  { 481, 11, 13, 12, 1, -13 },
  { 499, 6, 13, 5, 0, -13 },
  { 509, 8, 16, 5, -3, -13 },
  { 525, 11, 13, 10, 1, -13 },
  { 543, 6, 13, 9, 1, -13 },
  { 553, 14, 13, 15, 1, -13 },
  { 576, 11, 13, 12, 1, -13 },
  { 594, 11, 13, 13, 1, -13 },
  { 612, 9, 13, 10, 1, -13 },
  { 627, 11, 16, 13, 1, -13 },
  { 649, 9, 13, 10, 1, -13 },
  { 664, 9, 13, 9, 0, -13 },
  { 679, 9, 13, 9, 2, -13 },
  { 694, 10, 13, 12, 2, -13 },
  { 711, 9, 13, 10, 2, -13 },
  { 726, 15, 13, 15, 2, -13 },
  { 751, 12, 13, 9, -1, -13 },
  { 771, 9, 13, 9, 2, -13 },
  { 786, 10, 13, 10, 0, -13 },
  { 803, 7, 16, 5, 0, -13 },
  { 817, 3, 13, 6, 2, -13 },
  { 822, 7, 16, 5, -1, -13 },
  { 836, 8, 8, 10, 1, -13 },
  { 844, 8, 1, 7, -2, 2 },
  { 845, 2, 3, 5, 3, -14 },
  { 846, 9, 10, 10, 1, -10 },
  { 858, 8, 14, 10, 1, -14 },
  { 872, 7, 10, 8, 1, -10 },
  { 881, 10, 14, 10, 1, -14 },
  { 899, 7, 10, 9, 1, -10 },
  { 908, 10, 18, 5, -2, -14 },
  { 931, 10, 14, 10, 0, -10 },
  { 949, 8, 14, 10, 1, -14 },
  { 963, 3, 13, 4, 1, -13 },
  { 968, 6, 17, 4, -2, -13 },
  { 981, 8, 14, 8, 1, -14 },
  { 995, 3, 14, 4, 1, -14 },
  { 1001, 13, 10, 15, 1, -10 },
  { 1018, 9, 10, 10, 0, -10 },
  { 1030, 8, 10, 10, 1, -10 },
  { 1040, 9, 14, 10, 0, -10 },
  { 1056, 9, 14, 10, 1, -10 },
  { 1072, 6, 10, 7, 1, -10 },
  { 1080, 7, 10, 8, 0, -10 },
  { 1089, 5, 12, 6, 1, -12 },
  { 1097, 9, 10, 10, 1, -10 },
  { 1109, 8, 10, 8, 1, -10 },
  { 1119, 12, 10, 12, 1, -10 },
  { 1134, 10, 10, 8, -1, -10 },
  { 1147, 11, 14, 8, -2, -10 },
  { 1167, 8, 10, 8, 0, -10 },
  { 1177, 7, 16, 6, 0, -13 },
  { 1191, 1, 18, 10, 5, -14 },
  { 1194, 7, 16, 6, -1, -13 },
  { 1208, 9, 2, 10, 1, -7 },
};

const GFXfont NotoSans_LightItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_LIGHTITALIC18PT7B_H_
