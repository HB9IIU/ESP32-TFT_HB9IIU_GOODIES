#ifndef _NOTOSANS_LIGHTITALIC69PT7B_H_
#define _NOTOSANS_LIGHTITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x3E,
  0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x0E, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xE1,
  0xC0, 0x70, 0xF0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x60, 0xC0,
  0x38, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0x8E, 0x0F, 0x80, 0x3F, 0x07, 0x00, 0xC0, 0x3E, 0x03, 0x80, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x01, 0xF9, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0E,
  0xFE, 0x00, 0x00, 0x07, 0x1F, 0x80, 0x00, 0x03, 0x87, 0xE0, 0x00, 0x03,
  0x81, 0xF0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x03, 0x80, 0xF8, 0x18, 0x01, 0xC1, 0xF8, 0x0F,
  0xC0, 0xE3, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3C,
  0x00, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00,
  0x07, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xC0, 0x03, 0xC0, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x0F, 0x07, 0xF0, 0x70,
  0x01, 0xE0, 0xF0, 0x7F, 0xE3, 0x80, 0x0E, 0x0F, 0x0F, 0xFF, 0x9C, 0x00,
  0xF0, 0x70, 0xF8, 0x3C, 0xF0, 0x07, 0x07, 0x87, 0x80, 0xF7, 0x80, 0x78,
  0x78, 0x78, 0x07, 0x9E, 0x07, 0x87, 0x87, 0x80, 0x1C, 0xF8, 0xF8, 0x38,
  0x3C, 0x00, 0xE3, 0xFF, 0x83, 0xC1, 0xC0, 0x07, 0x8F, 0xF8, 0x3C, 0x1E,
  0x00, 0x3C, 0x1F, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x0F, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x03,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x1C, 0x00, 0x01, 0xE0,
  0x78, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x79, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x78, 0x00,
  0x00, 0x00, 0x7E, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF0,
  0xFC, 0x03, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x80,
  0x1E, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x3C, 0x00, 0x00, 0xF8, 0x1E, 0x1E,
  0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x07, 0x80, 0x00,
  0x03, 0xCF, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xC0, 0x00,
  0x1F, 0x3C, 0x03, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0xFE, 0x00, 0xFE, 0x07,
  0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x78,
  0xF1, 0xE3, 0xC7, 0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x70,
  0xC1, 0x80, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xF0, 0x00,
  0x78, 0x03, 0x80, 0x03, 0xF8, 0x0E, 0x00, 0x07, 0xF8, 0x38, 0x00, 0x03,
  0xF8, 0xC0, 0x00, 0x03, 0xF3, 0x00, 0x04, 0x03, 0xFC, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xE1, 0xC0,
  0x00, 0x1F, 0x03, 0x80, 0x00, 0xF8, 0x0E, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x3E, 0x00, 0x70, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x79, 0xFF, 0xFF, 0xFF, 0xE7, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xE0, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x01,
  0xF0, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFB, 0x80, 0xFD,
  0xE0, 0xFE, 0x78, 0x7E, 0x1E, 0x7F, 0x07, 0xBF, 0x03, 0xCF, 0x80, 0xF1,
  0x80, 0x3C, 0x40, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xE7, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x0E, 0x00, 0x00, 0x78, 0x01, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x80, 0x00, 0x03, 0xF0, 0x38, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x02, 0x00, 0x00, 0x1F, 0x00,
  0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x03, 0xC0, 0xFF, 0xE0, 0x01, 0xE1, 0xFF, 0xFC, 0x00, 0xE3, 0xFF, 0xFF,
  0x00, 0xF3, 0xE0, 0x0F, 0xC0, 0x7B, 0xC0, 0x03, 0xF0, 0x3F, 0xC0, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0x0F, 0x0F, 0xC0, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x00,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01,
  0xF0, 0xE0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7F, 0x03, 0xE0, 0x00,
  0x77, 0x81, 0xF8, 0x00, 0xFB, 0xC0, 0x7F, 0x01, 0xF3, 0xC0, 0x1F, 0xFF,
  0xF1, 0xE0, 0x07, 0xFF, 0xF0, 0xF0, 0x00, 0xFF, 0xC0, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x03,
  0x80, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xF0, 0x03, 0xE0,
  0x40, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0x0E, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0xF1, 0xE0, 0x01, 0xF8, 0x03, 0xC0, 0x07, 0x1C, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x73, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0x38, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x77, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x78,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x77, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x07,
  0x70, 0x03, 0xC0, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x0F, 0xF0, 0x03, 0x80, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x0E, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x1E, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x01, 0xEE, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0x3C, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x03, 0xCE, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x78, 0xE0, 0x07, 0x00, 0x07, 0xC0, 0x07, 0x8E,
  0x00, 0x78, 0x00, 0xFC, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x1C, 0xE0, 0x1E,
  0x0F, 0x00, 0x3C, 0x03, 0x8E, 0x03, 0xE0, 0xF0, 0x03, 0xFB, 0xF0, 0xFD,
  0xFC, 0x07, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x78, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x78, 0x00, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x3F,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x01, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x1F,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x1E,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x00,
  0x7F, 0x80, 0x07, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0xFE, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0x00, 0x00,
  0x7F, 0xFF, 0x8F, 0x80, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x04, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x3F, 0x80, 0x00, 0x00, 0x07, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xBC,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xEE, 0x00,
  0x00, 0x00, 0x3D, 0xE0, 0x07, 0xB8, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1C, 0xF0,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xC0, 0x00,
  0x00, 0xF1, 0xE0, 0x03, 0x87, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x1E, 0x1C,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0x70, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x03, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x01, 0xE0,
  0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x1E, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x38, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xC0, 0x0F, 0x00,
  0x07, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x73, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1F, 0xC0,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x70, 0x01, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x0E, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x9E, 0x00,
  0x00, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x70, 0x01, 0xE3, 0xC0, 0x00,
  0x07, 0x80, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x78, 0x00, 0x01,
  0xE0, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x70, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xF0,
  0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x0E, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x07, 0x80, 0x00,
  0x07, 0x8E, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0xF7, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xC0, 0x0F, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x07, 0xF0, 0x07, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x0F, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x3F,
  0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x60,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x80, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x07, 0xC7, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x71,
  0xE0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x0F, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x78, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x07,
  0x80, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x01,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x1C, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x07,
  0x80, 0x03, 0xC0, 0x78, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0x81, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x38, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x78, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x1E,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0x70, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0x78, 0xF8,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0x87, 0x80, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00,
  0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x00, 0x03, 0xFE, 0x03, 0xC0, 0x03, 0xFF, 0xE0, 0xE0, 0x03,
  0xFF, 0xFC, 0x38, 0x01, 0xFC, 0x0F, 0x0E, 0x00, 0xFC, 0x00, 0xE7, 0x80,
  0x7C, 0x00, 0x1D, 0xE0, 0x3E, 0x00, 0x07, 0x70, 0x1F, 0x00, 0x00, 0xFC,
  0x07, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F,
  0xC0, 0x78, 0x00, 0x07, 0xF0, 0x1E, 0x00, 0x03, 0xB8, 0x07, 0x80, 0x01,
  0xEE, 0x00, 0xF0, 0x00, 0xF3, 0x80, 0x3E, 0x00, 0x79, 0xE0, 0x07, 0xC0,
  0x7C, 0x78, 0x01, 0xFF, 0xFE, 0x1C, 0x00, 0x3F, 0xFE, 0x07, 0x00, 0x03,
  0xFF, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x7F, 0xC0, 0x00, 0xF0, 0x7F, 0xFC, 0x00, 0x78, 0x7F, 0xFF,
  0x80, 0x1E, 0x3E, 0x07, 0xF0, 0x07, 0x9E, 0x00, 0x7C, 0x01, 0xCF, 0x00,
  0x0F, 0x80, 0x77, 0x80, 0x01, 0xE0, 0x3D, 0xC0, 0x00, 0x78, 0x0F, 0xE0,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x7E,
  0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x78, 0x1E, 0xC0, 0x00, 0x3E, 0x07,
  0xB8, 0x00, 0x1F, 0x01, 0xCF, 0x00, 0x1F, 0x80, 0x71, 0xE0, 0x0F, 0xC0,
  0x1C, 0x3F, 0xFF, 0xE0, 0x0F, 0x07, 0xFF, 0xE0, 0x03, 0x80, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xE0, 0x1E, 0x01, 0xF8, 0x00, 0x20,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x04, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0xF0, 0x00,
  0x0F, 0xFF, 0x83, 0xC0, 0x00, 0xFF, 0xFF, 0x0F, 0x00, 0x07, 0xF0, 0x3E,
  0x3C, 0x00, 0x3F, 0x00, 0x3C, 0xE0, 0x01, 0xF0, 0x00, 0x77, 0x80, 0x0F,
  0x80, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x07, 0xE0, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x00, 0xFC, 0x00,
  0x78, 0x00, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x3B, 0xC0, 0x07, 0xC0, 0x01,
  0xCF, 0x00, 0x0F, 0x80, 0x1E, 0x38, 0x00, 0x3F, 0x01, 0xF0, 0xE0, 0x00,
  0x7F, 0xFF, 0x83, 0x80, 0x00, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0xFF, 0xC0,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x01,
  0xE0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x1E, 0x3C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x87,
  0x80, 0x07, 0xF0, 0x78, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x06, 0x01, 0xF8, 0x01, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x08, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x02, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xE0, 0x00, 0xFF,
  0xF8, 0x1C, 0x00, 0x7F, 0xFF, 0x83, 0x80, 0x1F, 0xC0, 0xF8, 0xF0, 0x07,
  0xE0, 0x07, 0x9C, 0x01, 0xF0, 0x00, 0x73, 0x80, 0x7C, 0x00, 0x07, 0xF0,
  0x1F, 0x00, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0xFE, 0x03, 0xC0, 0x00, 0x1F, 0x80,
  0x78, 0x00, 0x07, 0xF0, 0x0F, 0x00, 0x01, 0xDE, 0x00, 0xF0, 0x00, 0x73,
  0xC0, 0x1F, 0x00, 0x3C, 0x70, 0x03, 0xF0, 0x1F, 0x1E, 0x00, 0x3F, 0xFF,
  0xC3, 0xC0, 0x03, 0xFF, 0xF0, 0x78, 0x00, 0x1F, 0xF8, 0x0F, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x04, 0x00, 0x00, 0xF8, 0x00, 0xC0,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0xE0, 0x00, 0xE0, 0x7F, 0xFC,
  0x00, 0xF0, 0xFF, 0xFF, 0x00, 0x78, 0xFC, 0x0F, 0xC0, 0x3C, 0xF0, 0x03,
  0xE0, 0x1C, 0xF0, 0x00, 0xF8, 0x0E, 0xF0, 0x00, 0x3C, 0x0F, 0x70, 0x00,
  0x1E, 0x07, 0xF0, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x03, 0xC1, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x08, 0x3E, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0x0F, 0x3F, 0x80, 0x00, 0x07, 0xBF, 0xC0, 0x00, 0x03, 0xBC, 0xF0,
  0x00, 0x01, 0xFC, 0x78, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x00, 0xFC, 0x0F,
  0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x78, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xC7,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x1C, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x80,
  0xE7, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0x07, 0x70, 0x00, 0x79, 0xC0, 0x01,
  0xE0, 0x7B, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x78, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x0F, 0xFC, 0x00, 0x78, 0x1F, 0xFF, 0x00, 0x3C, 0x3F, 0xFF,
  0xC0, 0x1E, 0x3F, 0x07, 0xF0, 0x0F, 0x3E, 0x00, 0xF8, 0x07, 0x3C, 0x00,
  0x3E, 0x07, 0xBC, 0x00, 0x0F, 0x03, 0xDC, 0x00, 0x07, 0x81, 0xFC, 0x00,
  0x03, 0xC0, 0xFC, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x7E, 0x00,
  0x00, 0x78, 0x3E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x7F, 0xFC, 0x00, 0x0F,
  0x0F, 0xFF, 0xF0, 0x00, 0x78, 0xFC, 0x1F, 0xC0, 0x03, 0x8F, 0x00, 0x3E,
  0x00, 0x1C, 0xF0, 0x00, 0xF8, 0x00, 0xEF, 0x00, 0x03, 0xC0, 0x0F, 0x70,
  0x00, 0x1E, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xC0,
  0x1F, 0x00, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x3D, 0x80, 0x00, 0x7C,
  0x01, 0xEE, 0x00, 0x07, 0xC0, 0x0F, 0x78, 0x00, 0xFC, 0x00, 0x79, 0xE0,
  0x0F, 0xC0, 0x03, 0x87, 0xFF, 0xFC, 0x00, 0x3C, 0x1F, 0xFF, 0xC0, 0x01,
  0xE0, 0x7F, 0xF8, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xC0,
  0x03, 0xFF, 0xE0, 0x70, 0x03, 0xFF, 0xFC, 0x1C, 0x01, 0xFC, 0x0F, 0x8F,
  0x00, 0xFC, 0x00, 0xF3, 0x80, 0x7C, 0x00, 0x1C, 0xE0, 0x3E, 0x00, 0x03,
  0xF8, 0x1F, 0x00, 0x00, 0xFE, 0x07, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x1F, 0x81, 0xE0, 0x00, 0x0F, 0xE0, 0x78, 0x00, 0x03, 0xF0, 0x1E, 0x00,
  0x01, 0xFC, 0x07, 0x80, 0x00, 0xEF, 0x00, 0xF0, 0x00, 0x73, 0xC0, 0x3E,
  0x00, 0x78, 0xF0, 0x07, 0xC0, 0x7C, 0x78, 0x01, 0xFF, 0xFE, 0x1E, 0x00,
  0x3F, 0xFF, 0x07, 0x80, 0x03, 0xFF, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x3F, 0xC0, 0x38, 0x3F, 0xF0,
  0x1E, 0x1F, 0xFC, 0x07, 0x8F, 0xC3, 0x01, 0xC7, 0x80, 0x00, 0x73, 0xC0,
  0x00, 0x1D, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x03, 0xE0, 0x7E, 0x00, 0x0C, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x84, 0x00, 0x01, 0xF0, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x3F,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0xFE, 0x07, 0x80, 0x00,
  0xEF, 0x03, 0xC0, 0x00, 0x77, 0x01, 0xE0, 0x00, 0xF3, 0x80, 0xF8, 0x00,
  0xF3, 0xC0, 0x3E, 0x01, 0xF1, 0xE0, 0x1F, 0xFF, 0xF0, 0xF0, 0x07, 0xFF,
  0xE0, 0x70, 0x00, 0xFF, 0xE0, 0x38, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0xB8, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x73,
  0x80, 0x03, 0xC3, 0xC0, 0x03, 0xCE, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xC3, 0xC0,
  0x0F, 0x01, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x07, 0x00, 0x38, 0x3C, 0x01,
  0xE0, 0x1C, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0x70, 0x07, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xF0, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80,
  0x1E, 0x07, 0x80, 0x70, 0x1E, 0x00, 0x78, 0x1C, 0x01, 0xC0, 0xF0, 0x01,
  0xE0, 0xF0, 0x07, 0x03, 0xC0, 0x07, 0x83, 0x80, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x01, 0xE3,
  0xC0, 0x07, 0x8F, 0x00, 0x07, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x78,
  0x00, 0x79, 0xE0, 0x00, 0x79, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x07, 0xB8, 0x00, 0x0E, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0x3F, 0xFF, 0x00, 0x01, 0x7F, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xE0, 0x03, 0xFF, 0xFE, 0xC0, 0x00, 0xFF, 0xFC, 0x80, 0x00, 0x1F,
  0xF0,
};

const GFXglyph NotoSans_LightItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 15, 50, 16, 2, -49 },
  { 95, 18, 18, 24, 8, -49 },
  { 136, 42, 49, 43, 2, -49 },
  { 394, 33, 56, 38, 3, -52 },
  { 625, 45, 51, 54, 6, -50 },
  { 912, 41, 51, 47, 3, -50 },
  { 1174, 7, 18, 14, 8, -49 },
  { 1190, 21, 60, 18, 2, -49 },
  { 1348, 21, 60, 18, -5, -49 },
  { 1506, 30, 30, 37, 8, -52 },
  { 1619, 32, 33, 39, 5, -41 },
  { 1751, 11, 17, 15, -3, -8 },
  { 1775, 17, 3, 22, 2, -20 },
  { 1782, 6, 7, 16, 2, -6 },
  { 1788, 32, 49, 23, -3, -49 },
  { 1984, 33, 51, 38, 4, -50 },
  { 2195, 18, 49, 38, 11, -49 },
  { 2306, 36, 50, 38, 0, -50 },
  { 2531, 34, 51, 38, 2, -50 },
  { 2748, 36, 49, 38, 1, -49 },
  { 2969, 34, 50, 38, 3, -49 },
  { 3182, 33, 51, 38, 5, -50 },
  { 3393, 32, 49, 38, 7, -49 },
  { 3589, 34, 51, 38, 3, -50 },
  { 3806, 33, 51, 38, 3, -50 },
  { 4017, 12, 38, 16, 2, -37 },
  { 4074, 17, 46, 16, -3, -37 },
  { 4172, 32, 32, 39, 5, -41 },
  { 4300, 32, 17, 39, 5, -33 },
  { 4368, 32, 32, 39, 5, -41 },
  { 4496, 25, 51, 29, 5, -50 },
  { 4656, 52, 55, 58, 4, -49 },
  { 5014, 39, 49, 38, -4, -49 },
  { 5253, 37, 49, 41, 3, -49 },
  { 5480, 39, 51, 41, 5, -50 },
  { 5729, 41, 49, 46, 3, -49 },
  { 5981, 35, 49, 36, 3, -49 },
  { 6196, 35, 49, 33, 3, -49 },
  { 6411, 41, 51, 47, 5, -50 },
  { 6673, 44, 49, 47, 3, -49 },
  { 6943, 24, 49, 21, 0, -49 },
  { 7090, 29, 62, 17, -11, -49 },
  { 7315, 41, 49, 38, 3, -49 },
  { 7567, 26, 49, 33, 3, -49 },
  { 7727, 54, 49, 57, 3, -49 },
  { 8058, 45, 49, 48, 3, -49 },
  { 8334, 42, 51, 50, 5, -50 },
  { 8602, 36, 49, 39, 3, -49 },
  { 8823, 42, 62, 50, 5, -50 },
  { 9149, 36, 49, 39, 3, -49 },
  { 9370, 34, 51, 35, 1, -50 },
  { 9587, 34, 49, 34, 6, -49 },
  { 9796, 42, 50, 47, 6, -49 },
  { 10059, 36, 49, 38, 7, -49 },
  { 10280, 55, 49, 58, 8, -49 },
  { 10617, 45, 49, 35, -4, -49 },
  { 10893, 35, 49, 34, 6, -49 },
  { 11108, 40, 49, 37, -1, -49 },
  { 11353, 27, 60, 21, -1, -49 },
  { 11556, 12, 49, 23, 7, -49 },
  { 11630, 26, 60, 21, -5, -49 },
  { 11825, 33, 31, 39, 3, -50 },
  { 11953, 27, 3, 26, -6, 7 },
  { 11964, 10, 11, 17, 10, -53 },
  { 11978, 34, 38, 39, 3, -37 },
  { 12140, 34, 53, 40, 2, -52 },
  { 12366, 28, 38, 31, 4, -37 },
  { 12499, 38, 53, 40, 3, -52 },
  { 12751, 28, 38, 34, 4, -37 },
  { 12884, 38, 70, 20, -8, -53 },
  { 13217, 35, 54, 40, 2, -37 },
  { 13454, 33, 52, 39, 2, -52 },
  { 13669, 15, 50, 16, 2, -50 },
  { 13763, 26, 67, 16, -9, -50 },
  { 13981, 33, 52, 32, 2, -52 },
  { 14196, 15, 52, 16, 2, -52 },
  { 14294, 53, 37, 59, 2, -37 },
  { 14540, 33, 38, 39, 2, -38 },
  { 14697, 31, 38, 39, 4, -37 },
  { 14845, 37, 53, 40, -1, -37 },
  { 15091, 34, 53, 40, 3, -37 },
  { 15317, 26, 37, 27, 2, -37 },
  { 15438, 27, 38, 30, 1, -37 },
  { 15567, 20, 46, 22, 4, -45 },
  { 15682, 33, 38, 39, 4, -37 },
  { 15839, 31, 37, 30, 3, -37 },
  { 15983, 46, 37, 47, 4, -37 },
  { 16196, 36, 37, 32, -2, -37 },
  { 16363, 41, 54, 30, -7, -37 },
  { 16640, 31, 37, 30, -1, -37 },
  { 16784, 26, 60, 23, 1, -49 },
  { 16979, 3, 69, 37, 19, -52 },
  { 17005, 25, 60, 23, -3, -49 },
  { 17193, 32, 7, 39, 5, -28 },
};

const GFXfont NotoSans_LightItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_LIGHTITALIC69PT7B_H_
