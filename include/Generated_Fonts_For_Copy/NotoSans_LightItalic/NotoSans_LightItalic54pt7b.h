#ifndef _NOTOSANS_LIGHTITALIC54PT7B_H_
#define _NOTOSANS_LIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x78, 0x02,
  0x00, 0x3C, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x0E, 0x38, 0x39, 0xC0, 0xE7,
  0x03, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0xC6, 0x06, 0x38, 0x18, 0xC0, 0x63,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x38, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x06, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x07, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x03, 0xF7, 0x3F, 0x01, 0xE1, 0xC0,
  0x80, 0xF0, 0x70, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x07,
  0x03, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3E, 0x70, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x37,
  0xE0, 0x00, 0x0C, 0x7C, 0x00, 0x03, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x0C, 0x1E, 0x0E, 0x03, 0x0F,
  0x03, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x3F,
  0xE0, 0x00, 0x38, 0x07, 0x9E, 0x00, 0x07, 0x00, 0xE0, 0x70, 0x00, 0x70,
  0x1E, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x38, 0x03, 0x00,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x0E, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x1C, 0x00,
  0x70, 0x07, 0x03, 0x80, 0x06, 0x00, 0x70, 0x70, 0x00, 0x60, 0x06, 0x0E,
  0x00, 0x0E, 0x00, 0xE0, 0xE0, 0x40, 0xE0, 0x0E, 0x1C, 0x3F, 0x8E, 0x00,
  0xC3, 0x8F, 0xFC, 0x60, 0x1C, 0x70, 0xE1, 0xE7, 0x03, 0x87, 0x1C, 0x0E,
  0x70, 0x78, 0xE3, 0x80, 0x63, 0xDF, 0x1C, 0x38, 0x06, 0x3F, 0xE1, 0x87,
  0x00, 0x70, 0xF8, 0x38, 0x70, 0x07, 0x00, 0x07, 0x06, 0x00, 0x60, 0x00,
  0xE0, 0xE0, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x0E,
  0x00, 0x38, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x0C,
  0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x38,
  0x00, 0xC0, 0x38, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x70,
  0x0E, 0x00, 0x0F, 0x0E, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x3C, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x71, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x3C, 0x07, 0x00, 0x1C, 0x38, 0x03, 0xC0, 0x1E, 0x38, 0x00, 0xF0,
  0x0E, 0x3C, 0x00, 0x38, 0x0E, 0x1C, 0x00, 0x0E, 0x07, 0x1E, 0x00, 0x07,
  0x87, 0x0E, 0x00, 0x01, 0xE7, 0x07, 0x00, 0x00, 0x77, 0x83, 0x80, 0x00,
  0x3F, 0x81, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x07, 0xE0, 0x1E, 0x00, 0x0F, 0xF8, 0x0F, 0x80, 0x0F, 0x1E, 0x03, 0xF0,
  0x3F, 0x07, 0x00, 0xFF, 0xFE, 0x03, 0xC0, 0x1F, 0xFC, 0x00, 0xF0, 0x01,
  0x80, 0x00, 0x00, 0x3C, 0xE3, 0x8E, 0x39, 0xC7, 0x1C, 0x71, 0x86, 0x38,
  0xC3, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x40,
  0x0C, 0x00, 0x60, 0x1C, 0x00, 0xF8, 0x1C, 0x00, 0x7E, 0x18, 0x00, 0x0F,
  0x98, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xF8, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x0E, 0x00, 0x0F,
  0x06, 0x00, 0x1E, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x18, 0x03, 0x80, 0x10,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x87, 0x83, 0xC1, 0xC1, 0xE0,
  0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x33, 0xDF, 0xF7, 0x90, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x07,
  0x00, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0F, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0F,
  0x38, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x03, 0x80,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC1, 0xF3, 0x87, 0xC7, 0x3E, 0x1E, 0xF8, 0x38, 0xC0,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x70,
  0x01, 0xE0, 0x04, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x01,
  0xFC, 0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x01, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x08, 0x1F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC2, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x3C, 0x0F, 0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x1E, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x70, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x1C,
  0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1E, 0x07,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x82, 0x00, 0x01, 0xE0, 0x70, 0x00, 0xF8, 0x0F, 0xC0,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x7F, 0x00, 0x70, 0xFF, 0xE0, 0x39, 0xFF, 0xF8, 0x1D, 0xE0, 0x1E, 0x0F,
  0xC0, 0x07, 0x8F, 0xC0, 0x01, 0xC7, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0x79,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03,
  0x9C, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x38, 0x1C, 0x00,
  0x3C, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x80,
  0xF0, 0x00, 0x78, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0E,
  0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7C, 0x03, 0xC0, 0x38,
  0x00, 0xF0, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0F,
  0x38, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xC7, 0x00, 0x07, 0xE3, 0xC0, 0x07,
  0xE1, 0xF0, 0x07, 0x70, 0x7E, 0x1F, 0x38, 0x1F, 0xFF, 0x3C, 0x03, 0xFE,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x0E, 0x07, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1E, 0x07,
  0x83, 0xE0, 0x78, 0x08, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xC0, 0x3C, 0x10, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0x00, 0xC3, 0x80, 0x07, 0xFF, 0x80, 0x71,
  0xC0, 0x0F, 0xFF, 0xC0, 0x39, 0xC0, 0x0F, 0x00, 0xE0, 0x1C, 0xE0, 0x0F,
  0x00, 0x70, 0x0E, 0x60, 0x0F, 0x00, 0x38, 0x07, 0x70, 0x0F, 0x00, 0x38,
  0x03, 0xB8, 0x07, 0x00, 0x1C, 0x01, 0xD8, 0x07, 0x00, 0x0E, 0x00, 0xFC,
  0x03, 0x80, 0x06, 0x00, 0x7E, 0x01, 0xC0, 0x07, 0x00, 0x3F, 0x01, 0xC0,
  0x03, 0x80, 0x1B, 0x80, 0xE0, 0x01, 0xC0, 0x1D, 0xC0, 0x70, 0x01, 0xC0,
  0x0E, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x70, 0x1C, 0x00, 0xF0, 0x07, 0x38,
  0x0E, 0x00, 0x78, 0x07, 0x1C, 0x07, 0x00, 0x6C, 0x07, 0x8E, 0x01, 0xC0,
  0x76, 0x07, 0x87, 0x00, 0xF0, 0xF3, 0x87, 0x81, 0x80, 0x3F, 0xF0, 0xFF,
  0x80, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0xE0, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x38, 0x01, 0xFC, 0x00, 0xE0, 0x00,
  0xF8, 0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x07, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x3F,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x70,
  0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x0E,
  0x00, 0x7C, 0x00, 0x08, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x80,
  0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x0F, 0xE0, 0x00, 0xE0, 0x01, 0xF8, 0x00,
  0xE0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3F, 0x00, 0x70,
  0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0x02, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFC, 0xF0, 0x00, 0x7F,
  0xF8, 0xF0, 0x00, 0x7F, 0xF8, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0x38, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x01, 0xC0, 0x0F, 0x80, 0x03,
  0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x10, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x03, 0x9F, 0x00, 0x00, 0x01, 0xDF, 0xC0, 0x00, 0x00, 0xFE, 0xE0, 0x00,
  0x00, 0xFE, 0x70, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0xDC, 0x00, 0x00, 0x1D, 0xC0,
  0x77, 0x00, 0x00, 0x07, 0xE0, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x07, 0x70,
  0x00, 0x00, 0xEE, 0x01, 0xDC, 0x00, 0x00, 0x73, 0x80, 0x73, 0x00, 0x00,
  0x39, 0xE0, 0x38, 0xE0, 0x00, 0x0E, 0x70, 0x0E, 0x38, 0x00, 0x07, 0x1C,
  0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x38,
  0xE0, 0x00, 0x38, 0xE0, 0x1C, 0x18, 0x00, 0x1C, 0x38, 0x07, 0x06, 0x00,
  0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x70, 0x70, 0x01, 0xC0,
  0xE0, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x03,
  0x81, 0xC0, 0x1E, 0x07, 0x00, 0xE0, 0x30, 0x07, 0x01, 0xC0, 0x38, 0x0C,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x0E, 0x00, 0xE0,
  0x1C, 0x03, 0x87, 0x80, 0x78, 0x0E, 0x00, 0x61, 0xC0, 0x1C, 0x03, 0x80,
  0x1C, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x38, 0x01, 0xC0, 0x38, 0x01, 0xDC,
  0x00, 0x70, 0x0E, 0x00, 0x77, 0x00, 0x3C, 0x07, 0x00, 0x1F, 0x80, 0x0E,
  0x01, 0xC0, 0x03, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x7C, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x1C, 0x03, 0xB8, 0x00, 0x03,
  0x80, 0x77, 0x00, 0x00, 0x70, 0x0E, 0xF0, 0x00, 0x0E, 0x01, 0xCE, 0x00,
  0x01, 0xC0, 0x39, 0xC0, 0x00, 0x70, 0x0E, 0x1C, 0x00, 0x0E, 0x01, 0xC3,
  0x80, 0x01, 0xC0, 0x38, 0x78, 0x00, 0x38, 0x07, 0x07, 0x00, 0x07, 0x00,
  0xE0, 0xE0, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x38, 0x07, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x3C, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x1E, 0x03, 0x80, 0x70, 0x01, 0xC0, 0xE0, 0x1E, 0x00, 0x38, 0x1C, 0x03,
  0x80, 0x03, 0x83, 0x80, 0x70, 0x00, 0x70, 0x70, 0x0E, 0x00, 0x0F, 0x0E,
  0x01, 0xC0, 0x00, 0xE3, 0x80, 0x70, 0x00, 0x1C, 0x70, 0x0E, 0x00, 0x01,
  0xCE, 0x01, 0xC0, 0x00, 0x39, 0xC0, 0x38, 0x00, 0x07, 0xB8, 0x07, 0x00,
  0x00, 0x7E, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x38, 0x00, 0x00, 0xF8, 0x07,
  0x00, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0E, 0x01, 0xFC,
  0x00, 0xE0, 0x03, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xF0, 0x1C,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x3C, 0x07, 0x00, 0x07, 0xC0, 0x70, 0x01, 0xF8, 0x0F, 0x07, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0E, 0x01, 0xFC, 0x00,
  0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3C,
  0x07, 0x00, 0x0F, 0x80, 0x70, 0x0F, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x03, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0x04, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x60, 0x00, 0xF8, 0x0F, 0xC1, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x50, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03,
  0x80, 0x01, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xF0, 0x00, 0x1C,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x70,
  0x00, 0x77, 0x00, 0x03, 0x87, 0x00, 0x07, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x67, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x07, 0x00, 0x1C, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x07, 0x00, 0x38, 0x70, 0x03, 0xC0, 0x70, 0x03, 0x83, 0x00, 0x38,
  0x07, 0x00, 0x70, 0x30, 0x03, 0x80, 0x70, 0x07, 0x03, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x30, 0x07, 0x00, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80,
  0x38, 0x1C, 0x00, 0x70, 0x38, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x38,
  0x38, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x03, 0x0E, 0x00, 0x38, 0xE0, 0x00,
  0x31, 0xC0, 0x03, 0x8E, 0x00, 0x03, 0x1C, 0x00, 0x39, 0xC0, 0x00, 0x33,
  0x80, 0x03, 0x9C, 0x00, 0x03, 0x38, 0x00, 0x19, 0x80, 0x00, 0x37, 0x00,
  0x01, 0xB8, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x1C, 0x00,
  0x1C, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x20, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0E, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x0C, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0x80, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x07, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xF0, 0xE1, 0xC1, 0xC1, 0x83, 0x83, 0x83,
  0x00, 0x3F, 0xC1, 0xC0, 0x3F, 0xF8, 0x60, 0x1F, 0x9F, 0x18, 0x1F, 0x00,
  0xCE, 0x07, 0x80, 0x1B, 0x83, 0xC0, 0x06, 0xE1, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1,
  0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x3E, 0x0E,
  0x00, 0x0F, 0x83, 0x80, 0x06, 0xE0, 0xF0, 0x03, 0xB8, 0x1E, 0x01, 0xCC,
  0x07, 0xC1, 0xE7, 0x00, 0xFF, 0xE1, 0xC0, 0x0F, 0xF0, 0x70, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x83, 0xFC, 0x01, 0xE3, 0xFF, 0x80,
  0x71, 0xF3, 0xF0, 0x1C, 0xE0, 0x1E, 0x07, 0x70, 0x03, 0x81, 0xF8, 0x00,
  0xF0, 0xFC, 0x00, 0x1C, 0x3E, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x0F, 0x38, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0x78, 0x00,
  0x07, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x70, 0x6C,
  0x00, 0x3C, 0x39, 0x80, 0x3E, 0x0E, 0x78, 0x3F, 0x03, 0x0F, 0xFF, 0x00,
  0xC1, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xF0, 0x1F, 0xCF, 0x81, 0xF0, 0x02, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0x01, 0xF0, 0x7C, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x03, 0xFC, 0x1C, 0x00, 0x7F, 0xF0, 0xE0, 0x0F, 0xE7, 0xC7,
  0x00, 0xF8, 0x07, 0x38, 0x07, 0x80, 0x1F, 0x80, 0x78, 0x00, 0x7C, 0x07,
  0x80, 0x03, 0xE0, 0x38, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x3F,
  0x01, 0xC0, 0x03, 0xF0, 0x0F, 0x00, 0x3B, 0x80, 0x3C, 0x03, 0x9C, 0x01,
  0xF8, 0x78, 0xE0, 0x07, 0xFF, 0x86, 0x00, 0x0F, 0xF0, 0x30, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0x9F, 0x80,
  0xF0, 0x0F, 0x07, 0x80, 0x1C, 0x3C, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x00,
  0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x80, 0x07, 0x9C, 0x00, 0x7C,
  0x70, 0x0F, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x01, 0x01, 0xF0, 0x3C, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xF1, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x30, 0x03, 0xFF, 0x87, 0x00, 0xFE, 0x7C, 0x70,
  0x1F, 0x00, 0xE7, 0x01, 0xE0, 0x07, 0x60, 0x3C, 0x00, 0x3E, 0x07, 0x80,
  0x03, 0xE0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C,
  0x1E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0x38,
  0x00, 0x0F, 0x03, 0x80, 0x01, 0xF0, 0x38, 0x00, 0x36, 0x03, 0x80, 0x07,
  0xE0, 0x3C, 0x00, 0xEE, 0x01, 0xE0, 0x1C, 0xE0, 0x1F, 0x87, 0x8E, 0x00,
  0xFF, 0xF1, 0xC0, 0x03, 0xFC, 0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x08, 0x00,
  0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x3F, 0xC0, 0x38, 0x7F, 0xF0,
  0x1C, 0x7E, 0xFC, 0x0E, 0x70, 0x0F, 0x07, 0x70, 0x03, 0x83, 0x70, 0x01,
  0xC3, 0xF0, 0x00, 0xE1, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x78, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x78, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x78, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0x78, 0x00, 0x70,
  0x78, 0x00, 0x38, 0x78, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E,
  0x7C, 0x00, 0x07, 0x7E, 0x00, 0x07, 0x77, 0x80, 0x03, 0xF1, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x1C,
  0x07, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0x03, 0xF8, 0x01, 0xFC, 0x03, 0x87, 0xFE, 0x03, 0xFF, 0x01, 0xC7, 0xDF,
  0x83, 0xEF, 0xC0, 0xE7, 0x01, 0xC3, 0x80, 0xF0, 0x76, 0x00, 0xF3, 0x00,
  0x38, 0x36, 0x00, 0x3B, 0x00, 0x1C, 0x3F, 0x00, 0x1F, 0x80, 0x0E, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x87, 0x80, 0x03,
  0xC0, 0x01, 0xC3, 0x80, 0x01, 0xC0, 0x00, 0xE3, 0xC0, 0x01, 0xE0, 0x00,
  0x71, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x87, 0x00, 0x03, 0x80, 0x01, 0xC7, 0x80, 0x03, 0xC0, 0x00, 0xE3, 0x80,
  0x01, 0xC0, 0x00, 0xF1, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x03, 0xFC, 0x01, 0xC3, 0xFF, 0xC0, 0x71,
  0xFF, 0xF0, 0x1C, 0xF0, 0x1E, 0x07, 0x70, 0x03, 0x81, 0xB8, 0x00, 0xE0,
  0xFC, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0xE1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x87, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x70, 0xF0, 0x00,
  0x1C, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x78, 0x00,
  0x1C, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8,
  0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0xF0,
  0x0F, 0xC1, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60,
  0x7F, 0x80, 0x07, 0x0F, 0xFE, 0x00, 0x38, 0xF9, 0xF8, 0x01, 0xCE, 0x01,
  0xE0, 0x0E, 0xE0, 0x07, 0x00, 0x6E, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0xE0,
  0x3E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x70, 0x0D, 0x80, 0x07, 0x80, 0xE6, 0x00, 0xF8, 0x07, 0x3C, 0x1F, 0x80,
  0x38, 0xFF, 0xF0, 0x01, 0xC3, 0xFF, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xC0, 0x3F,
  0xF8, 0x70, 0x3F, 0x9F, 0x1C, 0x1F, 0x00, 0xE7, 0x07, 0x80, 0x1D, 0x83,
  0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x3C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x1E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF0,
  0xE0, 0x00, 0x3C, 0x38, 0x00, 0x1F, 0x0E, 0x00, 0x0D, 0xC3, 0x80, 0x07,
  0xE0, 0xF0, 0x03, 0xB8, 0x1E, 0x01, 0xCE, 0x07, 0xE1, 0xE3, 0x80, 0xFF,
  0xF1, 0xC0, 0x0F, 0xF0, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x03, 0xF0, 0x70, 0xFF, 0x07, 0x1F, 0xF0, 0x73, 0x80, 0x07, 0x70,
  0x00, 0x6E, 0x00, 0x0E, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0x9F, 0xC1, 0xE0, 0x06,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x0F,
  0x0F, 0x80, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x40, 0x7F, 0xC0, 0x3F, 0xC0,
  0x02, 0x00, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x7C, 0x38, 0x00,
  0x1E, 0x0E, 0x00, 0x0F, 0x83, 0x80, 0x06, 0xE0, 0xF0, 0x03, 0xB8, 0x3C,
  0x01, 0xCC, 0x07, 0xC3, 0xE3, 0x00, 0xFF, 0xE1, 0xC0, 0x1F, 0xF0, 0x70,
  0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x77, 0x00, 0x01, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x3C, 0x00, 0x3C,
  0x38, 0x00, 0x70, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x0F, 0x03,
  0x80, 0x1C, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x1C,
  0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x78, 0x00, 0xE0, 0xE0, 0x01, 0xC3,
  0xC0, 0x03, 0x87, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x00,
  0x0E, 0xE0, 0x01, 0xF0, 0x00, 0xEE, 0x00, 0x1F, 0x00, 0x1C, 0xE0, 0x03,
  0xF0, 0x01, 0xCE, 0x00, 0x37, 0x00, 0x3C, 0xE0, 0x07, 0x70, 0x03, 0x8E,
  0x00, 0x77, 0x00, 0x78, 0xE0, 0x0E, 0x70, 0x07, 0x0E, 0x00, 0xE7, 0x00,
  0xF0, 0x70, 0x1C, 0x70, 0x0E, 0x07, 0x01, 0xC3, 0x01, 0xE0, 0x70, 0x38,
  0x30, 0x1C, 0x07, 0x03, 0x83, 0x81, 0xC0, 0x70, 0x70, 0x38, 0x38, 0x07,
  0x07, 0x03, 0x83, 0x80, 0x70, 0xE0, 0x38, 0x70, 0x07, 0x0E, 0x03, 0x87,
  0x00, 0x71, 0xC0, 0x38, 0xE0, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x73, 0x80,
  0x39, 0xC0, 0x07, 0x38, 0x03, 0x9C, 0x00, 0x77, 0x00, 0x39, 0xC0, 0x07,
  0x70, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x00, 0xE0,
  0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x00, 0xF0,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x0E,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x70, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x3C, 0x00,
  0x1C, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x90, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xBF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xE4, 0x00, 0x0F,
  0xC0,
};

const GFXglyph NotoSans_LightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 12, 40, 13, 1, -39 },
  { 61, 14, 14, 19, 6, -39 },
  { 86, 33, 39, 34, 2, -39 },
  { 247, 26, 44, 30, 2, -41 },
  { 390, 36, 40, 42, 4, -39 },
  { 570, 33, 40, 37, 2, -39 },
  { 735, 6, 14, 11, 6, -39 },
  { 746, 16, 48, 14, 2, -39 },
  { 842, 17, 48, 14, -4, -39 },
  { 944, 24, 24, 29, 6, -41 },
  { 1016, 25, 26, 31, 4, -32 },
  { 1098, 9, 13, 12, -2, -6 },
  { 1113, 13, 3, 17, 2, -16 },
  { 1118, 5, 6, 13, 1, -5 },
  { 1122, 25, 39, 18, -2, -39 },
  { 1244, 26, 40, 30, 3, -39 },
  { 1374, 15, 39, 30, 8, -39 },
  { 1448, 28, 39, 30, 0, -39 },
  { 1585, 27, 40, 30, 1, -39 },
  { 1720, 28, 39, 30, 1, -39 },
  { 1857, 27, 40, 30, 2, -39 },
  { 1992, 25, 40, 30, 4, -39 },
  { 2117, 25, 39, 30, 5, -39 },
  { 2239, 27, 40, 30, 2, -39 },
  { 2374, 25, 40, 30, 3, -39 },
  { 2499, 10, 30, 13, 1, -29 },
  { 2537, 14, 36, 13, -3, -29 },
  { 2600, 25, 25, 31, 4, -32 },
  { 2679, 25, 14, 31, 4, -26 },
  { 2723, 25, 25, 31, 4, -32 },
  { 2802, 20, 40, 23, 4, -39 },
  { 2902, 41, 43, 45, 3, -38 },
  { 3123, 30, 39, 30, -3, -39 },
  { 3270, 30, 39, 32, 2, -39 },
  { 3417, 30, 40, 32, 4, -39 },
  { 3567, 32, 39, 36, 2, -39 },
  { 3723, 28, 39, 28, 2, -39 },
  { 3860, 28, 39, 26, 2, -39 },
  { 3997, 32, 40, 37, 4, -39 },
  { 4157, 35, 39, 37, 2, -39 },
  { 4328, 19, 39, 16, 0, -39 },
  { 4421, 23, 49, 14, -9, -39 },
  { 4562, 33, 39, 30, 2, -39 },
  { 4723, 20, 39, 26, 2, -39 },
  { 4821, 42, 39, 45, 2, -39 },
  { 5026, 35, 39, 37, 2, -39 },
  { 5197, 33, 40, 39, 4, -39 },
  { 5362, 28, 39, 30, 2, -39 },
  { 5499, 33, 48, 39, 4, -39 },
  { 5697, 28, 39, 31, 2, -39 },
  { 5834, 27, 40, 27, 1, -39 },
  { 5969, 26, 39, 27, 5, -39 },
  { 6096, 32, 40, 37, 5, -39 },
  { 6256, 29, 39, 29, 5, -39 },
  { 6398, 44, 39, 45, 6, -39 },
  { 6613, 35, 39, 27, -3, -39 },
  { 6784, 27, 39, 27, 5, -39 },
  { 6916, 31, 39, 29, 0, -39 },
  { 7068, 20, 48, 16, 0, -39 },
  { 7188, 9, 39, 18, 6, -39 },
  { 7232, 21, 48, 16, -4, -39 },
  { 7358, 26, 24, 30, 2, -39 },
  { 7436, 22, 3, 21, -5, 5 },
  { 7445, 7, 8, 14, 8, -41 },
  { 7452, 26, 30, 30, 3, -29 },
  { 7550, 26, 42, 31, 2, -41 },
  { 7687, 22, 30, 24, 3, -29 },
  { 7770, 29, 42, 31, 3, -41 },
  { 7923, 22, 30, 27, 3, -29 },
  { 8006, 30, 54, 16, -7, -41 },
  { 8209, 28, 42, 31, 1, -29 },
  { 8356, 25, 41, 31, 2, -41 },
  { 8485, 11, 39, 13, 2, -39 },
  { 8539, 20, 52, 13, -7, -39 },
  { 8669, 25, 41, 25, 2, -41 },
  { 8798, 11, 41, 13, 2, -41 },
  { 8855, 41, 29, 46, 2, -29 },
  { 9004, 26, 29, 31, 2, -29 },
  { 9099, 25, 29, 30, 3, -29 },
  { 9190, 29, 42, 31, -1, -29 },
  { 9343, 26, 42, 31, 3, -29 },
  { 9480, 20, 29, 21, 2, -29 },
  { 9553, 22, 30, 23, 0, -29 },
  { 9636, 16, 37, 17, 3, -36 },
  { 9710, 26, 30, 31, 3, -29 },
  { 9808, 23, 29, 24, 3, -29 },
  { 9892, 36, 29, 37, 3, -29 },
  { 10023, 28, 29, 25, -2, -29 },
  { 10125, 32, 42, 24, -6, -29 },
  { 10293, 25, 29, 24, -1, -29 },
  { 10384, 20, 48, 18, 1, -39 },
  { 10504, 2, 54, 29, 15, -41 },
  { 10518, 20, 48, 18, -2, -39 },
  { 10638, 25, 6, 31, 4, -22 },
};

const GFXfont NotoSans_LightItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_LIGHTITALIC54PT7B_H_
