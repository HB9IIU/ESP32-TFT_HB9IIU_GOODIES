#ifndef _NOTOSANS_LIGHTITALIC10PT7B_H_
#define _NOTOSANS_LIGHTITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x48, 0xB4, 0x14, 0xA7, 0xCA, 0xFD, 0x45, 0x00, 0x11, 0xD4,
  0xA3, 0x16, 0xEC, 0x20, 0xE6, 0xAB, 0x37, 0x35, 0x59, 0xC0, 0x38, 0xA3,
  0x18, 0x96, 0x27, 0x40, 0xC0, 0x29, 0x49, 0x24, 0x40, 0x24, 0x92, 0x4A,
  0x80, 0x2A, 0x76, 0x90, 0x22, 0xF2, 0x20, 0xC0, 0xE0, 0x80, 0x12, 0x24,
  0x48, 0x80, 0x79, 0x99, 0x99, 0xE0, 0x75, 0xA8, 0x78, 0x42, 0x22, 0x23,
  0xC0, 0x78, 0x42, 0x60, 0x87, 0xC0, 0x08, 0xCA, 0x9F, 0x88, 0x40, 0x3A,
  0x18, 0x30, 0x87, 0xC0, 0x78, 0xE9, 0x99, 0xE0, 0xF8, 0x88, 0x44, 0x22,
  0x00, 0x3A, 0x4A, 0xE8, 0xC5, 0xC0, 0x3A, 0x52, 0xB2, 0x8B, 0x80, 0x40,
  0x80, 0x40, 0xA0, 0x16, 0x86, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0xE4,
  0xA8, 0x20, 0x7D, 0x06, 0xEE, 0x5C, 0xB7, 0xA0, 0x3C, 0x08, 0x51, 0x49,
  0x3D, 0x1C, 0x40, 0x3D, 0x14, 0x5E, 0x45, 0x2F, 0x00, 0x7C, 0x21, 0x08,
  0x41, 0xC0, 0x3D, 0x14, 0x51, 0x45, 0x1F, 0x80, 0x3D, 0x04, 0x1E, 0x41,
  0x0F, 0x00, 0x3D, 0x04, 0x1E, 0x41, 0x08, 0x00, 0x7E, 0x08, 0x26, 0x8A,
  0x27, 0x80, 0x22, 0x85, 0x13, 0xE4, 0x48, 0xA1, 0x00, 0x65, 0x24, 0xB0,
  0x08, 0x84, 0x21, 0x08, 0x84, 0xC0, 0x25, 0x25, 0x1C, 0x51, 0x48, 0x80,
  0x24, 0x44, 0x44, 0xF0, 0x21, 0x63, 0x63, 0x55, 0x5A, 0x5A, 0x92, 0x22,
  0xC5, 0x4A, 0xA4, 0xC9, 0xA1, 0x00, 0x7A, 0x18, 0x61, 0x86, 0x27, 0x00,
  0x39, 0x14, 0x5E, 0x41, 0x08, 0x00, 0x7A, 0x18, 0x61, 0x86, 0x27, 0x04,
  0x10, 0x39, 0x14, 0x5E, 0x51, 0x28, 0x80, 0x7A, 0x10, 0x61, 0x07, 0xC0,
  0xF9, 0x10, 0x84, 0x21, 0x00, 0x46, 0x18, 0x62, 0x8A, 0x2F, 0x00, 0x8C,
  0x65, 0x4A, 0x61, 0x00, 0x89, 0x99, 0xAA, 0xAA, 0xCC, 0xCC, 0x88, 0x22,
  0x28, 0x60, 0x82, 0x89, 0x31, 0x00, 0x8C, 0xA8, 0x84, 0x21, 0x00, 0x7C,
  0x21, 0x08, 0x41, 0x0F, 0x00, 0x74, 0x44, 0x48, 0x88, 0xC0, 0xAA, 0x54,
  0x31, 0x11, 0x22, 0x22, 0xC0, 0x11, 0x93, 0x90, 0xF0, 0x90, 0x7A, 0x63,
  0x17, 0x80, 0x22, 0x14, 0xD4, 0xA6, 0x3E, 0xF8, 0x88, 0xE0, 0x04, 0x13,
  0x52, 0x4A, 0x28, 0x9C, 0xFB, 0xC8, 0xE0, 0x08, 0x8C, 0x42, 0x10, 0x88,
  0x46, 0x00, 0x7A, 0x63, 0x17, 0x8B, 0xC0, 0x22, 0x14, 0xD4, 0xA6, 0x31,
  0x45, 0x68, 0x20, 0x92, 0x92, 0xC0, 0x22, 0x12, 0xA6, 0x32, 0x52, 0x55,
  0x5A, 0x7F, 0x49, 0x49, 0x89, 0x91, 0x7A, 0x53, 0x18, 0x80, 0xF9, 0x99,
  0xE0, 0x7A, 0x53, 0x1F, 0x42, 0x00, 0x7A, 0x63, 0x17, 0x08, 0x40, 0x74,
  0x48, 0x80, 0x74, 0x21, 0xE0, 0x7A, 0xA8, 0x99, 0x99, 0xF0, 0x8A, 0x98,
  0xC4, 0x00, 0xA7, 0x5D, 0xA4, 0x90, 0x5B, 0x08, 0xC9, 0x00, 0x44, 0xA2,
  0x8C, 0x20, 0x8C, 0x00, 0x72, 0x44, 0xE0, 0x32, 0x24, 0xC4, 0x48, 0x40,
  0xFF, 0xC0, 0x64, 0x92, 0x92, 0x80, 0xF0,
};

const GFXglyph NotoSans_LightItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 3, 2, 4, 1, -7 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 5, 9, 6, 0, -8 },
  { 16, 6, 7, 8, 1, -7 },
  { 22, 6, 7, 7, 0, -7 },
  { 28, 1, 2, 2, 1, -7 },
  { 29, 3, 9, 3, 0, -7 },
  { 33, 3, 9, 3, -1, -7 },
  { 37, 4, 5, 5, 1, -8 },
  { 40, 4, 5, 6, 1, -6 },
  { 43, 1, 2, 2, 0, -1 },
  { 44, 3, 1, 3, 0, -3 },
  { 45, 1, 1, 2, 0, -1 },
  { 46, 4, 7, 3, 0, -7 },
  { 50, 4, 7, 6, 1, -7 },
  { 54, 2, 7, 6, 2, -7 },
  { 56, 5, 7, 6, 0, -7 },
  { 61, 5, 7, 6, 0, -7 },
  { 66, 5, 7, 6, 0, -7 },
  { 71, 5, 7, 6, 0, -7 },
  { 76, 4, 7, 6, 1, -7 },
  { 80, 5, 7, 6, 1, -7 },
  { 85, 5, 7, 6, 0, -7 },
  { 90, 5, 7, 6, 0, -7 },
  { 95, 2, 5, 2, 0, -5 },
  { 97, 2, 6, 2, 0, -5 },
  { 99, 4, 5, 6, 1, -6 },
  { 102, 4, 3, 6, 1, -5 },
  { 104, 4, 5, 6, 1, -6 },
  { 107, 3, 7, 4, 1, -7 },
  { 110, 7, 8, 8, 1, -7 },
  { 117, 6, 7, 6, -1, -7 },
  { 123, 6, 7, 6, 0, -7 },
  { 129, 5, 7, 6, 1, -7 },
  { 134, 6, 7, 7, 0, -7 },
  { 140, 6, 7, 5, 0, -7 },
  { 146, 6, 7, 5, 0, -7 },
  { 152, 6, 7, 7, 1, -7 },
  { 158, 7, 7, 7, 0, -7 },
  { 165, 3, 7, 3, 0, -7 },
  { 168, 5, 9, 3, -2, -7 },
  { 174, 6, 7, 6, 0, -7 },
  { 180, 4, 7, 5, 0, -7 },
  { 184, 8, 7, 8, 0, -7 },
  { 191, 7, 7, 7, 0, -7 },
  { 198, 6, 7, 7, 1, -7 },
  { 204, 6, 7, 6, 0, -7 },
  { 210, 6, 9, 7, 1, -7 },
  { 217, 6, 7, 6, 0, -7 },
  { 223, 5, 7, 5, 0, -7 },
  { 228, 5, 7, 5, 1, -7 },
  { 233, 6, 7, 7, 1, -7 },
  { 239, 5, 7, 5, 1, -7 },
  { 244, 8, 7, 8, 1, -7 },
  { 251, 7, 7, 5, -1, -7 },
  { 258, 5, 7, 5, 1, -7 },
  { 263, 6, 7, 5, 0, -7 },
  { 269, 4, 9, 3, 0, -7 },
  { 274, 2, 7, 3, 1, -7 },
  { 276, 4, 9, 3, -1, -7 },
  { 281, 5, 4, 6, 0, -7 },
  { 284, 4, 1, 4, -1, 1 },
  { 285, 2, 2, 3, 1, -8 },
  { 286, 5, 5, 6, 0, -5 },
  { 290, 5, 8, 6, 0, -8 },
  { 295, 4, 5, 5, 1, -5 },
  { 298, 6, 8, 6, 0, -8 },
  { 304, 4, 5, 5, 1, -5 },
  { 307, 5, 10, 3, -1, -8 },
  { 314, 5, 7, 6, 0, -5 },
  { 319, 5, 8, 6, 0, -8 },
  { 324, 2, 7, 2, 0, -7 },
  { 326, 3, 9, 2, -1, -7 },
  { 330, 5, 8, 5, 0, -8 },
  { 335, 2, 8, 2, 0, -8 },
  { 337, 8, 5, 9, 0, -5 },
  { 342, 5, 5, 6, 0, -5 },
  { 346, 4, 5, 6, 1, -5 },
  { 349, 5, 7, 6, 0, -5 },
  { 354, 5, 7, 6, 0, -5 },
  { 359, 4, 5, 4, 0, -5 },
  { 362, 4, 5, 4, 0, -5 },
  { 365, 2, 7, 3, 1, -7 },
  { 367, 4, 5, 6, 1, -5 },
  { 370, 5, 5, 4, 0, -5 },
  { 374, 6, 5, 7, 1, -5 },
  { 378, 5, 5, 5, 0, -5 },
  { 382, 6, 7, 4, -1, -5 },
  { 388, 4, 5, 4, 0, -5 },
  { 391, 4, 9, 3, 0, -7 },
  { 396, 1, 10, 5, 2, -8 },
  { 398, 3, 9, 3, 0, -7 },
  { 402, 4, 1, 6, 1, -4 },
};

const GFXfont NotoSans_LightItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_LIGHTITALIC10PT7B_H_
