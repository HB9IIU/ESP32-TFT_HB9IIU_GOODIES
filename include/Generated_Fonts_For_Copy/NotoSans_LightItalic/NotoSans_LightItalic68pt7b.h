#ifndef _NOTOSANS_LIGHTITALIC68PT7B_H_
#define _NOTOSANS_LIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x1F,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x3C, 0x07, 0x0E, 0x03, 0xC3, 0x80, 0xF0,
  0xE0, 0x38, 0x78, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x70, 0x60,
  0x1C, 0x38, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7E, 0x1C, 0x0E,
  0x00, 0xF8, 0x1C, 0x02, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x01, 0xF8, 0xE0, 0x00, 0x00, 0xFE, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x03, 0x83, 0xE0,
  0x00, 0x03, 0x81, 0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0xC0, 0x0E, 0x0F, 0xC0,
  0xF8, 0x0E, 0x3F, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x78, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xE0, 0x0F, 0x01,
  0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0xF0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x0E,
  0x01, 0xC0, 0xE0, 0x03, 0xC1, 0xE0, 0xFF, 0x8E, 0x00, 0x38, 0x3C, 0x3F,
  0xFC, 0xE0, 0x07, 0x83, 0x87, 0xE7, 0xEE, 0x00, 0x70, 0x78, 0xF8, 0x1E,
  0xF0, 0x0F, 0x0F, 0x0F, 0x00, 0xEF, 0x01, 0xE1, 0xE1, 0xE0, 0x0F, 0x78,
  0x3C, 0x1C, 0x1C, 0x00, 0xF7, 0xFF, 0x83, 0xC3, 0xC0, 0x0F, 0x3F, 0xF0,
  0x78, 0x38, 0x00, 0xF0, 0xFE, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0x81,
  0xE0, 0x0E, 0x00, 0x00, 0x7E, 0xFC, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x3C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC1, 0xF8, 0x00,
  0x00, 0x01, 0xE3, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0xF8,
  0x03, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x00, 0x78, 0xF8, 0x00, 0x1F, 0x00, 0x78, 0x78, 0x00, 0x07, 0xC0, 0x38,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x1E, 0x00,
  0x00, 0x3E, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x3E, 0x07, 0x80, 0x00, 0x03,
  0xFE, 0x03, 0xC0, 0x00, 0x01, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x3E, 0x00,
  0x00, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x7E, 0xF0, 0x07, 0xE0, 0x00, 0xFC,
  0x3C, 0x01, 0xF8, 0x01, 0xFC, 0x1F, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xC0,
  0x1F, 0xFF, 0xF8, 0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x60, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x08, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x07, 0xE0,
  0x1C, 0x00, 0x3F, 0x80, 0xE0, 0x00, 0x7F, 0x06, 0x00, 0x00, 0xFE, 0x70,
  0x00, 0x00, 0xFF, 0x80, 0x7C, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0x3F, 0xF8, 0x01, 0xD8, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x3E, 0x07,
  0x80, 0x03, 0xE0, 0x1C, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x06, 0x00, 0x1E, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x79, 0xFF, 0xFF, 0xFB, 0xE6, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7E, 0x78, 0x3F, 0x1C,
  0x3F, 0x0F, 0x3F, 0x83, 0xCF, 0x80, 0xF3, 0xC0, 0x3C, 0x40, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x07, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x40, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x03, 0xE7, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xBF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x0F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x02, 0x00, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x60,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x7F, 0xC0, 0x01, 0xE1, 0xFF, 0xF8, 0x00, 0xE1, 0xFF,
  0xFE, 0x00, 0xF3, 0xF0, 0x3F, 0x80, 0x7B, 0xC0, 0x03, 0xE0, 0x3F, 0xC0,
  0x00, 0xF0, 0x1D, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1E, 0x0F, 0xC0,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x17, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x78, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x1F,
  0xC0, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0B, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x00, 0xFE, 0x07, 0x80, 0x00, 0xEE,
  0x03, 0xE0, 0x01, 0xEF, 0x00, 0xFC, 0x03, 0xE7, 0x80, 0x3F, 0xFF, 0xE3,
  0xC0, 0x0F, 0xFF, 0xE3, 0xC0, 0x03, 0xFF, 0xC1, 0xE0, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x07, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x0F, 0xC0, 0xFC,
  0x0F, 0x80, 0xF8, 0x06, 0x00, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC1, 0xE0, 0x03, 0xE0, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x78, 0x70, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0x1E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xE3, 0x80, 0x07, 0xE0, 0x07, 0x80,
  0x1C, 0xF0, 0x01, 0xF0, 0x00, 0xE0, 0x03, 0x9C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x77, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x0E, 0xF0, 0x03, 0xC0, 0x00,
  0xE0, 0x01, 0xDC, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x3B, 0x80, 0x1E, 0x00,
  0x07, 0x80, 0x07, 0xF0, 0x03, 0x80, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0x07, 0xF0, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0xEE, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x1D, 0xC0,
  0x0E, 0x00, 0x03, 0x80, 0x07, 0xB8, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF7,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x07,
  0x9C, 0x00, 0xE0, 0x01, 0xF8, 0x01, 0xE3, 0x80, 0x1C, 0x00, 0x3F, 0x00,
  0x78, 0x70, 0x03, 0xC0, 0x0E, 0xE0, 0x0F, 0x0F, 0x00, 0x7C, 0x07, 0x9E,
  0x07, 0xC1, 0xE0, 0x07, 0xE3, 0xE1, 0xE3, 0xF0, 0x3C, 0x00, 0x7F, 0xF8,
  0x3F, 0xFC, 0x03, 0x80, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x03, 0x80, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x01, 0xF8, 0x01, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x1F,
  0x80, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x1F, 0x80, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x3F, 0x80,
  0x3C, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x00, 0x20,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x08, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00,
  0x78, 0x00, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x1C, 0x00,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x0F,
  0xC0, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x78,
  0x00, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x1F,
  0xF0, 0x00, 0x78, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x00, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF,
  0xF8, 0x78, 0x00, 0x03, 0xFF, 0xF8, 0x78, 0x00, 0x07, 0xFF, 0xF8, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0x80,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x0C, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x00, 0x00, 0x70, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x3F, 0x80, 0x00, 0x00, 0x07, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xBC,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x78, 0x00, 0x00, 0x01, 0xFC, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x73,
  0x80, 0x00, 0x00, 0x3D, 0xE0, 0x07, 0x9C, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xE3,
  0xC0, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x71, 0xE0, 0x00, 0x00,
  0xF1, 0xE0, 0x07, 0x87, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0x78, 0x78, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x0F, 0x0E,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x07,
  0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x78,
  0x01, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x3C,
  0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xF0,
  0x07, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x1C, 0x1C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE0, 0x07,
  0x80, 0x07, 0x9E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x78, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x73, 0x80, 0x00, 0x03, 0xC0, 0x0F, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0xE1, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x03, 0xC0, 0x38,
  0x00, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0xF0, 0x00,
  0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x00, 0x1E,
  0x03, 0x80, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x00, 0x0E, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0x78, 0x70, 0x03, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0xF0, 0x03, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0x80, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1C, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0xFE, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0x80, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x01, 0xF0,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x7C,
  0x07, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x1C, 0x00,
  0x07, 0xF0, 0x07, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0x00,
  0x07, 0x80, 0x1F, 0x80, 0x00, 0x20, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x02, 0x00, 0x00, 0x1F, 0x80, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x0F,
  0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x01, 0xC0,
  0x01, 0xE0, 0x70, 0x00, 0x78, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x03, 0xC0,
  0x1E, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x1C, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x01,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x3C, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07,
  0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0,
  0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00, 0xE1, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0x81, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x70, 0x07,
  0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x7C,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x60, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xC0, 0x07, 0xFF, 0xE0, 0xE0,
  0x0F, 0xFB, 0xF8, 0xF0, 0x0F, 0xC0, 0x1C, 0x70, 0x0F, 0xC0, 0x07, 0x38,
  0x0F, 0x80, 0x01, 0xBC, 0x0F, 0x80, 0x00, 0xFE, 0x07, 0x80, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0xFC, 0x0E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x7E, 0x03, 0xC0,
  0x00, 0x77, 0x01, 0xE0, 0x00, 0x77, 0x80, 0xF8, 0x00, 0x73, 0xC0, 0x3E,
  0x00, 0x79, 0xC0, 0x1F, 0x80, 0xF8, 0xE0, 0x07, 0xFF, 0xF0, 0x70, 0x01,
  0xFF, 0xF0, 0x38, 0x00, 0x7F, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x00, 0xE0, 0x3F, 0xF0,
  0x00, 0x78, 0x3F, 0xFF, 0x00, 0x1E, 0x3F, 0xFF, 0xE0, 0x07, 0x9F, 0x00,
  0xF8, 0x01, 0xCF, 0x00, 0x1F, 0x00, 0xF3, 0x80, 0x03, 0xC0, 0x3D, 0xC0,
  0x00, 0x78, 0x0F, 0xE0, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x01, 0xE0, 0x7E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x78, 0x3E, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x1F,
  0xC0, 0x00, 0x7C, 0x07, 0xB8, 0x00, 0x3F, 0x01, 0xCF, 0x00, 0x1F, 0x80,
  0x71, 0xE0, 0x1F, 0xC0, 0x1C, 0x3F, 0xFF, 0xE0, 0x0F, 0x07, 0xFF, 0xE0,
  0x03, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xF0,
  0x1F, 0x80, 0x0C, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x04, 0x03, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x0F, 0xFF,
  0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x1C, 0x00, 0x1F, 0xFF, 0xF1, 0xE0, 0x01,
  0xF8, 0x03, 0xCF, 0x00, 0x1F, 0x00, 0x0F, 0x78, 0x01, 0xF0, 0x00, 0x3B,
  0xC0, 0x1F, 0x00, 0x00, 0xDC, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x3C,
  0x00, 0x07, 0x70, 0x01, 0xF0, 0x00, 0xF3, 0x80, 0x07, 0xC0, 0x0F, 0x1C,
  0x00, 0x3F, 0x01, 0xF1, 0xE0, 0x00, 0xFF, 0xFF, 0x0F, 0x00, 0x03, 0xFF,
  0xE0, 0x70, 0x00, 0x0F, 0xFE, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x01, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0E,
  0x1E, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x7C, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xF0, 0x78, 0x03, 0xFE,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x06, 0x01, 0xF8, 0x01, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x60, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x83, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x1C, 0x00, 0x3F, 0xFF, 0x07, 0x00, 0x1F, 0xFF, 0xF0, 0xE0, 0x07,
  0xE0, 0x0F, 0x1C, 0x01, 0xF8, 0x00, 0xF7, 0x80, 0x7C, 0x00, 0x0E, 0xF0,
  0x1F, 0x00, 0x00, 0xDC, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x81, 0xE0,
  0x00, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x3F, 0x80,
  0x78, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x03, 0xDC, 0x01, 0xF0, 0x00, 0xF3,
  0x80, 0x1F, 0x00, 0x3C, 0xF0, 0x03, 0xF0, 0x1F, 0x1E, 0x00, 0x3F, 0xFF,
  0xC3, 0xC0, 0x03, 0xFF, 0xE0, 0x70, 0x00, 0x3F, 0xF8, 0x1E, 0x00, 0x00,
  0x70, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x04, 0x00, 0x01, 0xF0, 0x00, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x1F, 0x80, 0x00, 0xE0, 0x3F, 0xF8, 0x00, 0xF0, 0x7F, 0xFE, 0x00,
  0x78, 0x7F, 0x7F, 0x80, 0x3C, 0xF8, 0x07, 0xE0, 0x1C, 0x70, 0x01, 0xF0,
  0x1E, 0x70, 0x00, 0x78, 0x0F, 0x70, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0x0F,
  0x03, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x01,
  0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x08, 0x00, 0x78,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x08, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x0F, 0x3F, 0x00, 0x00, 0x0F, 0x7F, 0x80, 0x00, 0x0E, 0xF7, 0x80,
  0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0x1F, 0x81, 0xE0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x0E, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xE1, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1C, 0x3F, 0xBF, 0x81, 0xFF,
  0xFE, 0x01, 0xC7, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0x1C, 0xF0, 0x03, 0xC7,
  0x80, 0x1F, 0x01, 0xDC, 0x00, 0x3C, 0x70, 0x00, 0xF0, 0x3D, 0xC0, 0x01,
  0xCE, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x3F, 0xFC, 0x00, 0x78, 0x3F, 0xFF,
  0x00, 0x3C, 0x7F, 0xFF, 0xC0, 0x1C, 0x7C, 0x03, 0xF0, 0x0E, 0x7C, 0x00,
  0xF8, 0x0F, 0x78, 0x00, 0x3C, 0x07, 0xB8, 0x00, 0x1F, 0x03, 0xF8, 0x00,
  0x07, 0x81, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xE0, 0xFC, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x3F, 0xF0, 0x00, 0x0F,
  0x07, 0xFF, 0xE0, 0x00, 0x70, 0x7F, 0xFF, 0x80, 0x03, 0x8F, 0x80, 0x7C,
  0x00, 0x1C, 0xF0, 0x01, 0xF0, 0x00, 0xE7, 0x00, 0x07, 0x80, 0x0F, 0x70,
  0x00, 0x1E, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0x80,
  0x1F, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x00, 0xF8,
  0x01, 0xEE, 0x00, 0x0F, 0xC0, 0x0F, 0x78, 0x00, 0xFC, 0x00, 0x79, 0xE0,
  0x1F, 0xC0, 0x03, 0x87, 0xFF, 0xFC, 0x00, 0x3C, 0x1F, 0xFF, 0x80, 0x01,
  0xE0, 0x7F, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x70, 0x01, 0xFF, 0xF8, 0x38, 0x01, 0xFF, 0xFF, 0x0E,
  0x00, 0xFC, 0x01, 0xE3, 0x80, 0x7E, 0x00, 0x3D, 0xE0, 0x3E, 0x00, 0x07,
  0x78, 0x1F, 0x00, 0x00, 0xDC, 0x07, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7E, 0x0F, 0x00, 0x00,
  0x1F, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x07, 0xF0, 0x1E, 0x00,
  0x01, 0xFC, 0x07, 0x80, 0x00, 0xEF, 0x01, 0xF0, 0x00, 0xF3, 0x80, 0x3E,
  0x00, 0x79, 0xE0, 0x0F, 0xC0, 0x7C, 0x78, 0x01, 0xFF, 0xFE, 0x1E, 0x00,
  0x3F, 0xFE, 0x07, 0x00, 0x07, 0xFF, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x38, 0x1F, 0xF0,
  0x1E, 0x0F, 0xFC, 0x07, 0x8F, 0xFE, 0x01, 0xC7, 0xC0, 0x00, 0x73, 0xC0,
  0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3E, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x84, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x3F,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xDF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x20, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xE0,
  0xF0, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x1D, 0xC0,
  0xF0, 0x00, 0x3B, 0xC0, 0xF0, 0x00, 0x7B, 0xC0, 0xF8, 0x00, 0xF3, 0xC0,
  0x7C, 0x03, 0xE3, 0x80, 0x7F, 0xFF, 0xC3, 0x80, 0x3F, 0xFF, 0x03, 0x80,
  0x0F, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0,
  0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x78, 0x03, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xBC, 0x00,
  0x07, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xCF, 0x00, 0x03,
  0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xCE,
  0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xF3, 0x80,
  0x07, 0x87, 0x80, 0x0F, 0x1C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0xE0, 0x03,
  0xC1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x38, 0x01, 0xE0,
  0x78, 0x03, 0xC1, 0xC0, 0x0F, 0x01, 0xC0, 0x1E, 0x0E, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x03, 0xC0, 0x78, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x1C, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0xF0, 0x38,
  0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x00, 0x3C, 0x1C, 0x00,
  0xE0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x38,
  0x78, 0x00, 0x78, 0xF0, 0x01, 0xC3, 0x80, 0x03, 0xC7, 0x00, 0x0E, 0x3C,
  0x00, 0x1E, 0x78, 0x00, 0x71, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0x9E, 0x00,
  0x07, 0xBC, 0x00, 0x1C, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xEF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x81, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFE, 0xC0, 0x01, 0xFF,
  0xFC, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph NotoSans_LightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 15, 50, 16, 2, -49 },
  { 95, 18, 18, 24, 7, -49 },
  { 136, 41, 49, 43, 2, -49 },
  { 388, 32, 56, 37, 3, -52 },
  { 612, 44, 50, 53, 6, -49 },
  { 887, 41, 50, 46, 3, -49 },
  { 1144, 8, 18, 13, 7, -49 },
  { 1162, 21, 60, 18, 2, -49 },
  { 1320, 21, 60, 18, -5, -49 },
  { 1478, 29, 30, 37, 8, -52 },
  { 1587, 32, 32, 39, 5, -40 },
  { 1715, 11, 17, 15, -3, -8 },
  { 1739, 17, 3, 21, 2, -20 },
  { 1746, 6, 7, 16, 2, -6 },
  { 1752, 31, 49, 23, -3, -49 },
  { 1942, 32, 50, 37, 4, -49 },
  { 2142, 18, 49, 37, 11, -49 },
  { 2253, 35, 49, 37, 0, -49 },
  { 2468, 35, 50, 37, 1, -49 },
  { 2687, 35, 49, 37, 1, -49 },
  { 2902, 34, 50, 37, 3, -49 },
  { 3115, 33, 50, 37, 4, -49 },
  { 3322, 31, 49, 37, 7, -49 },
  { 3512, 34, 50, 37, 3, -49 },
  { 3725, 33, 50, 37, 3, -49 },
  { 3932, 12, 38, 16, 2, -37 },
  { 3989, 17, 46, 16, -3, -37 },
  { 4087, 32, 32, 39, 5, -41 },
  { 4215, 31, 17, 39, 5, -32 },
  { 4281, 32, 32, 39, 5, -41 },
  { 4409, 25, 50, 28, 5, -49 },
  { 4566, 51, 54, 57, 4, -48 },
  { 4911, 38, 49, 38, -4, -49 },
  { 5144, 37, 49, 41, 3, -49 },
  { 5371, 38, 50, 40, 5, -49 },
  { 5609, 40, 49, 46, 3, -49 },
  { 5854, 35, 49, 36, 3, -49 },
  { 6069, 35, 49, 33, 3, -49 },
  { 6284, 40, 50, 47, 5, -49 },
  { 6534, 43, 49, 46, 3, -49 },
  { 6798, 24, 49, 21, 0, -49 },
  { 6945, 28, 61, 17, -11, -49 },
  { 7159, 41, 49, 38, 3, -49 },
  { 7411, 25, 49, 33, 3, -49 },
  { 7565, 53, 49, 56, 3, -49 },
  { 7890, 44, 49, 47, 3, -49 },
  { 8160, 41, 50, 49, 5, -49 },
  { 8417, 35, 49, 38, 3, -49 },
  { 8632, 41, 61, 49, 5, -49 },
  { 8945, 35, 49, 39, 3, -49 },
  { 9160, 34, 50, 34, 1, -49 },
  { 9373, 34, 49, 34, 6, -49 },
  { 9582, 41, 50, 47, 6, -49 },
  { 9839, 36, 49, 37, 7, -49 },
  { 10060, 54, 49, 57, 8, -49 },
  { 10391, 44, 49, 35, -4, -49 },
  { 10661, 34, 49, 34, 6, -49 },
  { 10870, 40, 49, 36, -1, -49 },
  { 11115, 26, 60, 20, -1, -49 },
  { 11310, 12, 49, 23, 7, -49 },
  { 11384, 26, 60, 20, -5, -49 },
  { 11579, 32, 30, 38, 3, -49 },
  { 11699, 27, 3, 26, -6, 7 },
  { 11710, 9, 11, 17, 10, -52 },
  { 11723, 33, 38, 38, 3, -37 },
  { 11880, 34, 53, 39, 2, -52 },
  { 12106, 27, 38, 31, 4, -37 },
  { 12235, 37, 53, 39, 3, -52 },
  { 12481, 28, 38, 34, 4, -37 },
  { 12614, 37, 68, 20, -8, -52 },
  { 12929, 35, 53, 39, 2, -37 },
  { 13161, 33, 52, 38, 2, -52 },
  { 13376, 15, 50, 16, 2, -50 },
  { 13470, 26, 66, 16, -9, -50 },
  { 13685, 32, 52, 32, 2, -52 },
  { 13893, 15, 52, 16, 2, -52 },
  { 13991, 52, 37, 58, 2, -37 },
  { 14232, 33, 37, 38, 2, -37 },
  { 14385, 31, 38, 38, 4, -37 },
  { 14533, 37, 53, 39, -1, -37 },
  { 14779, 34, 53, 39, 3, -37 },
  { 15005, 26, 37, 26, 2, -37 },
  { 15126, 27, 38, 29, 1, -37 },
  { 15255, 21, 46, 22, 3, -45 },
  { 15376, 32, 37, 38, 4, -36 },
  { 15524, 30, 36, 30, 3, -36 },
  { 15659, 45, 36, 47, 4, -36 },
  { 15862, 35, 36, 32, -2, -36 },
  { 16020, 40, 52, 30, -7, -36 },
  { 16280, 31, 36, 30, -1, -36 },
  { 16420, 26, 60, 23, 1, -49 },
  { 16615, 4, 68, 37, 18, -52 },
  { 16649, 25, 60, 23, -3, -49 },
  { 16837, 32, 8, 39, 5, -28 },
};

const GFXfont NotoSans_LightItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_LIGHTITALIC68PT7B_H_
