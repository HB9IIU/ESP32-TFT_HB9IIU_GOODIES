#ifndef _NOTOSANS_LIGHTITALIC50PT7B_H_
#define _NOTOSANS_LIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x03,
  0xE0, 0x78, 0x02, 0x00, 0x1C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38,
  0x30, 0xC0, 0xC3, 0x07, 0x1C, 0x1C, 0x70, 0x61, 0x81, 0x86, 0x06, 0x18,
  0x18, 0xE0, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x30,
  0x06, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x80, 0x60, 0x07, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0E, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFF, 0x01, 0xE3, 0x0E, 0x03, 0x83, 0x00, 0x07, 0x03, 0x00,
  0x07, 0x07, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x8C, 0x00, 0x03, 0xCC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x19, 0xF0, 0x00, 0x18, 0x70, 0x00, 0x38, 0x38, 0x00, 0x30, 0x38,
  0x00, 0x30, 0x38, 0x00, 0x30, 0x38, 0x00, 0x30, 0x38, 0x00, 0x70, 0x70,
  0x00, 0x60, 0x70, 0x80, 0x61, 0xE0, 0xF0, 0x67, 0xC0, 0xFF, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x0E, 0x03, 0xFE, 0x00, 0x0E, 0x03, 0x87, 0x00, 0x06, 0x03, 0x81, 0xC0,
  0x07, 0x01, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x70, 0x07, 0x00, 0xC0, 0x38,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x30, 0x07,
  0x03, 0x80, 0x18, 0x03, 0x81, 0x80, 0x1C, 0x01, 0x81, 0xC0, 0x0E, 0x00,
  0xC1, 0xC0, 0x07, 0x00, 0xE1, 0xC0, 0x03, 0x80, 0x70, 0xC1, 0xE1, 0xC0,
  0x30, 0xE3, 0xFC, 0xE0, 0x38, 0xE3, 0xDF, 0x70, 0x18, 0x63, 0x83, 0x98,
  0x1C, 0x63, 0x80, 0xCE, 0x3C, 0x71, 0xC0, 0x73, 0xFC, 0x70, 0xC0, 0x38,
  0xFC, 0x30, 0xE0, 0x1C, 0x00, 0x38, 0x60, 0x0E, 0x00, 0x38, 0x30, 0x06,
  0x00, 0x38, 0x38, 0x03, 0x00, 0x18, 0x1C, 0x01, 0x80, 0x1C, 0x0E, 0x01,
  0xC0, 0x1C, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x0E, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0x60, 0x38, 0x0E, 0x00, 0x38,
  0x1C, 0x06, 0x00, 0x1C, 0x1C, 0x07, 0x00, 0x07, 0xFC, 0x07, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x07,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0,
  0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07,
  0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x07, 0x1E, 0x07, 0x80,
  0x1C, 0xF0, 0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x03, 0x9C, 0x00, 0x38, 0x1C,
  0x60, 0x00, 0xE0, 0xE3, 0x80, 0x01, 0xC3, 0x8E, 0x00, 0x03, 0x9C, 0x38,
  0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0xF0, 0x1C, 0x00, 0x1F, 0xE0, 0x78, 0x00, 0xF3, 0x80, 0xF8, 0x1F,
  0x07, 0x01, 0xFF, 0xF8, 0x1E, 0x03, 0xFF, 0x80, 0x3C, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0xE3, 0x8E, 0x38, 0xC3, 0x1C, 0x71, 0x86, 0x18, 0xE0, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x20, 0x1C, 0x03, 0xC0, 0xC0, 0x1F, 0x06, 0x00, 0x3E,
  0x30, 0x00, 0x7D, 0x00, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0x00,
  0x01, 0xD8, 0x00, 0x1C, 0x60, 0x01, 0xC3, 0x00, 0x1C, 0x1C, 0x01, 0xC0,
  0x60, 0x1C, 0x03, 0x80, 0x20, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x0F, 0x0E, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0xF8, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0x1C, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x1E, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0xFB, 0x0F,
  0x39, 0xF1, 0xDE, 0x0E, 0xE0, 0x72, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xF3, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x7C, 0x01, 0xE0,
  0x18, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0xC0, 0x00, 0xF0, 0x7C, 0x03, 0xF0, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x18, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x1C,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x01,
  0xC0, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x02, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0xC0, 0x03, 0xE0, 0x78,
  0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x83, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x3F, 0x80, 0x38, 0xFF, 0xE0,
  0x33, 0xC1, 0xF0, 0x77, 0x00, 0x78, 0x7C, 0x00, 0x38, 0x78, 0x00, 0x38,
  0x78, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38,
  0x60, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x78, 0x00, 0xE0,
  0x38, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x40, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x0F, 0x80, 0x3C, 0x01, 0xE0,
  0x1C, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x00,
  0xE0, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x81, 0xE0, 0x00, 0xF3,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xF8,
  0x3C, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xF8, 0x01, 0xF8, 0x7C, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x0E, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x1F, 0x1E, 0x00,
  0x3E, 0x0E, 0x00, 0x7E, 0x0F, 0x81, 0xEE, 0x07, 0xFF, 0xCE, 0x01, 0xFF,
  0x1C, 0x00, 0x10, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xC0, 0x3E,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x03, 0x83,
  0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0xF8, 0x7C, 0x3C, 0x04, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFF, 0x83, 0xE1, 0xF0, 0xC0,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0xD0, 0x03, 0x87, 0x00, 0x1F, 0xFC,
  0x06, 0x38, 0x01, 0xFF, 0xF0, 0x1C, 0xE0, 0x0E, 0x01, 0xC0, 0x73, 0x00,
  0x70, 0x06, 0x01, 0xDC, 0x03, 0x80, 0x38, 0x07, 0x60, 0x1C, 0x00, 0xE0,
  0x1D, 0x80, 0x60, 0x03, 0x80, 0x7E, 0x03, 0x80, 0x0C, 0x01, 0xF8, 0x0C,
  0x00, 0x70, 0x06, 0xE0, 0x70, 0x01, 0xC0, 0x1B, 0x01, 0xC0, 0x06, 0x00,
  0xEC, 0x07, 0x00, 0x38, 0x03, 0xB0, 0x1C, 0x00, 0xE0, 0x1C, 0xC0, 0x70,
  0x07, 0x80, 0x73, 0x01, 0xC0, 0x1E, 0x03, 0x8C, 0x07, 0x00, 0xD8, 0x1E,
  0x38, 0x0E, 0x06, 0x60, 0xF0, 0xE0, 0x3F, 0xF1, 0xFF, 0x83, 0x80, 0x7F,
  0x83, 0xFC, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00,
  0x0F, 0x80, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x38,
  0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x06, 0x1E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0xE0, 0x03, 0xE0, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00,
  0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x81, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0xF0,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xF0, 0x70, 0x00, 0x7C, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xCF, 0xE0, 0x0F, 0xC0, 0x06, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x08, 0x00, 0xFC,
  0x07, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x70, 0x03, 0xF0, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0x00, 0x07, 0xC0,
  0x18, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0x60,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x3E, 0x07, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x1F,
  0x80, 0x70, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x01, 0xF0, 0x00,
  0x70, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xF9, 0xC0, 0x03, 0xFF, 0xCE, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x1F, 0x00, 0x07, 0x00, 0x7E, 0x03,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03,
  0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x01,
  0xE0, 0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x01, 0x8F, 0x00, 0x00, 0x0E, 0x7C, 0x00, 0x00, 0x3B, 0xF0, 0x00,
  0x00, 0xFC, 0xE0, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1B, 0x80, 0x00, 0x0E, 0xC0, 0x37,
  0x00, 0x00, 0x1F, 0x80, 0xEE, 0x00, 0x00, 0x77, 0x01, 0xDC, 0x00, 0x00,
  0xCE, 0x03, 0x98, 0x00, 0x03, 0x98, 0x07, 0x30, 0x00, 0x0E, 0x70, 0x0C,
  0x60, 0x00, 0x1C, 0xE0, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x71, 0xC0, 0x00,
  0xC3, 0x80, 0xE3, 0x80, 0x03, 0x86, 0x01, 0xC7, 0x00, 0x06, 0x1C, 0x03,
  0x06, 0x00, 0x1C, 0x38, 0x0E, 0x0C, 0x00, 0x70, 0x70, 0x1C, 0x18, 0x00,
  0xE0, 0xE0, 0x38, 0x38, 0x03, 0x83, 0x80, 0x70, 0x70, 0x06, 0x07, 0x00,
  0xC0, 0xE0, 0x1C, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x07, 0x01, 0xC0,
  0x70, 0x0E, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x30, 0x07, 0x01, 0xC0, 0x38,
  0xE0, 0x0C, 0x03, 0x80, 0x33, 0x80, 0x38, 0x06, 0x00, 0x67, 0x00, 0x70,
  0x1C, 0x00, 0xDC, 0x00, 0xE0, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x70, 0x03,
  0xE0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x01, 0x80, 0x0F, 0x00, 0x1C,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x03, 0x80, 0x7C, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x00, 0xE0, 0x1F,
  0x00, 0x00, 0x70, 0x0D, 0xC0, 0x00, 0x30, 0x0E, 0xE0, 0x00, 0x38, 0x07,
  0x38, 0x00, 0x1C, 0x03, 0x9C, 0x00, 0x0E, 0x01, 0xCE, 0x00, 0x07, 0x00,
  0xC3, 0x80, 0x03, 0x00, 0xE1, 0xC0, 0x03, 0x80, 0x70, 0x70, 0x01, 0xC0,
  0x38, 0x38, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0x70, 0x0C, 0x07, 0x00, 0x30,
  0x0E, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x0E, 0x07, 0x00, 0xE0, 0x07, 0x03,
  0x80, 0x70, 0x01, 0xC1, 0xC0, 0x38, 0x00, 0xE0, 0xE0, 0x18, 0x00, 0x70,
  0x60, 0x1C, 0x00, 0x1C, 0x70, 0x0E, 0x00, 0x0E, 0x38, 0x07, 0x00, 0x03,
  0x9C, 0x03, 0x80, 0x01, 0xCE, 0x01, 0x80, 0x00, 0xE6, 0x01, 0xC0, 0x00,
  0x3F, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x07, 0xC0, 0x38, 0x00,
  0x03, 0xE0, 0x18, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0x00, 0x7C, 0x01, 0xC0, 0x07, 0x80, 0x70,
  0x00, 0xF0, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x0E, 0x00,
  0x0F, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x0F, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0x00, 0x3E, 0x01, 0xC0, 0x07, 0x80, 0x70, 0x00, 0xF0,
  0x18, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1F, 0x03,
  0x80, 0x1F, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x07, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x38,
  0x00, 0x70, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x9F, 0xC0, 0x3C,
  0x00, 0x60, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x80, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0xE0, 0x00,
  0x07, 0x18, 0x00, 0x03, 0xC6, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x81, 0xC0, 0x00,
  0x60, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0xE0, 0x00, 0xFC, 0x00, 0x38,
  0xE0, 0x01, 0xDC, 0x00, 0x38, 0xE0, 0x01, 0xDC, 0x00, 0x38, 0xE0, 0x01,
  0x9C, 0x00, 0x70, 0xE0, 0x03, 0x9C, 0x00, 0x70, 0xE0, 0x03, 0x1C, 0x00,
  0xE0, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0xE0, 0x06, 0x1C, 0x01, 0xC0, 0xE0,
  0x0E, 0x1C, 0x01, 0xC0, 0xE0, 0x0C, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x0C,
  0x03, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x60, 0x38, 0x0C, 0x07, 0x00,
  0x60, 0x38, 0x0C, 0x07, 0x00, 0x60, 0x70, 0x0C, 0x0E, 0x00, 0x60, 0x70,
  0x0C, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x0E, 0x1C,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x00, 0x73,
  0x80, 0x0E, 0x30, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x00, 0x73, 0x00, 0x0E,
  0x60, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x00, 0x76, 0x00, 0x0E, 0xE0, 0x00,
  0x7E, 0x00, 0x0E, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xB8, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01,
  0xC1, 0xC0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xE0, 0x70, 0x18, 0x0C, 0x06,
  0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0x60,
  0x30, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x70,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x19, 0x80,
  0x00, 0x39, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x01, 0x80, 0x70, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x30, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x0C, 0x00, 0x1C,
  0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x06,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xE0, 0xE1, 0xC1,
  0xC1, 0x83, 0x83, 0x00, 0x3F, 0x83, 0x80, 0x7F, 0xE1, 0x80, 0x7E, 0x78,
  0xC0, 0x78, 0x0E, 0xE0, 0x78, 0x03, 0x70, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x1E, 0x0C, 0x00, 0x1F, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x0F, 0x81,
  0xC0, 0x0D, 0xC0, 0xF0, 0x0C, 0xE0, 0x3C, 0x1E, 0x60, 0x0F, 0xFC, 0x30,
  0x03, 0xFC, 0x18, 0x00, 0x20, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x7F, 0x00, 0x38, 0xFF, 0xC0,
  0x18, 0xF1, 0xF0, 0x1C, 0xE0, 0x3C, 0x0E, 0xC0, 0x0E, 0x07, 0xC0, 0x03,
  0x83, 0xE0, 0x01, 0xC1, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xF0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0xC0,
  0x00, 0x71, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x38, 0x3C,
  0x00, 0x3C, 0x3B, 0x00, 0x3C, 0x1D, 0x80, 0x3C, 0x0C, 0x70, 0x3C, 0x06,
  0x3F, 0xFC, 0x03, 0x07, 0xF8, 0x02, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0,
  0x1F, 0xFF, 0x03, 0xF1, 0xF0, 0x78, 0x01, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x10, 0x3E, 0x07, 0x01,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xC1, 0xC0,
  0x0F, 0xFE, 0x38, 0x03, 0xF3, 0xE7, 0x00, 0xF0, 0x0C, 0xC0, 0x3C, 0x00,
  0xF8, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x70, 0x30, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0,
  0x18, 0x00, 0x1E, 0x03, 0x80, 0x07, 0xC0, 0x70, 0x01, 0xF8, 0x0E, 0x00,
  0x76, 0x01, 0xE0, 0x1C, 0xC0, 0x1E, 0x0F, 0x38, 0x01, 0xFF, 0xC7, 0x00,
  0x1F, 0xE0, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFC,
  0x03, 0xF3, 0xE0, 0x78, 0x0F, 0x0F, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00,
  0x73, 0x80, 0x07, 0x38, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x03, 0xE6, 0x00,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x08, 0x3E, 0x07, 0x81, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xE0, 0x80, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x06, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xC0, 0x1F, 0xFC,
  0x30, 0x0F, 0xCF, 0x9C, 0x07, 0x80, 0x66, 0x03, 0xC0, 0x0D, 0x81, 0xE0,
  0x03, 0xE0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x06,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x30, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0xF0, 0x38,
  0x00, 0x7C, 0x0E, 0x00, 0x37, 0x03, 0x80, 0x1D, 0x80, 0xF0, 0x0E, 0xE0,
  0x1E, 0x0F, 0x38, 0x03, 0xFF, 0x8E, 0x00, 0x7F, 0x83, 0x00, 0x02, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x03,
  0x00, 0x1E, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x83,
  0xF8, 0x03, 0x8F, 0xFC, 0x03, 0x1F, 0x3E, 0x07, 0x38, 0x0F, 0x07, 0x70,
  0x07, 0x07, 0xC0, 0x07, 0x07, 0xC0, 0x03, 0x07, 0x80, 0x03, 0x0F, 0x00,
  0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xDF, 0x00, 0x3F, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x78,
  0x07, 0x00, 0xF0, 0x07, 0x01, 0xE0, 0x07, 0x03, 0xC0, 0x06, 0x07, 0x80,
  0x0E, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x78, 0x00,
  0x0C, 0xF0, 0x00, 0x1D, 0xF8, 0x00, 0x1F, 0xB8, 0x00, 0x1F, 0x1C, 0x00,
  0x1E, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x07, 0x00,
  0x38, 0x07, 0x00, 0x38, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x01, 0xC0,
  0x70, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x00, 0x03, 0x83, 0xF0, 0x03, 0xF0, 0x06, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0C, 0x79, 0xF0, 0xF9, 0xF0, 0x39, 0xC0, 0xE3, 0x80, 0xF0, 0x76, 0x00,
  0xEE, 0x00, 0xE0, 0xF8, 0x01, 0xD8, 0x01, 0xC1, 0xE0, 0x03, 0xE0, 0x03,
  0x83, 0xC0, 0x07, 0x80, 0x07, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0xC0, 0x01, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x30, 0x00, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xC0,
  0x01, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x00, 0x38, 0x70,
  0x00, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x83, 0xF8, 0x01, 0x87, 0xFF, 0x00, 0xC7, 0xFF, 0xC0,
  0xE7, 0x01, 0xE0, 0x77, 0x00, 0x70, 0x3F, 0x00, 0x38, 0x1F, 0x00, 0x1E,
  0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x3C,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xCF, 0xC0,
  0x3C, 0x03, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x8F, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01,
  0xCE, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0x3C, 0x0F, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xE0, 0xFE,
  0x00, 0x18, 0x7F, 0xE0, 0x03, 0x1E, 0x3E, 0x00, 0xE7, 0x01, 0xE0, 0x1D,
  0xC0, 0x1C, 0x03, 0xE0, 0x01, 0xC0, 0x7C, 0x00, 0x38, 0x0F, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x70, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00,
  0x0E, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x1E, 0x07,
  0x60, 0x07, 0x80, 0xEC, 0x01, 0xE0, 0x1C, 0xE0, 0x78, 0x03, 0x9F, 0xFE,
  0x00, 0x60, 0xFF, 0x00, 0x1C, 0x02, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x81,
  0x80, 0x7F, 0xF0, 0xC0, 0x7E, 0x7C, 0xE0, 0x78, 0x06, 0x60, 0x78, 0x01,
  0xB0, 0x78, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x3C, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x60,
  0x00, 0x3C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x0C, 0x00, 0x0F, 0x07,
  0x00, 0x0F, 0x83, 0x80, 0x0F, 0xC1, 0xC0, 0x0E, 0xC0, 0xF0, 0x0E, 0xE0,
  0x3C, 0x1E, 0x70, 0x0F, 0xFE, 0x38, 0x03, 0xFC, 0x1C, 0x00, 0x20, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0x83, 0xF0, 0x30, 0xFE, 0x03, 0x1F, 0xE0, 0x73, 0x80, 0x07, 0x70, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF,
  0x07, 0xE3, 0xF0, 0x70, 0x03, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x8C, 0x00, 0x78, 0xF0, 0x1F, 0x0F, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x04, 0x1F,
  0xE0, 0x3F, 0x80, 0x10, 0x00, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0x60, 0xE0,
  0x06, 0xE0, 0xE0, 0x0E, 0xE0, 0x78, 0x3C, 0xE0, 0x7F, 0xF0, 0xC0, 0x3F,
  0xE0, 0xC0, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x77, 0x00,
  0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x71, 0xC0, 0x03, 0xC7, 0x00, 0x0E,
  0x1C, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x0E, 0x07,
  0x00, 0x18, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x03, 0x60, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xF0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xF0, 0x01, 0xDC, 0x00, 0xF8, 0x00,
  0xEE, 0x00, 0x6C, 0x00, 0xE7, 0x00, 0x76, 0x00, 0x73, 0x80, 0x33, 0x00,
  0x71, 0xC0, 0x39, 0x80, 0x38, 0xE0, 0x1C, 0xC0, 0x38, 0x70, 0x1C, 0x70,
  0x1C, 0x38, 0x0E, 0x38, 0x1C, 0x1C, 0x0E, 0x1C, 0x0E, 0x0E, 0x07, 0x0E,
  0x0E, 0x07, 0x07, 0x07, 0x07, 0x01, 0x83, 0x83, 0x87, 0x00, 0xC3, 0x81,
  0xC3, 0x80, 0x61, 0xC0, 0x61, 0xC0, 0x31, 0xC0, 0x31, 0xC0, 0x18, 0xE0,
  0x18, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x06, 0x70, 0x06, 0x70, 0x03, 0x30,
  0x03, 0x70, 0x01, 0xB8, 0x01, 0xB8, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1E, 0x70,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x0E,
  0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x00, 0x70,
  0x07, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0E,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x08, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xC0,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0x83, 0xFC, 0x7C, 0x00, 0xFF,
  0xE8, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_LightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 37, 12, 1, -36 },
  { 52, 14, 13, 18, 5, -36 },
  { 75, 30, 36, 32, 2, -36 },
  { 210, 24, 41, 28, 2, -38 },
  { 333, 33, 37, 39, 4, -36 },
  { 486, 30, 37, 34, 2, -36 },
  { 625, 6, 13, 10, 5, -36 },
  { 635, 15, 44, 13, 2, -36 },
  { 718, 16, 44, 13, -4, -36 },
  { 806, 21, 22, 27, 6, -38 },
  { 864, 23, 23, 29, 4, -29 },
  { 931, 8, 12, 11, -2, -6 },
  { 943, 12, 3, 16, 2, -15 },
  { 948, 5, 5, 12, 1, -4 },
  { 952, 23, 36, 17, -2, -36 },
  { 1056, 24, 37, 28, 3, -36 },
  { 1167, 13, 36, 28, 8, -36 },
  { 1226, 26, 36, 28, 0, -36 },
  { 1343, 25, 37, 28, 1, -36 },
  { 1459, 26, 36, 28, 1, -36 },
  { 1576, 25, 37, 28, 2, -36 },
  { 1692, 24, 37, 28, 3, -36 },
  { 1803, 23, 36, 28, 5, -36 },
  { 1907, 25, 37, 28, 2, -36 },
  { 2023, 24, 37, 28, 2, -36 },
  { 2134, 9, 28, 12, 1, -27 },
  { 2166, 12, 33, 12, -2, -27 },
  { 2216, 23, 24, 29, 4, -30 },
  { 2285, 23, 13, 29, 4, -24 },
  { 2323, 23, 24, 29, 4, -30 },
  { 2392, 18, 37, 21, 4, -36 },
  { 2476, 38, 41, 42, 3, -36 },
  { 2671, 28, 36, 28, -3, -36 },
  { 2797, 27, 36, 30, 2, -36 },
  { 2919, 28, 37, 30, 4, -36 },
  { 3049, 30, 36, 34, 2, -36 },
  { 3184, 26, 36, 26, 2, -36 },
  { 3301, 26, 36, 24, 2, -36 },
  { 3418, 29, 37, 34, 4, -36 },
  { 3553, 32, 36, 34, 2, -36 },
  { 3697, 17, 36, 15, 0, -36 },
  { 3774, 21, 45, 13, -8, -36 },
  { 3893, 30, 36, 28, 2, -36 },
  { 4028, 19, 36, 24, 2, -36 },
  { 4114, 39, 36, 41, 2, -36 },
  { 4290, 33, 36, 35, 2, -36 },
  { 4439, 30, 37, 36, 4, -36 },
  { 4578, 26, 36, 28, 2, -36 },
  { 4695, 30, 45, 36, 4, -36 },
  { 4864, 26, 36, 28, 2, -36 },
  { 4981, 25, 37, 25, 1, -36 },
  { 5097, 24, 36, 25, 5, -36 },
  { 5205, 31, 37, 34, 4, -36 },
  { 5349, 26, 36, 27, 5, -36 },
  { 5466, 40, 36, 42, 6, -36 },
  { 5646, 32, 36, 25, -3, -36 },
  { 5790, 25, 36, 25, 5, -36 },
  { 5903, 29, 36, 27, 0, -36 },
  { 6034, 19, 44, 15, 0, -36 },
  { 6139, 9, 36, 17, 5, -36 },
  { 6180, 19, 44, 15, -4, -36 },
  { 6285, 24, 22, 28, 2, -36 },
  { 6351, 19, 2, 19, -4, 5 },
  { 6356, 7, 8, 13, 7, -38 },
  { 6363, 25, 28, 28, 2, -27 },
  { 6451, 25, 39, 29, 1, -38 },
  { 6573, 20, 28, 23, 3, -27 },
  { 6643, 27, 39, 29, 2, -38 },
  { 6775, 20, 28, 25, 3, -27 },
  { 6845, 27, 50, 15, -6, -38 },
  { 7014, 26, 39, 29, 1, -27 },
  { 7141, 24, 38, 28, 1, -38 },
  { 7255, 11, 36, 12, 1, -36 },
  { 7305, 19, 48, 12, -7, -36 },
  { 7419, 24, 38, 23, 1, -38 },
  { 7533, 11, 38, 12, 1, -38 },
  { 7586, 39, 27, 43, 1, -27 },
  { 7718, 25, 27, 28, 1, -27 },
  { 7803, 23, 27, 28, 3, -27 },
  { 7881, 27, 39, 29, -1, -27 },
  { 8013, 25, 39, 29, 2, -27 },
  { 8135, 20, 27, 19, 1, -27 },
  { 8203, 20, 28, 21, 0, -27 },
  { 8273, 14, 34, 16, 3, -33 },
  { 8333, 24, 28, 28, 3, -27 },
  { 8417, 22, 27, 22, 2, -27 },
  { 8492, 33, 27, 34, 3, -27 },
  { 8604, 27, 27, 23, -2, -27 },
  { 8696, 29, 39, 22, -5, -27 },
  { 8838, 23, 27, 22, -1, -27 },
  { 8916, 19, 44, 17, 1, -36 },
  { 9021, 2, 50, 27, 14, -38 },
  { 9034, 18, 44, 17, -2, -36 },
  { 9133, 23, 5, 29, 4, -20 },
};

const GFXfont NotoSans_LightItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_LIGHTITALIC50PT7B_H_
