#ifndef _NOTOSANS_LIGHTITALIC51PT7B_H_
#define _NOTOSANS_LIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x20, 0x00, 0x38, 0x3B, 0x83,
  0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x30, 0x31, 0x81, 0x9C, 0x1C, 0xE0, 0xE6,
  0x06, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0xE0, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF,
  0x01, 0xF3, 0x9F, 0x03, 0xC3, 0x81, 0x07, 0x83, 0x00, 0x07, 0x03, 0x00,
  0x07, 0x03, 0x00, 0x06, 0x07, 0x00, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00,
  0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xEC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x18, 0xF0, 0x00, 0x18, 0x78, 0x00, 0x18, 0x38, 0x00, 0x38, 0x18,
  0x00, 0x38, 0x18, 0x00, 0x30, 0x38, 0x00, 0x30, 0x38, 0x00, 0x30, 0x38,
  0x00, 0x70, 0x70, 0x80, 0x60, 0xF0, 0xF8, 0x67, 0xC0, 0xFF, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0x03, 0xFE, 0x00, 0x07, 0x03, 0xEF, 0x00, 0x07, 0x01, 0xC1, 0xC0,
  0x03, 0x81, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x30, 0x03, 0x80, 0xE0, 0x18,
  0x01, 0x80, 0x60, 0x0C, 0x01, 0xC0, 0x70, 0x06, 0x01, 0xC0, 0x38, 0x03,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0xC0, 0x0C, 0x01, 0xC0, 0xE0, 0x0E, 0x00,
  0xE0, 0xE0, 0x07, 0x00, 0x60, 0xE0, 0x03, 0x80, 0x30, 0x60, 0x01, 0xC0,
  0x38, 0x71, 0xFC, 0xE0, 0x18, 0x71, 0xFF, 0x70, 0x1C, 0x71, 0xE3, 0xF8,
  0x0C, 0x31, 0xC0, 0xEE, 0x0E, 0x38, 0xE0, 0x37, 0xFE, 0x38, 0xE0, 0x19,
  0xFE, 0x38, 0x70, 0x0C, 0x3C, 0x18, 0x30, 0x06, 0x00, 0x1C, 0x38, 0x03,
  0x00, 0x1C, 0x1C, 0x01, 0x80, 0x1C, 0x0C, 0x01, 0xC0, 0x0C, 0x06, 0x00,
  0xE0, 0x0E, 0x07, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x0C, 0x07, 0x00, 0x38,
  0x0E, 0x03, 0x00, 0x0C, 0x0E, 0x03, 0x80, 0x07, 0x0F, 0x03, 0x80, 0x03,
  0xFF, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x0E,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x7C, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0xF0, 0x70, 0x00, 0xE3, 0xC0, 0x70, 0x03, 0x8F,
  0x00, 0x70, 0x07, 0x3C, 0x00, 0xF0, 0x1C, 0x70, 0x00, 0xE0, 0x70, 0xE0,
  0x00, 0xE0, 0xE3, 0x80, 0x01, 0xE3, 0x87, 0x00, 0x01, 0xCE, 0x0E, 0x00,
  0x01, 0xFC, 0x1C, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x0F, 0x80, 0x70, 0x00, 0x3B, 0x80, 0xF0, 0x01, 0xE7, 0x80, 0xF8, 0x1F,
  0x87, 0x80, 0xFF, 0xFC, 0x07, 0x00, 0xFF, 0xE0, 0x07, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x3B, 0x9C, 0xE7, 0x31, 0x9C, 0xE6, 0x31, 0x8C, 0x00, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x01, 0x00, 0x60, 0x0E, 0x01, 0x80, 0x3E, 0x0C, 0x00,
  0x7E, 0x30, 0x00, 0x3C, 0xC0, 0x00, 0x3F, 0x3F, 0xC0, 0x3F, 0xFF, 0x00,
  0xF0, 0x0C, 0x07, 0xE0, 0x00, 0x39, 0x80, 0x01, 0xC6, 0x00, 0x0E, 0x1C,
  0x00, 0x70, 0x30, 0x07, 0x80, 0xE0, 0x0C, 0x03, 0x80, 0x10, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x30,
  0x70, 0x60, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE2,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x1E,
  0x03, 0x80, 0x0E, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x78, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x3E, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x81, 0xFE, 0x1F, 0x38,
  0xF8, 0xCF, 0x87, 0x3C, 0x1C, 0x40, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x10,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xC0, 0x3E, 0x03, 0xC0, 0x03, 0x80,
  0x40, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x30, 0x00, 0x3C, 0x0F, 0xC0, 0x7E,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x0E, 0x01, 0xC0,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3B, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0xC0, 0x01, 0xE0, 0x7C, 0x07, 0xE0, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x3C, 0x00, 0x70, 0xFF, 0x80, 0x39, 0xFF,
  0xF0, 0x19, 0xC0, 0x7C, 0x1D, 0xC0, 0x0E, 0x0F, 0x80, 0x07, 0x87, 0x80,
  0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x81, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0E,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0xF0, 0x01, 0xE1, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x78, 0x00, 0x7C, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xCE, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x3C, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x0E, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x3C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x83, 0x80, 0x0F, 0xC1, 0xE0, 0x0E, 0xE0, 0x7C, 0x3E, 0xE0,
  0x1F, 0xFE, 0x70, 0x03, 0xFC, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x38, 0x0F, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0xE0, 0x7C, 0x1E, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x3E, 0x0F, 0x83, 0xC0, 0x20, 0x00, 0x00, 0x20, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xE0,
  0x1E, 0x20, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0xFF, 0x80, 0x70,
  0xE0, 0x07, 0xFF, 0xC0, 0x63, 0x80, 0x1E, 0x07, 0x00, 0xC7, 0x00, 0xF0,
  0x0E, 0x01, 0x9C, 0x03, 0xC0, 0x1C, 0x03, 0xB8, 0x07, 0x00, 0x38, 0x07,
  0x60, 0x1C, 0x00, 0x60, 0x0D, 0xC0, 0x30, 0x01, 0xC0, 0x1B, 0x80, 0xE0,
  0x03, 0x80, 0x37, 0x01, 0xC0, 0x06, 0x00, 0xEE, 0x03, 0x00, 0x0C, 0x01,
  0xD8, 0x0E, 0x00, 0x38, 0x03, 0xB0, 0x1C, 0x00, 0x70, 0x06, 0x60, 0x38,
  0x01, 0xC0, 0x1C, 0xC0, 0x70, 0x03, 0x80, 0x31, 0x80, 0xE0, 0x0F, 0x00,
  0xE3, 0x80, 0xE0, 0x3F, 0x03, 0x87, 0x01, 0xC0, 0xEE, 0x0E, 0x0E, 0x01,
  0xFF, 0x8F, 0xF8, 0x0C, 0x01, 0xFC, 0x0F, 0xE0, 0x1C, 0x00, 0x40, 0x02,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x02, 0x00, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xC0, 0x0F, 0xC0,
  0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0x70, 0x07, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0xF0, 0x0E,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x38, 0x38, 0x00, 0x07, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x0F, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0x00, 0xF8, 0x00,
  0x10, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x40, 0x0F, 0xC0, 0x7C, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1C, 0x01, 0xFC, 0x00, 0x70, 0x00, 0xF8, 0x01,
  0xC0, 0x01, 0xF0, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E,
  0x07, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x0F, 0x80, 0x70, 0x01, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0x08,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x0F, 0xFF, 0x38, 0x00, 0x3F, 0xFC, 0xE0, 0x00, 0xFF, 0xE3,
  0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0x03, 0x80, 0x7C, 0x00, 0x1E,
  0x00, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xC0,
  0x3F, 0xE0, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3B, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x01, 0xC0, 0x00,
  0xF0, 0x07, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x1E, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x18, 0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x0E, 0x7C, 0x00, 0x00, 0x1D,
  0xDC, 0x00, 0x00, 0x3F, 0x38, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x30, 0x03, 0xC0, 0x00, 0xE0, 0x03,
  0x80, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x00, 0x6E, 0x01, 0xB8, 0x00, 0x00, 0xEE, 0x01, 0x98, 0x00,
  0x01, 0xCE, 0x03, 0x98, 0x00, 0x01, 0xDC, 0x03, 0x9C, 0x00, 0x03, 0x9C,
  0x03, 0x9C, 0x00, 0x03, 0x9C, 0x03, 0x9C, 0x00, 0x07, 0x1C, 0x07, 0x1C,
  0x00, 0x06, 0x18, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x07, 0x0C, 0x00, 0x1C,
  0x38, 0x07, 0x0C, 0x00, 0x1C, 0x38, 0x06, 0x0E, 0x00, 0x38, 0x38, 0x0E,
  0x0E, 0x00, 0x38, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x0E, 0x00,
  0x60, 0x70, 0x0E, 0x06, 0x00, 0xE0, 0x70, 0x0C, 0x06, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0xC0, 0xE0, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x03, 0x80, 0xE0, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x06, 0x00,
  0xE0, 0x38, 0x03, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x9C, 0x01, 0xC0, 0x38, 0x03, 0xB8, 0x01, 0xC0, 0x70, 0x03, 0xB8,
  0x01, 0xC0, 0x70, 0x03, 0xF0, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xC0,
  0x7C, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0x00, 0x60, 0x1F, 0x80, 0x00, 0x70,
  0x0D, 0xC0, 0x00, 0x38, 0x06, 0x70, 0x00, 0x1C, 0x07, 0x38, 0x00, 0x0E,
  0x03, 0x8C, 0x00, 0x0E, 0x01, 0xC7, 0x00, 0x07, 0x00, 0xC3, 0x80, 0x03,
  0x80, 0xE0, 0xE0, 0x01, 0xC0, 0x70, 0x70, 0x00, 0xE0, 0x38, 0x18, 0x00,
  0xE0, 0x1C, 0x0E, 0x00, 0x70, 0x0C, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xC0,
  0x1C, 0x07, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xC0, 0x1C,
  0x07, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x70, 0x01,
  0xC0, 0xC0, 0x38, 0x00, 0x70, 0xE0, 0x1C, 0x00, 0x38, 0x70, 0x0C, 0x00,
  0x1C, 0x38, 0x0E, 0x00, 0x07, 0x1C, 0x07, 0x00, 0x03, 0x8C, 0x03, 0x80,
  0x00, 0xEE, 0x01, 0xC0, 0x00, 0x77, 0x01, 0xC0, 0x00, 0x3B, 0x80, 0xE0,
  0x00, 0x0F, 0xC0, 0x70, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x18,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0x00, 0xFE, 0x00, 0xE0,
  0x03, 0xC0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x78,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x81, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x07,
  0xC0, 0x38, 0x1F, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0x00, 0xFE, 0x00,
  0xE0, 0x03, 0xE0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00,
  0x78, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x1F, 0x01, 0xC0,
  0x1F, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03,
  0x80, 0x07, 0x00, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x3E, 0x00, 0xF0, 0x3E, 0x00, 0x10, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x60, 0x00,
  0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x03,
  0x00, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1C,
  0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xB8, 0x00, 0x1F, 0x00, 0x03,
  0x9C, 0x00, 0x0F, 0x80, 0x01, 0xCE, 0x00, 0x06, 0xC0, 0x01, 0xE7, 0x00,
  0x07, 0x60, 0x00, 0xE3, 0x80, 0x03, 0x30, 0x00, 0x71, 0xC0, 0x03, 0x98,
  0x00, 0x70, 0xE0, 0x01, 0x8C, 0x00, 0x38, 0x70, 0x01, 0xC6, 0x00, 0x38,
  0x38, 0x00, 0xE3, 0x00, 0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x06, 0x00,
  0x70, 0xE0, 0x0E, 0x03, 0x00, 0x70, 0x70, 0x0E, 0x01, 0x80, 0x38, 0x38,
  0x07, 0x00, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0x38, 0x1C, 0x07, 0x01, 0xC0, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x0E, 0x0E,
  0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x30,
  0x70, 0x01, 0xC3, 0x80, 0x18, 0x70, 0x00, 0xE1, 0x80, 0x0C, 0x38, 0x00,
  0x71, 0xC0, 0x06, 0x18, 0x00, 0x38, 0xC0, 0x03, 0x1C, 0x00, 0x1C, 0xE0,
  0x01, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x67,
  0x00, 0x03, 0xB8, 0x00, 0x33, 0x00, 0x01, 0xF8, 0x00, 0x1B, 0x80, 0x00,
  0xFC, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x1E, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0x9C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC3, 0x80,
  0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x38, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x30, 0x18, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0,
  0x60, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0E,
  0x03, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0xE0,
  0x70, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x1D, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0x70,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0x30, 0x03, 0x80, 0x38, 0x07, 0x00, 0x18,
  0x06, 0x00, 0x18, 0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x06, 0x38, 0x00, 0x06, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x0C, 0x0E,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x83, 0x01, 0xFF, 0xC7, 0x07, 0xC0,
  0xE7, 0x0F, 0x80, 0x66, 0x0E, 0x00, 0x3E, 0x1C, 0x00, 0x3E, 0x3C, 0x00,
  0x1E, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xF0, 0xE0, 0x03, 0x60, 0xE0, 0x07,
  0x60, 0x70, 0x0E, 0x60, 0x78, 0x3C, 0xE0, 0x3F, 0xF8, 0xE0, 0x1F, 0xE0,
  0xC0, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x70, 0xFF, 0x80, 0x38, 0xFF, 0xE0,
  0x1C, 0xE0, 0x78, 0x1C, 0xC0, 0x1E, 0x0E, 0xC0, 0x07, 0x07, 0xC0, 0x03,
  0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xF0, 0x00,
  0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x71, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x3C,
  0x00, 0x1C, 0x3B, 0x00, 0x1C, 0x1D, 0xC0, 0x1E, 0x0E, 0x70, 0x3E, 0x06,
  0x1F, 0xFC, 0x03, 0x07, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7E, 0x03, 0x0F, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x83,
  0xE0, 0x70, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0x01, 0xC0, 0x0F, 0xF8, 0x30, 0x03, 0xFF, 0xCE, 0x01, 0xF0, 0x39,
  0xC0, 0x78, 0x01, 0xB8, 0x0E, 0x00, 0x37, 0x03, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C,
  0x1C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x01,
  0xF0, 0x1C, 0x00, 0x3E, 0x03, 0x80, 0x0D, 0xC0, 0x38, 0x07, 0x38, 0x07,
  0x83, 0xC6, 0x00, 0x7F, 0xF0, 0xC0, 0x07, 0xF8, 0x38, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0x81, 0xE0,
  0x78, 0x07, 0x07, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x38, 0x00,
  0x71, 0xC0, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x07, 0xCF, 0x01, 0xFC, 0x7F,
  0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x81, 0xF0, 0x1C, 0x07, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7E, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x8F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFC, 0x1C,
  0x01, 0xFF, 0xE3, 0x00, 0xF8, 0x1C, 0x60, 0x3E, 0x00, 0xDC, 0x07, 0x00,
  0x1B, 0x81, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0F,
  0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0xF8, 0x0E, 0x00, 0x3F, 0x01, 0xC0,
  0x0E, 0xE0, 0x1C, 0x03, 0x9C, 0x03, 0xC1, 0xE7, 0x00, 0x3F, 0xF8, 0xE0,
  0x03, 0xFC, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x78, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x07, 0x0F, 0xF8, 0x07,
  0x1F, 0xFC, 0x07, 0x38, 0x1E, 0x0E, 0x70, 0x0F, 0x0E, 0xC0, 0x07, 0x0F,
  0x80, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1E,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x70, 0x3C, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x23, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x01, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x78, 0x0E, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x0E, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x0E, 0x0F,
  0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0xF0,
  0x00, 0x19, 0xF0, 0x00, 0x3B, 0xF0, 0x00, 0x3F, 0x38, 0x00, 0x3E, 0x38,
  0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x1F, 0xE0,
  0x1F, 0xE0, 0x18, 0x7F, 0xE0, 0x7F, 0xF0, 0x33, 0xC1, 0xE3, 0xC1, 0xE0,
  0x66, 0x01, 0xCE, 0x01, 0xE1, 0xD8, 0x03, 0x98, 0x01, 0xC3, 0xE0, 0x03,
  0x60, 0x03, 0x87, 0x80, 0x07, 0x80, 0x07, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x78, 0x00, 0x30, 0xE0, 0x00,
  0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x80, 0x03,
  0x8E, 0x00, 0x06, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0x00,
  0xE3, 0x80, 0x03, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0xE0, 0x00, 0x71, 0xC0, 0x01, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x80, 0x03, 0x87, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0xC3, 0xFF, 0x00, 0xE3, 0xFF, 0xC0, 0x63, 0xC1, 0xE0, 0x73, 0x80,
  0x78, 0x3B, 0x00, 0x1C, 0x1F, 0x00, 0x0E, 0x0F, 0x80, 0x07, 0x07, 0x80,
  0x03, 0x87, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x1C,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x07,
  0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3E, 0x07,
  0xC0, 0xF0, 0x03, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x01, 0xEE, 0x00,
  0x03, 0x9C, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x78, 0x03,
  0xC0, 0x7C, 0x1F, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x0E, 0x1F, 0xF0, 0x00, 0xC3, 0xFF, 0x80, 0x0C, 0x70, 0x3C,
  0x00, 0xCE, 0x01, 0xE0, 0x1D, 0x80, 0x0E, 0x01, 0xF0, 0x00, 0xE0, 0x1F,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x1C, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x00, 0xD8, 0x00, 0xE0, 0x1D, 0xC0,
  0x1E, 0x01, 0xCE, 0x07, 0xC0, 0x1C, 0x7F, 0xF0, 0x01, 0xC3, 0xFE, 0x00,
  0x38, 0x06, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xC1,
  0xC0, 0x7F, 0xF8, 0xC0, 0xF8, 0x1C, 0x60, 0xF8, 0x03, 0x70, 0x70, 0x01,
  0xB8, 0x70, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x3C, 0x00,
  0x0F, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x07,
  0x00, 0x0F, 0x83, 0x80, 0x07, 0xC1, 0xC0, 0x0E, 0xE0, 0x70, 0x0E, 0x70,
  0x3C, 0x1E, 0x70, 0x0F, 0xFE, 0x38, 0x03, 0xFC, 0x1C, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0xE1, 0xFC, 0x18, 0x7F, 0x83, 0x1C, 0x00, 0x67, 0x00, 0x1D,
  0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xFE, 0x0F, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0xC0, 0x07, 0x87,
  0xC0, 0x78, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x20, 0x7F,
  0xC0, 0x7F, 0x80, 0x10, 0x00, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xF0, 0xE0, 0x03, 0x70, 0xE0,
  0x07, 0x60, 0xF0, 0x0E, 0x60, 0x78, 0x3C, 0xE0, 0x7F, 0xF8, 0xE0, 0x1F,
  0xE0, 0xE0, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x38, 0x18, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x01, 0xC0, 0x0E, 0x07, 0x80,
  0x0C, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x00,
  0xE3, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x70, 0x00, 0x06,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0xEE, 0x00, 0x3C, 0x00, 0x7B,
  0x80, 0x1F, 0x00, 0x1C, 0xE0, 0x06, 0xE0, 0x07, 0x38, 0x03, 0xB8, 0x03,
  0x8E, 0x00, 0xEE, 0x00, 0xE3, 0x80, 0x73, 0x80, 0x70, 0xE0, 0x1C, 0xE0,
  0x1C, 0x38, 0x0E, 0x38, 0x0E, 0x0E, 0x03, 0x8E, 0x03, 0x83, 0x81, 0xC1,
  0x81, 0xC0, 0xE0, 0x70, 0x60, 0x70, 0x18, 0x38, 0x18, 0x38, 0x06, 0x0E,
  0x06, 0x0E, 0x01, 0x87, 0x01, 0x87, 0x00, 0x61, 0xC0, 0x71, 0xC0, 0x1C,
  0xE0, 0x1C, 0x70, 0x07, 0x38, 0x07, 0x38, 0x01, 0xCC, 0x01, 0xCE, 0x00,
  0x77, 0x00, 0x77, 0x00, 0x1D, 0x80, 0x1D, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00,
  0x78, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x1E, 0x30, 0x00, 0x07, 0x87, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80,
  0x01, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x87, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x0F, 0xE0,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xF2, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x02, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x1E, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xD0, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_LightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 12, 37, 12, 1, -36 },
  { 57, 13, 13, 18, 6, -36 },
  { 79, 31, 36, 32, 2, -36 },
  { 219, 24, 42, 28, 2, -39 },
  { 345, 33, 38, 40, 4, -37 },
  { 502, 31, 38, 35, 2, -37 },
  { 650, 5, 13, 10, 6, -36 },
  { 659, 15, 44, 14, 2, -36 },
  { 742, 16, 44, 14, -4, -36 },
  { 830, 22, 23, 28, 6, -39 },
  { 894, 23, 24, 29, 4, -30 },
  { 963, 8, 13, 11, -2, -6 },
  { 976, 12, 3, 16, 2, -15 },
  { 981, 5, 5, 12, 1, -4 },
  { 985, 23, 36, 17, -2, -36 },
  { 1089, 24, 38, 28, 3, -37 },
  { 1203, 14, 36, 28, 8, -36 },
  { 1266, 26, 37, 28, 0, -37 },
  { 1387, 26, 38, 28, 1, -37 },
  { 1511, 26, 37, 28, 1, -37 },
  { 1632, 25, 37, 28, 2, -36 },
  { 1748, 25, 38, 28, 3, -37 },
  { 1867, 24, 36, 28, 5, -36 },
  { 1975, 25, 38, 28, 2, -37 },
  { 2094, 25, 38, 28, 2, -37 },
  { 2213, 10, 29, 12, 1, -28 },
  { 2250, 12, 35, 12, -2, -28 },
  { 2303, 23, 24, 29, 4, -30 },
  { 2372, 23, 12, 29, 4, -24 },
  { 2407, 23, 24, 29, 4, -30 },
  { 2476, 18, 38, 21, 4, -37 },
  { 2562, 39, 41, 43, 3, -36 },
  { 2762, 29, 36, 28, -3, -36 },
  { 2893, 28, 36, 31, 2, -36 },
  { 3019, 28, 38, 30, 4, -37 },
  { 3152, 30, 36, 34, 2, -36 },
  { 3287, 26, 36, 27, 2, -36 },
  { 3404, 26, 36, 25, 2, -36 },
  { 3521, 30, 38, 35, 4, -37 },
  { 3664, 33, 36, 35, 2, -36 },
  { 3813, 18, 36, 15, 0, -36 },
  { 3894, 21, 45, 13, -8, -36 },
  { 4013, 31, 36, 28, 2, -36 },
  { 4153, 19, 36, 25, 2, -36 },
  { 4239, 40, 36, 42, 2, -36 },
  { 4419, 33, 36, 35, 2, -36 },
  { 4568, 31, 38, 37, 4, -37 },
  { 4716, 27, 36, 29, 2, -36 },
  { 4838, 31, 46, 37, 4, -37 },
  { 5017, 27, 36, 29, 2, -36 },
  { 5139, 25, 38, 26, 1, -37 },
  { 5258, 25, 36, 25, 5, -36 },
  { 5371, 31, 37, 35, 4, -36 },
  { 5515, 27, 36, 28, 5, -36 },
  { 5637, 41, 36, 43, 6, -36 },
  { 5822, 33, 36, 26, -3, -36 },
  { 5971, 25, 36, 25, 5, -36 },
  { 6084, 29, 36, 27, 0, -36 },
  { 6215, 19, 44, 15, 0, -36 },
  { 6320, 9, 36, 17, 5, -36 },
  { 6361, 20, 44, 15, -4, -36 },
  { 6471, 24, 23, 29, 2, -37 },
  { 6540, 20, 2, 20, -4, 5 },
  { 6545, 8, 8, 13, 7, -39 },
  { 6553, 24, 29, 28, 3, -28 },
  { 6640, 25, 40, 29, 2, -39 },
  { 6765, 20, 29, 23, 3, -28 },
  { 6838, 27, 40, 29, 3, -39 },
  { 6973, 21, 29, 25, 3, -28 },
  { 7050, 28, 51, 15, -6, -39 },
  { 7229, 27, 40, 29, 1, -28 },
  { 7364, 24, 39, 29, 2, -39 },
  { 7481, 10, 37, 12, 2, -37 },
  { 7528, 19, 49, 12, -7, -37 },
  { 7645, 24, 39, 24, 2, -39 },
  { 7762, 11, 39, 12, 2, -39 },
  { 7816, 39, 28, 44, 2, -28 },
  { 7953, 25, 28, 29, 1, -28 },
  { 8041, 23, 28, 29, 3, -28 },
  { 8122, 28, 40, 29, -1, -28 },
  { 8262, 25, 40, 29, 3, -28 },
  { 8387, 19, 28, 20, 2, -28 },
  { 8454, 21, 29, 22, 0, -28 },
  { 8531, 15, 35, 16, 3, -34 },
  { 8597, 24, 28, 29, 3, -27 },
  { 8681, 23, 27, 22, 2, -27 },
  { 8759, 34, 27, 35, 3, -27 },
  { 8874, 27, 27, 24, -2, -27 },
  { 8966, 30, 39, 22, -5, -27 },
  { 9113, 23, 27, 22, -1, -27 },
  { 9191, 19, 44, 17, 1, -36 },
  { 9296, 2, 51, 28, 14, -39 },
  { 9309, 19, 44, 17, -2, -36 },
  { 9414, 23, 6, 29, 4, -21 },
};

const GFXfont NotoSans_LightItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_LIGHTITALIC51PT7B_H_
