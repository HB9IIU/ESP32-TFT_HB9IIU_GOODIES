#ifndef _NOTOSANS_LIGHTITALIC65PT7B_H_
#define _NOTOSANS_LIGHTITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x06, 0x00, 0x00,
  0x1E, 0x07, 0x8E, 0x03, 0xCF, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xC0,
  0x78, 0xE0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x38, 0x0E, 0x1C, 0x07, 0x0E,
  0x03, 0x87, 0x01, 0xC3, 0x00, 0xC3, 0x80, 0x61, 0xC0, 0x70, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xBB, 0xFC, 0x01,
  0xF0, 0x70, 0x38, 0x07, 0xC0, 0xE0, 0x10, 0x1F, 0x03, 0x80, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0x3E, 0x38,
  0x00, 0x00, 0x7E, 0x70, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x39, 0xF8, 0x00, 0x00, 0x70, 0xF8, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x18, 0x07, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x80,
  0x1C, 0x0F, 0x81, 0xC0, 0x38, 0x7E, 0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x38, 0x03, 0xE1, 0xF0, 0x00, 0x0E, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x00, 0x38,
  0x1E, 0x00, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x00, 0x78, 0x01, 0xE0, 0xE0,
  0xFF, 0x0F, 0x00, 0x38, 0x3C, 0x3F, 0xF9, 0xE0, 0x0F, 0x0F, 0x0F, 0xFF,
  0x1C, 0x01, 0xC1, 0xC3, 0xC0, 0xF3, 0x80, 0x78, 0x78, 0xF0, 0x0E, 0x78,
  0x1E, 0x1E, 0x1C, 0x01, 0xCF, 0x87, 0x87, 0x87, 0x80, 0x38, 0xFF, 0xF0,
  0xE0, 0xE0, 0x07, 0x8F, 0xF8, 0x3C, 0x3C, 0x00, 0xF0, 0xFE, 0x0F, 0x07,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x3C, 0x00,
  0x70, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x01, 0xC0,
  0x00, 0xE0, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x03, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0xF0,
  0x00, 0x07, 0xCF, 0x80, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x7E, 0x00, 0x00, 0x00, 0x7B, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x3C, 0x3E, 0x01, 0xE0, 0x00, 0x70, 0xF8, 0x03, 0xE0, 0x01,
  0xE3, 0xE0, 0x03, 0xC0, 0x03, 0x87, 0x80, 0x03, 0xC0, 0x0F, 0x1E, 0x00,
  0x03, 0xC0, 0x3C, 0x38, 0x00, 0x07, 0x80, 0x78, 0xF0, 0x00, 0x07, 0x81,
  0xE1, 0xE0, 0x00, 0x07, 0x87, 0x83, 0x80, 0x00, 0x0F, 0x9E, 0x07, 0x00,
  0x00, 0x0F, 0x7C, 0x0E, 0x00, 0x00, 0x0F, 0xF0, 0x1C, 0x00, 0x00, 0x0F,
  0xC0, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0xF0,
  0x00, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0x3E,
  0x3C, 0x01, 0xF8, 0x01, 0xF8, 0x3C, 0x03, 0xFF, 0xFF, 0xC0, 0x3C, 0x01,
  0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0x78, 0xE1, 0xC3,
  0x87, 0x0C, 0x38, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x7C, 0x03, 0x80, 0x07, 0xF8, 0x18, 0x00, 0x07, 0xF0, 0xC0, 0x00,
  0x0F, 0xEE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x1C, 0x00,
  0x07, 0xC0, 0x70, 0x00, 0x7C, 0x03, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x40, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x33,
  0xFF, 0xFF, 0xFD, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xFE,
  0x01, 0xF7, 0x81, 0xF9, 0xC0, 0xFC, 0xF0, 0xFC, 0x3C, 0x7E, 0x0F, 0x3E,
  0x03, 0xC7, 0x00, 0xE1, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x01, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x01, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x40, 0x00, 0x01, 0xF0,
  0x38, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xF1, 0xC0,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x80, 0x00, 0x07, 0xC0, 0x70, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xE0, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xE0,
  0x00, 0xE0, 0xFF, 0xF0, 0x03, 0xC7, 0xFF, 0xF8, 0x07, 0x9F, 0x83, 0xF8,
  0x0E, 0x78, 0x01, 0xF0, 0x3D, 0xC0, 0x01, 0xF0, 0x7F, 0x00, 0x01, 0xE0,
  0xFC, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x3F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x3E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3F, 0x07, 0x80, 0x00,
  0xFE, 0x07, 0x80, 0x07, 0xBC, 0x0F, 0xC0, 0x3E, 0x70, 0x0F, 0xFF, 0xF9,
  0xE0, 0x0F, 0xFF, 0xC3, 0xC0, 0x07, 0xFE, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x06, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x30, 0x00,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x0F, 0xC1, 0xC0, 0x07, 0xC2, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x0F, 0xFE, 0x00, 0x38, 0x38, 0x00, 0x1F, 0xFF, 0xC0, 0x1E, 0x3C, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0x1C, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0x9E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xCE, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xEF, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x77, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3B, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x1F, 0xE0,
  0x0E, 0x00, 0x03, 0x80, 0x0F, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x07, 0x70,
  0x07, 0x80, 0x01, 0xC0, 0x03, 0xB8, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xDC,
  0x01, 0xC0, 0x00, 0xF0, 0x01, 0xEE, 0x00, 0xE0, 0x00, 0x78, 0x00, 0xE7,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x73, 0x80, 0x38, 0x00, 0x3C, 0x00, 0x79,
  0xC0, 0x1C, 0x00, 0x3E, 0x00, 0x78, 0xE0, 0x0E, 0x00, 0x1F, 0x00, 0x3C,
  0x70, 0x07, 0x80, 0x1F, 0x80, 0x3C, 0x38, 0x03, 0xC0, 0x1C, 0xE0, 0x3C,
  0x1C, 0x00, 0xF0, 0x3C, 0x70, 0x7C, 0x0F, 0x00, 0x3F, 0xFC, 0x3F, 0xFC,
  0x07, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xC0, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x7C,
  0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x00, 0xFC, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x01,
  0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x07, 0x00, 0x00,
  0xF8, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x0E, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF8, 0x0F,
  0x00, 0x00, 0xFE, 0x01, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x03, 0xF0, 0x00,
  0x02, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x10, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x1E, 0x00, 0x3F, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x01, 0xC0,
  0x00, 0x1F, 0x80, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0x80,
  0x00, 0x07, 0xE0, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x07, 0xF0,
  0x01, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0xFC, 0x00,
  0x00, 0x20, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x01, 0xFF, 0xFC, 0xF0, 0x00, 0x0F, 0xFF, 0xE3, 0xC0, 0x00, 0x3F, 0xFF,
  0x8F, 0x00, 0x00, 0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0x0E, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x01, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x00, 0x79, 0xFC, 0x00, 0x00, 0x00,
  0xF7, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x78, 0x00, 0x00, 0x03, 0xF8, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x01, 0xEE, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x3D,
  0xC0, 0x00, 0x00, 0x1D, 0xE0, 0x07, 0xB8, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x00, 0x00, 0x3C, 0xE0,
  0x07, 0x9E, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x1E, 0x38, 0x00, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x00, 0x00, 0x0E,
  0x1E, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0x00,
  0x70, 0xF0, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xE0,
  0x00, 0x3C, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x03, 0xC0, 0x0F, 0x03,
  0x80, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x0F, 0x00, 0x38,
  0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x01,
  0xE0, 0x1C, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x03, 0x80, 0x1E, 0x01, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0x81, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x38,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0xC1,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x9E, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xF3, 0xC0, 0x03, 0xC0, 0x1E, 0x00,
  0x0E, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xDC, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x3F, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x01,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0x80, 0x3F, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0xF0,
  0x00, 0x00, 0x70, 0x03, 0x9E, 0x00, 0x00, 0x1C, 0x00, 0xE7, 0x80, 0x00,
  0x0F, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x3C, 0x00, 0x00, 0xF0,
  0x07, 0x8F, 0x00, 0x00, 0x38, 0x01, 0xE1, 0xE0, 0x00, 0x0E, 0x00, 0x70,
  0x78, 0x00, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x01, 0xE0, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x0F,
  0x00, 0x38, 0x07, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x00, 0x1E, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0xF0, 0x07, 0x80,
  0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x00, 0x07,
  0x07, 0x80, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x78,
  0x03, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC7, 0x00, 0x3C,
  0x00, 0x00, 0x71, 0xC0, 0x0E, 0x00, 0x00, 0x1E, 0xF0, 0x07, 0x80, 0x00,
  0x07, 0xBC, 0x01, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0x80, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x03,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x80,
  0x1E, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xE0,
  0x03, 0xF8, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x0F,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0xFC, 0x00,
  0x02, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x17, 0x40, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x3E, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE7,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0xC7, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x87, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x07, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x70, 0x00, 0xF0,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x78,
  0x03, 0xC0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x07, 0x00, 0xF0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x0F,
  0x00, 0x38, 0x07, 0x00, 0x07, 0x01, 0xE0, 0x03, 0x80, 0xF0, 0x00, 0x70,
  0x1E, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x00,
  0x70, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x03, 0x83, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x8E, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x9C, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xB8,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x70, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0,
  0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x78,
  0x01, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x38, 0x78, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF0, 0x78, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1C,
  0x0F, 0x03, 0x80, 0xE0, 0x00, 0x07, 0xF8, 0x07, 0x00, 0x1F, 0xFE, 0x0E,
  0x00, 0x7F, 0xFF, 0x0E, 0x00, 0xFC, 0x07, 0x8E, 0x01, 0xF0, 0x03, 0x9E,
  0x03, 0xE0, 0x01, 0xDC, 0x07, 0xC0, 0x00, 0xDC, 0x07, 0x80, 0x00, 0xFC,
  0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x0F, 0xC0, 0x70, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x3B, 0xC0,
  0x78, 0x00, 0x7B, 0x80, 0x3C, 0x00, 0xF3, 0x80, 0x3E, 0x01, 0xE3, 0x80,
  0x1F, 0xFF, 0xC3, 0x80, 0x0F, 0xFF, 0x07, 0x80, 0x07, 0xFE, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x3F, 0xC0, 0x01, 0xE0, 0xFF, 0xF0, 0x01, 0xC3, 0xFF, 0xF8,
  0x01, 0xC7, 0xC0, 0xFC, 0x03, 0xCF, 0x00, 0x3C, 0x03, 0xDC, 0x00, 0x3E,
  0x03, 0xB8, 0x00, 0x1E, 0x03, 0xB0, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x0F,
  0x07, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C,
  0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xE0, 0x77, 0x00, 0x03, 0xC0,
  0x73, 0x80, 0x0F, 0xC0, 0x73, 0xC0, 0x1F, 0x80, 0xF1, 0xFF, 0xFF, 0x00,
  0xE0, 0xFF, 0xFC, 0x00, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0x00, 0xE0, 0x1F, 0x80, 0x04, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x00, 0xFC, 0x00, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x78,
  0x00, 0x7F, 0xFF, 0x8F, 0x00, 0x1F, 0xC0, 0xF1, 0xE0, 0x07, 0xC0, 0x07,
  0x38, 0x01, 0xF0, 0x00, 0x77, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x0F, 0x00,
  0x00, 0xFC, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x00, 0x70, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x07,
  0xE0, 0x0E, 0x00, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x77, 0x00, 0x3C, 0x00,
  0x1C, 0xE0, 0x07, 0xC0, 0x07, 0x3C, 0x00, 0x7C, 0x03, 0xC7, 0x80, 0x07,
  0xFF, 0xF0, 0xE0, 0x00, 0x7F, 0xFC, 0x1C, 0x00, 0x07, 0xFE, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x3E, 0x03, 0xF0, 0x07, 0xC1, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x9E,
  0x00, 0x07, 0xC7, 0x80, 0x07, 0xE3, 0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x40, 0xFC, 0x00,
  0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xDE, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x10, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x03, 0x80, 0x07, 0xFF, 0x81, 0xC0, 0x0F, 0xFF, 0xF0, 0xE0,
  0x0F, 0xE0, 0x78, 0xF0, 0x0F, 0x80, 0x0E, 0x70, 0x0F, 0x80, 0x03, 0xB8,
  0x0F, 0x80, 0x01, 0xDC, 0x07, 0x80, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF8, 0x1E, 0x00,
  0x00, 0xFC, 0x07, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0xEE, 0x01, 0xE0,
  0x00, 0xEF, 0x00, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x01, 0xE3, 0xC0, 0x0F,
  0xFF, 0xE1, 0xC0, 0x03, 0xFF, 0xE1, 0xE0, 0x00, 0xFF, 0xC0, 0xF0, 0x00,
  0x06, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x04, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x0F, 0xF0, 0x00, 0xF0, 0x7F, 0xF8, 0x01, 0xC3, 0xFF, 0xF8,
  0x03, 0x8F, 0x81, 0xF8, 0x0F, 0x3C, 0x00, 0xF0, 0x1E, 0xF0, 0x00, 0xF0,
  0x3B, 0xC0, 0x01, 0xE0, 0x76, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x07, 0x83,
  0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0xF0, 0x03, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0xE0, 0x0F,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x03, 0x8F, 0xC0, 0x00, 0x07, 0x3F, 0x80, 0x00,
  0x1F, 0xE7, 0x80, 0x00, 0x3F, 0x8F, 0x00, 0x00, 0x7E, 0x0F, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80,
  0x03, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x70, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1C, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x07, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x03, 0xCF, 0x00,
  0xF0, 0xF0, 0x07, 0x80, 0xF7, 0x00, 0x1E, 0x78, 0x00, 0xF0, 0x3B, 0x80,
  0x07, 0x9C, 0x00, 0x3C, 0x0E, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x3F, 0xE0, 0x03, 0x81, 0xFF, 0xE0, 0x07, 0x0F, 0xFF, 0xE0, 0x0E,
  0x3F, 0x07, 0xE0, 0x3C, 0xF0, 0x03, 0xE0, 0x7B, 0xC0, 0x03, 0xC0, 0xEF,
  0x00, 0x07, 0x81, 0xDC, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0x1E, 0x0F, 0xC0,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x07, 0xF8, 0x00, 0x07,
  0x03, 0xFF, 0xC0, 0x00, 0xE1, 0xFF, 0xFC, 0x00, 0x1C, 0x7C, 0x0F, 0xC0,
  0x07, 0x9E, 0x00, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x80, 0x1D, 0xC0, 0x00,
  0xF0, 0x03, 0xB8, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x1F, 0x80,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x1F, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x03,
  0xC0, 0x1F, 0xC0, 0x00, 0xF0, 0x03, 0x9C, 0x00, 0x7E, 0x00, 0x73, 0xC0,
  0x1F, 0x80, 0x0E, 0x3F, 0xFF, 0xE0, 0x03, 0xC3, 0xFF, 0xF0, 0x00, 0x78,
  0x1F, 0xF8, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x07, 0x00, 0x1F, 0xFE, 0x07, 0x00, 0x7F, 0xFF, 0x87, 0x00, 0xFE, 0x07,
  0x8F, 0x01, 0xF0, 0x01, 0xCE, 0x03, 0xE0, 0x00, 0xEE, 0x07, 0xC0, 0x00,
  0xEE, 0x07, 0x80, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x0F,
  0xC0, 0x78, 0x00, 0x1D, 0xC0, 0x78, 0x00, 0x3B, 0xC0, 0x3C, 0x00, 0xF3,
  0xC0, 0x3E, 0x01, 0xE3, 0xC0, 0x1F, 0xFF, 0xC3, 0x80, 0x0F, 0xFF, 0x87,
  0x80, 0x07, 0xFE, 0x07, 0x80, 0x00, 0x60, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x7F, 0x80, 0xE0, 0xFF, 0xC0,
  0x70, 0xFF, 0xC0, 0x38, 0xFC, 0x20, 0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7E, 0x01, 0xF0, 0x7C, 0x00, 0x10, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC2, 0x00, 0x03, 0xE1, 0xE0, 0x03, 0xE0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x18, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x07, 0xC1, 0xC0, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x7E, 0x07, 0x00,
  0x01, 0xFC, 0x0F, 0x00, 0x03, 0x78, 0x1E, 0x00, 0x0E, 0xE0, 0x3C, 0x00,
  0x79, 0xC0, 0x7C, 0x03, 0xE3, 0x80, 0x7F, 0xFF, 0x87, 0x00, 0x7F, 0xFC,
  0x1E, 0x00, 0x7F, 0xF0, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x78, 0x03, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x0F, 0x00, 0x07, 0x00, 0x78, 0x00, 0x38, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x1F,
  0x00, 0x01, 0xCE, 0x00, 0x07, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x3C, 0x00, 0x3B, 0x80, 0x03, 0xC7, 0x80, 0x07, 0x78, 0x00, 0x78,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0x1E, 0x00, 0x39, 0xE0, 0x03, 0xC3, 0xC0,
  0x0F, 0x1C, 0x00, 0xF0, 0x78, 0x01, 0xC3, 0x80, 0x1E, 0x0F, 0x00, 0x78,
  0x70, 0x07, 0x81, 0xE0, 0x0E, 0x0E, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xC0,
  0x3C, 0x07, 0x80, 0x70, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x01, 0xE0,
  0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x01, 0xC0, 0xF0, 0x1E, 0x07, 0x00, 0x38,
  0x1C, 0x03, 0xC1, 0xE0, 0x07, 0x07, 0x80, 0x78, 0x38, 0x00, 0xE0, 0xE0,
  0x0F, 0x0F, 0x00, 0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x1C,
  0x78, 0x00, 0x71, 0xE0, 0x03, 0x8F, 0x00, 0x0E, 0x38, 0x00, 0x73, 0xC0,
  0x01, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x07,
  0x78, 0x00, 0x3B, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x70, 0x07, 0xC0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x07, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7B, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x17, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xE8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xC0,
};

const GFXglyph NotoSans_LightItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 14, 47, 15, 2, -46 },
  { 84, 17, 16, 23, 7, -46 },
  { 118, 40, 46, 41, 2, -46 },
  { 348, 31, 53, 36, 3, -49 },
  { 554, 43, 48, 51, 5, -47 },
  { 812, 39, 48, 44, 3, -47 },
  { 1046, 7, 16, 13, 7, -46 },
  { 1060, 20, 56, 17, 2, -46 },
  { 1200, 20, 56, 17, -5, -46 },
  { 1340, 29, 28, 35, 7, -49 },
  { 1442, 30, 30, 37, 5, -38 },
  { 1555, 11, 16, 14, -3, -8 },
  { 1577, 16, 3, 20, 2, -19 },
  { 1583, 5, 7, 15, 2, -6 },
  { 1588, 30, 46, 22, -3, -46 },
  { 1761, 31, 48, 36, 4, -47 },
  { 1947, 18, 46, 36, 10, -46 },
  { 2051, 34, 47, 36, 0, -47 },
  { 2251, 33, 48, 36, 1, -47 },
  { 2449, 34, 47, 36, 1, -47 },
  { 2649, 33, 47, 36, 2, -46 },
  { 2843, 31, 48, 36, 4, -47 },
  { 3029, 31, 46, 36, 6, -46 },
  { 3208, 32, 48, 36, 3, -47 },
  { 3400, 31, 48, 36, 3, -47 },
  { 3586, 11, 36, 15, 2, -35 },
  { 3636, 16, 43, 15, -3, -35 },
  { 3722, 30, 31, 37, 5, -39 },
  { 3839, 30, 16, 37, 5, -31 },
  { 3899, 30, 31, 37, 5, -39 },
  { 4016, 23, 48, 27, 5, -47 },
  { 4154, 49, 52, 55, 4, -46 },
  { 4473, 36, 46, 36, -3, -46 },
  { 4680, 35, 46, 39, 3, -46 },
  { 4882, 36, 48, 38, 5, -47 },
  { 5098, 38, 46, 44, 3, -46 },
  { 5317, 33, 46, 34, 3, -46 },
  { 5507, 33, 46, 31, 3, -46 },
  { 5697, 38, 48, 44, 5, -47 },
  { 5925, 41, 46, 44, 3, -46 },
  { 6161, 23, 46, 20, 0, -46 },
  { 6294, 28, 58, 16, -11, -46 },
  { 6497, 39, 46, 36, 3, -46 },
  { 6722, 24, 46, 32, 3, -46 },
  { 6860, 51, 46, 54, 3, -46 },
  { 7154, 42, 46, 45, 3, -46 },
  { 7396, 39, 48, 47, 5, -47 },
  { 7630, 34, 46, 37, 3, -46 },
  { 7826, 39, 58, 47, 5, -47 },
  { 8109, 34, 46, 37, 3, -46 },
  { 8305, 32, 48, 33, 1, -47 },
  { 8497, 32, 46, 32, 6, -46 },
  { 8681, 40, 47, 45, 5, -46 },
  { 8916, 35, 46, 35, 6, -46 },
  { 9118, 52, 46, 55, 8, -46 },
  { 9417, 42, 46, 33, -4, -46 },
  { 9659, 32, 46, 32, 6, -46 },
  { 9843, 38, 46, 35, -1, -46 },
  { 10062, 25, 56, 19, -1, -46 },
  { 10237, 11, 46, 22, 7, -46 },
  { 10301, 25, 56, 19, -5, -46 },
  { 10476, 31, 29, 36, 3, -47 },
  { 10589, 26, 3, 25, -6, 6 },
  { 10599, 9, 11, 16, 10, -50 },
  { 10612, 32, 36, 36, 3, -35 },
  { 10756, 32, 50, 37, 2, -49 },
  { 10956, 27, 36, 29, 3, -35 },
  { 11078, 35, 50, 37, 3, -49 },
  { 11297, 26, 36, 32, 4, -35 },
  { 11414, 36, 66, 19, -8, -50 },
  { 11711, 33, 51, 37, 2, -35 },
  { 11922, 31, 49, 37, 2, -49 },
  { 12112, 14, 47, 15, 2, -47 },
  { 12195, 25, 63, 15, -9, -47 },
  { 12392, 31, 49, 30, 2, -49 },
  { 12582, 14, 49, 15, 2, -49 },
  { 12668, 50, 35, 56, 2, -35 },
  { 12887, 31, 35, 37, 2, -35 },
  { 13023, 30, 36, 37, 3, -35 },
  { 13158, 35, 50, 37, -1, -35 },
  { 13377, 32, 50, 37, 3, -35 },
  { 13577, 25, 35, 25, 2, -35 },
  { 13687, 25, 36, 28, 1, -35 },
  { 13800, 20, 44, 21, 3, -43 },
  { 13910, 31, 36, 37, 4, -35 },
  { 14050, 29, 35, 29, 3, -35 },
  { 14177, 43, 35, 45, 4, -35 },
  { 14366, 34, 35, 30, -2, -35 },
  { 14515, 39, 51, 29, -7, -35 },
  { 14764, 29, 35, 29, -1, -35 },
  { 14891, 24, 56, 22, 1, -46 },
  { 15059, 3, 65, 35, 18, -49 },
  { 15084, 24, 56, 22, -3, -46 },
  { 15252, 30, 8, 37, 5, -27 },
};

const GFXfont NotoSans_LightItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_LIGHTITALIC65PT7B_H_
