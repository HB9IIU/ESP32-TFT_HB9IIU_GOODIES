#ifndef _NOTOSANS_LIGHTITALIC11PT7B_H_
#define _NOTOSANS_LIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x84, 0xB6, 0x80, 0x14, 0x29, 0xF9, 0x22, 0x9F, 0x92,
  0x28, 0x18, 0xD5, 0x0C, 0x18, 0xAA, 0x9C, 0x20, 0x63, 0x4A, 0xA5, 0xBD,
  0xA5, 0x52, 0xC6, 0x18, 0x48, 0xB0, 0x87, 0x31, 0x61, 0x3F, 0xE0, 0x12,
  0x44, 0x88, 0x88, 0x84, 0x21, 0x11, 0x12, 0x22, 0x48, 0x27, 0x0E, 0xA0,
  0x21, 0x3E, 0x42, 0x00, 0xC0, 0xE0, 0x80, 0x08, 0x88, 0x44, 0x22, 0x10,
  0x32, 0x63, 0x18, 0xC6, 0x5C, 0x75, 0x24, 0x94, 0x38, 0x10, 0x42, 0x10,
  0x84, 0x3E, 0x78, 0x10, 0x4E, 0x08, 0x20, 0xBC, 0x04, 0x21, 0x8A, 0x4B,
  0xF0, 0x84, 0x3C, 0x84, 0x1C, 0x08, 0x20, 0xBC, 0x3A, 0x21, 0xE8, 0xC6,
  0x5C, 0xF8, 0x44, 0x22, 0x21, 0x10, 0x38, 0x92, 0x4E, 0x4A, 0x28, 0x9E,
  0x74, 0x63, 0x17, 0x88, 0x5C, 0x40, 0x20, 0x20, 0x00, 0xB0, 0x09, 0x91,
  0x83, 0x04, 0xFF, 0xC0, 0x82, 0x0C, 0x36, 0x40, 0xE1, 0x12, 0x48, 0x08,
  0x3E, 0x41, 0x99, 0xA5, 0xA5, 0xC9, 0xB6, 0x80, 0x78, 0x04, 0x18, 0x50,
  0xA2, 0x47, 0x90, 0xE1, 0x3C, 0x94, 0x5F, 0x45, 0x14, 0x7E, 0x3D, 0x08,
  0x20, 0x82, 0x08, 0x1E, 0x3C, 0x45, 0x0A, 0x14, 0x28, 0x51, 0x7C, 0x3C,
  0x84, 0x1E, 0x41, 0x04, 0x3E, 0x3C, 0x84, 0x10, 0x79, 0x04, 0x20, 0x3D,
  0x08, 0x20, 0x9E, 0x18, 0x9E, 0x22, 0x45, 0x0B, 0xF4, 0x28, 0x51, 0x42,
  0x32, 0x24, 0x44, 0x4C, 0x08, 0x44, 0x21, 0x08, 0x44, 0x26, 0x00, 0x22,
  0x49, 0x23, 0x85, 0x0A, 0x12, 0x44, 0x21, 0x10, 0x84, 0x21, 0x1F, 0x20,
  0x90, 0xD4, 0x6A, 0x55, 0x52, 0xA9, 0x65, 0x12, 0x21, 0x22, 0x52, 0x52,
  0x4A, 0x4A, 0x44, 0x84, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0xA1, 0x3C, 0x38,
  0x94, 0x51, 0x79, 0x04, 0x20, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0xA1, 0x3C,
  0x10, 0x10, 0x38, 0x94, 0x51, 0x79, 0x24, 0xA2, 0x3D, 0x04, 0x08, 0x10,
  0x20, 0xBC, 0xF9, 0x08, 0x44, 0x21, 0x08, 0x42, 0x8A, 0x14, 0x28, 0x50,
  0xA2, 0x78, 0x86, 0x28, 0xA4, 0x91, 0x84, 0x10, 0x88, 0xC4, 0x66, 0x53,
  0x2A, 0xA5, 0x31, 0x10, 0x88, 0x22, 0x28, 0x50, 0x41, 0x85, 0x11, 0x62,
  0x8C, 0x54, 0xC4, 0x21, 0x08, 0x3C, 0x10, 0x84, 0x21, 0x04, 0x3E, 0x34,
  0x44, 0x44, 0x88, 0x8C, 0xAA, 0x55, 0x31, 0x11, 0x12, 0x22, 0x2C, 0x10,
  0xA2, 0x92, 0xC4, 0xF0, 0x80, 0x7C, 0x63, 0x29, 0x78, 0x20, 0x85, 0x99,
  0x45, 0x14, 0xBC, 0x78, 0x88, 0x8E, 0x08, 0x5F, 0x18, 0xCA, 0x5E, 0x79,
  0xBC, 0x8E, 0x1C, 0x43, 0x88, 0x20, 0x82, 0x10, 0x41, 0x08, 0x00, 0x3D,
  0x14, 0x62, 0x89, 0xE0, 0x84, 0xE0, 0x20, 0x85, 0x99, 0x45, 0x28, 0xA2,
  0x21, 0x24, 0xA4, 0x10, 0x22, 0x22, 0x44, 0x44, 0x80, 0x20, 0x84, 0xD4,
  0x61, 0x89, 0x26, 0x25, 0x24, 0xA4, 0x7B, 0xA2, 0x52, 0x29, 0x18, 0x94,
  0x48, 0x59, 0x94, 0x52, 0x8A, 0x20, 0x74, 0x63, 0x19, 0x70, 0x59, 0x94,
  0x51, 0x4B, 0xC8, 0x20, 0x80, 0x7C, 0x63, 0x29, 0x78, 0x42, 0x20, 0x5B,
  0x10, 0x88, 0x40, 0x74, 0x43, 0x1E, 0x5E, 0x49, 0x30, 0x8C, 0x63, 0x29,
  0x78, 0x99, 0xAA, 0xC8, 0x93, 0x6A, 0xD6, 0xA9, 0x92, 0x00, 0x4A, 0x88,
  0x45, 0x48, 0x44, 0x92, 0x8A, 0x30, 0x82, 0x10, 0x80, 0x78, 0x88, 0x84,
  0x78, 0x12, 0x22, 0xC4, 0x44, 0x44, 0xFF, 0xE0, 0x62, 0x22, 0x32, 0x44,
  0x48, 0xF8,
};

const GFXglyph NotoSans_LightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 3, 3, 4, 1, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 6, 9, 6, 0, -8 },
  { 20, 7, 8, 9, 1, -8 },
  { 27, 7, 8, 7, 0, -8 },
  { 34, 1, 3, 2, 1, -8 },
  { 35, 4, 10, 3, 0, -8 },
  { 40, 4, 10, 3, -1, -8 },
  { 45, 5, 4, 6, 1, -8 },
  { 48, 5, 5, 6, 1, -6 },
  { 52, 1, 2, 2, 0, -1 },
  { 53, 3, 1, 3, 0, -3 },
  { 54, 1, 1, 3, 0, -1 },
  { 55, 5, 8, 4, 0, -8 },
  { 60, 5, 8, 6, 1, -8 },
  { 65, 3, 8, 6, 2, -8 },
  { 68, 6, 8, 6, 0, -8 },
  { 74, 6, 8, 6, 0, -8 },
  { 80, 6, 8, 6, 0, -8 },
  { 86, 6, 8, 6, 0, -8 },
  { 92, 5, 8, 6, 1, -8 },
  { 97, 5, 8, 6, 1, -8 },
  { 102, 6, 8, 6, 0, -8 },
  { 108, 5, 8, 6, 1, -8 },
  { 113, 2, 6, 3, 0, -6 },
  { 115, 3, 7, 3, -1, -6 },
  { 118, 5, 6, 6, 1, -7 },
  { 122, 5, 2, 6, 1, -5 },
  { 124, 5, 6, 6, 1, -7 },
  { 128, 4, 8, 5, 1, -8 },
  { 132, 8, 9, 9, 1, -8 },
  { 141, 7, 8, 6, -1, -8 },
  { 148, 6, 8, 7, 0, -8 },
  { 154, 6, 8, 7, 1, -8 },
  { 160, 7, 8, 7, 0, -8 },
  { 167, 6, 8, 6, 0, -8 },
  { 173, 6, 8, 5, 0, -8 },
  { 179, 6, 8, 8, 1, -8 },
  { 185, 7, 8, 7, 0, -8 },
  { 192, 4, 8, 3, 0, -8 },
  { 196, 5, 10, 3, -2, -8 },
  { 203, 7, 8, 6, 0, -8 },
  { 210, 5, 8, 5, 0, -8 },
  { 215, 9, 8, 9, 0, -8 },
  { 224, 8, 8, 8, 0, -8 },
  { 232, 7, 8, 8, 1, -8 },
  { 239, 6, 8, 6, 0, -8 },
  { 245, 7, 10, 8, 1, -8 },
  { 254, 6, 8, 6, 0, -8 },
  { 260, 6, 8, 6, 0, -8 },
  { 266, 5, 8, 5, 1, -8 },
  { 271, 7, 8, 8, 1, -8 },
  { 278, 6, 8, 6, 1, -8 },
  { 284, 9, 8, 9, 1, -8 },
  { 293, 7, 8, 6, -1, -8 },
  { 300, 5, 8, 5, 1, -8 },
  { 305, 6, 8, 6, 0, -8 },
  { 311, 4, 10, 3, 0, -8 },
  { 316, 2, 8, 4, 1, -8 },
  { 318, 4, 10, 3, -1, -8 },
  { 323, 6, 5, 6, 0, -8 },
  { 327, 4, 1, 4, -1, 1 },
  { 328, 1, 1, 3, 2, -8 },
  { 329, 5, 6, 6, 1, -6 },
  { 333, 6, 8, 6, 0, -8 },
  { 339, 4, 6, 5, 1, -6 },
  { 342, 5, 8, 6, 1, -8 },
  { 347, 4, 6, 5, 1, -6 },
  { 350, 6, 11, 3, -1, -8 },
  { 359, 6, 9, 6, 0, -6 },
  { 366, 6, 8, 6, 0, -8 },
  { 372, 3, 8, 3, 0, -8 },
  { 375, 4, 11, 3, -1, -8 },
  { 381, 6, 8, 5, 0, -8 },
  { 387, 3, 8, 3, 0, -8 },
  { 390, 9, 6, 9, 0, -6 },
  { 397, 6, 6, 6, 0, -6 },
  { 402, 5, 6, 6, 1, -6 },
  { 406, 6, 9, 6, 0, -6 },
  { 413, 5, 9, 6, 1, -6 },
  { 419, 5, 6, 4, 0, -6 },
  { 423, 4, 6, 5, 0, -6 },
  { 426, 3, 7, 4, 1, -7 },
  { 429, 5, 6, 6, 1, -6 },
  { 433, 4, 6, 5, 1, -6 },
  { 436, 7, 6, 8, 1, -6 },
  { 442, 5, 6, 5, 0, -6 },
  { 446, 6, 9, 5, -1, -6 },
  { 453, 5, 6, 5, 0, -6 },
  { 457, 4, 10, 4, 0, -8 },
  { 462, 1, 11, 6, 3, -8 },
  { 464, 4, 10, 4, 0, -8 },
  { 469, 5, 1, 6, 1, -4 },
};

const GFXfont NotoSans_LightItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_LIGHTITALIC11PT7B_H_
