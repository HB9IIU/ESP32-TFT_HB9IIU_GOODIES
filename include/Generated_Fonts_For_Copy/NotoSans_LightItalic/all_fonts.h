#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_LightItalic
// Headers: 67

#include "NotoSans_LightItalic6pt7b.h"
#include "NotoSans_LightItalic7pt7b.h"
#include "NotoSans_LightItalic8pt7b.h"
#include "NotoSans_LightItalic9pt7b.h"
#include "NotoSans_LightItalic10pt7b.h"
#include "NotoSans_LightItalic11pt7b.h"
#include "NotoSans_LightItalic12pt7b.h"
#include "NotoSans_LightItalic13pt7b.h"
#include "NotoSans_LightItalic14pt7b.h"
#include "NotoSans_LightItalic15pt7b.h"
#include "NotoSans_LightItalic16pt7b.h"
#include "NotoSans_LightItalic17pt7b.h"
#include "NotoSans_LightItalic18pt7b.h"
#include "NotoSans_LightItalic19pt7b.h"
#include "NotoSans_LightItalic20pt7b.h"
#include "NotoSans_LightItalic21pt7b.h"
#include "NotoSans_LightItalic22pt7b.h"
#include "NotoSans_LightItalic23pt7b.h"
#include "NotoSans_LightItalic24pt7b.h"
#include "NotoSans_LightItalic25pt7b.h"
#include "NotoSans_LightItalic26pt7b.h"
#include "NotoSans_LightItalic27pt7b.h"
#include "NotoSans_LightItalic28pt7b.h"
#include "NotoSans_LightItalic29pt7b.h"
#include "NotoSans_LightItalic30pt7b.h"
#include "NotoSans_LightItalic31pt7b.h"
#include "NotoSans_LightItalic32pt7b.h"
#include "NotoSans_LightItalic33pt7b.h"
#include "NotoSans_LightItalic34pt7b.h"
#include "NotoSans_LightItalic35pt7b.h"
#include "NotoSans_LightItalic36pt7b.h"
#include "NotoSans_LightItalic37pt7b.h"
#include "NotoSans_LightItalic38pt7b.h"
#include "NotoSans_LightItalic39pt7b.h"
#include "NotoSans_LightItalic40pt7b.h"
#include "NotoSans_LightItalic41pt7b.h"
#include "NotoSans_LightItalic42pt7b.h"
#include "NotoSans_LightItalic43pt7b.h"
#include "NotoSans_LightItalic44pt7b.h"
#include "NotoSans_LightItalic45pt7b.h"
#include "NotoSans_LightItalic46pt7b.h"
#include "NotoSans_LightItalic47pt7b.h"
#include "NotoSans_LightItalic48pt7b.h"
#include "NotoSans_LightItalic49pt7b.h"
#include "NotoSans_LightItalic50pt7b.h"
#include "NotoSans_LightItalic51pt7b.h"
#include "NotoSans_LightItalic52pt7b.h"
#include "NotoSans_LightItalic53pt7b.h"
#include "NotoSans_LightItalic54pt7b.h"
#include "NotoSans_LightItalic55pt7b.h"
#include "NotoSans_LightItalic56pt7b.h"
#include "NotoSans_LightItalic57pt7b.h"
#include "NotoSans_LightItalic58pt7b.h"
#include "NotoSans_LightItalic59pt7b.h"
#include "NotoSans_LightItalic60pt7b.h"
#include "NotoSans_LightItalic61pt7b.h"
#include "NotoSans_LightItalic62pt7b.h"
#include "NotoSans_LightItalic63pt7b.h"
#include "NotoSans_LightItalic64pt7b.h"
#include "NotoSans_LightItalic65pt7b.h"
#include "NotoSans_LightItalic66pt7b.h"
#include "NotoSans_LightItalic67pt7b.h"
#include "NotoSans_LightItalic68pt7b.h"
#include "NotoSans_LightItalic69pt7b.h"
#include "NotoSans_LightItalic70pt7b.h"
#include "NotoSans_LightItalic71pt7b.h"
#include "NotoSans_LightItalic72pt7b.h"
