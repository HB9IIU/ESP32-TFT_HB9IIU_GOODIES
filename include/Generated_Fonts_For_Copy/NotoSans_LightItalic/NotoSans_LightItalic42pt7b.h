#ifndef _NOTOSANS_LIGHTITALIC42PT7B_H_
#define _NOTOSANS_LIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03,
  0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x1E, 0x0F, 0x07, 0x00, 0x70,
  0xEE, 0x19, 0x83, 0x30, 0xE6, 0x18, 0xC3, 0x30, 0x66, 0x0C, 0xC1, 0x18,
  0x62, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x30, 0x07, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x0C, 0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0x98, 0x60, 0xE1,
  0x80, 0x0C, 0x18, 0x01, 0xC1, 0x80, 0x1C, 0x18, 0x01, 0xC3, 0x00, 0x0C,
  0x30, 0x00, 0xE3, 0x00, 0x0F, 0x30, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x6F, 0x00, 0x06, 0x78, 0x00, 0x43, 0x80, 0x0C, 0x18,
  0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x38, 0x81, 0x87,
  0x0F, 0x1B, 0xE0, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0xFF, 0x00,
  0x18, 0x1C, 0x30, 0x03, 0x81, 0x81, 0x80, 0x30, 0x30, 0x18, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x70, 0x18, 0x1C, 0x06, 0x01, 0x81, 0x80, 0x60, 0x38,
  0x30, 0x06, 0x03, 0x06, 0x00, 0x60, 0x30, 0xE0, 0x06, 0x03, 0x0C, 0x00,
  0xE0, 0x71, 0x8F, 0xC6, 0x06, 0x31, 0xFE, 0x60, 0xE7, 0x38, 0x66, 0x0C,
  0x67, 0x07, 0x7F, 0x8C, 0x60, 0x33, 0xF1, 0x86, 0x03, 0x00, 0x38, 0xC0,
  0x30, 0x03, 0x0C, 0x07, 0x00, 0x60, 0xC0, 0x60, 0x0C, 0x0C, 0x06, 0x01,
  0xC1, 0xC0, 0x60, 0x18, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x18,
  0x0C, 0x0E, 0x01, 0xC1, 0xC0, 0xC0, 0x0C, 0x38, 0x18, 0x00, 0xFF, 0x03,
  0x80, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x70, 0x38,
  0x00, 0x30, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x01,
  0xC0, 0x06, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x60,
  0xE0, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0x18, 0x03, 0x9C, 0x0E, 0x01, 0x9C,
  0x03, 0x81, 0xCC, 0x00, 0xC0, 0xCE, 0x00, 0x70, 0xE6, 0x00, 0x1C, 0xE3,
  0x00, 0x07, 0xE1, 0x80, 0x01, 0xE0, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0xF8,
  0x38, 0x00, 0xEC, 0x0E, 0x01, 0xE7, 0x03, 0xFF, 0xC1, 0xC0, 0xFF, 0x80,
  0x70, 0x77, 0x66, 0x66, 0xCC, 0xCC, 0x80, 0x00, 0x70, 0x0E, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x80, 0x60, 0x38, 0x10, 0x0F, 0x8C, 0x00, 0xFB, 0x00, 0x07, 0xDF,
  0xC0, 0x7F, 0xF0, 0x3C, 0x00, 0x19, 0x00, 0x0E, 0x60, 0x07, 0x18, 0x03,
  0x83, 0x01, 0xC0, 0xC0, 0x20, 0x38, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x0E, 0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x38, 0x61, 0xC0, 0x7F, 0xFF,
  0xF8, 0x6F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1E,
  0x07, 0x07, 0x80, 0x60, 0xE0, 0x0E, 0x38, 0x01, 0xC6, 0x00, 0x19, 0xC0,
  0x03, 0x30, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x01, 0xB0, 0x00, 0x36, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1B, 0x00, 0x03, 0x60, 0x00, 0xEC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0xE6, 0x00, 0x18, 0xC0, 0x07, 0x1C, 0x01, 0xC1, 0x80, 0x70, 0x38, 0x1C,
  0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xE0, 0x7C, 0x1F, 0x0F, 0x63,
  0xCD, 0xE3, 0xB8, 0x74, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x3E, 0x07, 0x80, 0x60, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xE0, 0x1C, 0x0C, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0x80,
  0x07, 0xE0, 0x00, 0x47, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x20, 0x00, 0xE1, 0xC0, 0x1E,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x36, 0x00, 0x01, 0x98, 0x00, 0x0E, 0xE0, 0x00,
  0x73, 0x00, 0x03, 0x8C, 0x00, 0x1C, 0x30, 0x00, 0xE1, 0xC0, 0x03, 0x06,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x07, 0x03, 0x80, 0x38, 0x0E, 0x01,
  0xC0, 0x30, 0x0E, 0x00, 0xC0, 0x70, 0x03, 0x01, 0x80, 0x1C, 0x0C, 0x00,
  0x70, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x20, 0x01, 0xC1, 0x80, 0x3C, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x07, 0x80, 0x73, 0xFE, 0x06, 0x79, 0xF0, 0x6C,
  0x03, 0x8F, 0x80, 0x18, 0xF0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCC,
  0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x38,
  0xE0, 0x03, 0x8E, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x81, 0xC0, 0x3F, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00,
  0xF0, 0x3C, 0x0E, 0x00, 0xE0, 0x70, 0x03, 0x03, 0x00, 0x1C, 0x18, 0x00,
  0xE0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x03, 0x81, 0xC0, 0x38, 0x07,
  0x03, 0x80, 0x1C, 0x78, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFB, 0xC0,
  0x1E, 0x07, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x8E, 0x00,
  0x0C, 0x70, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xE0, 0x01, 0xC7,
  0x00, 0x0C, 0x1C, 0x00, 0xE0, 0xF0, 0x1E, 0x03, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0x81, 0xC0, 0xE0, 0x0E, 0x0C,
  0x00, 0x61, 0xC0, 0x07, 0x18, 0x00, 0x73, 0x80, 0x03, 0x38, 0x00, 0x33,
  0x00, 0x07, 0x30, 0x00, 0x73, 0x00, 0x07, 0x30, 0x00, 0x73, 0x80, 0x0F,
  0x38, 0x01, 0xE1, 0xC0, 0x36, 0x0F, 0x9E, 0xE0, 0x7F, 0xCE, 0x00, 0xE0,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x08, 0x07, 0x80, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0x06, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0xF0, 0xF0, 0xE0, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xF0,
  0x7F, 0xF8, 0xC0, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x01,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x20, 0x07, 0x18, 0x03, 0xFF, 0x03, 0x38,
  0x07, 0x8F, 0x03, 0x30, 0x1C, 0x07, 0x03, 0x30, 0x18, 0x06, 0x03, 0x60,
  0x30, 0x06, 0x03, 0x60, 0x70, 0x06, 0x03, 0x60, 0x60, 0x0E, 0x03, 0xE0,
  0x60, 0x0C, 0x03, 0xE0, 0xE0, 0x0C, 0x07, 0xC0, 0xC0, 0x1C, 0x06, 0xC0,
  0xC0, 0x18, 0x06, 0xC0, 0xC0, 0x38, 0x0C, 0xE0, 0xE0, 0x38, 0x1C, 0xE0,
  0x60, 0x6C, 0x38, 0x60, 0x7B, 0xCE, 0x70, 0x60, 0x3F, 0x87, 0xE0, 0x70,
  0x04, 0x01, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x02, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3B, 0x00, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x38, 0x60, 0x00, 0x60, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x01,
  0x80, 0x0E, 0x03, 0x00, 0x38, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x70, 0x00, 0xC0,
  0xC0, 0x01, 0x83, 0x80, 0x03, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x36, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0C, 0x01, 0xE0, 0x18,
  0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x83, 0x00,
  0x07, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x70, 0x60, 0x01,
  0xC0, 0xC0, 0x0F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0C, 0x03, 0xE0,
  0x18, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0xE0, 0x00, 0xC1, 0xC0, 0x01, 0x83,
  0x00, 0x03, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x70,
  0x00, 0x70, 0xC0, 0x01, 0xC1, 0x80, 0x07, 0x07, 0x00, 0x7C, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0xF0, 0x06, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xC0, 0x7E, 0x00, 0x60, 0x07, 0x80,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x70, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x30, 0x00, 0x70, 0x18, 0x00, 0xF0, 0x1C,
  0x03, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x02, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x01, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x3C, 0x01, 0xC0, 0x78, 0x00, 0x20,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x0F,
  0xFC, 0xE0, 0x07, 0xFE, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x1C, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x30, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x03,
  0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x38, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x60, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x07, 0x81, 0x80, 0x07, 0x00, 0xC0, 0x07, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x07, 0x00, 0x18, 0x07, 0x00,
  0x0C, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x00, 0x03, 0x07, 0x00,
  0x01, 0x8F, 0x00, 0x00, 0xCF, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3E, 0x60, 0x00, 0x1E, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x01, 0x80, 0x70, 0x00, 0xC0,
  0x18, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x18,
  0x00, 0x60, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x03, 0x60, 0x6C, 0x00, 0x03, 0xF0, 0x37, 0x00, 0x01, 0xB0, 0x1B, 0x80,
  0x01, 0x98, 0x0C, 0xC0, 0x01, 0xCC, 0x0E, 0x60, 0x00, 0xCE, 0x07, 0x30,
  0x00, 0xE7, 0x03, 0x18, 0x00, 0x63, 0x01, 0x8C, 0x00, 0x71, 0x80, 0xC7,
  0x00, 0x30, 0xC0, 0xE1, 0x80, 0x30, 0xE0, 0x70, 0xC0, 0x38, 0x70, 0x30,
  0x60, 0x18, 0x30, 0x18, 0x30, 0x1C, 0x18, 0x0C, 0x18, 0x0C, 0x1C, 0x0E,
  0x0C, 0x0E, 0x0E, 0x06, 0x07, 0x06, 0x06, 0x03, 0x01, 0x86, 0x03, 0x01,
  0x80, 0xC7, 0x01, 0x81, 0xC0, 0x63, 0x01, 0xC0, 0xE0, 0x33, 0x80, 0xE0,
  0x60, 0x19, 0x80, 0x60, 0x30, 0x0F, 0xC0, 0x30, 0x18, 0x03, 0xC0, 0x18,
  0x1C, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x0E, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x03,
  0xE0, 0x00, 0x60, 0x6C, 0x00, 0x0C, 0x0D, 0xC0, 0x03, 0x81, 0x98, 0x00,
  0x70, 0x33, 0x80, 0x0C, 0x0E, 0x30, 0x01, 0x81, 0xC6, 0x00, 0x30, 0x30,
  0xE0, 0x0E, 0x06, 0x0C, 0x01, 0xC0, 0xC1, 0xC0, 0x30, 0x38, 0x18, 0x06,
  0x07, 0x03, 0x00, 0xC0, 0xC0, 0x70, 0x38, 0x18, 0x06, 0x07, 0x03, 0x00,
  0xE0, 0xC0, 0xE0, 0x0C, 0x18, 0x18, 0x01, 0x83, 0x03, 0x00, 0x38, 0xE0,
  0x60, 0x03, 0x18, 0x1C, 0x00, 0x73, 0x03, 0x80, 0x06, 0x60, 0x60, 0x00,
  0xCC, 0x0C, 0x00, 0x1F, 0x81, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x0E,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x06, 0x38, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0C,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x30, 0x1F, 0x00, 0xC0, 0x1E, 0x07, 0x00, 0x38, 0x1C,
  0x00, 0x60, 0x60, 0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x70, 0x01, 0xC1,
  0xC0, 0x1E, 0x06, 0x07, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x06, 0x38, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06,
  0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x30, 0x1F, 0x00, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C,
  0x00, 0x70, 0x60, 0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x70, 0x70, 0x03, 0xC1,
  0xC0, 0x3C, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x60, 0x30, 0x03, 0x80,
  0xC0, 0x0E, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x70,
  0x1C, 0x00, 0xC0, 0x70, 0x03, 0x81, 0x80, 0x0E, 0x06, 0x00, 0x18, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC3, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0xC0, 0xF0, 0x0C, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC1, 0x80, 0x3C, 0x0F, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x38, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x61, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x86,
  0x00, 0x01, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0x98, 0x00, 0x0C, 0x60, 0x00, 0x71, 0x80, 0x01, 0x86, 0x00, 0x0E, 0x18,
  0x00, 0x30, 0x70, 0x01, 0xC1, 0xC0, 0x06, 0x07, 0x00, 0x38, 0x0C, 0x00,
  0xC0, 0x30, 0x07, 0x00, 0xC0, 0x38, 0x03, 0x00, 0xE0, 0x0C, 0x07, 0x00,
  0x30, 0x18, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x00, 0x0E, 0x1C, 0x00, 0x18,
  0x60, 0x00, 0x63, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x70, 0x00, 0x19, 0x80,
  0x00, 0x6E, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0xEC,
  0x00, 0x3C, 0x00, 0x33, 0x00, 0x0F, 0x00, 0x1C, 0xC0, 0x07, 0xC0, 0x06,
  0x30, 0x01, 0xB0, 0x01, 0x8E, 0x00, 0xEC, 0x00, 0xE3, 0x80, 0x33, 0x00,
  0x30, 0xE0, 0x1C, 0xC0, 0x1C, 0x38, 0x06, 0x30, 0x06, 0x0E, 0x01, 0x8E,
  0x03, 0x83, 0x80, 0xC3, 0x80, 0xC0, 0xE0, 0x30, 0xE0, 0x70, 0x18, 0x18,
  0x18, 0x18, 0x06, 0x06, 0x06, 0x0E, 0x01, 0x83, 0x01, 0x83, 0x00, 0x60,
  0xC0, 0x60, 0xC0, 0x18, 0x70, 0x18, 0x70, 0x06, 0x18, 0x06, 0x18, 0x01,
  0x8E, 0x01, 0x8E, 0x00, 0x63, 0x00, 0x63, 0x00, 0x19, 0xC0, 0x19, 0xC0,
  0x06, 0x60, 0x06, 0x60, 0x01, 0xB8, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x1B, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x06, 0x00, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x07, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0x98, 0x00,
  0x38, 0xC0, 0x01, 0x87, 0x00, 0x1C, 0x18, 0x01, 0xC0, 0xC0, 0x0C, 0x06,
  0x00, 0xE0, 0x38, 0x0E, 0x00, 0xC0, 0xE0, 0x06, 0x06, 0x00, 0x38, 0x70,
  0x01, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x33, 0x80, 0x01, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xE0, 0xC1, 0x83, 0x06,
  0x0C, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x70, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x06, 0xC0, 0x00,
  0xCC, 0x00, 0x1C, 0x60, 0x01, 0x86, 0x00, 0x38, 0x60, 0x03, 0x03, 0x00,
  0x60, 0x30, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x1C, 0x01, 0x81, 0x80, 0x0C,
  0x38, 0x00, 0xC3, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00,
  0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0x87, 0x0C, 0x18, 0x30, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0xE3, 0x07, 0xCF, 0x30, 0xF0, 0x33, 0x1C, 0x01,
  0xF1, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00,
  0x0C, 0x60, 0x00, 0xCE, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0,
  0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x0F, 0x86,
  0x01, 0xB0, 0x70, 0x33, 0x03, 0xFE, 0x30, 0x1F, 0xC3, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x38,
  0x01, 0x8F, 0xF0, 0x0C, 0xE3, 0xC0, 0xEC, 0x07, 0x06, 0xC0, 0x18, 0x3C,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E,
  0x30, 0x00, 0x71, 0x80, 0x03, 0x9C, 0x00, 0x18, 0xE0, 0x00, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x1E, 0x00, 0x38, 0xF0, 0x03, 0x86,
  0x80, 0x38, 0x37, 0x03, 0x81, 0x9F, 0xF8, 0x18, 0x7F, 0x80, 0x00, 0x3E,
  0x00, 0xFF, 0xC1, 0xF0, 0xE1, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x40, 0xFF, 0xE0, 0x3F, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0xF0, 0x70, 0x07, 0xF8, 0xE0, 0x3E, 0x39, 0x80, 0xF0, 0x1B,
  0x03, 0x80, 0x16, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x30, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x1C,
  0x00, 0x18, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x07, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x6C, 0x06, 0x01, 0x98, 0x0E, 0x07,
  0x70, 0x0F, 0xF8, 0xC0, 0x0F, 0xE1, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0x80,
  0xF1, 0xE1, 0xE0, 0x70, 0xE0, 0x18, 0xE0, 0x0C, 0xE0, 0x06, 0x60, 0x03,
  0x70, 0x03, 0xB8, 0x07, 0x98, 0x3F, 0x0F, 0xFE, 0x0F, 0xE0, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x60, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xFC, 0x30, 0x3E, 0x39, 0x81, 0xE0, 0x36, 0x0F, 0x00, 0x58, 0x38,
  0x01, 0xE1, 0xC0, 0x07, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0xC3, 0x00, 0x07, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x61, 0xC0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x0F, 0x07, 0x00,
  0x6C, 0x0C, 0x03, 0x70, 0x38, 0x1D, 0x80, 0x7F, 0xC6, 0x00, 0xFE, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x02, 0x00, 0x78, 0x0E, 0x03, 0xC0, 0x3F, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x78, 0x06, 0x3F, 0xE0, 0x67, 0x9F, 0x0E, 0xC0,
  0x70, 0xD8, 0x03, 0x0F, 0x00, 0x30, 0xE0, 0x03, 0x0E, 0x00, 0x31, 0xC0,
  0x03, 0x1C, 0x00, 0x71, 0x80, 0x07, 0x18, 0x00, 0x63, 0x80, 0x06, 0x38,
  0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xE3, 0x00, 0x0C, 0x70, 0x00, 0xC7,
  0x00, 0x0C, 0x60, 0x01, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0x8E, 0x00, 0x18,
  0x01, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x01, 0x06, 0x00,
  0xE0, 0x60, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x0C, 0x0E, 0x00, 0xC1,
  0xC0, 0x0C, 0x38, 0x01, 0xC7, 0x00, 0x18, 0xE0, 0x01, 0x9C, 0x00, 0x1B,
  0xE0, 0x03, 0xF6, 0x00, 0x3C, 0x70, 0x03, 0x83, 0x00, 0x30, 0x38, 0x03,
  0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x0E, 0x06, 0x00, 0xE0,
  0x60, 0x07, 0x0E, 0x00, 0x70, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18,
  0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C,
  0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E,
  0x06, 0x03, 0x01, 0x81, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x03, 0x1F, 0xE0,
  0xFF, 0x01, 0x9C, 0x70, 0xE3, 0xC1, 0xD8, 0x1C, 0xC0, 0x60, 0xD8, 0x06,
  0xC0, 0x38, 0x78, 0x03, 0xC0, 0x1C, 0x38, 0x01, 0xE0, 0x0E, 0x1C, 0x00,
  0xE0, 0x07, 0x1C, 0x00, 0x60, 0x03, 0x0E, 0x00, 0x70, 0x01, 0x86, 0x00,
  0x38, 0x00, 0xC3, 0x00, 0x18, 0x00, 0xE3, 0x80, 0x0C, 0x00, 0x61, 0xC0,
  0x06, 0x00, 0x30, 0xC0, 0x07, 0x00, 0x18, 0x60, 0x03, 0x80, 0x1C, 0x30,
  0x01, 0x80, 0x0E, 0x38, 0x00, 0xC0, 0x06, 0x1C, 0x00, 0xE0, 0x03, 0x0C,
  0x00, 0x70, 0x01, 0x86, 0x00, 0x30, 0x01, 0xC3, 0x00, 0x18, 0x00, 0xE3,
  0x80, 0x0C, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x63, 0xFE, 0x06, 0x79, 0xF0,
  0xEE, 0x07, 0x0D, 0x80, 0x30, 0xF0, 0x03, 0x0E, 0x00, 0x31, 0xE0, 0x03,
  0x1C, 0x00, 0x31, 0xC0, 0x07, 0x18, 0x00, 0x71, 0x80, 0x06, 0x38, 0x00,
  0x63, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x30, 0x00, 0xC7, 0x00,
  0x0C, 0x70, 0x01, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0xCE, 0x00, 0x18, 0xE0,
  0x03, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x07, 0xC7, 0x80, 0xF0, 0x1C,
  0x1C, 0x00, 0xE1, 0x80, 0x06, 0x38, 0x00, 0x63, 0x00, 0x06, 0x70, 0x00,
  0x76, 0x00, 0x07, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x18, 0x60,
  0x03, 0x87, 0x00, 0x70, 0x38, 0x0E, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x03, 0x1F, 0xE0, 0x06, 0x71, 0xE0, 0x1D, 0x80, 0xE0,
  0x36, 0x00, 0xC0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x70, 0xE0,
  0x00, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x38, 0x3C, 0x00, 0x70, 0x78, 0x01, 0xC0, 0xD0, 0x07, 0x01, 0xB8, 0x1E,
  0x03, 0x3F, 0xF0, 0x0E, 0x3F, 0xC0, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0xF0, 0xC1, 0xF1, 0xCC, 0x1E, 0x03, 0x61, 0xE0, 0x0B,
  0x0E, 0x00, 0x78, 0xE0, 0x03, 0xC6, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80,
  0x07, 0x18, 0x00, 0x39, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x70, 0x00, 0xE3,
  0x80, 0x07, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x03,
  0x60, 0xC0, 0x37, 0x07, 0x03, 0xB8, 0x1F, 0xF1, 0x80, 0x7F, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x06, 0x3F, 0x06, 0x7B, 0x0E, 0xC0, 0x0D, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0xC3, 0xE3, 0xE1, 0xC0, 0x11, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x8C, 0x01, 0xC7, 0xFF, 0xC0, 0xFF,
  0x80, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x07, 0xFF,
  0xDF, 0xFE, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0C,
  0x00, 0x31, 0xC0, 0x03, 0x1C, 0x00, 0x71, 0x80, 0x07, 0x18, 0x00, 0x63,
  0x80, 0x06, 0x38, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xE3, 0x00, 0x0C,
  0x70, 0x00, 0xC7, 0x00, 0x1C, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x03,
  0x8E, 0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0xF8, 0xE0, 0x1B, 0x07, 0x03,
  0x30, 0x7F, 0xE3, 0x03, 0xFC, 0x30, 0xE0, 0x01, 0xF8, 0x00, 0x6E, 0x00,
  0x39, 0x80, 0x0C, 0x60, 0x07, 0x18, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x70,
  0x70, 0x1C, 0x1C, 0x0E, 0x03, 0x03, 0x00, 0xC1, 0xC0, 0x30, 0x60, 0x0C,
  0x38, 0x03, 0x0C, 0x00, 0xC7, 0x00, 0x39, 0x80, 0x0E, 0xC0, 0x01, 0xB0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x7E,
  0x00, 0xF0, 0x06, 0xE0, 0x0F, 0x00, 0xE6, 0x01, 0xB0, 0x0E, 0x60, 0x1B,
  0x00, 0xC6, 0x03, 0x30, 0x1C, 0x60, 0x33, 0x01, 0x86, 0x06, 0x30, 0x38,
  0x60, 0x63, 0x03, 0x06, 0x0C, 0x30, 0x70, 0x60, 0xC3, 0x06, 0x06, 0x18,
  0x30, 0xE0, 0x61, 0x83, 0x8C, 0x06, 0x30, 0x39, 0xC0, 0x63, 0x03, 0x98,
  0x06, 0x60, 0x1B, 0x80, 0x66, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x3C, 0x1C, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0xE0, 0x70,
  0x01, 0x81, 0x80, 0x07, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x33, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0x60, 0x00, 0x39, 0xC0, 0x01, 0xC3, 0x00, 0x0E, 0x0E, 0x00,
  0x70, 0x18, 0x01, 0x80, 0x70, 0x0C, 0x00, 0xC0, 0x70, 0x03, 0x83, 0x80,
  0x06, 0x00, 0x03, 0x80, 0x07, 0x03, 0x80, 0x06, 0x01, 0x80, 0x0E, 0x01,
  0x80, 0x0C, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x01,
  0xC0, 0x30, 0x01, 0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0xC0, 0x00,
  0xC1, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xE3, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x01,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x17, 0xFE, 0x03, 0xE0,
  0xFF, 0xE8, 0x03, 0xFC,
};

const GFXglyph NotoSans_LightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 30, 10, 1, -30 },
  { 35, 11, 11, 15, 5, -30 },
  { 51, 26, 30, 26, 1, -30 },
  { 149, 20, 34, 23, 2, -32 },
  { 234, 28, 30, 33, 3, -30 },
  { 339, 25, 30, 28, 2, -30 },
  { 433, 4, 11, 8, 5, -30 },
  { 439, 12, 37, 11, 2, -30 },
  { 495, 13, 37, 11, -3, -30 },
  { 556, 18, 19, 23, 5, -32 },
  { 599, 20, 20, 24, 3, -25 },
  { 649, 7, 10, 9, -2, -5 },
  { 658, 11, 2, 13, 1, -12 },
  { 661, 4, 4, 10, 1, -4 },
  { 663, 20, 30, 14, -2, -30 },
  { 738, 19, 30, 23, 3, -30 },
  { 810, 11, 30, 23, 7, -30 },
  { 852, 22, 30, 23, 0, -30 },
  { 935, 21, 30, 23, 1, -30 },
  { 1014, 22, 30, 23, 0, -30 },
  { 1097, 21, 30, 23, 2, -30 },
  { 1176, 20, 30, 23, 3, -30 },
  { 1251, 20, 30, 23, 4, -30 },
  { 1326, 21, 30, 23, 2, -30 },
  { 1405, 20, 30, 23, 2, -30 },
  { 1480, 8, 23, 10, 1, -23 },
  { 1503, 11, 28, 10, -2, -23 },
  { 1542, 20, 20, 24, 3, -25 },
  { 1592, 19, 10, 24, 3, -20 },
  { 1616, 20, 20, 24, 3, -25 },
  { 1666, 15, 30, 18, 3, -30 },
  { 1723, 32, 34, 35, 2, -30 },
  { 1859, 23, 30, 23, -2, -30 },
  { 1946, 23, 30, 25, 2, -30 },
  { 2033, 24, 30, 25, 3, -30 },
  { 2123, 25, 30, 28, 2, -30 },
  { 2217, 21, 30, 22, 2, -30 },
  { 2296, 21, 30, 20, 2, -30 },
  { 2375, 25, 30, 29, 3, -30 },
  { 2469, 27, 30, 29, 2, -30 },
  { 2571, 15, 30, 13, 0, -30 },
  { 2628, 18, 38, 11, -7, -30 },
  { 2714, 25, 30, 23, 2, -30 },
  { 2808, 15, 30, 20, 2, -30 },
  { 2865, 33, 30, 35, 2, -30 },
  { 2989, 27, 30, 29, 2, -30 },
  { 3091, 26, 30, 30, 3, -30 },
  { 3189, 22, 30, 24, 2, -30 },
  { 3272, 26, 37, 30, 3, -30 },
  { 3393, 22, 30, 24, 2, -30 },
  { 3476, 21, 30, 21, 1, -30 },
  { 3555, 20, 30, 21, 4, -30 },
  { 3630, 25, 30, 29, 4, -30 },
  { 3724, 22, 30, 23, 4, -30 },
  { 3807, 34, 30, 35, 5, -30 },
  { 3935, 27, 30, 21, -2, -30 },
  { 4037, 21, 30, 21, 4, -30 },
  { 4116, 24, 30, 22, 0, -30 },
  { 4206, 16, 37, 12, 0, -30 },
  { 4280, 7, 30, 14, 4, -30 },
  { 4307, 16, 37, 12, -3, -30 },
  { 4381, 20, 19, 24, 2, -30 },
  { 4429, 17, 2, 16, -4, 4 },
  { 4434, 6, 7, 11, 6, -32 },
  { 4440, 20, 23, 23, 2, -23 },
  { 4498, 21, 32, 24, 1, -32 },
  { 4582, 17, 23, 19, 2, -23 },
  { 4631, 23, 32, 24, 2, -32 },
  { 4723, 17, 23, 21, 2, -23 },
  { 4772, 23, 42, 12, -5, -32 },
  { 4893, 22, 33, 24, 1, -23 },
  { 4984, 20, 32, 24, 1, -32 },
  { 5064, 9, 31, 10, 1, -31 },
  { 5099, 16, 41, 10, -6, -31 },
  { 5181, 20, 32, 20, 1, -32 },
  { 5261, 9, 32, 10, 1, -32 },
  { 5297, 33, 23, 36, 1, -23 },
  { 5392, 20, 23, 24, 1, -23 },
  { 5450, 20, 23, 24, 2, -23 },
  { 5508, 23, 33, 24, -1, -23 },
  { 5603, 21, 33, 24, 2, -23 },
  { 5690, 16, 23, 16, 1, -23 },
  { 5736, 17, 23, 18, 0, -23 },
  { 5785, 13, 28, 13, 2, -28 },
  { 5831, 20, 22, 24, 2, -22 },
  { 5886, 18, 22, 18, 2, -22 },
  { 5936, 28, 22, 29, 2, -22 },
  { 6013, 22, 22, 20, -1, -22 },
  { 6074, 24, 32, 18, -4, -22 },
  { 6170, 19, 22, 19, -1, -22 },
  { 6223, 15, 37, 14, 1, -30 },
  { 6293, 2, 42, 23, 11, -32 },
  { 6304, 16, 37, 14, -2, -30 },
  { 6378, 20, 4, 24, 3, -17 },
};

const GFXfont NotoSans_LightItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_LIGHTITALIC42PT7B_H_
