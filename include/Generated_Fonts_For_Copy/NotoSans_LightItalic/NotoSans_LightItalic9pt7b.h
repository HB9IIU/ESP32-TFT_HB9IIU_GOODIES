#ifndef _NOTOSANS_LIGHTITALIC9PT7B_H_
#define _NOTOSANS_LIGHTITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xF0, 0x29, 0xF2, 0xBE, 0x51, 0x40, 0x13, 0xD8, 0x43,
  0x1B, 0x88, 0x42, 0xAB, 0x3A, 0xB5, 0x59, 0x80, 0x10, 0xA2, 0x8C, 0xD6,
  0x27, 0x80, 0xC0, 0x2A, 0x49, 0x20, 0x24, 0x92, 0x70, 0x2A, 0x5A, 0x4F,
  0x44, 0xC0, 0xE0, 0x80, 0x32, 0x44, 0x88, 0x69, 0x99, 0x9A, 0xE0, 0xE5,
  0x24, 0x80, 0x32, 0x42, 0x22, 0x23, 0xC0, 0x32, 0x42, 0x61, 0x0B, 0xC0,
  0x19, 0x95, 0x27, 0x88, 0x7A, 0x1C, 0x11, 0x78, 0x34, 0x8E, 0x99, 0xE0,
  0xF2, 0x24, 0x48, 0x32, 0x52, 0x65, 0x45, 0xC0, 0x32, 0x52, 0x93, 0x8B,
  0x80, 0x40, 0x80, 0x40, 0xA0, 0x78, 0x43, 0xFF, 0xC3, 0x68, 0xC4, 0xA8,
  0x20, 0x3E, 0xB6, 0x9D, 0x5B, 0xE8, 0x0E, 0x00, 0x11, 0x94, 0xE8, 0xC4,
  0x7A, 0x5C, 0x98, 0xF8, 0x3A, 0x21, 0x08, 0x43, 0xC0, 0x79, 0x14, 0x51,
  0x8B, 0xC0, 0x7A, 0x1C, 0x88, 0x78, 0x7A, 0x1C, 0x88, 0x40, 0x3A, 0x21,
  0x2A, 0xCB, 0xC0, 0x45, 0x17, 0xD1, 0x8A, 0x20, 0x69, 0x25, 0x80, 0x24,
  0x94, 0x94, 0x4D, 0x46, 0x14, 0x92, 0x40, 0x44, 0x44, 0x8F, 0x22, 0xCD,
  0x9B, 0x5A, 0xB2, 0x80, 0x25, 0x95, 0x55, 0x9A, 0x20, 0x32, 0x63, 0x18,
  0xC7, 0xC0, 0x7A, 0x52, 0xE8, 0x40, 0x32, 0x63, 0x18, 0xC7, 0x44, 0x10,
  0x7A, 0x52, 0xE9, 0x48, 0x3A, 0x10, 0x41, 0x0B, 0x80, 0xF4, 0x44, 0x48,
  0x8C, 0x63, 0x19, 0x70, 0x9C, 0xA9, 0x4C, 0x20, 0x93, 0x66, 0xD6, 0xAD,
  0x91, 0x00, 0x24, 0x61, 0x0C, 0x4B, 0x20, 0x9A, 0xC4, 0x48, 0x78, 0x88,
  0x84, 0x78, 0x69, 0x49, 0x30, 0xFC, 0x31, 0x22, 0x22, 0xE0, 0x22, 0x93,
  0x10, 0xF0, 0x90, 0x3A, 0x63, 0x27, 0x00, 0x42, 0x1C, 0x94, 0xC7, 0xC0,
  0x34, 0x88, 0x70, 0x08, 0x4E, 0x98, 0xC9, 0xC0, 0x35, 0x68, 0x70, 0x19,
  0x1C, 0x42, 0x21, 0x08, 0xC0, 0x3A, 0x63, 0x27, 0x0B, 0x80, 0x42, 0x1C,
  0x94, 0xCA, 0x40, 0x45, 0x68, 0x20, 0x92, 0x92, 0xC0, 0x42, 0x16, 0xC4,
  0x52, 0x40, 0x55, 0x68, 0x76, 0x95, 0x4C, 0x99, 0x20, 0x72, 0x53, 0x29,
  0x00, 0x32, 0x63, 0x17, 0x00, 0x72, 0x53, 0x1F, 0x42, 0x00, 0x3A, 0x63,
  0x27, 0x08, 0x40, 0x74, 0x48, 0x80, 0x78, 0x42, 0xE0, 0x5D, 0x29, 0x80,
  0x4A, 0x63, 0x2F, 0x00, 0x99, 0xA6, 0x40, 0x96, 0x5B, 0x72, 0x48, 0x56,
  0x26, 0x90, 0x4A, 0x4C, 0x62, 0x13, 0x00, 0x72, 0x44, 0xE0, 0x34, 0x48,
  0x44, 0xC0, 0xFF, 0x80, 0x65, 0x14, 0xA0, 0xF0,
};

const GFXglyph NotoSans_LightItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 6, 6, 6, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 6, 7, 7, 1, -7 },
  { 20, 6, 7, 6, 0, -7 },
  { 26, 1, 2, 2, 1, -6 },
  { 27, 3, 7, 2, 0, -6 },
  { 30, 3, 7, 2, -1, -6 },
  { 33, 4, 4, 5, 1, -7 },
  { 35, 4, 4, 5, 1, -5 },
  { 37, 1, 2, 2, 0, -1 },
  { 38, 3, 1, 3, 0, -3 },
  { 39, 1, 1, 2, 0, -1 },
  { 40, 4, 6, 3, 0, -6 },
  { 43, 4, 7, 5, 1, -7 },
  { 47, 3, 6, 5, 1, -6 },
  { 50, 5, 7, 5, 0, -7 },
  { 55, 5, 7, 5, 0, -7 },
  { 60, 5, 6, 5, 0, -6 },
  { 64, 5, 6, 5, 0, -6 },
  { 68, 4, 7, 5, 1, -7 },
  { 72, 4, 6, 5, 1, -6 },
  { 75, 5, 7, 5, 0, -7 },
  { 80, 5, 7, 5, 0, -7 },
  { 85, 2, 5, 2, 0, -5 },
  { 87, 2, 6, 2, 0, -5 },
  { 89, 4, 4, 5, 1, -5 },
  { 91, 4, 2, 5, 1, -4 },
  { 92, 4, 4, 5, 1, -5 },
  { 94, 3, 7, 4, 1, -7 },
  { 97, 7, 7, 8, 0, -6 },
  { 104, 5, 6, 5, 0, -6 },
  { 108, 5, 6, 5, 0, -6 },
  { 112, 5, 7, 5, 1, -7 },
  { 117, 6, 6, 6, 0, -6 },
  { 122, 5, 6, 5, 0, -6 },
  { 126, 5, 6, 4, 0, -6 },
  { 130, 5, 7, 6, 1, -7 },
  { 135, 6, 6, 6, 0, -6 },
  { 140, 3, 6, 3, 0, -6 },
  { 143, 3, 8, 2, -1, -6 },
  { 146, 6, 6, 5, 0, -6 },
  { 151, 4, 6, 4, 0, -6 },
  { 154, 7, 6, 7, 0, -6 },
  { 160, 6, 6, 6, 0, -6 },
  { 165, 5, 7, 6, 1, -7 },
  { 170, 5, 6, 5, 0, -6 },
  { 174, 5, 9, 6, 1, -7 },
  { 180, 5, 6, 5, 0, -6 },
  { 184, 5, 7, 5, 0, -7 },
  { 189, 4, 6, 4, 1, -6 },
  { 192, 5, 6, 6, 1, -6 },
  { 196, 5, 6, 5, 1, -6 },
  { 200, 7, 6, 8, 1, -6 },
  { 206, 6, 6, 5, -1, -6 },
  { 211, 4, 6, 4, 1, -6 },
  { 214, 5, 6, 5, 0, -6 },
  { 218, 3, 7, 3, 0, -6 },
  { 221, 1, 6, 3, 1, -6 },
  { 222, 4, 7, 3, -1, -6 },
  { 226, 5, 4, 5, 0, -6 },
  { 229, 4, 1, 3, -1, 1 },
  { 230, 2, 2, 2, 1, -7 },
  { 231, 5, 5, 5, 0, -5 },
  { 235, 5, 7, 5, 0, -7 },
  { 240, 4, 5, 4, 0, -5 },
  { 243, 5, 7, 5, 0, -7 },
  { 248, 4, 5, 4, 0, -5 },
  { 251, 5, 9, 3, -1, -7 },
  { 257, 5, 7, 5, 0, -5 },
  { 262, 5, 7, 5, 0, -7 },
  { 267, 2, 7, 2, 0, -7 },
  { 269, 3, 9, 2, -1, -7 },
  { 273, 5, 7, 4, 0, -7 },
  { 278, 2, 7, 2, 0, -7 },
  { 280, 7, 5, 8, 0, -5 },
  { 285, 5, 5, 5, 0, -5 },
  { 289, 5, 5, 5, 0, -5 },
  { 293, 5, 7, 5, 0, -5 },
  { 298, 5, 7, 5, 0, -5 },
  { 303, 4, 5, 3, 0, -5 },
  { 306, 4, 5, 4, 0, -5 },
  { 309, 3, 6, 3, 0, -6 },
  { 312, 5, 5, 5, 0, -5 },
  { 316, 4, 5, 4, 0, -5 },
  { 319, 6, 5, 6, 0, -5 },
  { 323, 4, 5, 4, 0, -5 },
  { 326, 5, 7, 4, -1, -5 },
  { 331, 4, 5, 4, 0, -5 },
  { 334, 4, 7, 3, 0, -6 },
  { 338, 1, 9, 5, 2, -7 },
  { 340, 3, 7, 3, 0, -6 },
  { 343, 4, 1, 5, 1, -4 },
};

const GFXfont NotoSans_LightItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_LIGHTITALIC9PT7B_H_
