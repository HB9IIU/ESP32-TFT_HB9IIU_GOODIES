#ifndef _NOTOSANS_LIGHTITALIC32PT7B_H_
#define _NOTOSANS_LIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0x83,
  0x06, 0x0C, 0x10, 0x60, 0x00, 0x00, 0x04, 0x1C, 0x30, 0x00, 0x63, 0x63,
  0xC6, 0xC6, 0xC6, 0x84, 0x84, 0x8C, 0x00, 0x40, 0x80, 0x18, 0x30, 0x03,
  0x06, 0x00, 0x40, 0x80, 0x08, 0x30, 0x03, 0x06, 0x00, 0x60, 0x81, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0x60, 0x80, 0x08, 0x10, 0x01, 0x06, 0x00, 0x60,
  0xC0, 0x0C, 0x10, 0x01, 0x02, 0x17, 0xFF, 0xFC, 0x0C, 0x18, 0x01, 0x02,
  0x00, 0x20, 0xC0, 0x0C, 0x18, 0x01, 0x82, 0x00, 0x20, 0xC0, 0x0C, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x70, 0x03, 0xFF, 0x0E, 0x66, 0x0C,
  0x60, 0x18, 0x40, 0x18, 0x40, 0x18, 0xC0, 0x18, 0xC0, 0x0C, 0x80, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0x98, 0x01, 0x0C, 0x01, 0x0C, 0x01,
  0x0C, 0x03, 0x18, 0x03, 0x18, 0xE2, 0x70, 0x7F, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x1F, 0x00, 0x63, 0x38, 0x04, 0x61, 0x80,
  0xC6, 0x18, 0x18, 0x40, 0x83, 0x0C, 0x18, 0x20, 0xC1, 0x86, 0x08, 0x18,
  0xC0, 0x81, 0x18, 0x08, 0x31, 0x1E, 0x83, 0x33, 0xFC, 0x66, 0x63, 0xCE,
  0x4C, 0x17, 0x8C, 0xC1, 0x01, 0x88, 0x10, 0x31, 0x81, 0x02, 0x18, 0x30,
  0x61, 0x83, 0x0C, 0x18, 0x31, 0x81, 0x86, 0x10, 0x18, 0x63, 0x01, 0x8C,
  0x60, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1C, 0xE0, 0x03, 0x06, 0x00, 0x60,
  0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x03,
  0x18, 0x00, 0x37, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x1C, 0xC0, 0x33,
  0x06, 0x06, 0x60, 0x30, 0x46, 0x01, 0x8C, 0xC0, 0x19, 0x8C, 0x00, 0xF0,
  0xC0, 0x07, 0x0C, 0x00, 0xF0, 0x60, 0x1B, 0x07, 0x8F, 0x18, 0x1F, 0xC0,
  0xC0, 0x6F, 0x6D, 0x24, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18,
  0x02, 0x00, 0xC0, 0x02, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80,
  0xC0, 0x40, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x18, 0x00, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x30, 0xC0, 0xE3, 0x00, 0xE8, 0x00, 0xFF, 0xC1,
  0x80, 0x0B, 0x00, 0xE4, 0x07, 0x18, 0x18, 0x60, 0x40, 0xC0, 0x02, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x7F, 0xFF, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x19, 0xCC, 0x66, 0x33, 0x10, 0xFF, 0x5F,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0x78, 0x30, 0x30,
  0xC0, 0x31, 0x80, 0x66, 0x00, 0xCC, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0,
  0x0D, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x58, 0x01, 0xB0, 0x03, 0x60, 0x06,
  0xC0, 0x19, 0x80, 0x33, 0x00, 0xC6, 0x01, 0x86, 0x06, 0x0F, 0x38, 0x07,
  0xE0, 0x00, 0x03, 0x83, 0x87, 0xC7, 0x6E, 0x36, 0x10, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x03, 0x01, 0x80, 0xC0, 0x00, 0xFC, 0x01, 0xEF, 0x01, 0x80, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0xFF, 0xE3, 0xFF, 0xF0, 0x03, 0xF8, 0x0F, 0x9E, 0x1C, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x80, 0x38, 0xF1,
  0xF0, 0x7F, 0xC0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x60,
  0x01, 0xB0, 0x01, 0x90, 0x01, 0x98, 0x01, 0x8C, 0x01, 0x86, 0x01, 0x83,
  0x01, 0x81, 0x01, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0xC0, 0x20, 0xC0,
  0x30, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x03, 0xFF, 0x07, 0xFF, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x1F, 0xE0,
  0x1F, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x80, 0x38, 0xF1, 0xF0,
  0x7F, 0xC0, 0x00, 0x7E, 0x03, 0xC4, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xCF, 0xC1, 0xB9, 0xE3, 0x80,
  0xCE, 0x00, 0xDC, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x13,
  0x00, 0x63, 0x01, 0xC6, 0x03, 0x07, 0x1C, 0x07, 0xE0, 0x00, 0x7F, 0xFE,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFC, 0x03, 0x9E, 0x06, 0x07,
  0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x06, 0x06, 0x0E,
  0x03, 0x18, 0x01, 0xF0, 0x07, 0xE0, 0x1E, 0x30, 0x38, 0x18, 0x70, 0x0C,
  0x60, 0x0C, 0x40, 0x04, 0xC0, 0x0C, 0x40, 0x0C, 0x60, 0x0C, 0x60, 0x18,
  0x38, 0x70, 0x1F, 0xE0, 0x01, 0xF8, 0x07, 0xBC, 0x0E, 0x06, 0x18, 0x06,
  0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x07,
  0x30, 0x06, 0x18, 0x0E, 0x1C, 0x36, 0x0F, 0xE6, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0xE0, 0xC3, 0xC0,
  0xFF, 0x00, 0x1C, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x38, 0xC0, 0x03, 0x81, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x60, 0x30, 0x18, 0x18, 0x08,
  0x0C, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x80, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x20, 0x00, 0x00, 0x3F, 0x9F, 0x79, 0x03, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x03, 0x30, 0x3F, 0xC3,
  0x60, 0x60, 0xC3, 0x40, 0xC0, 0x83, 0xC1, 0x81, 0x83, 0xC1, 0x01, 0x83,
  0xC3, 0x01, 0x83, 0x83, 0x01, 0x03, 0x82, 0x03, 0x02, 0x82, 0x03, 0x06,
  0x83, 0x07, 0x0C, 0xC3, 0x0D, 0x1C, 0xC1, 0xF9, 0xF8, 0xC0, 0x60, 0xC0,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x80,
  0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0x8C,
  0x00, 0xC3, 0x00, 0x30, 0x40, 0x18, 0x10, 0x06, 0x06, 0x03, 0x01, 0x80,
  0xFF, 0xE0, 0x7F, 0xF8, 0x18, 0x06, 0x0C, 0x01, 0x86, 0x00, 0x21, 0x80,
  0x0C, 0xC0, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x0C, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x60, 0x38, 0x10, 0x07, 0x0C, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x06, 0x08, 0x01, 0x86, 0x01, 0xC1, 0xFF, 0xC0, 0x7F,
  0xE0, 0x18, 0x0E, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03,
  0x08, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x18, 0x60, 0x0C, 0x1F, 0xFE, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x78, 0x04, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0xCF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x18,
  0x0E, 0x02, 0x00, 0xE0, 0xC0, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60,
  0x03, 0x08, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80,
  0x06, 0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0xC4, 0x00,
  0x31, 0x80, 0x0C, 0x30, 0x07, 0x06, 0x01, 0xC0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1E, 0x00, 0x87, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x0F, 0xE6, 0x03, 0xFC, 0x80, 0x01,
  0xB0, 0x00, 0x62, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x04,
  0x18, 0x01, 0x83, 0x80, 0x30, 0x3E, 0x3E, 0x01, 0xFF, 0x00, 0x06, 0x00,
  0x18, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x06,
  0x00, 0x18, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x60, 0xC0, 0x03,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x10, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x00, 0x07,
  0xE1, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x60, 0x3F, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x06, 0x00, 0x60, 0xC0, 0x18,
  0x18, 0x06, 0x02, 0x01, 0x80, 0xC0, 0xE0, 0x18, 0x38, 0x03, 0x0E, 0x00,
  0x63, 0x80, 0x08, 0xE0, 0x03, 0x30, 0x00, 0x6E, 0x00, 0x0F, 0x60, 0x01,
  0xCC, 0x00, 0x70, 0xC0, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x30, 0x30, 0x04,
  0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0x40, 0x01, 0xE0, 0xA0,
  0x00, 0xB0, 0xD8, 0x00, 0xD0, 0x6C, 0x00, 0xD8, 0x36, 0x00, 0x6C, 0x1B,
  0x00, 0x66, 0x18, 0x80, 0x23, 0x0C, 0x40, 0x31, 0x06, 0x20, 0x11, 0x83,
  0x18, 0x18, 0xC1, 0x0C, 0x18, 0x61, 0x86, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0x60, 0x84, 0x18, 0x30, 0x46, 0x0C, 0x10, 0x32, 0x06, 0x18, 0x1B, 0x02,
  0x0C, 0x0F, 0x03, 0x06, 0x07, 0x81, 0x83, 0x03, 0x80, 0xC3, 0x00, 0x80,
  0x60, 0x06, 0x00, 0x18, 0x38, 0x00, 0xC1, 0xC0, 0x06, 0x0A, 0x00, 0x20,
  0xD8, 0x03, 0x06, 0xC0, 0x18, 0x33, 0x00, 0xC1, 0x98, 0x06, 0x18, 0x40,
  0x20, 0xC3, 0x03, 0x06, 0x18, 0x18, 0x30, 0x60, 0xC1, 0x03, 0x06, 0x18,
  0x08, 0x60, 0xC0, 0x63, 0x06, 0x03, 0x18, 0x30, 0x0C, 0xC1, 0x00, 0x64,
  0x18, 0x01, 0x60, 0xC0, 0x0F, 0x06, 0x00, 0x78, 0x30, 0x01, 0xC3, 0x00,
  0x0C, 0x00, 0x00, 0xFE, 0x00, 0x3E, 0xF8, 0x07, 0x01, 0xC0, 0xC0, 0x0E,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x7C, 0x00,
  0x06, 0xC0, 0x00, 0x64, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60,
  0x01, 0x83, 0x00, 0x38, 0x38, 0x07, 0x01, 0xF3, 0xE0, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x03, 0xFF, 0x01, 0x81, 0xC0, 0x80, 0x70, 0xC0, 0x18, 0x60,
  0x0C, 0x30, 0x06, 0x18, 0x03, 0x08, 0x01, 0x8C, 0x01, 0x86, 0x01, 0xC3,
  0x03, 0xC1, 0xFF, 0x81, 0xFE, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x3E, 0xF8, 0x07, 0x01, 0xC0, 0xC0, 0x0E, 0x18,
  0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x7C, 0x00, 0x06,
  0xC0, 0x00, 0x64, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01,
  0x83, 0x00, 0x38, 0x38, 0x07, 0x01, 0xF3, 0xE0, 0x07, 0xF8, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x07,
  0xF8, 0x03, 0xFF, 0x01, 0x81, 0xC0, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C,
  0x30, 0x06, 0x18, 0x03, 0x08, 0x01, 0x8C, 0x01, 0x86, 0x01, 0x83, 0x0F,
  0x81, 0xFF, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x0C, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x18,
  0x03, 0xFC, 0x0F, 0xFC, 0x30, 0x08, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC8, 0x07, 0x1E, 0x7C, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x40,
  0x01, 0x98, 0x00, 0x23, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x00,
  0x06, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x20, 0x00, 0xCC, 0x00,
  0x11, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x06, 0x0E, 0x01, 0xC0, 0xF9, 0xE0, 0x07, 0xF8,
  0x00, 0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x00, 0xC8, 0x00, 0xC4, 0x00, 0x63,
  0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x18, 0x18, 0x0C,
  0x04, 0x0C, 0x02, 0x0C, 0x01, 0x86, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0xC0, 0x18, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xD8,
  0x07, 0x80, 0x6C, 0x02, 0xC0, 0x66, 0x03, 0x60, 0x33, 0x01, 0x30, 0x11,
  0x81, 0x98, 0x18, 0xC0, 0x8C, 0x0C, 0x60, 0xC6, 0x0C, 0x30, 0x43, 0x06,
  0x18, 0x61, 0x86, 0x0C, 0x30, 0x43, 0x06, 0x30, 0x23, 0x03, 0x18, 0x11,
  0x81, 0x98, 0x08, 0x80, 0xCC, 0x04, 0xC0, 0x2C, 0x02, 0x40, 0x16, 0x01,
  0x60, 0x0A, 0x00, 0xB0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x18, 0x00, 0x03, 0x00, 0x38, 0x18, 0x01, 0x80, 0x40, 0x18, 0x03, 0x01,
  0x80, 0x18, 0x18, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00,
  0x6C, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x6C, 0x00, 0x06, 0x60, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00, 0x30,
  0x20, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x30, 0x38, 0x01, 0x83,
  0x80, 0x0C, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x0C, 0x60, 0x1C, 0x60,
  0x18, 0x20, 0x30, 0x30, 0x60, 0x30, 0x60, 0x30, 0xC0, 0x11, 0x80, 0x19,
  0x80, 0x1B, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x03, 0xF0, 0x7F, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xFC, 0x0F, 0xC0, 0xC1,
  0x04, 0x18, 0x61, 0x86, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0x41, 0x04, 0x18,
  0x61, 0x86, 0x08, 0x20, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0xFC, 0x0F, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x01, 0xA0, 0x01, 0x20, 0x03, 0x30, 0x02, 0x10, 0x06,
  0x18, 0x0C, 0x18, 0x0C, 0x08, 0x18, 0x0C, 0x10, 0x04, 0x30, 0x06, 0x60,
  0x06, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xCC, 0x66, 0x31, 0x07, 0xE6,
  0x3C, 0x6C, 0xE0, 0x51, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0xB0, 0x03, 0x60,
  0x04, 0xC0, 0x19, 0x80, 0x32, 0x00, 0x64, 0x01, 0xCC, 0x03, 0x18, 0x0E,
  0x30, 0x2C, 0x31, 0x98, 0x3E, 0x20, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0xFC, 0x1B, 0x8E,
  0x1E, 0x06, 0x1C, 0x06, 0x18, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x02, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x70, 0x1C,
  0xD0, 0x38, 0xDC, 0x70, 0xCF, 0xC0, 0x07, 0xF8, 0xF0, 0x8E, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0F, 0x18, 0x3F, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x0F, 0xCC, 0x1E, 0x36, 0x1C, 0x0F, 0x0C, 0x03, 0x8C, 0x01, 0x86,
  0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x18, 0x40, 0x0C,
  0x20, 0x0E, 0x18, 0x07, 0x0C, 0x05, 0x06, 0x06, 0x81, 0xCE, 0xC0, 0x7C,
  0x60, 0x07, 0xE0, 0x71, 0x86, 0x06, 0x60, 0x36, 0x01, 0xB0, 0x1B, 0x01,
  0xD9, 0xF8, 0xFF, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0F, 0x1C, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x06, 0x10, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0F, 0xF8, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x0F, 0x80, 0x01, 0xC0, 0x00, 0x03, 0xF1, 0x0F, 0x1B, 0x1C, 0x0F, 0x18,
  0x07, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x0C, 0x40, 0x0C, 0x40, 0x1C, 0x60, 0x1C, 0x60, 0x28, 0x60, 0x78, 0x39,
  0xD8, 0x1F, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x80, 0xC0, 0xFF, 0x80, 0x3E, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x7E, 0x1B, 0x8E,
  0x34, 0x0C, 0x70, 0x18, 0xC0, 0x33, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x20, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0x98, 0x03,
  0x30, 0x06, 0x60, 0x0C, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x18,
  0x30, 0x41, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x0F, 0x80, 0xE0, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x07, 0x18, 0x18, 0x30, 0x60, 0x61, 0x80, 0x86, 0x03, 0x18,
  0x06, 0x60, 0x0D, 0xC0, 0x17, 0x80, 0x39, 0x80, 0xE3, 0x01, 0x82, 0x03,
  0x06, 0x06, 0x0C, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x18, 0x06, 0x0C, 0x10,
  0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x20,
  0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0x18, 0xF8, 0x3E, 0x0D, 0xCE, 0x73,
  0x87, 0x83, 0x60, 0xC2, 0x80, 0xA0, 0x31, 0x80, 0x60, 0x19, 0xC0, 0x70,
  0x08, 0xC0, 0x30, 0x0C, 0x60, 0x18, 0x06, 0x30, 0x0C, 0x03, 0x10, 0x04,
  0x01, 0x98, 0x06, 0x00, 0x8C, 0x03, 0x00, 0xC6, 0x01, 0x80, 0x63, 0x00,
  0xC0, 0x33, 0x00, 0x40, 0x19, 0x80, 0x60, 0x08, 0xC0, 0x30, 0x0C, 0x00,
  0x18, 0xFC, 0x37, 0x1C, 0x78, 0x18, 0xE0, 0x31, 0x80, 0x67, 0x00, 0xCC,
  0x01, 0x98, 0x03, 0x30, 0x06, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00,
  0xCC, 0x01, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x18, 0x07, 0xF0, 0x78, 0xE3,
  0x81, 0xCC, 0x03, 0x60, 0x0D, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x02, 0xC0, 0x1B, 0x00, 0xC6, 0x07, 0x1E, 0x78,
  0x3F, 0x80, 0x06, 0x3F, 0x01, 0x98, 0xE0, 0x68, 0x18, 0x14, 0x06, 0x06,
  0x00, 0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x82, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x03, 0x07, 0x01, 0xC1, 0x40, 0xE0,
  0xDC, 0x70, 0x33, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0xE2, 0x3C, 0x6C, 0xE0, 0x79, 0x80, 0x76, 0x00, 0xCC, 0x01, 0xB0, 0x03,
  0x60, 0x06, 0xC0, 0x0D, 0x80, 0x32, 0x00, 0x64, 0x01, 0xCC, 0x03, 0x98,
  0x0A, 0x30, 0x3C, 0x39, 0xD8, 0x3E, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x18, 0xF1,
  0xB9, 0x1E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00,
  0x07, 0xF0, 0xE1, 0xC6, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x32, 0x01,
  0x9C, 0x38, 0x7F, 0x80, 0x08, 0x0C, 0x06, 0x02, 0x0F, 0xF9, 0x80, 0xC0,
  0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x87, 0xC0, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x00, 0x66,
  0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x04, 0x40, 0x19, 0x80, 0x33, 0x00,
  0x66, 0x01, 0xCC, 0x03, 0x18, 0x0A, 0x30, 0x2C, 0x71, 0xD8, 0x7E, 0x30,
  0x80, 0x1F, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xC0, 0x63, 0x01, 0x0C, 0x0C,
  0x10, 0x60, 0x41, 0x81, 0x8C, 0x06, 0x30, 0x19, 0x80, 0x66, 0x01, 0xB0,
  0x02, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x60, 0x1E, 0x03, 0x01, 0xB0,
  0x38, 0x0D, 0x81, 0x60, 0x4C, 0x1B, 0x06, 0x60, 0x98, 0x33, 0x0C, 0xC3,
  0x18, 0x46, 0x18, 0xC6, 0x31, 0x86, 0x21, 0x8C, 0x33, 0x04, 0xC1, 0x90,
  0x26, 0x0D, 0x81, 0x60, 0x68, 0x0B, 0x01, 0xC0, 0x50, 0x0C, 0x03, 0x80,
  0x60, 0x18, 0x00, 0x0C, 0x03, 0x86, 0x03, 0x01, 0x83, 0x00, 0xC1, 0x80,
  0x31, 0x80, 0x19, 0x80, 0x05, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x01, 0x90, 0x00, 0xCC, 0x00, 0xC2, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0xC0,
  0x30, 0xC0, 0x18, 0x00, 0x04, 0x00, 0xE0, 0xC0, 0x18, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x00, 0x81, 0x80, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x13, 0x00, 0x02,
  0xC0, 0x00, 0x58, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x07, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x40, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xFF, 0xE0, 0x00, 0x70,
  0x1E, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x0F, 0x00, 0xE0, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x3C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0xF0, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x18, 0x01, 0xC0, 0x38, 0x1C, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x03, 0xC0, 0x70, 0x00, 0x3E,
  0x03, 0xFF, 0x0E, 0x03, 0xF0,
};

const GFXglyph NotoSans_LightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 23, 8, 1, -23 },
  { 22, 8, 8, 11, 4, -23 },
  { 30, 19, 23, 20, 1, -23 },
  { 85, 16, 26, 18, 1, -24 },
  { 137, 20, 23, 25, 3, -23 },
  { 195, 20, 23, 22, 1, -23 },
  { 253, 3, 8, 6, 4, -23 },
  { 256, 10, 28, 9, 1, -23 },
  { 291, 9, 28, 9, -2, -23 },
  { 323, 14, 14, 17, 4, -24 },
  { 348, 15, 15, 18, 2, -19 },
  { 377, 5, 8, 7, -1, -4 },
  { 382, 8, 1, 10, 1, -9 },
  { 383, 3, 3, 7, 1, -3 },
  { 385, 14, 23, 11, -1, -23 },
  { 426, 15, 23, 18, 2, -23 },
  { 470, 9, 23, 18, 5, -23 },
  { 496, 17, 23, 18, 0, -23 },
  { 545, 16, 23, 18, 1, -23 },
  { 591, 17, 23, 18, 0, -23 },
  { 640, 16, 23, 18, 1, -23 },
  { 686, 15, 23, 18, 2, -23 },
  { 730, 15, 23, 18, 3, -23 },
  { 774, 16, 23, 18, 1, -23 },
  { 820, 16, 23, 18, 1, -23 },
  { 866, 6, 17, 7, 1, -17 },
  { 879, 9, 21, 7, -2, -17 },
  { 903, 15, 15, 18, 2, -19 },
  { 932, 15, 8, 18, 2, -15 },
  { 947, 15, 15, 18, 2, -19 },
  { 976, 11, 23, 13, 3, -23 },
  { 1008, 24, 26, 27, 2, -23 },
  { 1086, 18, 23, 18, -2, -23 },
  { 1138, 18, 23, 19, 1, -23 },
  { 1190, 18, 23, 19, 2, -23 },
  { 1242, 19, 23, 22, 1, -23 },
  { 1297, 17, 23, 17, 1, -23 },
  { 1346, 17, 23, 15, 1, -23 },
  { 1395, 19, 23, 22, 2, -23 },
  { 1450, 21, 23, 22, 1, -23 },
  { 1511, 11, 23, 10, 0, -23 },
  { 1543, 13, 29, 8, -5, -23 },
  { 1591, 19, 23, 18, 1, -23 },
  { 1646, 12, 23, 16, 1, -23 },
  { 1681, 25, 23, 26, 1, -23 },
  { 1753, 21, 23, 22, 1, -23 },
  { 1814, 20, 23, 23, 2, -23 },
  { 1872, 17, 23, 18, 1, -23 },
  { 1921, 20, 28, 23, 2, -23 },
  { 1991, 17, 23, 18, 1, -23 },
  { 2040, 15, 23, 16, 1, -23 },
  { 2084, 16, 23, 16, 3, -23 },
  { 2130, 19, 23, 22, 3, -23 },
  { 2185, 17, 23, 17, 3, -23 },
  { 2234, 25, 23, 27, 4, -23 },
  { 2306, 21, 23, 16, -2, -23 },
  { 2367, 16, 23, 16, 3, -23 },
  { 2413, 18, 23, 17, 0, -23 },
  { 2465, 12, 28, 10, 0, -23 },
  { 2507, 6, 23, 11, 3, -23 },
  { 2525, 12, 28, 10, -2, -23 },
  { 2567, 16, 14, 18, 1, -23 },
  { 2595, 13, 2, 12, -3, 3 },
  { 2599, 4, 6, 8, 5, -25 },
  { 2602, 15, 17, 18, 2, -17 },
  { 2634, 16, 24, 18, 1, -24 },
  { 2682, 13, 17, 15, 2, -17 },
  { 2710, 17, 24, 18, 2, -24 },
  { 2761, 13, 17, 16, 2, -17 },
  { 2789, 18, 32, 9, -4, -24 },
  { 2861, 16, 25, 18, 1, -17 },
  { 2911, 15, 24, 18, 1, -24 },
  { 2956, 7, 23, 7, 1, -23 },
  { 2977, 12, 31, 7, -4, -23 },
  { 3024, 15, 24, 15, 1, -24 },
  { 3069, 7, 24, 7, 1, -24 },
  { 3090, 25, 17, 27, 1, -17 },
  { 3144, 15, 17, 18, 1, -17 },
  { 3176, 14, 17, 18, 2, -17 },
  { 3206, 18, 25, 18, -1, -17 },
  { 3263, 15, 25, 18, 2, -17 },
  { 3310, 12, 17, 12, 1, -17 },
  { 3336, 13, 17, 14, 0, -17 },
  { 3364, 9, 21, 10, 2, -21 },
  { 3388, 15, 17, 18, 2, -17 },
  { 3420, 14, 17, 14, 2, -17 },
  { 3450, 21, 17, 22, 2, -17 },
  { 3495, 17, 17, 15, -1, -17 },
  { 3532, 19, 25, 14, -3, -17 },
  { 3592, 14, 17, 14, 0, -17 },
  { 3622, 12, 28, 11, 1, -23 },
  { 3664, 1, 32, 17, 9, -24 },
  { 3668, 11, 28, 11, -1, -23 },
  { 3707, 15, 3, 18, 2, -13 },
};

const GFXfont NotoSans_LightItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_LIGHTITALIC32PT7B_H_
