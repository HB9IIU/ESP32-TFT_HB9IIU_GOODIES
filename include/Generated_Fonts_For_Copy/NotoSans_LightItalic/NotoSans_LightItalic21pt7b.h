#ifndef _NOTOSANS_LIGHTITALIC21PT7B_H_
#define _NOTOSANS_LIGHTITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x32, 0x22, 0x24, 0x44, 0x40, 0x08, 0x80, 0x6D, 0x24, 0x92,
  0x88, 0x04, 0x20, 0x42, 0x04, 0x40, 0x84, 0x08, 0x47, 0xFF, 0x08, 0x81,
  0x08, 0x11, 0x0F, 0xFE, 0x21, 0x02, 0x10, 0x22, 0x02, 0x20, 0x42, 0x00,
  0x02, 0x00, 0x80, 0xFC, 0xC9, 0x24, 0x09, 0x02, 0x40, 0xD0, 0x0E, 0x02,
  0xC0, 0x98, 0x26, 0x09, 0x22, 0xC7, 0xC0, 0x40, 0x10, 0x00, 0x38, 0x1A,
  0x21, 0xB1, 0x09, 0x08, 0x88, 0x48, 0x46, 0xC2, 0x25, 0xF1, 0x59, 0xF4,
  0x88, 0x24, 0x42, 0x42, 0x22, 0x12, 0x10, 0x90, 0x8B, 0x03, 0x80, 0x0F,
  0x80, 0xC6, 0x04, 0x10, 0x20, 0x81, 0x08, 0x0C, 0x80, 0x38, 0x03, 0x80,
  0x66, 0x1E, 0x18, 0xA0, 0x49, 0x01, 0x88, 0x0C, 0x61, 0xA1, 0xF8, 0xC0,
  0x69, 0x28, 0x0C, 0x21, 0x08, 0x21, 0x04, 0x30, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x81, 0x00, 0x18, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x30,
  0x82, 0x18, 0x43, 0x08, 0x43, 0x00, 0x04, 0x01, 0x04, 0x43, 0x90, 0x1F,
  0xC5, 0x03, 0x41, 0x98, 0x02, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x36, 0x44, 0x80, 0xF8, 0xC0, 0x00,
  0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x60, 0x10, 0x0C, 0x00, 0x0F, 0x86, 0x33, 0x04, 0x81, 0x60,
  0x50, 0x14, 0x05, 0x01, 0xC0, 0xF0, 0x2C, 0x0B, 0x06, 0x41, 0x10, 0x83,
  0xC0, 0x0C, 0x76, 0xA2, 0x08, 0x21, 0x84, 0x10, 0x43, 0x08, 0x20, 0x82,
  0x00, 0x0F, 0xC3, 0x0C, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x3F, 0xE0, 0x0F, 0xC3,
  0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x60, 0x78, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x20, 0x09, 0x03, 0x1F, 0xC0, 0x00, 0x60, 0x1C, 0x07, 0x01,
  0xA0, 0x64, 0x08, 0x82, 0x20, 0x84, 0x20, 0x88, 0x13, 0xFF, 0x80, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x1F, 0xC4, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x07,
  0xE0, 0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x20, 0xCF, 0xC0, 0x07,
  0xC3, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x05, 0xF1, 0x82, 0x40, 0xB0, 0x2C,
  0x0B, 0x02, 0x41, 0x98, 0xC3, 0xE0, 0x7F, 0xE0, 0x20, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x10, 0x0C,
  0x00, 0x0F, 0x84, 0x33, 0x04, 0x81, 0x30, 0x44, 0x20, 0xB0, 0x78, 0x61,
  0x10, 0x28, 0x0A, 0x02, 0x80, 0x90, 0x47, 0xE0, 0x0F, 0x0C, 0x22, 0x05,
  0x81, 0x40, 0x50, 0x14, 0x0D, 0x87, 0x3E, 0x80, 0x20, 0x18, 0x04, 0x03,
  0x01, 0x8F, 0x80, 0x64, 0x00, 0x00, 0x12, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x00, 0x11, 0x18, 0x84, 0x40, 0x00, 0x80, 0xC1, 0x83, 0x06, 0x04, 0x01,
  0x80, 0x30, 0x07, 0x00, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x0C, 0x38, 0x70, 0x40, 0x00, 0x7D,
  0x0C, 0x08, 0x10, 0x20, 0x82, 0x08, 0x20, 0x81, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x01, 0xF0, 0x06, 0x0C, 0x18, 0x02, 0x30, 0x03, 0x20, 0xE1, 0x43,
  0x11, 0x44, 0x31, 0x84, 0x21, 0x88, 0x21, 0x88, 0x23, 0x88, 0x62, 0x8C,
  0xA4, 0x47, 0x18, 0x40, 0x00, 0x20, 0x00, 0x18, 0x20, 0x0F, 0xC0, 0x00,
  0xC0, 0x1C, 0x01, 0x40, 0x34, 0x02, 0x40, 0x64, 0x04, 0x40, 0x86, 0x08,
  0x21, 0xFE, 0x30, 0x22, 0x02, 0x60, 0x24, 0x02, 0xC0, 0x30, 0x1F, 0xC2,
  0x0C, 0x40, 0x98, 0x12, 0x02, 0x40, 0xC8, 0x71, 0xFC, 0x60, 0xC8, 0x09,
  0x01, 0x20, 0x2C, 0x0D, 0x03, 0x3F, 0x80, 0x07, 0xE3, 0x04, 0xC0, 0x30,
  0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0F, 0xE0, 0x1F, 0x81, 0x06, 0x10, 0x33, 0x01, 0x20, 0x12,
  0x01, 0x20, 0x12, 0x01, 0x60, 0x14, 0x03, 0x40, 0x24, 0x06, 0xC0, 0xC8,
  0x38, 0xFE, 0x00, 0x1F, 0xE2, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08,
  0x01, 0xFC, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x3F, 0xC0,
  0x1F, 0xE2, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0xFC, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x00, 0x07, 0xF1, 0x81,
  0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x3E, 0x80, 0x28, 0x06,
  0x80, 0x48, 0x04, 0xC0, 0x46, 0x04, 0x3F, 0x80, 0x10, 0x08, 0x80, 0x44,
  0x02, 0x60, 0x32, 0x01, 0x10, 0x08, 0x80, 0x47, 0xFE, 0x60, 0x22, 0x01,
  0x10, 0x08, 0x80, 0x4C, 0x06, 0x60, 0x22, 0x01, 0x00, 0x1E, 0x10, 0x20,
  0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x3C, 0x00, 0x01,
  0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x18, 0xB0, 0xE0, 0x10, 0x31, 0x06, 0x10, 0xC3, 0x18,
  0x23, 0x02, 0x60, 0x2C, 0x03, 0x40, 0x64, 0x04, 0x20, 0x42, 0x04, 0x10,
  0xC1, 0x08, 0x18, 0x80, 0x80, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x80, 0xFF, 0x18, 0x03, 0x18, 0x03,
  0x18, 0x05, 0x38, 0x0F, 0x2C, 0x0A, 0x24, 0x12, 0x24, 0x12, 0x24, 0x22,
  0x44, 0x26, 0x44, 0x44, 0x44, 0xC4, 0x46, 0x84, 0xC3, 0x0C, 0x83, 0x08,
  0x82, 0x08, 0x18, 0x0C, 0x60, 0x21, 0x80, 0x8D, 0x02, 0x24, 0x18, 0x98,
  0x42, 0x21, 0x08, 0x84, 0x41, 0x11, 0x04, 0xC4, 0x1A, 0x10, 0x28, 0xC0,
  0xA2, 0x01, 0x88, 0x04, 0x00, 0x0F, 0xC1, 0x06, 0x20, 0x34, 0x01, 0x40,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x28, 0x02, 0xC0,
  0x46, 0x18, 0x3F, 0x00, 0x1F, 0x82, 0x18, 0x41, 0x98, 0x12, 0x02, 0x40,
  0xC8, 0x11, 0x0C, 0x7E, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20,
  0x00, 0x0F, 0xC1, 0x06, 0x20, 0x34, 0x01, 0x40, 0x1C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x28, 0x02, 0xC0, 0x46, 0x08, 0x3F, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x1F, 0x82, 0x18, 0x41, 0x98, 0x12,
  0x02, 0x40, 0xC8, 0x31, 0xFC, 0x7E, 0x08, 0x41, 0x0C, 0x20, 0x8C, 0x11,
  0x83, 0x20, 0x20, 0x0F, 0xE3, 0x04, 0x40, 0x18, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x10, 0x02, 0x00, 0x40, 0x09, 0x02, 0x3F, 0x80,
  0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x00, 0x20, 0x19, 0x00, 0x98, 0x04,
  0x80, 0x24, 0x03, 0x20, 0x11, 0x00, 0x98, 0x04, 0x80, 0x64, 0x03, 0x20,
  0x11, 0x00, 0x88, 0x08, 0x60, 0xC1, 0xF8, 0x00, 0x80, 0x30, 0x0B, 0x01,
  0x60, 0x44, 0x18, 0x82, 0x10, 0xC2, 0x10, 0x46, 0x08, 0x81, 0x30, 0x34,
  0x03, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x80, 0xA0, 0x60, 0xD0, 0x50, 0x48,
  0x28, 0x64, 0x24, 0x22, 0x12, 0x11, 0x11, 0x10, 0x88, 0x88, 0x48, 0x48,
  0x24, 0x24, 0x14, 0x14, 0x0A, 0x0A, 0x07, 0x05, 0x03, 0x03, 0x01, 0x81,
  0x80, 0x18, 0x08, 0x40, 0x83, 0x08, 0x08, 0x80, 0x4C, 0x01, 0x40, 0x0C,
  0x00, 0x60, 0x05, 0x00, 0x68, 0x06, 0x20, 0x21, 0x02, 0x0C, 0x20, 0x23,
  0x01, 0x00, 0x80, 0x70, 0x24, 0x19, 0x04, 0x42, 0x09, 0x82, 0x40, 0xA0,
  0x30, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x00, 0x1F, 0xF0, 0x02,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0x80, 0x0F, 0x18, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0,
  0x80, 0xF0, 0x88, 0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x10, 0x0F, 0x01,
  0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x08, 0xF8, 0x04, 0x03, 0x80, 0xA0, 0x44, 0x11, 0x08, 0x42,
  0x09, 0x02, 0xC0, 0x40, 0xFF, 0xC8, 0x80, 0x1F, 0x4C, 0x56, 0x0D, 0x02,
  0xC0, 0xA0, 0x28, 0x1A, 0x06, 0x83, 0x31, 0x47, 0x90, 0x10, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x0B, 0xE3, 0x0D, 0x81, 0x60, 0x50, 0x14, 0x05, 0x03,
  0xC0, 0xB0, 0x6C, 0x32, 0xF8, 0x1F, 0x98, 0x18, 0x08, 0x0C, 0x04, 0x02,
  0x01, 0x00, 0xC0, 0x20, 0x0F, 0x80, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x04, 0x3E, 0x88, 0x33, 0x06, 0x40, 0xD8, 0x12, 0x02, 0x40, 0x48, 0x19,
  0x07, 0x31, 0xC3, 0xC8, 0x1F, 0x18, 0xD8, 0x28, 0x2C, 0x77, 0xC2, 0x01,
  0x00, 0xC0, 0x20, 0x8F, 0x80, 0x00, 0xF0, 0x18, 0x01, 0x00, 0x10, 0x03,
  0x00, 0xFC, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0xE0,
  0x00, 0x1F, 0x4C, 0x36, 0x0D, 0x03, 0xC0, 0xA0, 0x28, 0x0A, 0x06, 0x83,
  0xB1, 0xC7, 0x90, 0x04, 0x03, 0x00, 0x88, 0x63, 0xE0, 0x10, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x0B, 0xE3, 0x0D, 0x83, 0x60, 0xD0, 0x24, 0x09, 0x02,
  0xC0, 0xA0, 0x68, 0x12, 0x04, 0x31, 0x00, 0x22, 0x64, 0x44, 0x4C, 0x88,
  0x80, 0x03, 0x01, 0x00, 0x00, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0xE0, 0x10, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x48, 0x62, 0x31, 0x98, 0x4C, 0x16, 0x07, 0x81, 0x20,
  0xC4, 0x21, 0x08, 0x22, 0x0C, 0x11, 0x32, 0x22, 0x26, 0x44, 0x44, 0xC8,
  0x88, 0x2F, 0x9E, 0x30, 0xA3, 0x60, 0xC1, 0x60, 0x81, 0x40, 0x83, 0x41,
  0x82, 0x41, 0x02, 0xC1, 0x02, 0x81, 0x06, 0x81, 0x04, 0x83, 0x04, 0x2F,
  0x8C, 0x36, 0x0D, 0x83, 0x40, 0x90, 0x24, 0x0B, 0x06, 0x81, 0xA0, 0x48,
  0x10, 0x1F, 0x08, 0x26, 0x0D, 0x01, 0xC0, 0x60, 0x38, 0x0A, 0x02, 0xC1,
  0x90, 0xC3, 0xE0, 0x17, 0xC3, 0x0C, 0xC0, 0x98, 0x12, 0x02, 0x40, 0x48,
  0x1B, 0x02, 0x60, 0xCC, 0x31, 0x7C, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x1F, 0x4C, 0x36, 0x0D, 0x03, 0xC0, 0xA0, 0x28, 0x0A, 0x06, 0x83,
  0xB1, 0xC7, 0x90, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x2F, 0x30, 0x60,
  0x60, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x3F, 0x90, 0x08, 0x04,
  0x03, 0x00, 0x60, 0x18, 0x04, 0x02, 0x41, 0x3F, 0x00, 0x10, 0x82, 0x3F,
  0x21, 0x84, 0x10, 0x41, 0x0C, 0x20, 0x81, 0xC0, 0x20, 0x48, 0x14, 0x0D,
  0x02, 0x40, 0x90, 0x2C, 0x1A, 0x06, 0x83, 0x31, 0x47, 0x90, 0x80, 0xC0,
  0xB0, 0xC8, 0x44, 0x62, 0x21, 0x20, 0x90, 0x50, 0x28, 0x18, 0x00, 0x83,
  0x06, 0x0C, 0x28, 0x50, 0xB1, 0x44, 0xC9, 0x13, 0x24, 0x85, 0x12, 0x14,
  0x58, 0x61, 0x41, 0x85, 0x04, 0x08, 0x00, 0x10, 0x61, 0x18, 0x22, 0x06,
  0x80, 0x60, 0x0C, 0x02, 0x80, 0xD8, 0x31, 0x04, 0x23, 0x02, 0x00, 0x10,
  0x11, 0x02, 0x18, 0x60, 0x84, 0x08, 0xC0, 0x88, 0x09, 0x80, 0x90, 0x0A,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x0E, 0x00, 0x3F,
  0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x60, 0x3F, 0x80,
  0x03, 0x04, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x30, 0xE0, 0x20, 0x30,
  0x20, 0x20, 0x20, 0x20, 0x60, 0x38, 0xFF, 0xFF, 0xF8, 0x0C, 0x06, 0x02,
  0x06, 0x04, 0x04, 0x04, 0x04, 0x06, 0x07, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x30, 0xE0, 0x60, 0x4E, 0x61, 0xC0,
};

const GFXglyph NotoSans_LightItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 15, 5, 1, -15 },
  { 9, 6, 5, 7, 2, -15 },
  { 13, 12, 15, 13, 1, -15 },
  { 36, 10, 17, 12, 1, -16 },
  { 58, 13, 15, 16, 2, -15 },
  { 83, 13, 15, 14, 1, -15 },
  { 108, 3, 5, 4, 2, -15 },
  { 110, 6, 18, 6, 1, -15 },
  { 124, 6, 18, 6, -1, -15 },
  { 138, 10, 9, 11, 2, -16 },
  { 150, 9, 10, 12, 2, -12 },
  { 162, 4, 5, 5, -1, -2 },
  { 165, 5, 1, 7, 1, -6 },
  { 166, 1, 2, 5, 1, -2 },
  { 167, 10, 15, 7, -1, -15 },
  { 186, 10, 15, 12, 1, -15 },
  { 205, 6, 15, 12, 3, -15 },
  { 217, 11, 15, 12, 0, -15 },
  { 238, 11, 15, 12, 0, -15 },
  { 259, 11, 15, 12, 0, -15 },
  { 280, 10, 15, 12, 1, -15 },
  { 299, 10, 15, 12, 1, -15 },
  { 318, 10, 15, 12, 2, -15 },
  { 337, 10, 15, 12, 1, -15 },
  { 356, 10, 15, 12, 1, -15 },
  { 375, 3, 11, 5, 1, -11 },
  { 380, 5, 14, 5, -1, -11 },
  { 389, 9, 10, 12, 2, -13 },
  { 401, 9, 5, 12, 2, -10 },
  { 407, 9, 10, 12, 2, -13 },
  { 419, 7, 15, 9, 2, -15 },
  { 433, 16, 17, 18, 1, -15 },
  { 467, 12, 15, 12, -1, -15 },
  { 490, 11, 15, 13, 1, -15 },
  { 511, 11, 15, 12, 2, -15 },
  { 532, 12, 15, 14, 1, -15 },
  { 555, 11, 15, 11, 1, -15 },
  { 576, 11, 15, 10, 1, -15 },
  { 597, 12, 15, 14, 2, -15 },
  { 620, 13, 15, 14, 1, -15 },
  { 645, 7, 15, 6, 0, -15 },
  { 659, 8, 19, 5, -3, -15 },
  { 678, 12, 15, 12, 1, -15 },
  { 701, 8, 15, 10, 1, -15 },
  { 716, 16, 15, 17, 1, -15 },
  { 746, 14, 15, 15, 1, -15 },
  { 773, 12, 15, 15, 2, -15 },
  { 796, 11, 15, 12, 1, -15 },
  { 817, 12, 19, 15, 2, -15 },
  { 846, 11, 15, 12, 1, -15 },
  { 867, 11, 15, 11, 0, -15 },
  { 888, 10, 15, 10, 2, -15 },
  { 907, 13, 15, 14, 2, -15 },
  { 932, 11, 15, 11, 2, -15 },
  { 953, 17, 15, 18, 2, -15 },
  { 985, 13, 15, 11, -1, -15 },
  { 1010, 10, 15, 10, 2, -15 },
  { 1029, 12, 15, 11, 0, -15 },
  { 1052, 8, 18, 6, 0, -15 },
  { 1070, 4, 15, 7, 2, -15 },
  { 1078, 8, 18, 6, -2, -15 },
  { 1096, 10, 9, 12, 1, -15 },
  { 1108, 8, 1, 8, -2, 2 },
  { 1109, 3, 3, 5, 3, -16 },
  { 1111, 10, 11, 12, 1, -11 },
  { 1125, 10, 16, 12, 1, -16 },
  { 1145, 9, 11, 10, 1, -11 },
  { 1158, 11, 16, 12, 1, -16 },
  { 1180, 9, 11, 10, 1, -11 },
  { 1193, 12, 21, 6, -3, -16 },
  { 1225, 10, 16, 12, 1, -11 },
  { 1245, 10, 16, 12, 1, -16 },
  { 1265, 4, 15, 5, 1, -15 },
  { 1273, 8, 20, 5, -3, -15 },
  { 1293, 10, 16, 10, 1, -16 },
  { 1313, 4, 16, 5, 1, -16 },
  { 1321, 16, 11, 18, 1, -11 },
  { 1343, 10, 11, 12, 1, -11 },
  { 1357, 10, 11, 12, 1, -11 },
  { 1371, 11, 16, 12, 0, -11 },
  { 1393, 10, 16, 12, 1, -11 },
  { 1413, 8, 11, 8, 1, -11 },
  { 1424, 9, 11, 9, 0, -11 },
  { 1437, 6, 14, 7, 1, -14 },
  { 1448, 10, 11, 12, 1, -11 },
  { 1462, 9, 11, 9, 1, -11 },
  { 1475, 14, 11, 14, 1, -11 },
  { 1495, 11, 11, 10, -1, -11 },
  { 1511, 12, 16, 9, -2, -11 },
  { 1535, 9, 11, 9, 0, -11 },
  { 1548, 8, 18, 7, 0, -15 },
  { 1566, 1, 21, 11, 6, -16 },
  { 1569, 8, 18, 7, -1, -15 },
  { 1587, 9, 3, 12, 2, -9 },
};

const GFXfont NotoSans_LightItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_LIGHTITALIC21PT7B_H_
