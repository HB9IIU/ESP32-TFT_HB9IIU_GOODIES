#ifndef _NOTOSANS_LIGHTITALIC40PT7B_H_
#define _NOTOSANS_LIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x3C, 0x1E, 0x0E, 0x00, 0x38, 0xE6,
  0x1C, 0xC3, 0x18, 0x67, 0x0C, 0xC3, 0x98, 0x63, 0x0C, 0x61, 0x88, 0x23,
  0x04, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x20, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xC0, 0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x3F, 0x80, 0x3F, 0xFE, 0x0F, 0x31, 0x83,
  0x84, 0x00, 0x61, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0E,
  0x10, 0x00, 0xC6, 0x00, 0x1E, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x19, 0xC0, 0x03, 0x1C, 0x00, 0x61, 0x80, 0x08, 0x30, 0x03,
  0x06, 0x00, 0x60, 0xC0, 0x0C, 0x38, 0x01, 0x8E, 0x18, 0x23, 0x83, 0xFF,
  0xE0, 0x1F, 0xE0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x03, 0xC0, 0x01, 0x83, 0xF8, 0x00, 0xC1, 0xC7, 0x00, 0x60, 0xE0,
  0xC0, 0x18, 0x30, 0x30, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01,
  0x80, 0xC0, 0xC0, 0x60, 0x30, 0x60, 0x18, 0x0C, 0x30, 0x0C, 0x06, 0x1C,
  0x03, 0x01, 0x86, 0x00, 0xC0, 0x63, 0x1F, 0xB0, 0x31, 0x8E, 0x76, 0x0C,
  0xE6, 0x0D, 0x86, 0x33, 0x03, 0x7F, 0x18, 0xC0, 0xC7, 0x8C, 0x70, 0x30,
  0x07, 0x18, 0x0C, 0x01, 0x86, 0x03, 0x00, 0xC1, 0x80, 0xC0, 0x60, 0x60,
  0x30, 0x38, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x81, 0x83, 0x00,
  0x60, 0xC0, 0xC0, 0x18, 0x70, 0x60, 0x07, 0xF8, 0x30, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0xE0,
  0x03, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x00, 0xE0,
  0x03, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x87, 0x00, 0x01, 0x9E, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x30, 0x01,
  0x38, 0x38, 0x06, 0x70, 0x1C, 0x06, 0x60, 0x0C, 0x0C, 0xE0, 0x0E, 0x1C,
  0xC0, 0x07, 0x18, 0xC0, 0x03, 0x30, 0xC0, 0x01, 0xE0, 0xC0, 0x01, 0xE0,
  0xC0, 0x01, 0xE0, 0xE0, 0x07, 0x60, 0x70, 0x0E, 0x70, 0x7F, 0xFC, 0x38,
  0x1F, 0xF0, 0x1C, 0x39, 0x8C, 0x67, 0x31, 0x8C, 0x62, 0x30, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x30, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x0C, 0x0C, 0x07, 0x84,
  0x00, 0xF2, 0x00, 0x1F, 0x1F, 0x03, 0xFF, 0x81, 0xC0, 0x01, 0xB0, 0x01,
  0x98, 0x03, 0x86, 0x03, 0x83, 0x01, 0x81, 0xC0, 0x40, 0x60, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x38, 0x61, 0x80, 0x7F, 0xFF, 0xF0, 0x2F,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x0F, 0x0F, 0x03, 0x80, 0x60, 0x60, 0x0E, 0x1C, 0x00,
  0xC7, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x67, 0x00, 0x0C, 0xC0, 0x01,
  0x98, 0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0xD8, 0x00, 0x3B, 0x00, 0x07,
  0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x70, 0x00, 0xEE, 0x00, 0x18,
  0xC0, 0x07, 0x18, 0x00, 0xC3, 0x00, 0x38, 0x60, 0x06, 0x0E, 0x01, 0xC0,
  0xE0, 0x70, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x60, 0x3C, 0x0F, 0x87,
  0xE1, 0xCC, 0xF1, 0xB8, 0x72, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0x00, 0x78, 0x3C, 0x07, 0x00, 0xE0, 0x10, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x0F, 0xC1, 0xE0,
  0x60, 0x06, 0x04, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x88, 0x00, 0x70, 0xC0, 0x0E, 0x0F,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0xB8, 0x00, 0x19, 0x80,
  0x01, 0x8C, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x38, 0x01, 0xC1,
  0x80, 0x1C, 0x0C, 0x01, 0xC0, 0x60, 0x0C, 0x07, 0x00, 0xC0, 0x30, 0x0C,
  0x01, 0x80, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0xE0, 0x07, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x10, 0x01, 0xC3,
  0x00, 0x70, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFC,
  0x07, 0xC0, 0x81, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x78, 0x06,
  0x3F, 0xC0, 0xDC, 0x1C, 0x3E, 0x01, 0xC7, 0x80, 0x18, 0xE0, 0x03, 0x9C,
  0x00, 0x73, 0x00, 0x06, 0x60, 0x01, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x38, 0xE0, 0x06, 0x0C, 0x01, 0xC1, 0xC0, 0x70, 0x1F,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0xF0, 0x0F, 0x07, 0x03, 0x80, 0x70, 0x60, 0x06, 0x1C, 0x00,
  0xC3, 0x80, 0x18, 0x70, 0x03, 0x0E, 0x00, 0x61, 0xC0, 0x1C, 0x18, 0x07,
  0x01, 0x81, 0xC0, 0x1C, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7C, 0xE0,
  0x1C, 0x0E, 0x07, 0x00, 0xE1, 0x80, 0x0E, 0x70, 0x00, 0xCC, 0x00, 0x19,
  0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xE0, 0x03, 0x9C, 0x00, 0xE1,
  0xC0, 0x38, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0,
  0x1E, 0x0E, 0x07, 0x00, 0xE0, 0xC0, 0x0C, 0x30, 0x01, 0xC6, 0x00, 0x39,
  0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x03, 0x98, 0x00, 0x73,
  0x00, 0x0E, 0x60, 0x03, 0x8E, 0x00, 0xF0, 0xE0, 0x76, 0x0F, 0xFD, 0xC0,
  0xFE, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x7F,
  0xF0, 0x0F, 0xF8, 0x00, 0x04, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x87, 0x8F, 0x1C, 0x00,
  0x00, 0x80, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xC0,
  0x70, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0xE0, 0xE0, 0xE1, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x06, 0x18, 0x07, 0xFE, 0x0C, 0x60,
  0x1E, 0x3C, 0x18, 0xC0, 0x70, 0x30, 0x1B, 0x01, 0x80, 0x60, 0x36, 0x06,
  0x00, 0xC0, 0x6C, 0x0C, 0x03, 0x81, 0xB8, 0x30, 0x06, 0x03, 0x60, 0x60,
  0x0C, 0x06, 0xC0, 0xC0, 0x18, 0x0D, 0x81, 0x80, 0x60, 0x3B, 0x03, 0x00,
  0xC0, 0x66, 0x06, 0x03, 0x81, 0xCC, 0x0C, 0x0D, 0x07, 0x1C, 0x1C, 0x33,
  0x1C, 0x18, 0x1F, 0xC7, 0xF0, 0x30, 0x0E, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x40, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00,
  0x03, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x61, 0xC0, 0x03, 0x87, 0x00, 0x0C,
  0x0C, 0x00, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x0E, 0x03, 0x00, 0x70, 0x0C,
  0x01, 0x80, 0x38, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xC0, 0x06, 0x06,
  0x00, 0x18, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x38, 0x00,
  0x1C, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0, 0x00, 0x0C,
  0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x01, 0xC1, 0xFC, 0x0E, 0x00, 0xF0, 0x60,
  0x03, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x0E, 0x00, 0x18,
  0x60, 0x01, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0xE1, 0xC0, 0x1E, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0x00, 0x78, 0x38, 0x00, 0xC1, 0xC0, 0x07, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x38, 0x00, 0x31, 0xC0, 0x01,
  0x8C, 0x00, 0x1C, 0x60, 0x01, 0xC3, 0x00, 0x1E, 0x38, 0x03, 0xE1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F,
  0x81, 0xC0, 0xF0, 0x01, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x08, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x1C, 0x3F, 0xC0, 0x38, 0x03,
  0xC0, 0x60, 0x03, 0xC0, 0xC0, 0x03, 0x81, 0x80, 0x03, 0x87, 0x00, 0x07,
  0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x31,
  0xC0, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xE3, 0x00,
  0x01, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x78, 0x60, 0x01,
  0xE0, 0xC0, 0x0F, 0x03, 0x80, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x3E,
  0x03, 0xC0, 0x02, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x07, 0xFC,
  0xE0, 0x07, 0xFC, 0xE0, 0x0F, 0xFC, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x18,
  0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x70, 0x00, 0x30, 0x70, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1E, 0x00, 0xE0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x06, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x30, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83,
  0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0x00, 0x07,
  0x03, 0x00, 0x0C, 0x07, 0x00, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x06, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0C, 0x0E, 0x00,
  0x0C, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x19, 0xE0, 0x00, 0x1B, 0x60, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0x30, 0x00,
  0x38, 0x38, 0x00, 0x30, 0x18, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x0C, 0x00,
  0x70, 0x0C, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x60, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF8, 0x36, 0x00, 0x01, 0xE0, 0x6C,
  0x00, 0x06, 0xC0, 0xD8, 0x00, 0x1D, 0x81, 0xB0, 0x00, 0x37, 0x07, 0x60,
  0x00, 0xEC, 0x0C, 0xC0, 0x01, 0x98, 0x19, 0x80, 0x06, 0x30, 0x31, 0x80,
  0x0C, 0x60, 0xE3, 0x00, 0x31, 0xC1, 0xC6, 0x00, 0xE3, 0x03, 0x0C, 0x01,
  0x86, 0x06, 0x18, 0x07, 0x0C, 0x0C, 0x30, 0x0C, 0x38, 0x38, 0x70, 0x30,
  0x70, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC1, 0x81, 0x81, 0x81, 0x87, 0x03,
  0x03, 0x03, 0x0C, 0x0E, 0x0E, 0x06, 0x30, 0x1C, 0x18, 0x0C, 0x60, 0x30,
  0x30, 0x0D, 0x80, 0x60, 0x60, 0x1B, 0x00, 0xC0, 0xC0, 0x3C, 0x03, 0x83,
  0x80, 0x78, 0x06, 0x06, 0x00, 0xE0, 0x0C, 0x0C, 0x01, 0x80, 0x18, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x78, 0x00, 0x18, 0x1E, 0x00,
  0x06, 0x07, 0xC0, 0x01, 0x81, 0xB0, 0x00, 0xE0, 0x6E, 0x00, 0x30, 0x39,
  0x80, 0x0C, 0x0C, 0x60, 0x03, 0x03, 0x1C, 0x01, 0xC0, 0xC3, 0x00, 0x70,
  0x70, 0xE0, 0x18, 0x1C, 0x18, 0x06, 0x06, 0x06, 0x01, 0x81, 0x81, 0xC0,
  0xE0, 0x60, 0x30, 0x30, 0x38, 0x0E, 0x0C, 0x0C, 0x01, 0x83, 0x03, 0x00,
  0x60, 0xC0, 0xC0, 0x1C, 0x70, 0x30, 0x03, 0x18, 0x1C, 0x00, 0xE6, 0x06,
  0x00, 0x19, 0x81, 0x80, 0x06, 0x60, 0x60, 0x01, 0xF8, 0x18, 0x00, 0x3C,
  0x0E, 0x00, 0x0F, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x1C, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x38,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x70, 0x00, 0x03, 0x70, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x70, 0x38, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x0F, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xC3, 0xF8, 0x0E, 0x01,
  0xC0, 0x60, 0x07, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC1, 0xC0, 0x07, 0x0E,
  0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0xE1, 0xC0, 0x06,
  0x0C, 0x00, 0x70, 0x60, 0x0F, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xF0, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x06, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x38, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x70, 0x00, 0x03, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x1C, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0x1E, 0x03, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xFC,
  0x01, 0xC3, 0xF8, 0x0E, 0x01, 0xE0, 0x60, 0x07, 0x03, 0x00, 0x18, 0x18,
  0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x0C,
  0x18, 0x00, 0xE1, 0xC0, 0x0E, 0x0C, 0x00, 0xE0, 0x60, 0x7E, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x01, 0xC0, 0xC0, 0x0C, 0x07, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xE0, 0x38, 0x03, 0x01, 0xC0, 0x18, 0x0C, 0x00, 0xE0, 0x60, 0x03,
  0x03, 0x00, 0x18, 0x38, 0x00, 0xE1, 0x80, 0x03, 0x0C, 0x00, 0x1C, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x03, 0xC0, 0xE0, 0x70, 0x02, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x1E, 0x0F, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x03, 0x87, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x30,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC0, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1D, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x30, 0x00, 0x61, 0x80, 0x07, 0x0C,
  0x00, 0x30, 0x60, 0x03, 0x83, 0x00, 0x18, 0x18, 0x01, 0xC0, 0xC0, 0x0C,
  0x07, 0x00, 0xE0, 0x38, 0x06, 0x00, 0xC0, 0x70, 0x06, 0x03, 0x00, 0x30,
  0x30, 0x01, 0x83, 0x80, 0x0C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x8C, 0x00,
  0x1C, 0xE0, 0x00, 0x66, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x03, 0x80, 0x0E, 0xC0, 0x07,
  0x80, 0x0C, 0xC0, 0x07, 0x80, 0x1C, 0xC0, 0x0D, 0x80, 0x18, 0xC0, 0x0D,
  0x80, 0x18, 0xC0, 0x19, 0x80, 0x30, 0xC0, 0x19, 0x80, 0x30, 0xC0, 0x31,
  0x80, 0x70, 0xC0, 0x31, 0x80, 0x60, 0xC0, 0x61, 0x80, 0xE0, 0xC0, 0x61,
  0xC0, 0xC0, 0xC0, 0xE0, 0xC1, 0xC0, 0xC0, 0xC0, 0xC1, 0x80, 0xE1, 0xC0,
  0xC1, 0x80, 0xE1, 0x80, 0xC3, 0x00, 0xE3, 0x80, 0xC3, 0x00, 0xE3, 0x00,
  0xC6, 0x00, 0x67, 0x00, 0xC6, 0x00, 0x66, 0x00, 0xCE, 0x00, 0x66, 0x00,
  0xCC, 0x00, 0x6C, 0x00, 0xDC, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0x78, 0x00,
  0xD8, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01,
  0xC0, 0x70, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x18,
  0x60, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x7C, 0x00, 0x0E, 0xE0, 0x00, 0xC6, 0x00, 0x18, 0x60,
  0x03, 0x86, 0x00, 0x70, 0x70, 0x06, 0x03, 0x00, 0xE0, 0x30, 0x1C, 0x03,
  0x81, 0x80, 0x18, 0x38, 0x01, 0x87, 0x00, 0x18, 0x60, 0x01, 0xCC, 0x00,
  0x0D, 0xC0, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xC1, 0x83, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x30, 0x60, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x6C, 0x00, 0x0C, 0x80, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x30, 0x07,
  0x06, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x81, 0x80, 0x18, 0x70,
  0x03, 0x0C, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x1C, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC7, 0x18, 0xE3, 0x0C, 0x20, 0x00, 0x70, 0x00, 0x7F,
  0x8C, 0x1E, 0x39, 0x87, 0x01, 0xB1, 0xC0, 0x3C, 0x70, 0x03, 0x8C, 0x00,
  0x73, 0x80, 0x0E, 0x70, 0x01, 0xCC, 0x00, 0x33, 0x80, 0x06, 0x70, 0x00,
  0xCC, 0x00, 0x39, 0x80, 0x07, 0x30, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x0F,
  0x1C, 0x01, 0x61, 0x80, 0x78, 0x38, 0x3B, 0x03, 0xFE, 0x60, 0x3F, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x0E, 0x00,
  0x63, 0xF8, 0x0E, 0xF3, 0xC0, 0xDC, 0x0E, 0x0D, 0x00, 0x60, 0xF0, 0x07,
  0x1E, 0x00, 0x71, 0xC0, 0x03, 0x1C, 0x00, 0x71, 0x80, 0x07, 0x18, 0x00,
  0x73, 0x80, 0x07, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xE3, 0x00,
  0x0C, 0x70, 0x01, 0xC7, 0x80, 0x18, 0x78, 0x03, 0x86, 0xC0, 0xF0, 0x47,
  0xFE, 0x0C, 0x3F, 0x80, 0x00, 0x7C, 0x03, 0xFF, 0x07, 0xC7, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x08, 0x3F, 0xF8, 0x0F, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x70,
  0x70, 0x0F, 0xF1, 0x80, 0x78, 0xE6, 0x03, 0x80, 0xD8, 0x1C, 0x01, 0x60,
  0xE0, 0x07, 0x83, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x70, 0x00, 0xC1, 0x80,
  0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0E,
  0x0C, 0x00, 0x38, 0x30, 0x01, 0xE0, 0xC0, 0x07, 0x03, 0x80, 0x3C, 0x0E,
  0x01, 0xB0, 0x1C, 0x0C, 0xC0, 0x3F, 0xE6, 0x00, 0x7E, 0x18, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0x01, 0xE3, 0xC1, 0xC0, 0x61, 0xC0, 0x38, 0xC0, 0x1C,
  0xC0, 0x0C, 0x60, 0x06, 0x70, 0x0E, 0x30, 0x1F, 0x1F, 0xFE, 0x1F, 0xF8,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x01, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0xC0, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x09, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xF0, 0xC0, 0xF1, 0xCC, 0x0E,
  0x03, 0x60, 0xE0, 0x0B, 0x0E, 0x00, 0x78, 0x60, 0x01, 0x87, 0x00, 0x0C,
  0x38, 0x00, 0x61, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x0C, 0x00, 0x70, 0x60, 0x03, 0x83,
  0x80, 0x3C, 0x1C, 0x03, 0x60, 0x70, 0x37, 0x01, 0xFF, 0x30, 0x07, 0xE1,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x08, 0x03, 0xC0, 0x7C, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x0F,
  0x00, 0xC7, 0xF8, 0x3B, 0xC7, 0x86, 0xE0, 0x70, 0xD8, 0x06, 0x1E, 0x00,
  0xC7, 0x80, 0x18, 0xE0, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x03,
  0x9C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0E,
  0x70, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x31,
  0xC0, 0x06, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x0B, 0xC0, 0x1F, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x20,
  0xC0, 0x38, 0x38, 0x0E, 0x06, 0x03, 0x80, 0xC0, 0xE0, 0x18, 0x38, 0x07,
  0x0E, 0x00, 0xE3, 0x80, 0x18, 0xE0, 0x03, 0x38, 0x00, 0x6F, 0x00, 0x1F,
  0xE0, 0x03, 0xEE, 0x00, 0x70, 0xC0, 0x0C, 0x1C, 0x01, 0x81, 0x80, 0x70,
  0x38, 0x0C, 0x03, 0x01, 0x80, 0x70, 0x30, 0x06, 0x06, 0x00, 0xE1, 0xC0,
  0x0C, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0xE0, 0x0C, 0x7F, 0x07, 0xF8, 0x33, 0x8E, 0x1C, 0x70,
  0x6C, 0x0E, 0x60, 0x70, 0xD0, 0x0D, 0x80, 0x61, 0xC0, 0x1E, 0x00, 0xC7,
  0x80, 0x38, 0x01, 0x8E, 0x00, 0x70, 0x03, 0x1C, 0x00, 0xC0, 0x0E, 0x30,
  0x01, 0x80, 0x18, 0x60, 0x07, 0x00, 0x31, 0xC0, 0x0C, 0x00, 0x63, 0x80,
  0x18, 0x00, 0xC6, 0x00, 0x30, 0x03, 0x8C, 0x00, 0xE0, 0x06, 0x18, 0x01,
  0xC0, 0x0C, 0x70, 0x03, 0x00, 0x18, 0xC0, 0x06, 0x00, 0x71, 0x80, 0x0C,
  0x00, 0xE3, 0x00, 0x38, 0x01, 0x86, 0x00, 0x60, 0x03, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x0F, 0x01, 0xC7, 0xF8, 0x33, 0xCF, 0x86, 0xE0, 0x70,
  0xD8, 0x06, 0x1E, 0x00, 0xC7, 0x80, 0x18, 0xE0, 0x03, 0x1C, 0x00, 0x63,
  0x00, 0x1C, 0x60, 0x03, 0x9C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x01, 0x8C,
  0x00, 0x71, 0x80, 0x0E, 0x70, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0E, 0x30,
  0x01, 0xCE, 0x00, 0x31, 0xC0, 0x06, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xC0,
  0x1E, 0x3C, 0x07, 0x01, 0xC1, 0xC0, 0x1C, 0x70, 0x01, 0x8C, 0x00, 0x33,
  0x80, 0x06, 0x60, 0x00, 0xEC, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00, 0x76, 0x00, 0x0C, 0xE0, 0x03, 0x8C,
  0x00, 0x61, 0xC0, 0x18, 0x1C, 0x0F, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x06, 0x3F, 0x80, 0x33, 0xCF, 0x00, 0xCC, 0x0E, 0x03,
  0x60, 0x18, 0x0F, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0, 0x03, 0x07, 0x00,
  0x1C, 0x18, 0x00, 0x70, 0x60, 0x01, 0xC3, 0x80, 0x07, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x78,
  0x01, 0x81, 0xE0, 0x0E, 0x06, 0xC0, 0xF0, 0x19, 0xFF, 0x80, 0xE3, 0xF8,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xC3, 0x07, 0x8E, 0x60, 0xE0, 0x36,
  0x1C, 0x01, 0x63, 0x80, 0x1E, 0x30, 0x00, 0xC7, 0x00, 0x0C, 0x70, 0x00,
  0xC6, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00,
  0x38, 0xC0, 0x03, 0x8C, 0x00, 0x78, 0xC0, 0x07, 0x0E, 0x00, 0xF0, 0x60,
  0x1B, 0x07, 0x03, 0x70, 0x3F, 0xE6, 0x01, 0xF8, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x0C, 0x7C,
  0x33, 0xC8, 0x6E, 0x00, 0xD8, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0x0F, 0x0F, 0x0C, 0x01, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0xC0, 0x38, 0xFF, 0xF0, 0x7F, 0xE0, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0xFF, 0xFF, 0xF1, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x7F, 0x07,
  0xF0, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x8C, 0x00, 0x73, 0x80,
  0x0C, 0x70, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0E, 0x30, 0x01, 0x8E, 0x00,
  0x31, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x39, 0xC0, 0x06, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x0B, 0x1C, 0x03, 0xE1, 0x81, 0xD8, 0x3F, 0xF3,
  0x03, 0xF8, 0x60, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xDC, 0x00, 0xC6,
  0x00, 0xE3, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x30, 0x60, 0x38, 0x38, 0x18,
  0x1C, 0x18, 0x06, 0x1C, 0x03, 0x0C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0x67,
  0x00, 0x33, 0x00, 0x1B, 0x80, 0x05, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x0E, 0x00, 0xFC, 0x03, 0xC0, 0x1B, 0x80, 0x78, 0x07, 0x70, 0x1B,
  0x00, 0xCE, 0x03, 0x60, 0x38, 0xC0, 0xEC, 0x06, 0x18, 0x19, 0x81, 0xC3,
  0x07, 0x30, 0x30, 0x60, 0xC6, 0x0E, 0x0C, 0x38, 0xC1, 0x81, 0x86, 0x1C,
  0x70, 0x31, 0xC1, 0x8C, 0x06, 0x30, 0x31, 0x80, 0xCE, 0x06, 0x60, 0x19,
  0x80, 0xCC, 0x03, 0x70, 0x1B, 0x00, 0x6C, 0x03, 0x60, 0x0D, 0x80, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x78, 0x30, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x18, 0x30,
  0x00, 0xC3, 0x80, 0x07, 0x38, 0x00, 0x1B, 0x80, 0x00, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1B, 0x80, 0x01, 0xCC, 0x00,
  0x1C, 0x70, 0x01, 0xC1, 0x80, 0x1C, 0x0C, 0x00, 0xC0, 0x30, 0x0C, 0x01,
  0x80, 0xE0, 0x06, 0x0E, 0x00, 0x38, 0x00, 0x03, 0x00, 0x06, 0x07, 0x00,
  0x1C, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06,
  0x00, 0x60, 0x1C, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0xE0, 0x01, 0x81, 0x80,
  0x03, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xE0, 0x00,
  0x31, 0x80, 0x00, 0x77, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x09, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x03, 0xE0, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0x80, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x1F, 0x03, 0xFF, 0x40, 0x0F, 0x80,
};

const GFXglyph NotoSans_LightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 29, 9, 1, -29 },
  { 34, 11, 11, 14, 4, -29 },
  { 50, 25, 29, 25, 1, -29 },
  { 141, 19, 32, 22, 2, -30 },
  { 217, 26, 29, 31, 3, -29 },
  { 312, 24, 29, 27, 2, -29 },
  { 399, 5, 11, 8, 4, -29 },
  { 406, 13, 35, 11, 1, -29 },
  { 463, 12, 35, 11, -3, -29 },
  { 516, 17, 17, 22, 5, -30 },
  { 553, 19, 19, 23, 3, -24 },
  { 599, 7, 10, 9, -2, -5 },
  { 608, 10, 2, 13, 1, -12 },
  { 611, 4, 4, 9, 1, -4 },
  { 613, 19, 29, 13, -2, -29 },
  { 682, 19, 29, 22, 2, -29 },
  { 751, 11, 29, 22, 6, -29 },
  { 791, 21, 29, 22, 0, -29 },
  { 868, 20, 29, 22, 1, -29 },
  { 941, 21, 29, 22, 0, -29 },
  { 1018, 19, 29, 22, 2, -29 },
  { 1087, 19, 29, 22, 3, -29 },
  { 1156, 18, 29, 22, 4, -29 },
  { 1222, 19, 29, 22, 2, -29 },
  { 1291, 19, 29, 22, 2, -29 },
  { 1360, 7, 22, 9, 1, -22 },
  { 1380, 10, 27, 9, -2, -22 },
  { 1414, 19, 19, 23, 3, -24 },
  { 1460, 18, 10, 23, 3, -19 },
  { 1483, 19, 19, 23, 3, -24 },
  { 1529, 15, 29, 17, 3, -29 },
  { 1584, 31, 32, 34, 2, -28 },
  { 1708, 22, 29, 22, -2, -29 },
  { 1788, 21, 29, 24, 2, -29 },
  { 1865, 22, 29, 24, 3, -29 },
  { 1945, 23, 29, 27, 2, -29 },
  { 2029, 20, 29, 21, 2, -29 },
  { 2102, 20, 29, 19, 2, -29 },
  { 2175, 24, 29, 27, 3, -29 },
  { 2262, 25, 29, 27, 2, -29 },
  { 2353, 14, 29, 12, 0, -29 },
  { 2404, 17, 36, 10, -7, -29 },
  { 2481, 24, 29, 22, 2, -29 },
  { 2568, 15, 29, 19, 2, -29 },
  { 2623, 31, 29, 33, 2, -29 },
  { 2736, 26, 29, 28, 2, -29 },
  { 2831, 24, 29, 29, 3, -29 },
  { 2918, 21, 29, 23, 2, -29 },
  { 2995, 24, 36, 29, 3, -29 },
  { 3103, 21, 29, 23, 2, -29 },
  { 3180, 20, 29, 20, 1, -29 },
  { 3253, 19, 29, 20, 4, -29 },
  { 3322, 25, 29, 27, 3, -29 },
  { 3413, 21, 29, 22, 4, -29 },
  { 3490, 32, 29, 34, 5, -29 },
  { 3606, 25, 29, 20, -2, -29 },
  { 3697, 20, 29, 20, 4, -29 },
  { 3770, 23, 29, 21, 0, -29 },
  { 3854, 15, 35, 12, 0, -29 },
  { 3920, 7, 29, 13, 4, -29 },
  { 3946, 15, 35, 12, -3, -29 },
  { 4012, 19, 18, 22, 2, -29 },
  { 4055, 16, 2, 15, -4, 4 },
  { 4059, 5, 7, 10, 6, -31 },
  { 4064, 19, 22, 22, 2, -22 },
  { 4117, 20, 30, 23, 1, -30 },
  { 4192, 16, 22, 18, 2, -22 },
  { 4236, 22, 30, 23, 2, -30 },
  { 4319, 17, 22, 20, 2, -22 },
  { 4366, 22, 41, 12, -5, -31 },
  { 4479, 21, 32, 23, 1, -22 },
  { 4563, 19, 30, 23, 1, -30 },
  { 4635, 9, 29, 9, 1, -29 },
  { 4668, 15, 39, 9, -5, -29 },
  { 4742, 19, 30, 19, 1, -30 },
  { 4814, 9, 30, 9, 1, -30 },
  { 4848, 31, 22, 34, 1, -22 },
  { 4934, 19, 22, 23, 1, -22 },
  { 4987, 19, 22, 23, 2, -22 },
  { 5040, 22, 31, 23, -1, -22 },
  { 5126, 20, 31, 23, 2, -22 },
  { 5204, 15, 22, 15, 1, -22 },
  { 5246, 16, 22, 17, 0, -22 },
  { 5290, 12, 26, 13, 2, -26 },
  { 5329, 19, 21, 23, 2, -21 },
  { 5379, 17, 21, 18, 2, -21 },
  { 5424, 27, 21, 27, 2, -21 },
  { 5495, 21, 21, 19, -1, -21 },
  { 5551, 23, 31, 18, -4, -21 },
  { 5641, 19, 21, 18, -1, -21 },
  { 5691, 15, 35, 14, 1, -29 },
  { 5757, 2, 40, 22, 11, -30 },
  { 5767, 15, 35, 14, -2, -29 },
  { 5833, 19, 4, 23, 3, -16 },
};

const GFXfont NotoSans_LightItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_LIGHTITALIC40PT7B_H_
