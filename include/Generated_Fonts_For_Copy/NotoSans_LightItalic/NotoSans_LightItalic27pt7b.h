#ifndef _NOTOSANS_LIGHTITALIC27PT7B_H_
#define _NOTOSANS_LIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x61, 0x86, 0x18, 0x41, 0x0C, 0x30, 0x82, 0x08, 0x61, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x66, 0x8D, 0x16, 0x2C, 0x51, 0xA2, 0x00, 0x01,
  0x84, 0x01, 0x04, 0x03, 0x0C, 0x03, 0x08, 0x02, 0x08, 0x02, 0x18, 0x3F,
  0xFF, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x30, 0x08, 0x20, 0x08, 0x20, 0xFF,
  0xFE, 0x18, 0x40, 0x10, 0x40, 0x10, 0x40, 0x30, 0xC0, 0x20, 0x80, 0x21,
  0x80, 0x00, 0xC0, 0x04, 0x01, 0xFC, 0x19, 0x31, 0x98, 0x08, 0x80, 0xC4,
  0x02, 0x20, 0x19, 0x00, 0x78, 0x00, 0xE0, 0x05, 0xC0, 0x26, 0x01, 0x10,
  0x18, 0x80, 0x8C, 0x84, 0xC7, 0xFC, 0x07, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x04, 0x00, 0x87, 0xC0, 0x42, 0x10, 0x31, 0x84, 0x18, 0x41, 0x04,
  0x10, 0x42, 0x0C, 0x11, 0x83, 0x0C, 0xC0, 0xC2, 0x27, 0x30, 0x93, 0x6C,
  0x6D, 0x8D, 0xF6, 0x43, 0x31, 0x30, 0xC0, 0x88, 0x30, 0x62, 0x08, 0x30,
  0x82, 0x08, 0x21, 0x84, 0x08, 0x43, 0x03, 0x31, 0x80, 0x78, 0x00, 0x80,
  0x03, 0xF0, 0x06, 0x18, 0x0C, 0x18, 0x0C, 0x08, 0x0C, 0x18, 0x0C, 0x10,
  0x04, 0x60, 0x07, 0xC0, 0x07, 0x00, 0x1F, 0x00, 0x31, 0x81, 0x60, 0xC3,
  0xC0, 0x46, 0xC0, 0x64, 0xC0, 0x3C, 0xC0, 0x18, 0xC0, 0x78, 0x60, 0xCC,
  0x3F, 0x86, 0x69, 0x6D, 0x20, 0x03, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x20,
  0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0xC0, 0xC0,
  0xC0, 0x40, 0x40, 0x60, 0x06, 0x02, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18,
  0x30, 0x20, 0xC0, 0x02, 0x00, 0x30, 0x02, 0x08, 0x20, 0xE2, 0x03, 0xC1,
  0x07, 0xF0, 0xA0, 0x12, 0x03, 0x30, 0x61, 0x00, 0x18, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x33, 0x26, 0x4C, 0xFC, 0xF0,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xFE, 0x18, 0x33, 0x03, 0x30,
  0x16, 0x01, 0x60, 0x14, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x02, 0x80, 0x68, 0x06, 0xC0, 0xCC, 0x18, 0x63, 0x03, 0xE0, 0x07,
  0x1E, 0x36, 0xE6, 0x44, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18,
  0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x00, 0x40, 0x1F, 0xE0, 0xC1, 0x82,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0xFC, 0x00, 0x80, 0x7F, 0x86, 0x06, 0x20, 0x30,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x60, 0x7E, 0x03, 0xF0, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x30, 0x71,
  0xFF, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x02, 0x80, 0x1A, 0x00, 0xD8, 0x06,
  0x60, 0x31, 0x81, 0x84, 0x0C, 0x10, 0x20, 0xC1, 0x03, 0x08, 0x08, 0x60,
  0x23, 0xFF, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x07, 0xFC, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x0D, 0xC0, 0x3F, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x63, 0x07, 0x07, 0xF0, 0x00, 0x00, 0x30,
  0x1F, 0xC3, 0x80, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x47,
  0x86, 0xC6, 0x38, 0x19, 0x80, 0x4C, 0x02, 0x40, 0x12, 0x00, 0x90, 0x0C,
  0xC0, 0x66, 0x06, 0x18, 0x60, 0x7E, 0x00, 0xFF, 0xF0, 0x03, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x1F, 0xC0, 0xC1, 0x82, 0x02, 0x18, 0x0C, 0x60, 0x21, 0x81,
  0x82, 0x04, 0x0C, 0x60, 0x0F, 0x00, 0xF8, 0x0E, 0x18, 0x60, 0x21, 0x00,
  0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x31, 0x01, 0x87, 0x0C, 0x0F, 0xE0, 0x01,
  0x80, 0x3F, 0x07, 0x0C, 0x30, 0x33, 0x01, 0x90, 0x04, 0x80, 0x24, 0x03,
  0x20, 0x19, 0x01, 0xCC, 0x1E, 0x3F, 0xA0, 0x63, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x20, 0xC1, 0xFC, 0x00, 0x11, 0xCC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x63, 0x00, 0x04, 0x1C, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x06, 0x18, 0x30, 0x41, 0x80, 0x00, 0x18,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x80, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E,
  0x01, 0x80, 0x08, 0x00, 0x00, 0x04, 0x1F, 0xE4, 0x18, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x7F, 0x80, 0x1E, 0x06, 0x01,
  0x80, 0x18, 0x18, 0x00, 0x61, 0x80, 0x01, 0x18, 0x1F, 0x0C, 0x83, 0x9C,
  0x2C, 0x30, 0x41, 0x41, 0x02, 0x0A, 0x18, 0x30, 0x50, 0x81, 0x87, 0x84,
  0x08, 0x2C, 0x20, 0xC1, 0x61, 0x06, 0x19, 0x0C, 0x51, 0x88, 0x3C, 0x78,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x04, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x40, 0x06, 0xC0, 0x09, 0x80,
  0x33, 0x00, 0x46, 0x01, 0x84, 0x06, 0x08, 0x0C, 0x10, 0x30, 0x30, 0x7F,
  0xE1, 0x80, 0xC2, 0x01, 0x8C, 0x01, 0x10, 0x02, 0x60, 0x05, 0x80, 0x0B,
  0x00, 0x18, 0x0F, 0xF8, 0x18, 0x18, 0x20, 0x18, 0x40, 0x31, 0x80, 0x63,
  0x00, 0xC4, 0x03, 0x08, 0x0C, 0x3F, 0xF0, 0x7F, 0xE0, 0xC0, 0x61, 0x00,
  0x42, 0x00, 0x8C, 0x01, 0x18, 0x02, 0x30, 0x0C, 0x40, 0x30, 0x81, 0xC3,
  0xFE, 0x00, 0x00, 0x30, 0x07, 0xFC, 0x18, 0x08, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xE0, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x0C, 0x1C, 0x08, 0x06, 0x08, 0x02,
  0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x10, 0x01, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x20, 0x03, 0x20, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x18,
  0x40, 0x30, 0x41, 0xE0, 0xFF, 0x00, 0x0F, 0xFC, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x3F, 0xF0, 0xFF, 0xC3,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xFF, 0xC3, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x03, 0xFF, 0x06, 0x03, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x7E,
  0xC0, 0xFE, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0x60, 0x0C,
  0x60, 0x08, 0x38, 0x38, 0x0F, 0xF0, 0x0C, 0x00, 0x86, 0x00, 0xC2, 0x00,
  0x61, 0x00, 0x31, 0x80, 0x10, 0xC0, 0x08, 0x40, 0x0C, 0x20, 0x06, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0C, 0x00, 0x84, 0x00, 0xC2, 0x00, 0x63, 0x00, 0x21,
  0x80, 0x10, 0xC0, 0x18, 0x40, 0x0C, 0x20, 0x06, 0x30, 0x02, 0x00, 0x0F,
  0x81, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x3F, 0x00, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x3E, 0x07, 0x80, 0x0C, 0x07, 0x0C, 0x0C, 0x08, 0x18,
  0x08, 0x30, 0x18, 0x60, 0x18, 0xC0, 0x11, 0x80, 0x13, 0x00, 0x37, 0x00,
  0x3F, 0x00, 0x31, 0x80, 0x21, 0x80, 0x20, 0x80, 0x60, 0xC0, 0x60, 0x40,
  0x60, 0x60, 0x40, 0x20, 0x40, 0x30, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0F, 0xFC, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC2, 0x80, 0x1E, 0x34, 0x00, 0xA1, 0xA0, 0x0D, 0x0D, 0x00, 0xD8,
  0x4C, 0x04, 0xC2, 0x60, 0x66, 0x33, 0x02, 0x21, 0x88, 0x31, 0x0C, 0x41,
  0x18, 0x42, 0x18, 0xC2, 0x11, 0x86, 0x30, 0xC8, 0x21, 0x86, 0xC1, 0x08,
  0x34, 0x18, 0x40, 0xE0, 0xC2, 0x06, 0x06, 0x30, 0x30, 0x20, 0x0C, 0x00,
  0xC3, 0x80, 0x20, 0xE0, 0x08, 0x68, 0x06, 0x1B, 0x01, 0x86, 0x40, 0x41,
  0x18, 0x10, 0x46, 0x0C, 0x30, 0x83, 0x0C, 0x30, 0xC3, 0x04, 0x20, 0x81,
  0x88, 0x20, 0x66, 0x18, 0x09, 0x86, 0x03, 0x61, 0x00, 0x50, 0x40, 0x1C,
  0x10, 0x07, 0x0C, 0x00, 0xC0, 0x00, 0x40, 0x07, 0xFC, 0x0E, 0x0E, 0x18,
  0x06, 0x30, 0x03, 0x30, 0x03, 0x60, 0x01, 0x60, 0x01, 0x40, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0,
  0x06, 0x60, 0x0C, 0x60, 0x18, 0x38, 0x70, 0x1F, 0xE0, 0x0F, 0xF0, 0x30,
  0x60, 0x80, 0xC2, 0x03, 0x18, 0x04, 0x60, 0x11, 0x00, 0xC4, 0x03, 0x30,
  0x18, 0xC1, 0xC3, 0xFC, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x07, 0xFC, 0x0E,
  0x0E, 0x18, 0x06, 0x30, 0x03, 0x30, 0x03, 0x60, 0x01, 0x60, 0x01, 0x40,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x06, 0xC0, 0x06, 0x60, 0x0C, 0x60, 0x18, 0x38, 0x70, 0x0F, 0xE0, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x0F, 0xF0, 0x30,
  0x60, 0x80, 0xC2, 0x03, 0x18, 0x04, 0x60, 0x31, 0x00, 0xC4, 0x02, 0x30,
  0x18, 0xFF, 0x83, 0xF8, 0x08, 0x30, 0x20, 0xC1, 0x81, 0x06, 0x06, 0x18,
  0x18, 0x40, 0x21, 0x00, 0xCC, 0x03, 0x00, 0x01, 0x80, 0x7F, 0xC7, 0x04,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x20, 0xE1, 0xFE, 0x00, 0x7F, 0xFE, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x00, 0x18, 0x01, 0x88, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00,
  0x31, 0x00, 0x10, 0x80, 0x08, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x10,
  0x01, 0x08, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x21, 0x80, 0x30,
  0x60, 0x30, 0x38, 0x70, 0x07, 0xF0, 0x00, 0x80, 0x0E, 0x00, 0x6C, 0x01,
  0x30, 0x0C, 0xC0, 0x23, 0x01, 0x8C, 0x04, 0x10, 0x30, 0x40, 0x81, 0x06,
  0x04, 0x30, 0x18, 0xC0, 0x66, 0x01, 0x98, 0x06, 0xC0, 0x0A, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x0F, 0x01, 0xC0, 0x6C, 0x05,
  0x01, 0xB0, 0x34, 0x0C, 0xC0, 0x90, 0x33, 0x06, 0x40, 0x8C, 0x11, 0x06,
  0x30, 0xC4, 0x10, 0x43, 0x10, 0xC1, 0x08, 0x42, 0x04, 0x61, 0x18, 0x11,
  0x04, 0x40, 0x4C, 0x13, 0x01, 0x20, 0x6C, 0x05, 0x81, 0xA0, 0x14, 0x07,
  0x80, 0x70, 0x1C, 0x01, 0x80, 0x70, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03,
  0x82, 0x01, 0x01, 0x81, 0x80, 0x41, 0x80, 0x21, 0x80, 0x19, 0x80, 0x04,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x48, 0x00,
  0x46, 0x00, 0x61, 0x00, 0x60, 0x80, 0x60, 0x60, 0x20, 0x10, 0x20, 0x0C,
  0x30, 0x06, 0x00, 0x80, 0x1E, 0x01, 0xB0, 0x18, 0x80, 0x84, 0x0C, 0x30,
  0xC1, 0x8C, 0x04, 0x40, 0x36, 0x01, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x0F, 0xFE,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xC3,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x0F, 0x80, 0x88, 0xCC, 0x44, 0x44, 0x66, 0x22, 0x22, 0x33, 0x11,
  0x10, 0x07, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x03, 0x0F, 0x80, 0x01, 0x80, 0x1C, 0x00, 0xA0, 0x08,
  0x80, 0xC4, 0x04, 0x30, 0x60, 0x82, 0x04, 0x30, 0x33, 0x00, 0x90, 0x07,
  0x80, 0x10, 0xFF, 0xC0, 0xCC, 0x62, 0x10, 0x03, 0x00, 0x7E, 0x46, 0x0A,
  0x60, 0x72, 0x01, 0xB0, 0x09, 0x00, 0xC8, 0x06, 0xC0, 0x36, 0x01, 0x30,
  0x19, 0x80, 0xC4, 0x0E, 0x31, 0xB0, 0xF9, 0x00, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x43, 0x02, 0x7E, 0x34, 0x11, 0xC0,
  0xCC, 0x06, 0x60, 0x32, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x02, 0x60, 0x33,
  0x01, 0xB8, 0x19, 0x61, 0x89, 0xF8, 0x00, 0x01, 0x81, 0xFC, 0x60, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x61, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0xC3, 0x07, 0xE4, 0x18, 0x28, 0x60, 0x30, 0x80,
  0x63, 0x00, 0xC6, 0x01, 0x08, 0x02, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x71,
  0x80, 0xC1, 0x02, 0x83, 0x19, 0x03, 0xE6, 0x00, 0x01, 0x80, 0xFE, 0x18,
  0x23, 0x03, 0x20, 0x26, 0x06, 0x61, 0xC7, 0xF8, 0x40, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x03, 0x0C, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0xF8, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x07, 0xF8, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x03, 0xC0, 0x00, 0x03, 0x04,
  0x3F, 0x21, 0x82, 0x8C, 0x06, 0x20, 0x19, 0x80, 0x66, 0x01, 0x10, 0x04,
  0xC0, 0x33, 0x00, 0xCC, 0x07, 0x30, 0x18, 0x40, 0xA1, 0x8D, 0x83, 0xE6,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x20, 0x60, 0xFF, 0x00, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x43, 0x02, 0x7E,
  0x34, 0x19, 0xC0, 0xCC, 0x06, 0x60, 0x32, 0x01, 0x30, 0x09, 0x80, 0xCC,
  0x06, 0x40, 0x32, 0x01, 0x30, 0x09, 0x80, 0xC8, 0x06, 0x00, 0x08, 0x70,
  0x80, 0x00, 0x01, 0x0C, 0x30, 0xC2, 0x08, 0x61, 0x86, 0x10, 0x43, 0x0C,
  0x20, 0x00, 0x40, 0x1C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x18, 0x1F,
  0x00, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x22, 0x06, 0x30, 0x61, 0x86, 0x0C, 0x60, 0x46, 0x02, 0x40, 0x36, 0x01,
  0xD8, 0x0C, 0x40, 0x43, 0x02, 0x08, 0x30, 0x61, 0x81, 0x08, 0x0C, 0x00,
  0x0C, 0x30, 0x82, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x18,
  0x41, 0x0C, 0x30, 0x80, 0x00, 0xC0, 0xC0, 0x9F, 0x1F, 0x8D, 0x0D, 0x84,
  0x70, 0x70, 0x33, 0x03, 0x81, 0x98, 0x18, 0x08, 0x80, 0xC0, 0x4C, 0x06,
  0x06, 0x60, 0x20, 0x33, 0x01, 0x01, 0x90, 0x18, 0x08, 0x80, 0xC0, 0x4C,
  0x04, 0x06, 0x60, 0x20, 0x32, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x9F, 0x8D,
  0x06, 0x70, 0x33, 0x01, 0x98, 0x0C, 0x80, 0x4C, 0x02, 0x60, 0x33, 0x01,
  0x90, 0x0D, 0x80, 0x4C, 0x06, 0x60, 0x33, 0x01, 0x80, 0x01, 0x80, 0x7F,
  0x06, 0x0C, 0x60, 0x22, 0x01, 0xB0, 0x0D, 0x00, 0x68, 0x03, 0xC0, 0x1E,
  0x00, 0xB0, 0x0C, 0x80, 0x66, 0x06, 0x38, 0x60, 0x7E, 0x00, 0x00, 0x30,
  0x09, 0xF8, 0x34, 0x10, 0x70, 0x30, 0xC0, 0x61, 0x80, 0xC2, 0x01, 0x8C,
  0x03, 0x18, 0x06, 0x30, 0x08, 0x60, 0x30, 0xC0, 0x63, 0x81, 0x87, 0x86,
  0x09, 0xF8, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x04, 0x3F, 0x21, 0x82, 0x8C, 0x06, 0x20, 0x19, 0x80,
  0x66, 0x01, 0x10, 0x04, 0xC0, 0x33, 0x00, 0xCC, 0x07, 0x30, 0x18, 0x40,
  0xA1, 0x8D, 0x83, 0xE6, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x00, 0xC4, 0xF3, 0x40, 0xE0, 0x30, 0x0C, 0x02, 0x01,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x00, 0x03, 0x03,
  0xFC, 0xC0, 0x98, 0x03, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x09, 0x83, 0x1F, 0xC0, 0x08, 0x08, 0x18, 0x10, 0xFF,
  0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x40,
  0x7C, 0x30, 0x09, 0x80, 0xCC, 0x06, 0x40, 0x32, 0x01, 0x30, 0x09, 0x80,
  0xCC, 0x06, 0x40, 0x32, 0x03, 0x30, 0x18, 0x81, 0xC6, 0x36, 0x1F, 0x20,
  0xC0, 0x34, 0x06, 0x40, 0x64, 0x0C, 0x40, 0x86, 0x18, 0x61, 0x06, 0x30,
  0x22, 0x02, 0x60, 0x2C, 0x02, 0xC0, 0x38, 0x03, 0x00, 0x81, 0x81, 0xC0,
  0xC0, 0xE0, 0xE0, 0xD0, 0x58, 0x68, 0x6C, 0x24, 0x26, 0x32, 0x33, 0x11,
  0x11, 0x98, 0x98, 0x48, 0x48, 0x2C, 0x2C, 0x14, 0x14, 0x0E, 0x0E, 0x06,
  0x06, 0x03, 0x00, 0x18, 0x0C, 0x30, 0x60, 0x43, 0x01, 0x98, 0x06, 0xC0,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x05, 0x80, 0x32, 0x01, 0x8C, 0x0C, 0x10,
  0x60, 0x63, 0x00, 0xC0, 0x0C, 0x03, 0x04, 0x06, 0x04, 0x06, 0x04, 0x0C,
  0x06, 0x08, 0x06, 0x18, 0x06, 0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x60,
  0x02, 0x40, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x40, 0x00, 0x1F, 0xF0,
  0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x0F, 0xF8, 0x03, 0xC1, 0x80, 0x40, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x07, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x18, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x30, 0x07, 0x03, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x0C, 0x0E, 0x00,
  0x7C, 0x0E, 0x39, 0xE0, 0x78,
};

const GFXglyph NotoSans_LightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 19, 6, 1, -19 },
  { 16, 7, 7, 9, 3, -19 },
  { 23, 16, 19, 17, 1, -19 },
  { 61, 13, 22, 15, 1, -20 },
  { 97, 18, 20, 21, 2, -20 },
  { 142, 16, 20, 18, 1, -20 },
  { 182, 3, 7, 5, 3, -19 },
  { 185, 8, 23, 7, 1, -19 },
  { 208, 8, 23, 7, -2, -19 },
  { 231, 12, 12, 15, 3, -21 },
  { 249, 13, 13, 15, 2, -16 },
  { 271, 4, 6, 6, -1, -3 },
  { 274, 6, 1, 8, 1, -8 },
  { 275, 2, 2, 6, 1, -2 },
  { 276, 12, 19, 9, -1, -19 },
  { 305, 12, 20, 15, 2, -20 },
  { 335, 8, 19, 15, 4, -19 },
  { 354, 14, 20, 15, 0, -20 },
  { 389, 13, 20, 15, 1, -20 },
  { 422, 14, 19, 15, 0, -19 },
  { 456, 14, 19, 15, 1, -19 },
  { 490, 13, 20, 15, 2, -20 },
  { 523, 12, 19, 15, 3, -19 },
  { 552, 14, 20, 15, 1, -20 },
  { 587, 13, 20, 15, 1, -20 },
  { 620, 5, 15, 6, 1, -15 },
  { 630, 7, 18, 6, -1, -15 },
  { 646, 13, 13, 15, 2, -16 },
  { 668, 12, 7, 15, 2, -13 },
  { 679, 13, 13, 15, 2, -16 },
  { 701, 10, 20, 11, 2, -20 },
  { 726, 21, 21, 23, 1, -19 },
  { 782, 15, 19, 15, -1, -19 },
  { 818, 15, 19, 16, 1, -19 },
  { 854, 15, 20, 16, 2, -20 },
  { 892, 16, 19, 18, 1, -19 },
  { 930, 14, 19, 14, 1, -19 },
  { 964, 14, 19, 13, 1, -19 },
  { 998, 16, 20, 18, 2, -20 },
  { 1038, 17, 19, 18, 1, -19 },
  { 1079, 9, 19, 8, 0, -19 },
  { 1101, 11, 24, 7, -4, -19 },
  { 1134, 16, 19, 15, 1, -19 },
  { 1172, 10, 19, 13, 1, -19 },
  { 1196, 21, 19, 22, 1, -19 },
  { 1246, 18, 19, 19, 1, -19 },
  { 1289, 16, 20, 19, 2, -20 },
  { 1329, 14, 19, 15, 1, -19 },
  { 1363, 16, 25, 19, 2, -20 },
  { 1413, 14, 19, 15, 1, -19 },
  { 1447, 13, 20, 14, 1, -20 },
  { 1480, 14, 19, 13, 2, -19 },
  { 1514, 17, 19, 19, 2, -19 },
  { 1555, 14, 19, 15, 3, -19 },
  { 1589, 22, 19, 23, 3, -19 },
  { 1642, 17, 19, 14, -1, -19 },
  { 1683, 13, 19, 13, 3, -19 },
  { 1714, 15, 19, 14, 0, -19 },
  { 1750, 10, 23, 8, 0, -19 },
  { 1779, 4, 19, 9, 3, -19 },
  { 1789, 10, 23, 8, -2, -19 },
  { 1818, 13, 12, 15, 1, -19 },
  { 1838, 10, 1, 10, -2, 3 },
  { 1840, 4, 5, 7, 4, -21 },
  { 1843, 13, 15, 15, 1, -15 },
  { 1868, 13, 21, 16, 1, -21 },
  { 1903, 11, 15, 12, 1, -15 },
  { 1924, 15, 21, 16, 1, -21 },
  { 1964, 12, 15, 13, 1, -15 },
  { 1987, 15, 27, 8, -3, -21 },
  { 2038, 14, 21, 16, 1, -15 },
  { 2075, 13, 21, 15, 1, -21 },
  { 2110, 6, 20, 6, 1, -20 },
  { 2125, 11, 26, 6, -4, -20 },
  { 2161, 13, 21, 13, 1, -21 },
  { 2196, 6, 21, 6, 1, -21 },
  { 2212, 21, 15, 23, 1, -15 },
  { 2252, 13, 15, 15, 1, -15 },
  { 2277, 13, 15, 15, 1, -15 },
  { 2302, 15, 21, 16, -1, -15 },
  { 2342, 14, 21, 16, 1, -15 },
  { 2379, 10, 15, 10, 1, -15 },
  { 2398, 11, 15, 12, 0, -15 },
  { 2419, 8, 18, 9, 1, -18 },
  { 2437, 13, 14, 15, 1, -14 },
  { 2460, 12, 14, 12, 1, -14 },
  { 2481, 17, 14, 19, 2, -14 },
  { 2511, 14, 14, 13, -1, -14 },
  { 2536, 16, 21, 12, -3, -14 },
  { 2578, 12, 14, 12, 0, -14 },
  { 2599, 10, 23, 9, 1, -19 },
  { 2628, 2, 28, 15, 7, -21 },
  { 2635, 10, 23, 9, -1, -19 },
  { 2664, 13, 3, 15, 2, -11 },
};

const GFXfont NotoSans_LightItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_LIGHTITALIC27PT7B_H_
