#ifndef _NOTOSANS_LIGHTITALIC44PT7B_H_
#define _NOTOSANS_LIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0xF0, 0x3C, 0x0F, 0x00, 0x30, 0xEE, 0x1D, 0xC3, 0xB0, 0x66, 0x0C, 0xC1,
  0x98, 0x76, 0x0C, 0xC1, 0x98, 0x33, 0x04, 0x00, 0x00, 0x0E, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x18, 0x03, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x30, 0x1C,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x80,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x70, 0x00,
  0x18, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1E, 0x30, 0x41,
  0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x07, 0x0C, 0x00, 0x1C, 0xC0, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xCF, 0x00, 0x06, 0x1C,
  0x00, 0x30, 0xE0, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06,
  0x0E, 0x00, 0x30, 0xE1, 0x01, 0x8E, 0x0F, 0xDB, 0xE0, 0x7F, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x20, 0xFE, 0x00, 0x0C, 0x1C,
  0x70, 0x01, 0x83, 0x83, 0x00, 0x38, 0x30, 0x38, 0x07, 0x07, 0x03, 0x80,
  0x60, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0C,
  0x03, 0x03, 0x00, 0xC0, 0x30, 0x60, 0x0C, 0x03, 0x0E, 0x00, 0xC0, 0x70,
  0xC0, 0x0C, 0x06, 0x18, 0xFC, 0xC0, 0x63, 0x1F, 0xEC, 0x0C, 0x73, 0x87,
  0xC1, 0xC6, 0x30, 0x3E, 0x38, 0xC6, 0x03, 0x7F, 0x1C, 0x60, 0x33, 0xE3,
  0x8E, 0x03, 0x00, 0x30, 0xC0, 0x30, 0x06, 0x0C, 0x03, 0x00, 0xE0, 0xC0,
  0x30, 0x1C, 0x1C, 0x07, 0x01, 0x81, 0x80, 0x60, 0x30, 0x18, 0x06, 0x07,
  0x01, 0x80, 0xE0, 0xE0, 0x1C, 0x0C, 0x0C, 0x01, 0xC1, 0xC1, 0x80, 0x0C,
  0x38, 0x38, 0x00, 0xFF, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x60, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80,
  0x38, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xC7, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xB8, 0x00, 0x03, 0xC7, 0x00, 0x31, 0xC0, 0xC0, 0x1C, 0xE0, 0x38,
  0x06, 0x70, 0x07, 0x03, 0xB8, 0x00, 0xE1, 0xCE, 0x00, 0x38, 0x63, 0x00,
  0x07, 0x38, 0xC0, 0x00, 0xFC, 0x30, 0x00, 0x1E, 0x0C, 0x00, 0x07, 0x03,
  0x80, 0x03, 0xE0, 0xF0, 0x03, 0xDC, 0x1E, 0x03, 0xC7, 0x03, 0xFF, 0xE0,
  0xE0, 0x7F, 0xE0, 0x1C, 0x37, 0x76, 0x66, 0x6C, 0xCC, 0xC0, 0x00, 0x78,
  0x03, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x04,
  0x06, 0x01, 0xE0, 0xC0, 0x1F, 0x18, 0x00, 0xF3, 0x00, 0x03, 0xDF, 0xE0,
  0x1F, 0xFC, 0x07, 0x80, 0x01, 0xB0, 0x00, 0x63, 0x00, 0x38, 0x60, 0x0E,
  0x0E, 0x03, 0xC0, 0xC0, 0x30, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x1C, 0x30, 0xE1,
  0x87, 0x0C, 0x18, 0x60, 0xC3, 0x00, 0x7F, 0xFF, 0xFC, 0x6F, 0xFF, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0xE3,
  0xC0, 0x78, 0x0E, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0,
  0x03, 0x38, 0x00, 0x33, 0x80, 0x03, 0x30, 0x00, 0x37, 0x00, 0x03, 0x70,
  0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0E,
  0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03,
  0x0E, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x83, 0xC0, 0x3F, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0xF0, 0x1E, 0x07, 0xE1, 0xEE, 0x3C, 0xEF, 0x0C, 0xE0, 0xC4,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xF3, 0xE0, 0x0E, 0x00, 0xE0,
  0x18, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0x0F, 0x81, 0xE0, 0x0E, 0x02, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x80, 0x03, 0xC3, 0x80, 0x1E, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0E, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00,
  0x07, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xC1, 0x80, 0x07,
  0x03, 0x00, 0x1C, 0x06, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x38, 0x03, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x0E,
  0x0E, 0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x80, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xC0,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x20, 0x01,
  0xE0, 0xE0, 0x1F, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0x86, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x01, 0x00, 0x38, 0xFF, 0x81, 0xDF,
  0xFE, 0x0D, 0xC0, 0x78, 0x78, 0x01, 0xC7, 0x80, 0x06, 0x3C, 0x00, 0x39,
  0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x00, 0x03, 0x98, 0x00,
  0x18, 0xC0, 0x00, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x60, 0xC0, 0x07, 0x07,
  0x00, 0x70, 0x1C, 0x0F, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0x80, 0x1F, 0x1F, 0x00, 0xF0, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00,
  0x70, 0x70, 0x01, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60,
  0x70, 0x03, 0x80, 0xC0, 0x1C, 0x03, 0x80, 0xE0, 0x07, 0x0F, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x3E, 0x1C, 0x01, 0xC0, 0x38,
  0x0E, 0x00, 0x70, 0x70, 0x00, 0xE1, 0x80, 0x03, 0x8E, 0x00, 0x06, 0x38,
  0x00, 0x18, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x70, 0x70, 0x03, 0xC0, 0xE0, 0x1E, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xF8, 0xF8, 0x0F, 0x01, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0x18, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x18, 0x00, 0x39,
  0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00,
  0x1C, 0xE0, 0x01, 0xE3, 0x00, 0x1E, 0x1C, 0x01, 0xB0, 0x78, 0x3B, 0x81,
  0xFF, 0x9C, 0x07, 0xF0, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x40, 0x3C, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x06, 0x0F, 0x0F, 0x0F, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xF0,
  0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x1F,
  0xFC, 0x3F, 0x3E, 0x30, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xE0,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x01, 0x87, 0x00, 0x7F, 0xE0, 0x71, 0x80, 0x7C, 0x78, 0x1C,
  0xE0, 0x38, 0x06, 0x03, 0x30, 0x1C, 0x03, 0x80, 0xDC, 0x06, 0x00, 0xC0,
  0x36, 0x03, 0x00, 0x30, 0x0D, 0x80, 0xC0, 0x1C, 0x07, 0x60, 0x70, 0x06,
  0x01, 0xD8, 0x18, 0x01, 0x80, 0x6E, 0x06, 0x00, 0x60, 0x1B, 0x81, 0x80,
  0x38, 0x0E, 0xE0, 0x60, 0x0E, 0x03, 0x38, 0x18, 0x07, 0x01, 0xCE, 0x06,
  0x03, 0x60, 0xE1, 0x81, 0xC1, 0xD8, 0x70, 0x60, 0x3F, 0xE7, 0xF8, 0x18,
  0x07, 0xE0, 0xFC, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x04, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xB8, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x18, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x1C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x1C,
  0x00, 0x70, 0x0C, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x0C,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0x80, 0x3E,
  0x03, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x78, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x1C, 0x00, 0xF0, 0x18, 0x00, 0x38, 0x18, 0x00, 0x38,
  0x38, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C,
  0x30, 0x00, 0x18, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x70,
  0x60, 0x01, 0xE0, 0x60, 0x0F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xEF, 0xE0, 0x1E, 0x00,
  0x20, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x03, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x38,
  0x07, 0xE0, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x01, 0x80, 0x0F, 0x80, 0x60,
  0x3F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x08, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x03, 0xC0, 0x07, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x03, 0xFF, 0x18, 0x00, 0xFF, 0xCE, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00,
  0xC0, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x1F, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x0E,
  0x00, 0x01, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x18, 0x00, 0x03, 0xFE, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x87, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x06,
  0x07, 0x80, 0x01, 0x83, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x0C, 0x70, 0x00, 0x03, 0x3C, 0x00, 0x00, 0xDF, 0x00, 0x00, 0x7E, 0xE0,
  0x00, 0x1F, 0x18, 0x00, 0x07, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0,
  0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00,
  0xC0, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x1C,
  0x01, 0x80, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0D, 0x80, 0x00, 0x3E, 0x03, 0x60, 0x00,
  0x1D, 0x81, 0xD8, 0x00, 0x06, 0xE0, 0x76, 0x00, 0x03, 0xB8, 0x19, 0x80,
  0x00, 0xCE, 0x06, 0x70, 0x00, 0x73, 0x01, 0x9C, 0x00, 0x18, 0xC0, 0xE3,
  0x00, 0x0C, 0x70, 0x38, 0xC0, 0x07, 0x1C, 0x0C, 0x30, 0x01, 0x87, 0x03,
  0x0C, 0x00, 0xE1, 0x81, 0xC3, 0x00, 0x30, 0x60, 0x70, 0xE0, 0x1C, 0x38,
  0x1C, 0x18, 0x06, 0x0E, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81, 0x81, 0xC0,
  0xC0, 0xE0, 0x60, 0x60, 0x70, 0x38, 0x18, 0x38, 0x1C, 0x0C, 0x07, 0x0C,
  0x07, 0x03, 0x01, 0xC7, 0x01, 0x80, 0xC0, 0x31, 0x80, 0x60, 0x70, 0x0C,
  0xC0, 0x38, 0x1C, 0x03, 0x70, 0x0E, 0x06, 0x00, 0xD8, 0x03, 0x81, 0x80,
  0x3E, 0x00, 0xC0, 0x60, 0x0F, 0x00, 0x30, 0x38, 0x03, 0xC0, 0x1C, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x3C, 0x00, 0x03, 0x03,
  0xC0, 0x00, 0x70, 0x3E, 0x00, 0x07, 0x03, 0x60, 0x00, 0x60, 0x77, 0x00,
  0x06, 0x07, 0x70, 0x00, 0xE0, 0x63, 0x00, 0x0E, 0x06, 0x38, 0x00, 0xE0,
  0x61, 0x80, 0x0C, 0x0E, 0x1C, 0x00, 0xC0, 0xE1, 0xC0, 0x1C, 0x0C, 0x0C,
  0x01, 0xC0, 0xC0, 0xE0, 0x18, 0x1C, 0x06, 0x01, 0x81, 0xC0, 0x70, 0x18,
  0x1C, 0x07, 0x03, 0x81, 0x80, 0x30, 0x38, 0x18, 0x03, 0x83, 0x03, 0x80,
  0x18, 0x30, 0x38, 0x01, 0xC3, 0x03, 0x00, 0x1C, 0x70, 0x30, 0x00, 0xC7,
  0x03, 0x00, 0x0E, 0x60, 0x70, 0x00, 0x66, 0x07, 0x00, 0x07, 0x60, 0x60,
  0x00, 0x7E, 0x06, 0x00, 0x03, 0xE0, 0x60, 0x00, 0x3C, 0x0E, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xF9, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0x38, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0E,
  0x01, 0xE0, 0x18, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x38, 0x00,
  0x30, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x07, 0x03, 0x00, 0x1C,
  0x0E, 0x01, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF9, 0xF8, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0x98, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x07,
  0x80, 0x1E, 0x01, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0E, 0x01, 0xE0, 0x18, 0x00, 0xE0, 0x30,
  0x00, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x06, 0x00,
  0x0E, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x30, 0x70, 0x00, 0xE0, 0xC0, 0x03,
  0x81, 0x80, 0x0F, 0x03, 0x00, 0x7C, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x30, 0x1C, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x60, 0x0C, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x70, 0x01, 0x80, 0xE0,
  0x03, 0x81, 0xC0, 0x07, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x1F,
  0xDF, 0x80, 0xF0, 0x06, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x80, 0x07,
  0x83, 0x80, 0x7C, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x1C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x61, 0x80, 0x00, 0x38, 0x60, 0x00,
  0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x1C, 0x30, 0x00, 0x07, 0x1C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x01, 0xC0, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0x60, 0x00, 0x0E, 0x60, 0x00,
  0x1C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x70, 0x00, 0x30, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x30, 0x01,
  0xC0, 0x30, 0x03, 0x80, 0x30, 0x03, 0x80, 0x30, 0x07, 0x00, 0x38, 0x07,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x38, 0x00, 0x18, 0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x60,
  0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x1B, 0x80, 0x07,
  0x80, 0x07, 0x70, 0x00, 0xF0, 0x00, 0xEE, 0x00, 0x36, 0x00, 0x39, 0xC0,
  0x06, 0xC0, 0x07, 0x38, 0x01, 0xD8, 0x00, 0xC7, 0x00, 0x33, 0x00, 0x38,
  0x60, 0x0E, 0x70, 0x06, 0x0C, 0x01, 0x8E, 0x01, 0xC1, 0x80, 0x71, 0xC0,
  0x30, 0x30, 0x0C, 0x38, 0x0E, 0x06, 0x03, 0x83, 0x01, 0x80, 0xC0, 0x60,
  0x60, 0x70, 0x18, 0x1C, 0x0C, 0x0E, 0x03, 0x03, 0x01, 0x81, 0x80, 0x60,
  0xE0, 0x30, 0x70, 0x0C, 0x18, 0x06, 0x0C, 0x01, 0x87, 0x00, 0xC3, 0x80,
  0x30, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x03, 0x1C, 0x00, 0xE7, 0x00, 0x63,
  0x00, 0x1C, 0xC0, 0x0C, 0xE0, 0x03, 0xB8, 0x01, 0x98, 0x00, 0x76, 0x00,
  0x33, 0x00, 0x0D, 0xC0, 0x06, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x3E,
  0x00, 0x1B, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x0C, 0x00, 0x1C,
  0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x07, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x07, 0x18, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x30, 0x03, 0x80, 0x03, 0x80, 0x30, 0x00, 0x38, 0x07, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x3D, 0x80, 0x00, 0xE6,
  0x00, 0x07, 0x1C, 0x00, 0x38, 0x30, 0x00, 0xC0, 0xC0, 0x07, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x60, 0x38, 0x01, 0xC0, 0xC0,
  0x03, 0x07, 0x00, 0x0C, 0x38, 0x00, 0x39, 0xC0, 0x00, 0xE6, 0x00, 0x01,
  0xB8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x01,
  0xFF, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0xC1, 0x83, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x38, 0x70, 0x60, 0xC1, 0x83, 0x07, 0x0E, 0x0C, 0x18,
  0x30, 0x60, 0xE1, 0xC1, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x06, 0x60, 0x00, 0x73,
  0x00, 0x03, 0x1C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x0C, 0x01,
  0xC0, 0x60, 0x0C, 0x03, 0x80, 0xE0, 0x0C, 0x06, 0x00, 0x60, 0x70, 0x01,
  0x83, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x01, 0x98, 0x00, 0x0D, 0xC0,
  0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xE1, 0xC1, 0xC1, 0x83,
  0x83, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0xC0, 0xF1, 0xE6, 0x0E, 0x03,
  0x30, 0xE0, 0x0F, 0x8E, 0x00, 0x78, 0x60, 0x01, 0xC7, 0x00, 0x0E, 0x30,
  0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0E,
  0x70, 0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00,
  0x1E, 0x38, 0x01, 0xF0, 0xC0, 0x0F, 0x07, 0x00, 0xD8, 0x3C, 0x1C, 0xC0,
  0xFF, 0xC6, 0x03, 0xF8, 0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x71, 0xFE, 0x01,
  0x9E, 0x3C, 0x06, 0xE0, 0x38, 0x3B, 0x00, 0x60, 0xF8, 0x01, 0xC3, 0xC0,
  0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07,
  0x18, 0x00, 0x1C, 0x60, 0x00, 0x71, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x38,
  0x00, 0x38, 0xE0, 0x00, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x18, 0x78, 0x00,
  0xE1, 0xB0, 0x07, 0x06, 0x60, 0x78, 0x19, 0xFF, 0xC0, 0xC1, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x3E, 0x3C, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x01, 0x81, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x7C, 0x1C,
  0x01, 0xFF, 0x1C, 0x03, 0xC7, 0x98, 0x07, 0x00, 0xD8, 0x0E, 0x00, 0xD8,
  0x1C, 0x00, 0x78, 0x38, 0x00, 0x78, 0x38, 0x00, 0x70, 0x30, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x60,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0,
  0xE0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x60, 0x07, 0xC0, 0x70, 0x0D, 0xC0,
  0x78, 0x39, 0x80, 0x3F, 0xF1, 0x80, 0x1F, 0xC1, 0x80, 0x00, 0x3E, 0x00,
  0x7F, 0xE0, 0x3E, 0x7C, 0x1C, 0x07, 0x0E, 0x00, 0xC7, 0x00, 0x31, 0x80,
  0x0C, 0xE0, 0x07, 0x30, 0x01, 0xDC, 0x01, 0xE7, 0x01, 0xF1, 0xFF, 0xF0,
  0x7F, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x01, 0x81, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF6,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x10,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x0C,
  0x07, 0xCF, 0x30, 0x1C, 0x03, 0x60, 0x70, 0x06, 0xC1, 0xC0, 0x07, 0x87,
  0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0,
  0x00, 0xE1, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x07,
  0x81, 0x80, 0x1F, 0x03, 0x80, 0x6E, 0x07, 0x83, 0x98, 0x07, 0xFE, 0x30,
  0x07, 0xF0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x60,
  0x0F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x3E, 0x01, 0xC7, 0xFC, 0x0C, 0x79, 0xE0, 0x6E, 0x03, 0x87, 0x60, 0x0C,
  0x3E, 0x00, 0x61, 0xE0, 0x03, 0x0E, 0x00, 0x18, 0x70, 0x00, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xE0, 0x01,
  0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x41, 0xC0, 0x1C, 0x0C, 0x01, 0xC0, 0x60, 0x1C,
  0x07, 0x01, 0xC0, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x0C, 0x1C, 0x00, 0x61,
  0xC0, 0x07, 0x1C, 0x00, 0x39, 0xC0, 0x01, 0x9E, 0x00, 0x0D, 0xB0, 0x00,
  0x79, 0xC0, 0x07, 0x86, 0x00, 0x38, 0x38, 0x01, 0x80, 0xC0, 0x0C, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x01, 0x80, 0x1C, 0x0C,
  0x00, 0x60, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x3E, 0x01, 0x87, 0xF8, 0x3F, 0xE0, 0x67, 0x9E, 0x1E, 0x78,
  0x1B, 0x81, 0xCC, 0x07, 0x0E, 0x80, 0x76, 0x01, 0xC3, 0xC0, 0x0F, 0x00,
  0x30, 0xF0, 0x03, 0xC0, 0x0C, 0x38, 0x00, 0xE0, 0x03, 0x0E, 0x00, 0x78,
  0x01, 0xC7, 0x00, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x00, 0x1C, 0x70, 0x01,
  0x80, 0x06, 0x18, 0x00, 0x60, 0x01, 0x86, 0x00, 0x38, 0x00, 0xE3, 0x80,
  0x0E, 0x00, 0x38, 0xE0, 0x03, 0x80, 0x0E, 0x30, 0x00, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0x00, 0xC7, 0x00, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x00, 0x1C,
  0x70, 0x01, 0x80, 0x06, 0x18, 0x00, 0x60, 0x01, 0x86, 0x00, 0x18, 0x00,
  0xE3, 0x80, 0x0E, 0x00, 0x38, 0x06, 0x07, 0xC0, 0x30, 0xFF, 0x81, 0x9F,
  0x3E, 0x0D, 0xC0, 0x70, 0xEC, 0x01, 0x87, 0xC0, 0x0C, 0x3C, 0x00, 0x61,
  0xC0, 0x03, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00,
  0x71, 0x80, 0x03, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x0F,
  0xFC, 0x00, 0xF9, 0xF0, 0x0E, 0x01, 0xC0, 0xE0, 0x07, 0x0E, 0x00, 0x38,
  0xE0, 0x00, 0xC7, 0x00, 0x06, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xD8, 0x00,
  0x0E, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x01, 0xDC,
  0x00, 0x0E, 0xE0, 0x00, 0x67, 0x00, 0x07, 0x18, 0x00, 0x70, 0xE0, 0x03,
  0x87, 0x00, 0x38, 0x1E, 0x07, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xF0, 0x01, 0x87, 0xF8, 0x01, 0x8E, 0x3C, 0x01, 0xB8, 0x0E, 0x03,
  0xB0, 0x06, 0x03, 0xE0, 0x07, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x03,
  0x80, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06,
  0x00, 0x07, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x18, 0x1E, 0x00, 0x38, 0x1B,
  0x00, 0x70, 0x19, 0x81, 0xE0, 0x19, 0xFF, 0xC0, 0x38, 0x7F, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0x30, 0x3E,
  0x79, 0x81, 0xC0, 0x36, 0x0E, 0x00, 0xD8, 0x70, 0x01, 0xE3, 0x80, 0x07,
  0x8E, 0x00, 0x1C, 0x30, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x18,
  0x00, 0x1C, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x18, 0x01, 0xF0,
  0x70, 0x0D, 0xC1, 0xE0, 0xE6, 0x03, 0xFF, 0x18, 0x07, 0xF0, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x83, 0x0F, 0xC1, 0x9F, 0xE0, 0xDC, 0x00,
  0xEC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7C,
  0x7C, 0x38, 0x02, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x80, 0x0E, 0x38, 0x07, 0x0F, 0xFF, 0x80, 0xFF, 0xC0,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x03, 0xFF, 0xFF,
  0xFF, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0x80,
  0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71,
  0x80, 0x03, 0x0C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00,
  0x71, 0x80, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x38,
  0x01, 0xE0, 0xC0, 0x1B, 0x07, 0x03, 0x98, 0x1F, 0xF8, 0xC0, 0x7F, 0x0E,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x19, 0x80, 0x07, 0x30, 0x00, 0xC6, 0x00,
  0x38, 0xC0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x0C, 0x06, 0x03,
  0x80, 0xC0, 0x60, 0x18, 0x1C, 0x03, 0x07, 0x00, 0x60, 0xE0, 0x0E, 0x38,
  0x01, 0xC7, 0x00, 0x39, 0xC0, 0x03, 0x30, 0x00, 0x6E, 0x00, 0x0D, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x1D,
  0x80, 0x1C, 0x00, 0xE6, 0x00, 0xF8, 0x03, 0x18, 0x03, 0x60, 0x1C, 0x60,
  0x1D, 0x80, 0x61, 0x80, 0x66, 0x03, 0x86, 0x03, 0x98, 0x0E, 0x18, 0x0C,
  0x60, 0x70, 0x60, 0x71, 0x81, 0xC1, 0x81, 0x86, 0x0E, 0x06, 0x0E, 0x18,
  0x38, 0x18, 0x30, 0x60, 0xC0, 0x71, 0xC1, 0x87, 0x01, 0xC6, 0x06, 0x18,
  0x07, 0x38, 0x1C, 0xE0, 0x1C, 0xC0, 0x73, 0x00, 0x77, 0x01, 0xDC, 0x01,
  0xD8, 0x07, 0x60, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x0F, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x00,
  0xC0, 0xE0, 0x00, 0xE0, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x73, 0x80, 0x00,
  0x37, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xC7, 0x00, 0x03,
  0x83, 0x00, 0x07, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x38, 0x00, 0xC0, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0x60,
  0x1C, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x70, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x0B, 0xFF, 0x00, 0xFC, 0x3F, 0x1F,
  0x80, 0x7F, 0xE8, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_LightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 31, 10, 1, -31 },
  { 40, 11, 11, 15, 5, -31 },
  { 56, 27, 31, 28, 1, -31 },
  { 161, 21, 36, 24, 2, -33 },
  { 256, 28, 32, 34, 4, -32 },
  { 368, 26, 32, 30, 2, -32 },
  { 472, 4, 11, 9, 5, -31 },
  { 478, 13, 38, 12, 2, -31 },
  { 540, 13, 38, 12, -3, -31 },
  { 602, 19, 19, 24, 5, -33 },
  { 648, 21, 21, 25, 3, -26 },
  { 704, 7, 11, 10, -2, -5 },
  { 714, 11, 2, 14, 1, -13 },
  { 717, 4, 4, 10, 1, -4 },
  { 719, 20, 31, 15, -2, -31 },
  { 797, 20, 32, 24, 3, -32 },
  { 877, 12, 31, 24, 7, -31 },
  { 924, 23, 32, 24, 0, -32 },
  { 1016, 22, 32, 24, 1, -32 },
  { 1104, 23, 32, 24, 0, -32 },
  { 1196, 22, 31, 24, 2, -31 },
  { 1282, 21, 32, 24, 3, -32 },
  { 1366, 21, 31, 24, 4, -31 },
  { 1448, 22, 32, 24, 2, -32 },
  { 1536, 21, 32, 24, 2, -32 },
  { 1620, 8, 24, 10, 1, -24 },
  { 1644, 11, 30, 10, -2, -24 },
  { 1686, 21, 20, 25, 3, -26 },
  { 1739, 21, 11, 25, 3, -21 },
  { 1768, 21, 20, 25, 3, -26 },
  { 1821, 16, 32, 18, 3, -32 },
  { 1885, 34, 35, 37, 2, -31 },
  { 2034, 24, 31, 24, -2, -31 },
  { 2127, 24, 31, 26, 2, -31 },
  { 2220, 25, 32, 26, 3, -32 },
  { 2320, 26, 31, 30, 2, -31 },
  { 2421, 23, 31, 23, 2, -31 },
  { 2511, 23, 31, 21, 2, -31 },
  { 2601, 26, 32, 30, 3, -32 },
  { 2705, 28, 31, 30, 2, -31 },
  { 2814, 15, 31, 13, 0, -31 },
  { 2873, 18, 39, 11, -7, -31 },
  { 2961, 26, 31, 24, 2, -31 },
  { 3062, 16, 31, 21, 2, -31 },
  { 3124, 34, 31, 36, 2, -31 },
  { 3256, 28, 31, 30, 2, -31 },
  { 3365, 27, 32, 32, 3, -32 },
  { 3473, 23, 31, 25, 2, -31 },
  { 3563, 27, 39, 32, 3, -32 },
  { 3695, 23, 31, 25, 2, -31 },
  { 3785, 22, 32, 22, 1, -32 },
  { 3873, 22, 31, 22, 4, -31 },
  { 3959, 26, 31, 30, 4, -31 },
  { 4060, 24, 31, 24, 4, -31 },
  { 4153, 35, 31, 37, 5, -31 },
  { 4289, 28, 31, 22, -2, -31 },
  { 4398, 22, 31, 22, 4, -31 },
  { 4484, 25, 31, 24, 0, -31 },
  { 4581, 16, 38, 13, 0, -31 },
  { 4657, 7, 31, 15, 5, -31 },
  { 4685, 16, 38, 13, -3, -31 },
  { 4761, 21, 20, 25, 2, -32 },
  { 4814, 17, 2, 17, -4, 4 },
  { 4819, 7, 7, 11, 6, -34 },
  { 4826, 21, 24, 25, 2, -24 },
  { 4889, 22, 33, 25, 1, -33 },
  { 4980, 18, 24, 20, 2, -24 },
  { 5034, 24, 33, 25, 2, -33 },
  { 5133, 18, 24, 22, 2, -24 },
  { 5187, 24, 45, 13, -5, -34 },
  { 5322, 23, 35, 25, 1, -24 },
  { 5423, 21, 33, 25, 1, -33 },
  { 5510, 10, 32, 10, 1, -32 },
  { 5550, 17, 43, 10, -6, -32 },
  { 5642, 21, 33, 21, 1, -33 },
  { 5729, 10, 33, 10, 1, -33 },
  { 5771, 34, 24, 38, 1, -24 },
  { 5873, 21, 24, 25, 1, -24 },
  { 5936, 21, 24, 25, 2, -24 },
  { 5999, 24, 34, 25, -1, -24 },
  { 6101, 22, 34, 25, 2, -24 },
  { 6195, 17, 24, 17, 1, -24 },
  { 6246, 18, 24, 19, 0, -24 },
  { 6300, 13, 29, 14, 2, -29 },
  { 6348, 21, 23, 25, 2, -23 },
  { 6409, 19, 23, 19, 2, -23 },
  { 6464, 30, 23, 30, 2, -23 },
  { 6551, 24, 23, 21, -2, -23 },
  { 6620, 26, 34, 19, -5, -23 },
  { 6731, 20, 23, 19, -1, -23 },
  { 6789, 16, 38, 15, 1, -31 },
  { 6865, 2, 44, 24, 12, -33 },
  { 6876, 16, 38, 15, -2, -31 },
  { 6952, 21, 5, 25, 3, -18 },
};

const GFXfont NotoSans_LightItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_LIGHTITALIC44PT7B_H_
