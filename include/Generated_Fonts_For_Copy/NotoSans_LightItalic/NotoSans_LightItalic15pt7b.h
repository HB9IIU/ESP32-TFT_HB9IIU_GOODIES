#ifndef _NOTOSANS_LIGHTITALIC15PT7B_H_
#define _NOTOSANS_LIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x22, 0x44, 0x00, 0xC0, 0x9A, 0xAA, 0x08, 0x82, 0x40,
  0x91, 0xB7, 0x12, 0x04, 0x81, 0x23, 0xFE, 0x24, 0x09, 0x02, 0x40, 0x08,
  0x7D, 0x22, 0x85, 0x06, 0x07, 0x12, 0x25, 0xF0, 0x81, 0x00, 0x30, 0x92,
  0x28, 0x92, 0x28, 0x94, 0xA5, 0xD6, 0xA4, 0x49, 0x24, 0x49, 0x24, 0x38,
  0x1C, 0x11, 0x08, 0x84, 0x82, 0x81, 0x83, 0x27, 0x12, 0x86, 0x43, 0x3E,
  0x40, 0xF0, 0x12, 0x44, 0x88, 0x88, 0x88, 0x88, 0x80, 0x10, 0x84, 0x10,
  0x84, 0x42, 0x10, 0x88, 0x8C, 0x00, 0x12, 0x47, 0xC8, 0x52, 0x60, 0x10,
  0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x29, 0x40, 0xF0, 0xC0, 0x02, 0x04,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x83, 0x00, 0x1C, 0x45, 0x0A, 0x18,
  0x30, 0x60, 0xC2, 0x85, 0x11, 0xC0, 0x13, 0xD1, 0x12, 0x22, 0x24, 0x40,
  0x1E, 0x21, 0x01, 0x01, 0x02, 0x04, 0x0C, 0x10, 0x20, 0x40, 0xFE, 0x1E,
  0x21, 0x01, 0x01, 0x02, 0x1C, 0x02, 0x02, 0x02, 0x02, 0xFC, 0x01, 0x02,
  0x06, 0x0A, 0x12, 0x22, 0x42, 0xFF, 0x04, 0x04, 0x04, 0x3E, 0x41, 0x02,
  0x07, 0x09, 0x81, 0x02, 0x04, 0x0B, 0xE0, 0x0E, 0x60, 0x82, 0x05, 0x9C,
  0xA1, 0x42, 0x85, 0x09, 0xE0, 0x7E, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10,
  0x20, 0x83, 0x00, 0x1C, 0x45, 0x0A, 0x12, 0x47, 0x11, 0x42, 0x85, 0x09,
  0xE0, 0x3C, 0x89, 0x0C, 0x18, 0x28, 0xDF, 0x02, 0x04, 0x13, 0xC0, 0x20,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x24, 0x48, 0x02, 0x18, 0xC6, 0x06, 0x03,
  0x01, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0xC6, 0x30,
  0x00, 0x78, 0x20, 0x42, 0x08, 0xC4, 0x10, 0x00, 0x0C, 0x00, 0x07, 0x83,
  0x08, 0x80, 0xA3, 0x98, 0x93, 0x22, 0x64, 0x4C, 0x91, 0x95, 0x51, 0x11,
  0x00, 0x1F, 0x80, 0x02, 0x03, 0x01, 0x41, 0x20, 0x90, 0x88, 0x7C, 0x42,
  0x21, 0x20, 0xA0, 0x20, 0x3C, 0x23, 0x41, 0x41, 0x42, 0x7C, 0x42, 0x82,
  0x82, 0x86, 0xF8, 0x0F, 0x98, 0x08, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x20, 0x0F, 0x80, 0x3C, 0x11, 0x90, 0x48, 0x14, 0x0A, 0x05, 0x05,
  0x02, 0x82, 0x43, 0x3E, 0x00, 0x3E, 0x41, 0x02, 0x04, 0x0F, 0x90, 0x40,
  0x81, 0x03, 0xE0, 0x3E, 0x41, 0x02, 0x04, 0x0F, 0x90, 0x40, 0x81, 0x02,
  0x00, 0x0F, 0x18, 0x48, 0x08, 0x08, 0x04, 0x32, 0x05, 0x02, 0x81, 0x20,
  0x8F, 0x80, 0x20, 0x90, 0x50, 0x28, 0x14, 0x13, 0xF9, 0x05, 0x02, 0x81,
  0x41, 0x20, 0x80, 0x38, 0x84, 0x22, 0x10, 0x84, 0x42, 0x38, 0x04, 0x10,
  0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x23, 0x00, 0x21, 0x91, 0x11,
  0x09, 0x05, 0x03, 0x81, 0x41, 0x10, 0x88, 0x42, 0x21, 0x00, 0x21, 0x10,
  0x84, 0x21, 0x10, 0x84, 0x3E, 0x20, 0x24, 0x0D, 0x41, 0xA8, 0x55, 0x0A,
  0xA2, 0x94, 0x94, 0x92, 0x8C, 0x51, 0x92, 0x22, 0x00, 0x20, 0x90, 0x54,
  0x2A, 0x14, 0x8A, 0x49, 0x25, 0x0A, 0x85, 0x41, 0x20, 0x80, 0x1E, 0x10,
  0x90, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x21, 0x8F, 0x00, 0x3C,
  0x45, 0x0A, 0x14, 0x28, 0x9E, 0x40, 0x81, 0x02, 0x00, 0x1E, 0x10, 0x90,
  0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x21, 0x8F, 0x01, 0x00, 0x40,
  0x10, 0x3C, 0x45, 0x0A, 0x14, 0x28, 0x9E, 0x44, 0x85, 0x0A, 0x10, 0x1F,
  0x20, 0x20, 0x20, 0x20, 0x18, 0x04, 0x02, 0x02, 0x04, 0xF8, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x20, 0x90, 0x50,
  0x28, 0x14, 0x0A, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x1F, 0x00, 0x81, 0x41,
  0x42, 0x42, 0x44, 0x44, 0x48, 0x48, 0x50, 0x50, 0x20, 0x84, 0x18, 0x42,
  0x8C, 0x28, 0xC4, 0x92, 0x49, 0x28, 0xA2, 0x8A, 0x28, 0xC3, 0x0C, 0x30,
  0x82, 0x00, 0x10, 0x44, 0x21, 0x10, 0x28, 0x0C, 0x01, 0x00, 0xC0, 0x48,
  0x22, 0x10, 0x8C, 0x10, 0x81, 0x42, 0x44, 0x44, 0x28, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x20, 0x3F, 0x80, 0x1C, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08,
  0x20, 0xE0, 0xAA, 0xA9, 0x54, 0x1C, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10,
  0x42, 0x08, 0xE0, 0x10, 0x30, 0xA1, 0x24, 0x50, 0xA0, 0x80, 0xFC, 0xD0,
  0x3A, 0x8E, 0x14, 0x28, 0x50, 0xA3, 0x7A, 0x10, 0x20, 0x20, 0x2E, 0x31,
  0x21, 0x41, 0x41, 0x42, 0x42, 0xBC, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x1E,
  0x01, 0x02, 0x02, 0x3A, 0x46, 0x82, 0x84, 0x84, 0x84, 0x8C, 0xF4, 0x3D,
  0x18, 0x7E, 0x82, 0x08, 0x1E, 0x07, 0x04, 0x08, 0x1E, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0xC0, 0x1D, 0x23, 0x41, 0x42,
  0x42, 0x42, 0x46, 0x7A, 0x04, 0x04, 0x88, 0x70, 0x10, 0x20, 0x20, 0x2E,
  0x31, 0x21, 0x42, 0x42, 0x42, 0x42, 0x82, 0x30, 0x02, 0x22, 0x44, 0x44,
  0x80, 0x0C, 0x00, 0x02, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x8C,
  0x00, 0x10, 0x20, 0x20, 0x23, 0x24, 0x28, 0x50, 0x70, 0x48, 0x48, 0x84,
  0x12, 0x22, 0x22, 0x44, 0x44, 0x80, 0x2E, 0xF3, 0x31, 0x22, 0x14, 0x21,
  0x42, 0x14, 0x22, 0x44, 0x28, 0x42, 0x2E, 0x31, 0x21, 0x42, 0x42, 0x42,
  0x42, 0x82, 0x3C, 0x8A, 0x0C, 0x18, 0x30, 0xA1, 0x3C, 0x2E, 0x31, 0x21,
  0x41, 0x41, 0x42, 0x42, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x3A, 0x8E, 0x0C,
  0x28, 0x50, 0xA3, 0x7A, 0x08, 0x10, 0x20, 0x40, 0x2C, 0xC2, 0x10, 0x41,
  0x04, 0x20, 0x3D, 0x04, 0x08, 0x18, 0x20, 0xBE, 0x44, 0xF4, 0x48, 0x88,
  0x8E, 0x42, 0x86, 0x0C, 0x28, 0x50, 0xA3, 0x7A, 0x86, 0x18, 0xA4, 0x92,
  0x8A, 0x10, 0x88, 0x66, 0x29, 0x4A, 0x54, 0xA5, 0x29, 0x8C, 0x62, 0x10,
  0x21, 0x12, 0x14, 0x08, 0x18, 0x14, 0x24, 0xC2, 0x10, 0x88, 0x44, 0x42,
  0x41, 0x20, 0x60, 0x30, 0x10, 0x08, 0x08, 0x08, 0x18, 0x00, 0x3E, 0x08,
  0x20, 0x82, 0x08, 0x10, 0x7C, 0x0C, 0x41, 0x04, 0x20, 0x8C, 0x10, 0x21,
  0x04, 0x10, 0x60, 0xFF, 0xFE, 0x10, 0x20, 0x82, 0x08, 0x20, 0xC6, 0x10,
  0x42, 0x08, 0xE0, 0xF2, 0x18,
};

const GFXglyph NotoSans_LightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 5, 2, -11 },
  { 9, 10, 11, 9, 0, -11 },
  { 23, 7, 12, 8, 1, -11 },
  { 34, 10, 11, 12, 1, -11 },
  { 48, 9, 11, 10, 1, -11 },
  { 61, 1, 4, 3, 2, -11 },
  { 62, 4, 13, 4, 1, -11 },
  { 69, 5, 13, 4, -1, -11 },
  { 78, 6, 6, 8, 2, -11 },
  { 83, 7, 7, 9, 1, -9 },
  { 90, 3, 4, 3, -1, -2 },
  { 92, 4, 1, 5, 0, -5 },
  { 93, 2, 1, 4, 0, -1 },
  { 94, 7, 11, 5, -1, -11 },
  { 104, 7, 11, 8, 1, -11 },
  { 114, 4, 11, 8, 2, -11 },
  { 120, 8, 11, 8, 0, -11 },
  { 131, 8, 11, 8, 0, -11 },
  { 142, 8, 11, 8, 0, -11 },
  { 153, 7, 11, 8, 1, -11 },
  { 163, 7, 11, 8, 1, -11 },
  { 173, 7, 11, 8, 1, -11 },
  { 183, 7, 11, 8, 1, -11 },
  { 193, 7, 11, 8, 1, -11 },
  { 203, 3, 8, 4, 0, -8 },
  { 206, 4, 10, 4, -1, -8 },
  { 211, 7, 7, 9, 1, -9 },
  { 218, 7, 4, 9, 1, -7 },
  { 222, 7, 7, 9, 1, -9 },
  { 229, 6, 11, 6, 1, -11 },
  { 238, 11, 12, 13, 1, -11 },
  { 255, 9, 11, 8, -1, -11 },
  { 268, 8, 11, 9, 1, -11 },
  { 279, 9, 11, 9, 1, -11 },
  { 292, 9, 11, 10, 1, -11 },
  { 305, 7, 11, 8, 1, -11 },
  { 315, 7, 11, 7, 1, -11 },
  { 325, 9, 11, 10, 1, -11 },
  { 338, 9, 11, 10, 1, -11 },
  { 351, 5, 11, 5, 0, -11 },
  { 358, 6, 14, 4, -2, -11 },
  { 369, 9, 11, 8, 1, -11 },
  { 382, 5, 11, 7, 1, -11 },
  { 389, 11, 11, 12, 1, -11 },
  { 405, 9, 11, 10, 1, -11 },
  { 418, 9, 11, 11, 1, -11 },
  { 431, 7, 11, 8, 1, -11 },
  { 441, 9, 14, 11, 1, -11 },
  { 457, 7, 11, 9, 1, -11 },
  { 467, 8, 11, 8, 0, -11 },
  { 478, 8, 11, 7, 1, -11 },
  { 489, 9, 11, 10, 1, -11 },
  { 502, 8, 11, 8, 1, -11 },
  { 513, 12, 11, 13, 2, -11 },
  { 530, 10, 11, 8, -1, -11 },
  { 544, 8, 11, 7, 1, -11 },
  { 555, 9, 11, 8, 0, -11 },
  { 568, 6, 13, 4, 0, -11 },
  { 578, 2, 11, 5, 2, -11 },
  { 581, 6, 13, 4, -1, -11 },
  { 591, 7, 7, 8, 1, -11 },
  { 598, 6, 1, 6, -1, 1 },
  { 599, 2, 2, 4, 2, -11 },
  { 600, 7, 8, 8, 1, -8 },
  { 607, 8, 11, 9, 0, -11 },
  { 618, 6, 8, 7, 1, -8 },
  { 624, 8, 11, 9, 1, -11 },
  { 635, 6, 8, 7, 1, -8 },
  { 641, 8, 15, 4, -2, -11 },
  { 656, 8, 12, 9, 0, -8 },
  { 668, 8, 11, 8, 0, -11 },
  { 679, 4, 11, 4, 0, -11 },
  { 685, 6, 15, 4, -2, -11 },
  { 697, 8, 11, 7, 0, -11 },
  { 708, 4, 11, 4, 0, -11 },
  { 714, 12, 8, 13, 0, -8 },
  { 726, 8, 8, 8, 0, -8 },
  { 734, 7, 8, 8, 1, -8 },
  { 741, 8, 12, 9, 0, -8 },
  { 753, 7, 12, 9, 1, -8 },
  { 764, 6, 8, 6, 0, -8 },
  { 770, 6, 8, 6, 0, -8 },
  { 776, 4, 10, 5, 1, -10 },
  { 781, 7, 8, 8, 1, -8 },
  { 788, 6, 8, 7, 1, -8 },
  { 794, 10, 8, 10, 1, -8 },
  { 804, 8, 8, 7, -1, -8 },
  { 812, 9, 12, 7, -2, -8 },
  { 826, 7, 8, 7, 0, -8 },
  { 833, 6, 13, 5, 0, -11 },
  { 843, 1, 15, 8, 4, -11 },
  { 845, 6, 13, 5, -1, -11 },
  { 855, 7, 2, 9, 1, -6 },
};

const GFXfont NotoSans_LightItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_LIGHTITALIC15PT7B_H_
