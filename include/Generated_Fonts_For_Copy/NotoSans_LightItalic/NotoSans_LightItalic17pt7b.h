#ifndef _NOTOSANS_LIGHTITALIC17PT7B_H_
#define _NOTOSANS_LIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x24, 0x40, 0x4C, 0xD9, 0x9A, 0x08, 0x82, 0x41,
  0x11, 0xF7, 0x12, 0x04, 0x82, 0x23, 0xEE, 0x24, 0x11, 0x04, 0x41, 0x20,
  0x04, 0x04, 0x3B, 0x48, 0x48, 0x48, 0x30, 0x1C, 0x12, 0x12, 0x14, 0xF8,
  0x20, 0x20, 0x38, 0x69, 0x09, 0x22, 0x44, 0x88, 0xA5, 0x15, 0x5D, 0x48,
  0x49, 0x0A, 0x22, 0x44, 0x88, 0xA0, 0xE0, 0x1E, 0x08, 0x42, 0x10, 0x88,
  0x14, 0x06, 0x06, 0x86, 0x12, 0x86, 0xA0, 0xC8, 0x71, 0xE2, 0xEA, 0x19,
  0x08, 0x84, 0x42, 0x10, 0x84, 0x21, 0x08, 0x41, 0x00, 0x10, 0x42, 0x10,
  0x84, 0x21, 0x10, 0x84, 0x42, 0x22, 0x00, 0x08, 0x13, 0x41, 0xF3, 0x09,
  0x32, 0x04, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08, 0x08, 0x29, 0x40,
  0xF0, 0x70, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x40, 0xC0, 0x1E, 0x21, 0x41, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x82,
  0xC4, 0x78, 0x35, 0x92, 0x22, 0x22, 0x44, 0x44, 0x1F, 0x08, 0x40, 0x20,
  0x10, 0x10, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x1F, 0xE0, 0x1F, 0x10,
  0x40, 0x20, 0x10, 0x10, 0xF0, 0x08, 0x02, 0x01, 0x00, 0xA0, 0x9F, 0x80,
  0x01, 0x81, 0x81, 0x41, 0x20, 0x90, 0x88, 0x88, 0x84, 0xFF, 0x81, 0x00,
  0x80, 0x80, 0x3F, 0x20, 0x20, 0x20, 0x40, 0x7C, 0x02, 0x02, 0x02, 0x02,
  0x84, 0xF8, 0x0F, 0x10, 0x20, 0x40, 0x58, 0x66, 0xC2, 0x82, 0x82, 0x82,
  0x44, 0x78, 0xFF, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40,
  0x40, 0x80, 0x1E, 0x21, 0x21, 0x21, 0x22, 0x1C, 0x64, 0x82, 0x82, 0x82,
  0x86, 0x7C, 0x3E, 0x61, 0x41, 0x41, 0x41, 0x43, 0x6E, 0x12, 0x02, 0x04,
  0x08, 0xF0, 0x30, 0x00, 0x00, 0x04, 0xC0, 0x10, 0x00, 0x00, 0x02, 0x44,
  0x80, 0x01, 0x06, 0x38, 0xC0, 0x60, 0x18, 0x06, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x30, 0x0C, 0x03, 0x03, 0x1C, 0x60, 0x80, 0x7C, 0x10, 0x41,
  0x0C, 0x62, 0x10, 0x40, 0x04, 0x30, 0x07, 0xC0, 0xC1, 0x88, 0x04, 0x87,
  0x94, 0xC8, 0xC4, 0x46, 0x42, 0x32, 0x12, 0x91, 0x14, 0x77, 0x20, 0x00,
  0x80, 0x03, 0x18, 0x07, 0x00, 0x01, 0x00, 0xC0, 0x50, 0x14, 0x08, 0x82,
  0x21, 0x08, 0x7E, 0x20, 0x88, 0x24, 0x0A, 0x01, 0x3F, 0x10, 0x48, 0x24,
  0x14, 0x13, 0xF1, 0x0C, 0x82, 0x41, 0x40, 0xA0, 0x9F, 0x80, 0x0F, 0xC4,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00,
  0xFC, 0x3F, 0x08, 0x22, 0x08, 0x81, 0x40, 0x50, 0x14, 0x05, 0x02, 0x40,
  0xA0, 0x48, 0x23, 0xF0, 0x3F, 0x20, 0x20, 0x20, 0x40, 0x7E, 0x40, 0x40,
  0x40, 0x80, 0x80, 0xFC, 0x3F, 0x20, 0x20, 0x20, 0x40, 0x40, 0x7E, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x0F, 0xC4, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x3E, 0x02, 0x80, 0x90, 0x24, 0x08, 0xFC, 0x20, 0x64, 0x08, 0x81, 0x10,
  0x24, 0x04, 0xFF, 0x10, 0x22, 0x04, 0x40, 0x90, 0x12, 0x04, 0x40, 0x80,
  0x3C, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x38, 0x02, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x3C, 0x00, 0x20,
  0xC8, 0x42, 0x20, 0x90, 0x48, 0x14, 0x06, 0x81, 0x20, 0x84, 0x21, 0x08,
  0x22, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08, 0x3F, 0x30,
  0x19, 0x81, 0x4C, 0x0C, 0x60, 0xA5, 0x05, 0x24, 0x49, 0x22, 0x49, 0x24,
  0x8A, 0x24, 0x51, 0x23, 0x09, 0x08, 0xC0, 0x30, 0x26, 0x08, 0xC1, 0x14,
  0x24, 0x84, 0x88, 0x91, 0x22, 0x24, 0x82, 0x90, 0x52, 0x06, 0x40, 0x80,
  0x1F, 0x86, 0x08, 0x81, 0x20, 0x14, 0x03, 0x80, 0x60, 0x14, 0x02, 0x80,
  0x48, 0x11, 0x06, 0x1F, 0x00, 0x3E, 0x10, 0x88, 0x24, 0x14, 0x12, 0x19,
  0xF0, 0x80, 0x40, 0x40, 0x20, 0x10, 0x00, 0x1F, 0x86, 0x08, 0x81, 0x20,
  0x14, 0x03, 0x80, 0x60, 0x14, 0x02, 0x80, 0x48, 0x11, 0x06, 0x1F, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x3F, 0x10, 0x88, 0x24, 0x14, 0x12, 0x19, 0xF0,
  0x88, 0x44, 0x42, 0x20, 0x90, 0x40, 0x1F, 0x90, 0x08, 0x04, 0x03, 0x00,
  0xC0, 0x18, 0x04, 0x03, 0x01, 0x00, 0x9F, 0x80, 0xFF, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x20, 0x24, 0x08, 0x81,
  0x20, 0x24, 0x04, 0x80, 0x90, 0x22, 0x04, 0x80, 0x90, 0x31, 0x04, 0x1F,
  0x00, 0x81, 0xC0, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x20, 0x90, 0x50, 0x30,
  0x18, 0x08, 0x00, 0x82, 0x0E, 0x18, 0x28, 0x61, 0x21, 0x44, 0x89, 0x22,
  0x24, 0x89, 0x12, 0x24, 0x50, 0xA1, 0x42, 0x86, 0x0C, 0x18, 0x10, 0x40,
  0x10, 0x61, 0x08, 0x22, 0x04, 0x80, 0x60, 0x08, 0x03, 0x80, 0x50, 0x12,
  0x04, 0x21, 0x04, 0x60, 0xC0, 0x83, 0x82, 0x84, 0x48, 0x48, 0x50, 0x60,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x3F, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x03, 0xFC, 0x1C, 0x42, 0x08, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x20, 0x82, 0x0E, 0x00, 0x92, 0x48, 0x92, 0x49,
  0x10, 0x1C, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x8E,
  0x00, 0x08, 0x14, 0x14, 0x24, 0x42, 0x42, 0x81, 0xFE, 0xC8, 0x80, 0x3D,
  0x43, 0x42, 0x82, 0x82, 0x82, 0x86, 0x8C, 0x74, 0x20, 0x20, 0x20, 0x20,
  0x5E, 0x61, 0x41, 0x41, 0x81, 0x82, 0x82, 0xC4, 0xB8, 0x3E, 0x81, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x78, 0x00, 0x80, 0x40, 0x20, 0x23, 0xD2, 0x19,
  0x0D, 0x04, 0x82, 0x41, 0x21, 0x91, 0x47, 0x40, 0x3C, 0x85, 0x0C, 0x2F,
  0x90, 0x20, 0x40, 0x7C, 0x03, 0x82, 0x01, 0x00, 0x81, 0xF0, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0xC0, 0x00,
  0x1E, 0x90, 0xC8, 0x68, 0x24, 0x12, 0x09, 0x0C, 0x8A, 0x3A, 0x01, 0x00,
  0x80, 0x8F, 0x80, 0x20, 0x20, 0x20, 0x40, 0x5E, 0x61, 0x41, 0x42, 0x82,
  0x82, 0x82, 0x82, 0x84, 0x20, 0x24, 0x94, 0x92, 0x40, 0x04, 0x00, 0x02,
  0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x30, 0x20, 0x20, 0x20,
  0x41, 0x42, 0x44, 0x48, 0x50, 0xB0, 0xD0, 0x88, 0x88, 0x84, 0x24, 0x94,
  0x92, 0x92, 0x48, 0x5E, 0xF3, 0x18, 0x50, 0xC2, 0x84, 0x28, 0x21, 0x41,
  0x0A, 0x10, 0x50, 0x82, 0x84, 0x20, 0x2F, 0x18, 0x48, 0x24, 0x24, 0x12,
  0x09, 0x04, 0x82, 0xC2, 0x00, 0x3E, 0x42, 0x41, 0x81, 0x81, 0x82, 0x82,
  0x84, 0x78, 0x2F, 0x18, 0x48, 0x24, 0x14, 0x0A, 0x09, 0x04, 0xC4, 0x5C,
  0x40, 0x20, 0x10, 0x08, 0x00, 0x3D, 0x43, 0x43, 0x82, 0x82, 0x82, 0x86,
  0x8A, 0x74, 0x04, 0x04, 0x04, 0x0C, 0x5D, 0x84, 0x10, 0x82, 0x08, 0x20,
  0x80, 0x3E, 0x81, 0x01, 0x01, 0x80, 0x81, 0x02, 0xF8, 0x22, 0x3E, 0x84,
  0x22, 0x10, 0x84, 0x38, 0x41, 0x41, 0x41, 0x42, 0x82, 0x82, 0x86, 0x8A,
  0xF4, 0x83, 0x0A, 0x14, 0x48, 0x8A, 0x14, 0x30, 0x40, 0x84, 0x31, 0x86,
  0x31, 0x4A, 0x29, 0x49, 0x45, 0x28, 0xC6, 0x18, 0xC2, 0x00, 0x30, 0x88,
  0x82, 0x81, 0x80, 0xC0, 0xA0, 0x50, 0x44, 0xC3, 0x00, 0x10, 0x44, 0x21,
  0x08, 0x44, 0x09, 0x02, 0x80, 0xA0, 0x30, 0x0C, 0x02, 0x01, 0x00, 0x40,
  0xE0, 0x00, 0x3E, 0x0C, 0x10, 0x41, 0x04, 0x10, 0x20, 0xFC, 0x0E, 0x10,
  0x40, 0x81, 0x02, 0x08, 0x60, 0x20, 0x40, 0x82, 0x04, 0x08, 0x0C, 0x00,
  0xFF, 0xFF, 0x80, 0x18, 0x08, 0x10, 0x40, 0x81, 0x02, 0x07, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x30, 0x00, 0x71, 0x8F,
};

const GFXglyph NotoSans_LightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 4, 4, 6, 2, -12 },
  { 9, 10, 12, 11, 1, -12 },
  { 24, 8, 14, 9, 1, -13 },
  { 38, 11, 12, 13, 1, -12 },
  { 55, 10, 12, 12, 1, -12 },
  { 70, 2, 4, 3, 2, -12 },
  { 71, 5, 15, 5, 1, -12 },
  { 81, 5, 15, 5, -1, -12 },
  { 91, 7, 8, 9, 2, -13 },
  { 98, 8, 8, 10, 1, -10 },
  { 106, 3, 4, 4, -1, -2 },
  { 108, 4, 1, 5, 1, -5 },
  { 109, 2, 2, 4, 0, -2 },
  { 110, 8, 12, 6, -1, -12 },
  { 122, 8, 12, 9, 1, -12 },
  { 134, 4, 12, 9, 3, -12 },
  { 140, 9, 12, 9, 0, -12 },
  { 154, 9, 12, 9, 0, -12 },
  { 168, 9, 12, 9, 0, -12 },
  { 182, 8, 12, 9, 1, -12 },
  { 194, 8, 12, 9, 1, -12 },
  { 206, 8, 12, 9, 2, -12 },
  { 218, 8, 12, 9, 1, -12 },
  { 230, 8, 12, 9, 1, -12 },
  { 242, 4, 9, 4, 0, -9 },
  { 247, 4, 11, 4, -1, -9 },
  { 253, 8, 8, 10, 1, -10 },
  { 261, 8, 4, 10, 1, -8 },
  { 265, 8, 8, 10, 1, -10 },
  { 273, 6, 12, 7, 1, -12 },
  { 282, 13, 14, 14, 1, -12 },
  { 305, 10, 12, 9, -1, -12 },
  { 320, 9, 12, 10, 1, -12 },
  { 334, 10, 12, 10, 1, -12 },
  { 349, 10, 12, 11, 1, -12 },
  { 364, 8, 12, 9, 1, -12 },
  { 376, 8, 12, 8, 1, -12 },
  { 388, 10, 12, 12, 1, -12 },
  { 403, 11, 12, 12, 1, -12 },
  { 420, 6, 12, 5, 0, -12 },
  { 429, 7, 15, 4, -3, -12 },
  { 443, 10, 12, 9, 1, -12 },
  { 458, 6, 12, 8, 1, -12 },
  { 467, 13, 12, 14, 1, -12 },
  { 487, 11, 12, 12, 1, -12 },
  { 504, 11, 12, 12, 1, -12 },
  { 521, 9, 12, 10, 1, -12 },
  { 535, 11, 15, 12, 1, -12 },
  { 556, 9, 12, 10, 1, -12 },
  { 570, 9, 12, 9, 0, -12 },
  { 584, 8, 12, 8, 2, -12 },
  { 596, 11, 12, 12, 1, -12 },
  { 613, 9, 12, 9, 2, -12 },
  { 627, 14, 12, 14, 2, -12 },
  { 648, 11, 12, 9, -1, -12 },
  { 665, 8, 12, 8, 2, -12 },
  { 677, 10, 12, 9, 0, -12 },
  { 692, 6, 15, 5, 0, -12 },
  { 704, 3, 12, 6, 2, -12 },
  { 709, 6, 15, 5, -1, -12 },
  { 721, 8, 7, 10, 1, -12 },
  { 728, 7, 1, 7, -2, 2 },
  { 729, 3, 3, 4, 2, -13 },
  { 731, 8, 9, 9, 1, -9 },
  { 740, 8, 13, 10, 1, -13 },
  { 753, 7, 9, 8, 1, -9 },
  { 761, 9, 13, 10, 1, -13 },
  { 776, 7, 9, 8, 1, -9 },
  { 784, 9, 17, 5, -2, -13 },
  { 804, 9, 13, 10, 0, -9 },
  { 819, 8, 13, 10, 1, -13 },
  { 832, 3, 12, 4, 1, -12 },
  { 837, 6, 16, 4, -2, -12 },
  { 849, 8, 13, 8, 1, -13 },
  { 862, 3, 13, 4, 1, -13 },
  { 867, 13, 9, 15, 1, -9 },
  { 882, 9, 9, 10, 0, -9 },
  { 893, 8, 9, 10, 1, -9 },
  { 902, 9, 13, 10, 0, -9 },
  { 917, 8, 13, 10, 1, -9 },
  { 930, 6, 9, 7, 1, -9 },
  { 937, 7, 9, 7, 0, -9 },
  { 945, 5, 11, 5, 1, -11 },
  { 952, 8, 9, 10, 1, -9 },
  { 961, 7, 9, 7, 1, -9 },
  { 969, 11, 9, 12, 1, -9 },
  { 982, 9, 9, 8, -1, -9 },
  { 993, 10, 13, 7, -2, -9 },
  { 1010, 7, 9, 8, 0, -9 },
  { 1018, 7, 15, 6, 0, -12 },
  { 1032, 1, 17, 9, 5, -13 },
  { 1035, 7, 15, 6, -1, -12 },
  { 1049, 8, 2, 10, 1, -7 },
};

const GFXfont NotoSans_LightItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_LIGHTITALIC17PT7B_H_
