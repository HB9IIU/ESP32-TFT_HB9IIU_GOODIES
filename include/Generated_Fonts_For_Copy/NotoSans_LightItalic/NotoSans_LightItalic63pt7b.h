#ifndef _NOTOSANS_LIGHTITALIC63PT7B_H_
#define _NOTOSANS_LIGHTITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x1E, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1E,
  0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x60, 0x38,
  0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xE1, 0xC1, 0xE0, 0x1F, 0x07, 0x00, 0x80, 0xF0, 0x1C,
  0x00, 0x03, 0xC0, 0x60, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1E, 0x03, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F,
  0x87, 0x00, 0x00, 0x1F, 0xB8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xDF,
  0x80, 0x00, 0x07, 0x1F, 0x00, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x01, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x70, 0x1E, 0x00, 0x01, 0xC0, 0x78, 0x20, 0x07, 0x07, 0xC0, 0xE0, 0x1C,
  0x3E, 0x03, 0xF8, 0xEF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x03, 0x80,
  0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00,
  0xE0, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x01,
  0xE0, 0xF0, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x08, 0x1C, 0x00, 0x70, 0x70,
  0x7F, 0x8E, 0x00, 0x78, 0x78, 0x7F, 0xE7, 0x00, 0x38, 0x78, 0x7C, 0xFB,
  0xC0, 0x3C, 0x38, 0x78, 0x1C, 0xE0, 0x1C, 0x38, 0x78, 0x0F, 0x78, 0x1C,
  0x3C, 0x38, 0x03, 0xBE, 0x3E, 0x1C, 0x38, 0x01, 0xCF, 0xFE, 0x1C, 0x1C,
  0x00, 0xE3, 0xFC, 0x1C, 0x1E, 0x00, 0x70, 0x38, 0x1E, 0x0E, 0x00, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x0E, 0x00, 0x0F,
  0x03, 0x80, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x0F, 0x00, 0x38, 0x03, 0xC0, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x00, 0x78, 0x1E, 0x01,
  0xE0, 0x00, 0x1E, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0xFE, 0x01, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x01, 0xE3,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF0,
  0xF0, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x3C,
  0x00, 0xF1, 0xE0, 0x00, 0x78, 0x03, 0x87, 0x00, 0x01, 0xE0, 0x1E, 0x3C,
  0x00, 0x03, 0xC0, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0x83, 0x80, 0x00, 0x1E,
  0x1E, 0x0E, 0x00, 0x00, 0x3C, 0xF0, 0x38, 0x00, 0x00, 0x7F, 0x80, 0xE0,
  0x00, 0x00, 0xFC, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xF0,
  0x00, 0x7E, 0x78, 0x07, 0xE0, 0x07, 0xE0, 0xF0, 0x0F, 0xFB, 0xFF, 0x01,
  0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x07,
  0x40, 0x00, 0x00, 0x00, 0x1E, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x3C, 0x70,
  0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x40, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0x78, 0x07, 0x00, 0x0F,
  0xE0, 0x70, 0x00, 0x3F, 0x86, 0x00, 0x00, 0x7E, 0x60, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C,
  0x38, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xF0, 0x1C, 0x00, 0x3E, 0x01, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x08, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07,
  0x80, 0xE0, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x33, 0xFF, 0xFF, 0xF9, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xBF, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x07,
  0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x7C, 0x0F, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x7E,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x3F, 0x78, 0x3E, 0x38, 0x7E, 0x1C, 0xFC, 0x1E, 0x7C,
  0x0F, 0x18, 0x07, 0x88, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x20, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x40, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xBF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x80, 0x00, 0x0F, 0x80, 0xC0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x7F, 0x00, 0x0F, 0x07, 0xFF, 0x80, 0x3C,
  0x7F, 0xFF, 0x00, 0xE7, 0xE0, 0x7E, 0x03, 0xBC, 0x00, 0x7C, 0x1F, 0xE0,
  0x00, 0xF0, 0x7E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x01,
  0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC,
  0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x07,
  0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0xFE, 0x07, 0x80,
  0x0F, 0x78, 0x1F, 0x80, 0xF9, 0xC0, 0x3F, 0xFF, 0xCF, 0x00, 0x3F, 0xFC,
  0x3C, 0x00, 0x3F, 0x80, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x08, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x83, 0xE0, 0x0F, 0x82, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0x0F, 0x00, 0x07, 0xFF, 0xF0, 0x07,
  0x0E, 0x00, 0x1F, 0xEF, 0xF0, 0x07, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x07,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x07,
  0x38, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x07,
  0x78, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x07,
  0x70, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x70, 0x07, 0x00, 0x03, 0x80, 0x07,
  0x70, 0x07, 0x00, 0x03, 0x80, 0x0F, 0x70, 0x07, 0x00, 0x03, 0x80, 0x0E,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0x0E, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0x1E,
  0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x1C, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x3C,
  0xF0, 0x0F, 0x00, 0x1F, 0x00, 0x38, 0x70, 0x0F, 0x00, 0x3F, 0x00, 0x78,
  0x70, 0x07, 0x00, 0x77, 0x00, 0xF0, 0x70, 0x07, 0x80, 0xF3, 0x81, 0xE0,
  0x70, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x78, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x38, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x07, 0xFC, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F,
  0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x07, 0xE0, 0x1C,
  0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFE, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x00, 0x80, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x07,
  0xFC, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x7E, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0xFE, 0x00,
  0x70, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x00, 0x18, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x01, 0xFF, 0xF8, 0xF0, 0x00, 0x0F, 0xFF, 0xC7, 0x80, 0x00, 0xFF, 0xFE,
  0x3C, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0x00, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x80, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x0F, 0x80,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0x1C, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00,
  0x1C, 0x1F, 0x00, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x00, 0x79, 0xF8, 0x00, 0x00, 0x03, 0x9F, 0xE0, 0x00, 0x00, 0x1D,
  0xEF, 0x00, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0x0F, 0xC1, 0xE0, 0x00,
  0x00, 0x7C, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x07, 0x70, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xB8, 0x00,
  0x00, 0x07, 0xB8, 0x01, 0xDE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0xE7, 0x00,
  0x00, 0x03, 0xCE, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x79, 0xC0,
  0x00, 0x01, 0xE7, 0x80, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x00, 0x00, 0xF1, 0xC0, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0x00, 0x70, 0xF0, 0x07, 0x87, 0x00, 0x00, 0x78, 0x78, 0x03, 0x83,
  0x80, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x1C, 0x01, 0xE0,
  0xE0, 0x00, 0x1C, 0x1E, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x78,
  0x3C, 0x00, 0x1E, 0x07, 0x80, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x1C,
  0x07, 0x00, 0x0F, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x07, 0x01, 0xE0, 0x0F,
  0x01, 0xC0, 0x07, 0x80, 0xF0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x78, 0x03,
  0x80, 0x78, 0x03, 0xC0, 0x38, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x0E, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xF0, 0x03, 0x80,
  0x3C, 0x00, 0xE0, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x38, 0x00, 0x70,
  0x03, 0x80, 0x07, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x03, 0x9C, 0x00, 0x3C,
  0x01, 0xE0, 0x01, 0xDE, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x00, 0x03, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0x70, 0x03, 0xBC, 0x00, 0x00, 0x38, 0x01, 0xDE, 0x00, 0x00,
  0x3C, 0x00, 0xE7, 0x00, 0x00, 0x1E, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x00,
  0x78, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x78, 0x00, 0x03, 0x80, 0x1C, 0x3C,
  0x00, 0x03, 0xC0, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x00,
  0xE0, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x01,
  0xC0, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0x00, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x70, 0x03, 0x80, 0x03,
  0xC0, 0x78, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x00, 0x70, 0x1E,
  0x00, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x38,
  0x00, 0x07, 0x87, 0x80, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x1E, 0x00, 0x00,
  0xE1, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x70,
  0x03, 0x80, 0x00, 0x0F, 0x78, 0x03, 0xC0, 0x00, 0x07, 0xBC, 0x01, 0xE0,
  0x00, 0x01, 0xDC, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x70, 0x00, 0x00,
  0x3F, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0xC0,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x70, 0x03, 0xFC, 0x00,
  0xF0, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF8, 0x07,
  0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0E, 0x00, 0xFF, 0x80, 0x0F, 0x00, 0x07, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x80, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x81, 0x80,
  0x00, 0x3E, 0x03, 0xC0, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xD0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x78, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x7B, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E,
  0x0E, 0x00, 0x03, 0xCE, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x71, 0xC0, 0x00,
  0xF0, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x87, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x3C, 0x03, 0x80, 0x07, 0x83, 0x80, 0x07, 0x80, 0x78, 0x00, 0xE0,
  0x70, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x01, 0xC0, 0x78, 0x00,
  0x78, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x07, 0x01, 0xC0,
  0x00, 0xE0, 0x78, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x83, 0xC0, 0x03, 0x83, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xC3, 0x80, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x77, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x01, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x0E, 0x03,
  0x81, 0xC0, 0x00, 0x07, 0xF0, 0x0C, 0x00, 0xFF, 0xF0, 0x70, 0x07, 0xFF,
  0xE1, 0xC0, 0x3F, 0x03, 0xC7, 0x01, 0xF0, 0x07, 0xBC, 0x0F, 0x80, 0x0E,
  0xE0, 0x78, 0x00, 0x1B, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF8, 0x1C, 0x00, 0x0E, 0xE0, 0x78,
  0x00, 0x77, 0x81, 0xF0, 0x03, 0x9C, 0x03, 0xE0, 0x3C, 0x70, 0x07, 0xF7,
  0xE1, 0xC0, 0x1F, 0xFF, 0x07, 0x00, 0x1F, 0xF0, 0x38, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xE0,
  0x00, 0xE0, 0xFF, 0xF0, 0x01, 0xC3, 0xFF, 0xF0, 0x07, 0x8F, 0x03, 0xF0,
  0x0F, 0x38, 0x01, 0xE0, 0x1C, 0xE0, 0x01, 0xE0, 0x3B, 0x80, 0x03, 0xC0,
  0xFE, 0x00, 0x03, 0x81, 0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x07, 0x81, 0xDC, 0x00, 0x1F,
  0x03, 0x98, 0x00, 0x7C, 0x07, 0x3C, 0x03, 0xF0, 0x1C, 0x3F, 0x7F, 0xC0,
  0x38, 0x3F, 0xFE, 0x00, 0x70, 0x3F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xF0,
  0x0E, 0x01, 0xF0, 0x00, 0x80, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x01, 0x80, 0x3F, 0xCF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x81, 0xE0, 0x00, 0xFF,
  0xF8, 0x78, 0x00, 0x7F, 0xFF, 0x1E, 0x00, 0x3F, 0x03, 0xE7, 0x00, 0x1F,
  0x00, 0x39, 0xC0, 0x0F, 0x00, 0x07, 0x70, 0x07, 0x80, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x1F, 0xC0,
  0x1C, 0x00, 0x0E, 0xE0, 0x07, 0x80, 0x07, 0x38, 0x01, 0xF0, 0x03, 0xCE,
  0x00, 0x3E, 0x03, 0xE3, 0x80, 0x0F, 0xF7, 0xE1, 0xE0, 0x01, 0xFF, 0xF0,
  0x70, 0x00, 0x1F, 0xF0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x1C, 0x1E, 0x00,
  0x07, 0x0F, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xF0,
  0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x8E, 0x00, 0x07, 0xC7, 0x80, 0x0F, 0xE1,
  0xE1, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x01,
  0x01, 0xF0, 0x01, 0xC0, 0x3F, 0xEF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x20, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x41,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x07, 0x00, 0x1F, 0xFF,
  0x07, 0x00, 0x3F, 0xFF, 0x87, 0x00, 0x7E, 0x07, 0xCE, 0x00, 0xF8, 0x01,
  0xCE, 0x01, 0xE0, 0x00, 0xEE, 0x03, 0xC0, 0x00, 0x6E, 0x07, 0xC0, 0x00,
  0x7E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07,
  0xE0, 0x78, 0x00, 0x0F, 0xE0, 0x38, 0x00, 0x1D, 0xC0, 0x3C, 0x00, 0x39,
  0xC0, 0x3E, 0x00, 0x7B, 0xC0, 0x1F, 0x01, 0xF3, 0xC0, 0x0F, 0xEF, 0xC3,
  0x80, 0x0F, 0xFF, 0x83, 0x80, 0x03, 0xFE, 0x03, 0x80, 0x00, 0x70, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x03, 0xF8, 0x00, 0x70, 0x7F, 0xF8, 0x01, 0xC3, 0xFF,
  0xF0, 0x0F, 0x1F, 0x03, 0xE0, 0x3C, 0xE0, 0x07, 0x80, 0xE7, 0x00, 0x0F,
  0x03, 0xB8, 0x00, 0x3C, 0x1F, 0xC0, 0x00, 0xF0, 0x7E, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0x0F, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x3E, 0x01, 0xC0, 0x01, 0xE0,
  0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x03,
  0x80, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0xF8, 0x00,
  0x00, 0xE7, 0xE0, 0x00, 0x07, 0xBF, 0xC0, 0x00, 0x1D, 0xC7, 0x00, 0x00,
  0x7E, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07,
  0x80, 0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x01, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xC3, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0x8F, 0x83, 0xE0, 0xF8, 0x3E, 0x03, 0x9E, 0x00, 0xF1,
  0xE0, 0x0F, 0x03, 0x9C, 0x00, 0xF3, 0x80, 0x0F, 0x03, 0xB0, 0x00, 0x77,
  0x00, 0x07, 0x03, 0xF0, 0x00, 0x76, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x7F, 0xC0,
  0x07, 0x07, 0xFF, 0x80, 0x3C, 0x3F, 0xFF, 0x00, 0xF1, 0xF0, 0x7E, 0x03,
  0x8F, 0x00, 0x7C, 0x0E, 0x70, 0x00, 0xF0, 0x3B, 0x80, 0x03, 0xC1, 0xFC,
  0x00, 0x0F, 0x07, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x38, 0x07, 0xF0, 0x00, 0x0E, 0x0F, 0xFF, 0x00, 0x03, 0x87, 0xFF, 0xE0,
  0x01, 0xC3, 0xC0, 0xFC, 0x00, 0x71, 0xC0, 0x0F, 0x00, 0x1C, 0xE0, 0x01,
  0xE0, 0x07, 0x70, 0x00, 0x78, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0xFC, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x01, 0xE0, 0x0E, 0xE0,
  0x00, 0xF8, 0x03, 0x98, 0x00, 0x7C, 0x00, 0xE7, 0x80, 0x7E, 0x00, 0x78,
  0xFD, 0xFF, 0x00, 0x1E, 0x1F, 0xFF, 0x80, 0x07, 0x83, 0xFF, 0x80, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x0E, 0x00, 0x7F, 0xFC, 0x1C,
  0x01, 0xFF, 0xFC, 0x38, 0x07, 0xE0, 0x7C, 0xE0, 0x1F, 0x00, 0x39, 0xC0,
  0x78, 0x00, 0x3B, 0x81, 0xE0, 0x00, 0x37, 0x07, 0xC0, 0x00, 0x7E, 0x0F,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x7F,
  0x03, 0x80, 0x01, 0xDC, 0x07, 0x80, 0x07, 0x38, 0x0F, 0x80, 0x1E, 0xF0,
  0x0F, 0x80, 0xF9, 0xE0, 0x0F, 0xEF, 0xC3, 0xC0, 0x1F, 0xFF, 0x07, 0x00,
  0x0F, 0xF8, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x7F, 0x01, 0xC1, 0xFF, 0x01, 0xC3, 0xFE, 0x03,
  0xC7, 0xC2, 0x03, 0x8E, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xB8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFC, 0x03, 0xE0, 0x78, 0x00, 0x30,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x84, 0x00, 0x07, 0x83, 0x80, 0x0F, 0xC1, 0xFE, 0x7F, 0xC0,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x03, 0xE0, 0x70, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x7E, 0x03, 0x80, 0x01, 0xDC, 0x07, 0x80, 0x07, 0x78, 0x0F, 0x00, 0x1C,
  0xE0, 0x1F, 0x00, 0xF1, 0xC0, 0x1F, 0xFF, 0xC3, 0x80, 0x1F, 0xFF, 0x07,
  0x00, 0x1F, 0xF8, 0x0E, 0x00, 0x03, 0x00, 0x20, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0x70,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x03,
  0x80, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x03, 0x80, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00,
  0x1C, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xEE, 0x00, 0x0F, 0xC0, 0x00, 0xF7, 0x00, 0x07,
  0x70, 0x00, 0xF3, 0x80, 0x07, 0xB8, 0x00, 0x79, 0xC0, 0x03, 0x9C, 0x00,
  0x78, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x3C,
  0x00, 0xE3, 0x80, 0x1E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x0F, 0x00, 0x70,
  0xE0, 0x0F, 0x07, 0x80, 0x70, 0x70, 0x07, 0x03, 0xC0, 0x38, 0x38, 0x07,
  0x81, 0xE0, 0x38, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x0F, 0x03, 0xC0, 0x78,
  0x1C, 0x07, 0x81, 0xC0, 0x3C, 0x0E, 0x03, 0xC1, 0xE0, 0x1E, 0x0E, 0x01,
  0xE0, 0xF0, 0x07, 0x07, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x00, 0x38, 0x78,
  0x01, 0xC3, 0x80, 0x1C, 0x78, 0x00, 0xE3, 0x80, 0x0E, 0x3C, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0x39, 0xC0, 0x03, 0x9E, 0x00, 0x1C, 0xE0, 0x01,
  0xCE, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00,
  0x03, 0xF8, 0x00, 0x3B, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x01, 0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x5F, 0xFF, 0x80, 0x07, 0xF1, 0xFF, 0x80, 0xFE,
  0x00, 0xFF, 0xFF, 0x40, 0x01, 0xFF, 0xF2, 0x00, 0x01, 0xFE, 0x00,
};

const GFXglyph NotoSans_LightItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 14, 46, 15, 2, -45 },
  { 82, 16, 16, 22, 7, -45 },
  { 114, 38, 45, 40, 2, -45 },
  { 328, 30, 52, 35, 3, -48 },
  { 523, 41, 47, 49, 5, -46 },
  { 764, 38, 47, 43, 3, -46 },
  { 988, 7, 16, 12, 7, -45 },
  { 1002, 19, 55, 17, 2, -45 },
  { 1133, 19, 55, 17, -4, -45 },
  { 1264, 28, 28, 34, 7, -48 },
  { 1362, 29, 30, 36, 5, -37 },
  { 1471, 11, 15, 14, -3, -7 },
  { 1492, 15, 4, 20, 2, -19 },
  { 1500, 5, 7, 15, 2, -6 },
  { 1505, 29, 45, 21, -3, -45 },
  { 1669, 29, 47, 35, 4, -46 },
  { 1840, 17, 45, 35, 10, -45 },
  { 1936, 33, 46, 35, 0, -46 },
  { 2126, 32, 47, 35, 1, -46 },
  { 2314, 33, 45, 35, 1, -45 },
  { 2500, 32, 46, 35, 2, -45 },
  { 2684, 30, 47, 35, 4, -46 },
  { 2861, 29, 45, 35, 6, -45 },
  { 3025, 31, 47, 35, 3, -46 },
  { 3208, 30, 47, 35, 3, -46 },
  { 3385, 11, 35, 15, 2, -34 },
  { 3434, 16, 42, 15, -3, -34 },
  { 3518, 29, 30, 36, 5, -38 },
  { 3627, 29, 16, 36, 5, -30 },
  { 3685, 29, 30, 36, 5, -38 },
  { 3794, 23, 47, 26, 5, -46 },
  { 3930, 48, 51, 53, 3, -45 },
  { 4236, 35, 45, 35, -3, -45 },
  { 4433, 34, 45, 38, 3, -45 },
  { 4625, 35, 47, 37, 5, -46 },
  { 4831, 37, 45, 42, 3, -45 },
  { 5040, 32, 45, 33, 3, -45 },
  { 5220, 32, 45, 30, 3, -45 },
  { 5400, 37, 47, 43, 5, -46 },
  { 5618, 40, 45, 43, 3, -45 },
  { 5843, 22, 45, 19, 0, -45 },
  { 5967, 26, 56, 16, -10, -45 },
  { 6149, 37, 45, 35, 3, -45 },
  { 6358, 23, 45, 31, 3, -45 },
  { 6488, 49, 45, 52, 3, -45 },
  { 6764, 41, 45, 44, 3, -45 },
  { 6995, 38, 47, 45, 5, -46 },
  { 7219, 32, 45, 35, 3, -45 },
  { 7399, 38, 57, 45, 5, -46 },
  { 7670, 33, 45, 36, 3, -45 },
  { 7856, 31, 47, 32, 1, -46 },
  { 8039, 31, 45, 31, 6, -45 },
  { 8214, 39, 46, 43, 5, -45 },
  { 8439, 34, 45, 34, 6, -45 },
  { 8631, 51, 45, 53, 7, -45 },
  { 8918, 40, 45, 32, -3, -45 },
  { 9143, 31, 45, 31, 6, -45 },
  { 9318, 37, 45, 34, -1, -45 },
  { 9527, 24, 55, 19, -1, -45 },
  { 9692, 11, 45, 21, 6, -45 },
  { 9754, 24, 55, 19, -5, -45 },
  { 9919, 30, 28, 35, 3, -45 },
  { 10024, 25, 3, 24, -6, 6 },
  { 10034, 9, 10, 16, 9, -48 },
  { 10046, 30, 35, 35, 3, -34 },
  { 10178, 31, 49, 36, 2, -48 },
  { 10368, 26, 35, 29, 3, -34 },
  { 10482, 34, 49, 36, 3, -48 },
  { 10691, 26, 35, 31, 3, -34 },
  { 10805, 35, 63, 18, -8, -48 },
  { 11081, 32, 49, 36, 2, -34 },
  { 11277, 30, 48, 36, 2, -48 },
  { 11457, 13, 46, 15, 2, -46 },
  { 11532, 23, 61, 15, -8, -46 },
  { 11708, 30, 48, 29, 2, -48 },
  { 11888, 14, 48, 15, 2, -48 },
  { 11972, 48, 34, 54, 2, -34 },
  { 12176, 30, 34, 36, 2, -34 },
  { 12304, 29, 35, 36, 3, -34 },
  { 12431, 34, 49, 36, -1, -34 },
  { 12640, 31, 49, 36, 3, -34 },
  { 12830, 24, 34, 24, 2, -34 },
  { 12932, 25, 35, 27, 1, -34 },
  { 13042, 19, 43, 20, 3, -42 },
  { 13145, 31, 35, 36, 3, -34 },
  { 13281, 28, 34, 28, 3, -34 },
  { 13400, 41, 34, 43, 4, -34 },
  { 13575, 33, 34, 30, -2, -34 },
  { 13716, 38, 49, 28, -7, -34 },
  { 13949, 29, 34, 28, -1, -34 },
  { 14073, 24, 55, 21, 1, -45 },
  { 14238, 3, 63, 34, 17, -48 },
  { 14262, 23, 55, 21, -3, -45 },
  { 14421, 29, 7, 36, 5, -26 },
};

const GFXfont NotoSans_LightItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_LIGHTITALIC63PT7B_H_
