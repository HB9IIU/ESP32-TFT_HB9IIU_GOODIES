#ifndef _IBMPLEXMONO_LIGHTITALIC49PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1E, 0x00, 0x38, 0x39, 0xC1, 0xCE,
  0x0C, 0x70, 0x63, 0x07, 0x18, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x63, 0x83,
  0x18, 0x38, 0xC1, 0xCE, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x07, 0xFF, 0x03, 0xFE, 0x3F, 0xF0,
  0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x80, 0x1C, 0x0C, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x7F, 0xE0,
  0x7F, 0xE3, 0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0x81, 0xC0,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x01, 0xF0, 0xCF, 0x80, 0x78, 0x38, 0x78, 0x1E, 0x06, 0x03, 0x83,
  0x80, 0xC0, 0x20, 0x70, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1E,
  0x0C, 0x00, 0x03, 0xE1, 0x80, 0x00, 0x3F, 0x30, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x06, 0xFE, 0x00, 0x00,
  0xC3, 0xC0, 0x00, 0x18, 0x3C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xC0, 0x78,
  0x00, 0x18, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x0C,
  0x07, 0x04, 0x03, 0x80, 0xE1, 0xC0, 0x60, 0x3C, 0x7C, 0x0C, 0x07, 0x03,
  0xC1, 0x83, 0xE0, 0x3E, 0x31, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xC0, 0x70, 0x70, 0x01, 0xC0, 0x70,
  0x18, 0x00, 0xC0, 0x30, 0x0E, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x80, 0xE0, 0x0C, 0x01, 0xC0, 0x60, 0x06, 0x00, 0xE0, 0x70, 0x07,
  0x00, 0x70, 0x70, 0x03, 0x80, 0x30, 0x70, 0x01, 0xC0, 0x18, 0x30, 0x00,
  0x60, 0x1C, 0x38, 0x00, 0x30, 0x1C, 0x38, 0x00, 0x1E, 0x1C, 0x18, 0x00,
  0x07, 0xFC, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x83, 0xFE,
  0x00, 0x01, 0x83, 0x87, 0x00, 0x01, 0xC3, 0x80, 0xC0, 0x01, 0xC3, 0x80,
  0x60, 0x00, 0xC1, 0x80, 0x30, 0x00, 0xC0, 0xC0, 0x1C, 0x00, 0xE0, 0xE0,
  0x0E, 0x00, 0xE0, 0x70, 0x06, 0x00, 0x60, 0x38, 0x03, 0x00, 0x70, 0x18,
  0x01, 0x80, 0x70, 0x0C, 0x01, 0xC0, 0x30, 0x07, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0xE0, 0x38, 0x00, 0xE0, 0xE0, 0x38, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x07,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x07,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x78, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x09, 0xC0, 0x03, 0xC0, 0x6E, 0x00, 0x1F, 0x03,
  0xB0, 0x00, 0xB8, 0x39, 0xC0, 0x0D, 0xE3, 0x8F, 0x00, 0xE7, 0x1C, 0x3C,
  0x1E, 0x1D, 0xC1, 0xFF, 0xE0, 0xFE, 0x07, 0xFE, 0x03, 0xE0, 0x0F, 0xC0,
  0x0E, 0x00, 0x39, 0xCE, 0x63, 0x39, 0xCE, 0x73, 0x19, 0xCE, 0x00, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x60, 0x1C, 0x03, 0x7E,
  0x0E, 0x0F, 0xDF, 0xE7, 0x3F, 0xC1, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xC6, 0x00,
  0x01, 0xC3, 0x80, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x60, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x07, 0xC3, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3E, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x87, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1D, 0xC0,
  0x00, 0x0E, 0xE0, 0x38, 0x0E, 0x70, 0x3E, 0x07, 0x38, 0x1F, 0x03, 0x9C,
  0x0F, 0x81, 0xCE, 0x07, 0x80, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x03, 0x83, 0x80, 0x03,
  0x81, 0xE0, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xF6, 0x00, 0x07, 0x9C, 0x00, 0x1E,
  0x38, 0x00, 0xF8, 0x70, 0x03, 0xC0, 0xE0, 0x0F, 0x01, 0xC0, 0x3C, 0x03,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x3C,
  0x00, 0xF0, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x07,
  0xC0, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x04, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x84, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x0C, 0x00,
  0x1C, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x0C, 0x00,
  0x38, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x61, 0xFC, 0x00, 0x73, 0xFF, 0x80, 0x3B, 0xFF, 0xE0, 0x1B, 0x80,
  0xF8, 0x0F, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x04, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x08, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x03, 0x83, 0xE0, 0x03, 0xC0, 0xFC, 0x07, 0xC0,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC7, 0xF0, 0x07, 0x3F, 0xF8, 0x0E, 0xFF, 0xF8, 0x3B, 0x80, 0xF8, 0x7C,
  0x00, 0x79, 0xF0, 0x00, 0x73, 0xC0, 0x00, 0xF7, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x0F,
  0x1E, 0x00, 0x3C, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x07, 0x81, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E,
  0x06, 0x00, 0x03, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0x0F, 0x80,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1E,
  0x01, 0xF0, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x87, 0x00,
  0x01, 0xC1, 0xE0, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xFE, 0x03, 0xE0, 0x7C, 0x1E, 0x00, 0x78, 0xE0, 0x00, 0xE7, 0x80,
  0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1E, 0xF0, 0x00, 0xF9, 0xE0, 0x06, 0xE7, 0xC0, 0x77, 0x0F, 0xFF,
  0x9C, 0x1F, 0xFC, 0xE0, 0x1F, 0xC3, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xF1, 0xF8, 0xFC, 0x3C,
  0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x20, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xF0, 0x3E, 0x3C, 0x01,
  0xE7, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFC, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x07, 0x07, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x1C, 0x07,
  0xC7, 0x18, 0x0F, 0xE7, 0x18, 0x1F, 0xF7, 0x38, 0x3C, 0x1F, 0x38, 0x38,
  0x0E, 0x30, 0x70, 0x0E, 0x30, 0x70, 0x06, 0x70, 0x60, 0x0E, 0x70, 0xE0,
  0x0E, 0x70, 0xE0, 0x0E, 0x70, 0xE0, 0x0C, 0x60, 0xE0, 0x0C, 0x60, 0xC0,
  0x1C, 0x60, 0xC0, 0x1C, 0xE0, 0xC0, 0x1C, 0xE0, 0xE0, 0x3C, 0xE0, 0xE0,
  0x58, 0xE0, 0xF0, 0xD8, 0xE0, 0x7F, 0x98, 0xE0, 0x7F, 0x38, 0xE0, 0x1E,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x19, 0xC0, 0x00,
  0x1C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x60,
  0x01, 0xC0, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x60, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x39, 0xC0,
  0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x70, 0x03, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC3, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x38,
  0x00, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0x00, 0x0F, 0x03, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x30,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x01,
  0xE1, 0xC0, 0x03, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01,
  0xF0, 0x3C, 0x03, 0xC0, 0x1E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x1C, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x10, 0xE0,
  0x00, 0x38, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x38,
  0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07,
  0x00, 0x7C, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38,
  0x00, 0x07, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x78, 0x70, 0x00, 0xF0, 0x60, 0x01, 0xE0, 0xE0, 0x07, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x04, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1F, 0xFC, 0xE0,
  0x1F, 0xFC, 0xE0, 0x1F, 0xFC, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0,
  0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0x70, 0x01, 0xF0, 0x78,
  0x03, 0x70, 0x3E, 0x0F, 0x70, 0x3F, 0xFE, 0x70, 0x1F, 0xFC, 0x60, 0x07,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x02, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0x78, 0x03,
  0xC0, 0x3C, 0x0F, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00,
  0x1C, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x39, 0xFC, 0x00,
  0x03, 0xBC, 0xE0, 0x00, 0x3F, 0x8E, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x3E,
  0x07, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x03, 0x80, 0x07, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x03, 0xF0, 0xEC, 0x00, 0x6E, 0x1D, 0x80, 0x1D, 0x83, 0xB8, 0x03,
  0x30, 0x77, 0x00, 0xEE, 0x0C, 0x60, 0x39, 0xC1, 0x8C, 0x06, 0x38, 0x71,
  0xC1, 0xC7, 0x0E, 0x38, 0x30, 0xC1, 0xC3, 0x0E, 0x18, 0x38, 0x63, 0x87,
  0x06, 0x0E, 0x60, 0xE0, 0xC1, 0xDC, 0x1C, 0x38, 0x1B, 0x03, 0x87, 0x03,
  0xE0, 0x60, 0xE0, 0x78, 0x0C, 0x1C, 0x06, 0x03, 0x83, 0x00, 0xC0, 0x70,
  0x60, 0x10, 0x0E, 0x1C, 0x02, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x70, 0x00,
  0x06, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x78, 0x00, 0x18, 0x1F, 0x80, 0x03, 0x03, 0xF0, 0x00, 0xE0, 0x76, 0x00,
  0x1C, 0x0E, 0xE0, 0x03, 0x81, 0xDC, 0x00, 0x70, 0x33, 0x80, 0x0C, 0x0E,
  0x30, 0x01, 0x81, 0xC7, 0x00, 0x70, 0x38, 0xE0, 0x0E, 0x07, 0x0C, 0x01,
  0xC0, 0xE1, 0xC0, 0x38, 0x18, 0x38, 0x06, 0x07, 0x07, 0x00, 0xC0, 0xE0,
  0x60, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0C, 0x03, 0x03, 0x03, 0x80, 0x70, 0x60, 0x70, 0x0E, 0x1C, 0x0E, 0x00,
  0xC3, 0x81, 0xC0, 0x1C, 0x70, 0x38, 0x03, 0x8E, 0x06, 0x00, 0x71, 0x81,
  0xC0, 0x06, 0x30, 0x38, 0x00, 0xEE, 0x07, 0x00, 0x1D, 0xC0, 0xE0, 0x01,
  0xB8, 0x1C, 0x00, 0x3F, 0x03, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0xF8, 0x1C,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3E, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x87, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1D, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x03, 0x83, 0x80, 0x03,
  0x81, 0xE0, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x78,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x1C, 0x00,
  0x3E, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0x87, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39,
  0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x87, 0x00,
  0x03, 0x83, 0x80, 0x03, 0x81, 0xE0, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0x3E,
  0x07, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0x00, 0x40, 0x01, 0xC0, 0x60, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x0E, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xE0,
  0x01, 0xE0, 0x70, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE3,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x1E, 0x1C, 0x00, 0x3E, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xF0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x03, 0x80,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x82, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xF0,
  0x1F, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0x87,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x30, 0x70,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x07,
  0x00, 0x0F, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x01,
  0x80, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0xC3, 0x00, 0xE0, 0x18, 0x30, 0x1E, 0x01, 0x83, 0x01, 0xE0, 0x38,
  0x30, 0x1F, 0x03, 0x83, 0x03, 0xF0, 0x30, 0x30, 0x37, 0x03, 0x07, 0x07,
  0x70, 0x70, 0x70, 0x63, 0x07, 0x07, 0x06, 0x30, 0x60, 0x70, 0xE3, 0x06,
  0x07, 0x0C, 0x30, 0xE0, 0x71, 0xC3, 0x0E, 0x06, 0x18, 0x30, 0xC0, 0x61,
  0x83, 0x0C, 0x06, 0x38, 0x31, 0xC0, 0x63, 0x03, 0x9C, 0x06, 0x70, 0x39,
  0x80, 0x66, 0x03, 0x98, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E,
  0xC0, 0x1B, 0x00, 0xFC, 0x01, 0xB0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x78, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x01,
  0xC0, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x30, 0x03, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x60, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x8E, 0x00,
  0x07, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x23, 0xC7,
  0x0C, 0x38, 0x61, 0xC3, 0x0C, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x1C, 0x1F,
  0xFF, 0x38, 0x7E, 0x07, 0x71, 0xF0, 0x06, 0xC3, 0x80, 0x07, 0x8F, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x63, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7,
  0x00, 0x07, 0x8E, 0x00, 0x0F, 0x0E, 0x00, 0x2E, 0x1E, 0x00, 0xD8, 0x3E,
  0x07, 0x3F, 0x3F, 0xFC, 0x7E, 0x3F, 0xF0, 0xFC, 0x1F, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x3F, 0x00, 0x71, 0xFF, 0x80, 0xE7, 0xFF,
  0x81, 0xDE, 0x0F, 0x83, 0xB0, 0x07, 0x06, 0xC0, 0x0F, 0x1F, 0x00, 0x0E,
  0x3C, 0x00, 0x1C, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0x63,
  0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0xC0, 0x00, 0x39, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00,
  0x07, 0x9C, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x6C, 0x00, 0xF0, 0xCE, 0x07,
  0xC3, 0x9F, 0xFF, 0x07, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x03, 0xE1, 0xE0, 0x07, 0x0E,
  0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0D,
  0xC0, 0x00, 0xEE, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xE0, 0x0F, 0x07, 0x81,
  0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x1F, 0x81, 0x80, 0x3F, 0xF1, 0xC0, 0x7F,
  0xFC, 0xE0, 0x7E, 0x07, 0x70, 0x3C, 0x00, 0xB8, 0x38, 0x00, 0x7C, 0x3C,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC0, 0xE0, 0x02,
  0xE0, 0x78, 0x03, 0x70, 0x3E, 0x07, 0x30, 0x0F, 0xFF, 0x18, 0x03, 0xFF,
  0x1C, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x03, 0xF0, 0x3E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x01,
  0xCC, 0x00, 0x06, 0x70, 0x00, 0x39, 0x80, 0x01, 0xEE, 0x00, 0x1F, 0x38,
  0x0F, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x03, 0x38, 0x00, 0x0E,
  0xE0, 0x00, 0x71, 0xC0, 0x03, 0x87, 0x80, 0x1E, 0x0F, 0x81, 0xF0, 0x1F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xF8, 0x0E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x07, 0x8C, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xC7, 0x03, 0xFF, 0xE7, 0x07, 0xE0, 0x77,
  0x0F, 0x80, 0x17, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78,
  0x38, 0x00, 0xF8, 0x3C, 0x01, 0xB8, 0x3E, 0x07, 0x38, 0x1F, 0xFE, 0x30,
  0x0F, 0xFC, 0x70, 0x03, 0xF0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x40, 0x01, 0xE0, 0xE0, 0x03, 0xC0,
  0xF8, 0x0F, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0xFC, 0x01, 0x8F, 0xFC, 0x0E, 0x7F, 0xF8,
  0x39, 0xC1, 0xE0, 0xEC, 0x03, 0xC3, 0xE0, 0x07, 0x0F, 0x00, 0x1C, 0x38,
  0x00, 0x71, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00,
  0x71, 0x80, 0x01, 0x86, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3,
  0x80, 0x03, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC7, 0x00,
  0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x06,
  0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x38, 0x06,
  0x03, 0xF0, 0x18, 0x1F, 0x00, 0xE0, 0xF0, 0x03, 0x8F, 0x80, 0x0E, 0x7C,
  0x00, 0x3B, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x10, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0xE0, 0x38, 0x07, 0xC0, 0xE0, 0x0F,
  0x83, 0x00, 0x1F, 0x1C, 0x00, 0x3E, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x81, 0xF8, 0x01, 0xC3, 0xFE, 0x00, 0xE7, 0xFF, 0x80,
  0x73, 0x83, 0xE0, 0x3B, 0x00, 0x70, 0x1F, 0x00, 0x38, 0x0D, 0x00, 0x1C,
  0x0F, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x03,
  0x80, 0xE0, 0x07, 0x80, 0x60, 0x07, 0x80, 0x70, 0x1F, 0x00, 0x38, 0x7E,
  0x00, 0x1C, 0x7C, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x23, 0x03,
  0x80, 0x33, 0x81, 0xC0, 0x3D, 0xC0, 0x70, 0x3C, 0xE0, 0x38, 0x3C, 0x70,
  0x0E, 0x3C, 0x30, 0x07, 0x3C, 0x18, 0x01, 0xFC, 0x1C, 0x00, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x08, 0x38, 0x03, 0x07, 0x00, 0xF0, 0xE0, 0x3C,
  0x18, 0x1F, 0x03, 0x07, 0xC0, 0xE1, 0xE0, 0x1C, 0xF8, 0x03, 0xBE, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x81, 0xCF,
  0xC3, 0xF8, 0x3B, 0xFC, 0xFF, 0x07, 0xC3, 0xB8, 0xF0, 0xD0, 0x7C, 0x0E,
  0x1C, 0x07, 0x81, 0xC7, 0x80, 0xE0, 0x38, 0xE0, 0x1C, 0x07, 0x1C, 0x03,
  0x00, 0xC3, 0x80, 0xE0, 0x18, 0x60, 0x1C, 0x03, 0x0C, 0x03, 0x80, 0xE3,
  0x80, 0x60, 0x1C, 0x70, 0x0C, 0x03, 0x8E, 0x03, 0x80, 0x61, 0xC0, 0x70,
  0x0C, 0x30, 0x0E, 0x01, 0x86, 0x01, 0xC0, 0x71, 0xC0, 0x30, 0x0E, 0x38,
  0x06, 0x01, 0xC7, 0x01, 0xC0, 0x30, 0xE0, 0x38, 0x06, 0x18, 0x07, 0x01,
  0xC3, 0x00, 0xE0, 0x38, 0xE0, 0x18, 0x07, 0x1C, 0x03, 0x00, 0xE0, 0x00,
  0x0F, 0xC0, 0x18, 0xFF, 0xC0, 0xE7, 0xFF, 0x83, 0x9C, 0x1E, 0x0E, 0xC0,
  0x3C, 0x3E, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x1C,
  0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x18, 0x60,
  0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xE3, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7,
  0x00, 0x07, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x63, 0x80, 0x03, 0x80, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3E, 0x07, 0xC0, 0xF0,
  0x03, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00,
  0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x1C,
  0xC0, 0x00, 0x39, 0x80, 0x00, 0xF3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8E,
  0x00, 0x0E, 0x0E, 0x00, 0x78, 0x1F, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xC7, 0xFE, 0x00,
  0xE7, 0xFF, 0x80, 0x77, 0x83, 0xE0, 0x3B, 0x00, 0x70, 0x1B, 0x00, 0x3C,
  0x1F, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00,
  0xC1, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x86, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xE0, 0xF0,
  0x00, 0xF0, 0x6C, 0x00, 0xF0, 0x33, 0x81, 0xF0, 0x39, 0xFF, 0xF0, 0x1C,
  0x7F, 0xF0, 0x0E, 0x0F, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0x1C, 0x1F, 0xFF, 0x38, 0x7E, 0x07, 0x70, 0xF0, 0x02,
  0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x78, 0x00, 0x1C,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x01, 0x9C,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0xF3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0F, 0x0E, 0x00,
  0x2E, 0x1E, 0x00, 0xDC, 0x3E, 0x07, 0x38, 0x3F, 0xFC, 0x60, 0x3F, 0xF1,
  0xC0, 0x1F, 0x83, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x3F, 0xF8, 0x0E, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3C, 0x03, 0xE0, 0xE0, 0x01, 0xE3, 0x80, 0x00, 0x87,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x3C, 0x00, 0x1C,
  0x3F, 0x00, 0xF8, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x10,
  0x06, 0x00, 0x70, 0x0C, 0x01, 0xE0, 0x38, 0x0F, 0xA0, 0x70, 0x3E, 0x00,
  0xE1, 0xF0, 0x01, 0xCF, 0xC0, 0x03, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0,
  0x01, 0xC6, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03,
  0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xC0, 0x00, 0xC7, 0x00, 0x07, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x18, 0x00,
  0x18, 0x60, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0xF8,
  0xF0, 0x02, 0xE1, 0xC0, 0x33, 0x07, 0xC1, 0xDC, 0x0F, 0xFE, 0x70, 0x1F,
  0xF1, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1B, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01,
  0xC1, 0x80, 0x07, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3,
  0x80, 0x07, 0x0E, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x00,
  0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xC0, 0x1E, 0x06, 0x00, 0xF0,
  0x18, 0x07, 0x80, 0x60, 0x7C, 0x03, 0x8F, 0xE0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x18, 0x07, 0x03, 0x0C, 0x03, 0x03, 0x8E,
  0x01, 0x80, 0xC7, 0x01, 0xC0, 0x63, 0x80, 0xE0, 0x39, 0xC0, 0x70, 0x1C,
  0xC0, 0x38, 0x0E, 0x60, 0x18, 0x07, 0x30, 0x0C, 0x03, 0xB8, 0x0E, 0x01,
  0xDC, 0x07, 0x00, 0xEE, 0x03, 0x80, 0x76, 0x01, 0x80, 0x3B, 0x00, 0xC0,
  0x19, 0x80, 0x60, 0x0D, 0xC0, 0x70, 0x0E, 0xE0, 0x38, 0x07, 0x60, 0x1C,
  0x03, 0x30, 0x0E, 0x03, 0x98, 0x0F, 0x01, 0xCC, 0x07, 0x81, 0xC7, 0x07,
  0xC1, 0xE3, 0x86, 0x71, 0xE1, 0xFF, 0x3F, 0xE0, 0x7F, 0x1F, 0xE0, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x1F, 0x81, 0xFC, 0x03, 0xFC,
  0x3F, 0xE0, 0x79, 0xC7, 0x0E, 0x1F, 0x0C, 0x60, 0x73, 0xC0, 0xCC, 0x07,
  0x70, 0x0E, 0x80, 0x70, 0x00, 0xF8, 0x07, 0x00, 0x0F, 0x80, 0x70, 0x00,
  0x70, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xC0, 0x16, 0x00, 0x0C, 0x01, 0x60,
  0x08, 0xC0, 0x36, 0x01, 0xCC, 0x06, 0x70, 0x78, 0xE0, 0x67, 0x0F, 0x0E,
  0x1C, 0x73, 0xC0, 0x7F, 0xC3, 0xF8, 0x07, 0xF8, 0x3F, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06,
  0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x18,
  0x00, 0x38, 0x18, 0x00, 0x38, 0x38, 0x00, 0x78, 0x38, 0x00, 0x78, 0x1C,
  0x00, 0xB8, 0x1C, 0x01, 0xB8, 0x1F, 0x07, 0x70, 0x0F, 0xFE, 0x70, 0x07,
  0xFC, 0x70, 0x03, 0xF0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x40, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xF8,
  0x0F, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0x81, 0xC1, 0xFF, 0xF8, 0xE1, 0xE0, 0x7E, 0x70,
  0xE0, 0x07, 0xF8, 0xE0, 0x00, 0xF8, 0x70, 0x00, 0x78, 0x38, 0x00, 0x70,
  0x18, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x18, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x07, 0x01, 0xC0,
  0x01, 0x81, 0xC0, 0x00, 0xC1, 0xF8, 0x00, 0x71, 0xFF, 0xE0, 0x38, 0xE3,
  0xFF, 0x9C, 0x70, 0x3F, 0xFE, 0x30, 0x01, 0xFF, 0x20, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xE0, 0x01, 0x81, 0xFC, 0x00, 0x60, 0xFF, 0x80,
  0x18, 0x78, 0xF0, 0x0E, 0x38, 0x1C, 0x03, 0x0E, 0x03, 0x81, 0xC7, 0x00,
  0xF0, 0xE1, 0xC0, 0x1F, 0xF0, 0x60, 0x03, 0xF8, 0x38, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 10, 34, 29, 10, -34 },
  { 44, 13, 13, 29, 11, -36 },
  { 66, 29, 34, 29, 1, -34 },
  { 190, 27, 46, 29, 1, -40 },
  { 346, 33, 36, 29, -1, -35 },
  { 495, 29, 36, 29, 0, -35 },
  { 626, 5, 13, 29, 15, -36 },
  { 635, 17, 44, 29, 11, -37 },
  { 729, 17, 44, 29, 3, -37 },
  { 823, 25, 24, 29, 3, -27 },
  { 898, 24, 25, 29, 3, -27 },
  { 973, 10, 14, 29, 7, -6 },
  { 991, 14, 3, 29, 8, -16 },
  { 997, 6, 5, 29, 10, -5 },
  { 1001, 28, 44, 29, 1, -37 },
  { 1155, 25, 36, 29, 3, -35 },
  { 1268, 23, 34, 29, 2, -34 },
  { 1366, 25, 35, 29, 2, -35 },
  { 1476, 25, 36, 29, 2, -35 },
  { 1589, 26, 34, 29, 1, -34 },
  { 1700, 25, 35, 29, 3, -34 },
  { 1810, 23, 35, 29, 3, -34 },
  { 1911, 24, 34, 29, 5, -34 },
  { 2013, 26, 36, 29, 2, -35 },
  { 2130, 22, 35, 29, 5, -35 },
  { 2227, 9, 26, 29, 10, -26 },
  { 2257, 12, 34, 29, 7, -26 },
  { 2308, 24, 27, 29, 4, -28 },
  { 2389, 25, 12, 29, 3, -21 },
  { 2427, 24, 27, 29, 2, -28 },
  { 2508, 20, 35, 29, 7, -35 },
  { 2596, 24, 40, 29, 3, -35 },
  { 2716, 25, 34, 29, 0, -34 },
  { 2823, 25, 34, 29, 2, -34 },
  { 2930, 24, 36, 29, 4, -35 },
  { 3038, 24, 34, 29, 3, -34 },
  { 3140, 26, 34, 29, 3, -34 },
  { 3251, 26, 34, 29, 3, -34 },
  { 3362, 24, 36, 29, 4, -35 },
  { 3470, 27, 34, 29, 2, -34 },
  { 3585, 27, 34, 29, 2, -34 },
  { 3700, 24, 35, 29, 3, -34 },
  { 3805, 28, 34, 29, 3, -34 },
  { 3924, 20, 34, 29, 4, -34 },
  { 4009, 27, 34, 29, 2, -34 },
  { 4124, 27, 34, 29, 2, -34 },
  { 4239, 25, 36, 29, 3, -35 },
  { 4352, 25, 34, 29, 3, -34 },
  { 4459, 25, 44, 29, 3, -35 },
  { 4597, 25, 34, 29, 3, -34 },
  { 4704, 27, 36, 29, 1, -35 },
  { 4826, 26, 34, 29, 5, -34 },
  { 4937, 25, 35, 29, 4, -34 },
  { 5047, 25, 34, 29, 6, -34 },
  { 5154, 28, 34, 29, 3, -34 },
  { 5273, 31, 34, 29, 0, -34 },
  { 5405, 27, 34, 29, 5, -34 },
  { 5520, 30, 34, 29, 0, -34 },
  { 5648, 20, 44, 29, 9, -37 },
  { 5758, 12, 44, 29, 9, -37 },
  { 5824, 20, 44, 29, 1, -37 },
  { 5934, 23, 19, 29, 4, -34 },
  { 5989, 24, 3, 29, 0, 5 },
  { 5998, 6, 9, 29, 11, -38 },
  { 6005, 23, 27, 29, 3, -26 },
  { 6083, 23, 37, 29, 3, -36 },
  { 6190, 21, 27, 29, 4, -26 },
  { 6261, 25, 37, 29, 3, -36 },
  { 6377, 22, 27, 29, 4, -26 },
  { 6452, 32, 46, 29, -1, -36 },
  { 6636, 24, 36, 29, 2, -26 },
  { 6744, 22, 36, 29, 3, -36 },
  { 6843, 22, 38, 29, 4, -37 },
  { 6948, 22, 46, 29, 4, -36 },
  { 7075, 25, 37, 29, 3, -36 },
  { 7191, 19, 37, 29, 6, -36 },
  { 7279, 27, 26, 29, 1, -26 },
  { 7367, 22, 26, 29, 3, -26 },
  { 7439, 23, 27, 29, 3, -26 },
  { 7517, 25, 36, 29, 1, -26 },
  { 7630, 23, 36, 29, 3, -26 },
  { 7734, 23, 25, 29, 6, -25 },
  { 7806, 23, 27, 29, 3, -26 },
  { 7884, 23, 35, 29, 4, -34 },
  { 7985, 22, 26, 29, 4, -25 },
  { 8057, 22, 26, 29, 4, -26 },
  { 8129, 25, 26, 29, 3, -25 },
  { 8211, 28, 27, 29, 1, -26 },
  { 8306, 24, 35, 29, 2, -25 },
  { 8411, 25, 27, 29, 2, -26 },
  { 8496, 22, 44, 29, 6, -37 },
  { 8617, 10, 44, 29, 10, -37 },
  { 8672, 23, 44, 29, 2, -37 },
  { 8799, 26, 10, 29, 2, -20 },
};

const GFXfont IBMPlexMono_LightItalic49pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic49pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic49pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _IBMPLEXMONO_LIGHTITALIC49PT7B_H_
