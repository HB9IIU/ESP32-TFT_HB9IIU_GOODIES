#ifndef _IBMPLEXMONO_LIGHTITALIC46PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x7C, 0x1F, 0x0F, 0xC1, 0xE0, 0x30, 0x6E, 0x0D, 0xC3, 0xB8, 0x76, 0x0E,
  0xC1, 0xD8, 0x37, 0x06, 0xE1, 0xDC, 0x3B, 0x07, 0x60, 0xC0, 0x00, 0x07,
  0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x18, 0x00, 0x07, 0x03, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x18, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x18, 0x18, 0x00, 0x07, 0x03, 0x00, 0x7F, 0xC0, 0xFF, 0x8F,
  0xF8, 0x1F, 0xF0, 0x07, 0x03, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x18,
  0x00, 0x07, 0x03, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x18, 0x00, 0x07,
  0x03, 0x00, 0x00, 0xC0, 0xE0, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE,
  0x00, 0xC0, 0xE0, 0x00, 0x18, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x18, 0x18, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x18, 0x18, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xC6, 0x7C,
  0x03, 0x83, 0x07, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x14, 0x38, 0x0C,
  0x00, 0x0E, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x38,
  0x18, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x78, 0x60, 0x00,
  0x0F, 0x18, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x33, 0xE0, 0x00, 0x0C, 0x3C, 0x00, 0x03, 0x07, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03, 0x80,
  0x01, 0x80, 0xE0, 0x00, 0x60, 0x38, 0x20, 0x18, 0x0C, 0x18, 0x0E, 0x07,
  0x0F, 0x03, 0x03, 0x80, 0xE0, 0xC1, 0xE0, 0x1F, 0x31, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x1C, 0x07, 0x0E, 0x00, 0x70, 0x18, 0x0C, 0x00,
  0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x0E, 0x01, 0x80, 0x30, 0x18,
  0x07, 0x00, 0xE0, 0x60, 0x0E, 0x01, 0xC1, 0xC0, 0x18, 0x03, 0x07, 0x00,
  0x30, 0x06, 0x0C, 0x00, 0x70, 0x1C, 0x30, 0x00, 0x60, 0x30, 0xE0, 0x00,
  0xE1, 0xC1, 0x80, 0x00, 0xFF, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0x83, 0xFC, 0x00, 0x07, 0x0E, 0x1C, 0x00, 0x1C, 0x30, 0x18, 0x00, 0x30,
  0xE0, 0x38, 0x00, 0xC1, 0x80, 0x30, 0x03, 0x83, 0x00, 0x60, 0x0E, 0x0E,
  0x01, 0xC0, 0x18, 0x1C, 0x03, 0x80, 0x60, 0x38, 0x07, 0x01, 0xC0, 0x60,
  0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0C, 0x00, 0xC0, 0x60, 0x38, 0x01, 0xC3,
  0x80, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0C,
  0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0,
  0x0E, 0x00, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x1C, 0x00,
  0x07, 0x87, 0x00, 0x07, 0xF3, 0x80, 0x01, 0xC7, 0xC0, 0x00, 0x60, 0x70,
  0x00, 0x18, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x18,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0F, 0x01, 0xF0, 0x01, 0x60, 0x66, 0x00, 0x2E, 0x1C, 0xE0,
  0x0C, 0xC3, 0x1C, 0x03, 0x1C, 0xE1, 0xE0, 0xE1, 0xD8, 0x1F, 0xF8, 0x3E,
  0x00, 0xFC, 0x03, 0xC0, 0x39, 0xCC, 0x67, 0x39, 0xCE, 0x63, 0x39, 0xC0,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x40, 0x0C, 0x01, 0xF0, 0x38, 0x1F, 0xFC, 0x71,
  0xFC, 0x7F, 0xDF, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x77, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x0C, 0x00,
  0x38, 0x1C, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x38, 0x08,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xC0, 0xE0,
  0xE0, 0x70, 0x30, 0x38, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x39, 0xF7,
  0xFF, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0x81,
  0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x03,
  0x0E, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8,
  0x1C, 0x07, 0x70, 0x7C, 0x0F, 0xC0, 0xF8, 0x3B, 0x80, 0xE0, 0x77, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x06, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x63, 0x80, 0x01, 0xC3, 0x00, 0x03,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0x80,
  0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xD8, 0x00, 0x1E, 0xE0, 0x00, 0xE3, 0x80, 0x0F, 0x0E, 0x00, 0x78,
  0x38, 0x03, 0xC0, 0xC0, 0x1C, 0x03, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x01, 0xE0, 0x70, 0x01,
  0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x82, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xE0, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0xE0, 0x70, 0x01, 0xC1,
  0xC0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x02, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x3C,
  0x00, 0x70, 0x3E, 0x03, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0xCC, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x38, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x38,
  0x00, 0x70, 0x70, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x3F, 0x80, 0x0C, 0xFF, 0xE0, 0x0D, 0x81, 0xF0, 0x1E,
  0x00, 0x78, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x70, 0xF0,
  0x00, 0x70, 0x78, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x3F, 0x80, 0xE7, 0xFF, 0x07, 0x70, 0x3C, 0x76, 0x00, 0x73, 0xC0,
  0x03, 0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xB8, 0x00,
  0x1C, 0xC0, 0x00, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0xE0, 0xF0, 0x1E, 0x01,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0x00,
  0x01, 0xD8, 0x00, 0x0E, 0x60, 0x00, 0x39, 0x80, 0x01, 0xCE, 0x00, 0x0F,
  0x38, 0x00, 0x38, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xF8, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x1C,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x07, 0x80, 0xF0, 0x1E, 0x00, 0x78, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x3E, 0x03, 0xC0, 0x0F, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xE0, 0x78, 0x1C,
  0x00, 0xE1, 0xC0, 0x03, 0x1C, 0x00, 0x1C, 0xC0, 0x00, 0x6E, 0x00, 0x03,
  0x70, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1D, 0xC0, 0x01, 0xEE, 0x00, 0x17, 0x38, 0x01, 0xF1,
  0xF0, 0x3B, 0x87, 0xFF, 0x38, 0x07, 0xE1, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x83, 0xE1, 0xF1, 0xF8, 0x78, 0x00, 0x01,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x78, 0x1F, 0x1E, 0x00, 0xE7, 0x80,
  0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x19, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x1E, 0x07, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x1C, 0x18, 0x00,
  0x30, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x31,
  0x80, 0xF8, 0xCE, 0x07, 0xF3, 0x30, 0x38, 0x2C, 0xC1, 0xC0, 0x73, 0x06,
  0x01, 0xDC, 0x38, 0x06, 0x70, 0xC0, 0x19, 0x83, 0x00, 0x66, 0x0C, 0x01,
  0x98, 0x70, 0x0E, 0x61, 0xC0, 0x3B, 0x87, 0x00, 0xCE, 0x18, 0x03, 0x38,
  0x60, 0x1C, 0xE1, 0xC0, 0x73, 0x07, 0x03, 0xCC, 0x0E, 0x1F, 0x30, 0x3F,
  0xDC, 0xC0, 0x7E, 0x63, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0x18, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x1C, 0x03, 0x80, 0x1C, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x06,
  0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1C,
  0x00, 0xF0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x60, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x3C,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x38, 0x00, 0xE0, 0x60, 0x00, 0xE1,
  0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x30, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80,
  0x01, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x3C, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x0E,
  0x07, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xC0, 0x00, 0xC7, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x07, 0x38, 0x00, 0x18, 0x60, 0x00, 0xE1, 0xC0, 0x07, 0x03,
  0x80, 0x38, 0x0F, 0x83, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x18, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0xE0,
  0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00,
  0xE3, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0xCE,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xE0,
  0x00, 0xE1, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x01,
  0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xC0, 0x01,
  0xC3, 0x80, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x3F, 0xE3, 0x00, 0xFF, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01,
  0xC3, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0xD8,
  0x0F, 0x07, 0x30, 0x0F, 0xFC, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x60, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x03, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x06,
  0x06, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x03,
  0x81, 0xC0, 0x1C, 0x07, 0x81, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x03, 0x80,
  0x07, 0x80, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00,
  0x70, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x1F, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x1D, 0xCE, 0x00, 0x03, 0xF1, 0xC0,
  0x00, 0x7C, 0x18, 0x00, 0x1F, 0x03, 0x80, 0x03, 0xC0, 0x30, 0x00, 0x70,
  0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x07, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0xF0, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xB8, 0x03, 0x70,
  0x66, 0x01, 0xD8, 0x19, 0x80, 0xE6, 0x0E, 0x60, 0x31, 0x83, 0x9C, 0x1C,
  0xE0, 0xE3, 0x06, 0x38, 0x30, 0xC3, 0x8E, 0x0C, 0x30, 0xC3, 0x03, 0x0E,
  0x60, 0xC1, 0xC1, 0xB8, 0x30, 0x70, 0x6C, 0x1C, 0x1C, 0x1F, 0x07, 0x06,
  0x07, 0x81, 0xC1, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x38, 0x08, 0x06,
  0x0E, 0x02, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60,
  0x07, 0x80, 0x03, 0x83, 0xE0, 0x01, 0xC1, 0xF0, 0x00, 0xE0, 0xD8, 0x00,
  0x60, 0x6E, 0x00, 0x30, 0x77, 0x00, 0x38, 0x39, 0x80, 0x1C, 0x1C, 0xC0,
  0x0E, 0x0E, 0x70, 0x07, 0x06, 0x38, 0x03, 0x03, 0x0C, 0x01, 0x83, 0x87,
  0x01, 0xC1, 0xC3, 0x80, 0xE0, 0xE0, 0xC0, 0x70, 0x70, 0x60, 0x38, 0x30,
  0x38, 0x18, 0x18, 0x1C, 0x0C, 0x1C, 0x06, 0x0E, 0x0E, 0x03, 0x07, 0x07,
  0x01, 0xC3, 0x83, 0x80, 0xE1, 0xC1, 0x80, 0x30, 0xC0, 0xC0, 0x1C, 0x60,
  0xE0, 0x0E, 0x70, 0x70, 0x03, 0x38, 0x38, 0x01, 0x9C, 0x1C, 0x00, 0xEE,
  0x0C, 0x00, 0x76, 0x06, 0x00, 0x1B, 0x07, 0x00, 0x0F, 0x83, 0x80, 0x07,
  0xC1, 0xC0, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0x81,
  0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x03,
  0x0E, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x06, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x63, 0x80, 0x01, 0xC3, 0x00, 0x03,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0x80,
  0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x01, 0xC0, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x18, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x01, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x60,
  0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x78, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xC0, 0x07, 0x81, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x01,
  0xC1, 0xC0, 0x03, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x07, 0x18, 0x00, 0x0E,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00,
  0x03, 0xB8, 0x00, 0x06, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x63, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38,
  0x0E, 0x00, 0xE0, 0x1E, 0x07, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x8E, 0x00,
  0x07, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70,
  0x38, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xC0, 0x00,
  0x70, 0x60, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x78, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x06, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x03, 0x80,
  0x60, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x07,
  0x00, 0x0E, 0x03, 0x80, 0x03, 0x81, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x01, 0xF0, 0x0F, 0x00,
  0x1E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x50, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x3C, 0x00,
  0x0E, 0x03, 0xC0, 0x07, 0x80, 0x7C, 0x07, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE8, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x61, 0x80,
  0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x30, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03,
  0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x60, 0x00, 0x71,
  0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C,
  0x00, 0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xE1, 0x80,
  0x01, 0x83, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1E, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xE0, 0x00,
  0x07, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x30, 0x30, 0x00,
  0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x38, 0x01,
  0xC0, 0x38, 0x01, 0x80, 0x38, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x07,
  0x00, 0x18, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x07, 0x0C, 0x07, 0x01, 0xC7, 0x03, 0xC0, 0x61, 0xC0, 0xF0,
  0x18, 0x70, 0x3C, 0x0E, 0x1C, 0x1B, 0x83, 0x07, 0x06, 0xE0, 0xC1, 0x83,
  0x98, 0x30, 0x60, 0xC6, 0x1C, 0x18, 0x71, 0x86, 0x06, 0x18, 0x61, 0x81,
  0x86, 0x18, 0x60, 0x63, 0x86, 0x38, 0x18, 0xC1, 0x8C, 0x06, 0x70, 0x63,
  0x03, 0x98, 0x18, 0xC0, 0xE6, 0x06, 0x70, 0x3B, 0x81, 0xD8, 0x0E, 0xC0,
  0x76, 0x03, 0x70, 0x1D, 0x80, 0xD8, 0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x0F,
  0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x03, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x3C, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03,
  0x80, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x78, 0x00, 0x70,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1D, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x60, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xCC, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x30, 0x00,
  0xE0, 0x70, 0x01, 0x80, 0x60, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x70,
  0x01, 0x80, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x0E, 0x00, 0x07, 0x38, 0x00,
  0x06, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE7, 0x18, 0xE3, 0x18, 0x63, 0x00, 0xFC, 0x18, 0x1F, 0xF8, 0xC1,
  0xE0, 0xEE, 0x1C, 0x01, 0xF1, 0xC0, 0x07, 0x9C, 0x00, 0x3C, 0xC0, 0x00,
  0xCE, 0x00, 0x06, 0x70, 0x00, 0x33, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xEE, 0x00, 0x06, 0x70, 0x00, 0x33, 0x80, 0x01, 0x98, 0x00, 0x1C,
  0xC0, 0x00, 0xE6, 0x00, 0x07, 0x38, 0x00, 0x71, 0xC0, 0x05, 0x86, 0x00,
  0x2C, 0x38, 0x02, 0xE0, 0xF0, 0x67, 0xE3, 0xFE, 0x1F, 0x0F, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC1, 0xF8, 0x03, 0x1F, 0xF8, 0x0C, 0xE0, 0xF0,
  0x76, 0x01, 0xC1, 0xF0, 0x03, 0x87, 0x80, 0x06, 0x1C, 0x00, 0x1C, 0x70,
  0x00, 0x71, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x39, 0xC0, 0x00, 0xE7,
  0x00, 0x03, 0x9C, 0x00, 0x0C, 0x70, 0x00, 0x71, 0xC0, 0x03, 0x87, 0x00,
  0x0E, 0x3A, 0x00, 0x70, 0xEE, 0x07, 0x83, 0x9F, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1C, 0x0F, 0x07, 0x00, 0x71, 0x80,
  0x06, 0x70, 0x00, 0xDC, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0B, 0x00, 0x03, 0xF0, 0x00,
  0xE6, 0x00, 0x38, 0xE0, 0x0E, 0x0F, 0x07, 0x80, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x03, 0xF0, 0x70, 0x1F, 0xF8, 0xC0,
  0x78, 0x19, 0x81, 0xC0, 0x1B, 0x07, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x30,
  0x00, 0x38, 0xE0, 0x00, 0x61, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x8E, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x30, 0xE0, 0x00,
  0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x07, 0x0E, 0x00, 0x1E,
  0x1C, 0x00, 0x38, 0x18, 0x00, 0xB0, 0x38, 0x02, 0x60, 0x3C, 0x19, 0xC0,
  0x3F, 0xE3, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07,
  0x81, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0x73, 0x80, 0x07, 0x70, 0x00, 0x77,
  0x00, 0x07, 0x60, 0x00, 0x6E, 0x00, 0x1E, 0xE0, 0x07, 0xCE, 0x07, 0xF0,
  0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x04, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0x60, 0x01, 0xC7, 0x00,
  0x38, 0x3C, 0x0F, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x3C, 0x03, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7E, 0x0E, 0x03, 0xFF, 0x18,
  0x0F, 0x03, 0x30, 0x38, 0x03, 0x60, 0xE0, 0x03, 0xC3, 0x80, 0x03, 0x86,
  0x00, 0x07, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x31, 0xC0,
  0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00,
  0x0C, 0x30, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xE1, 0xC0, 0x03,
  0xC1, 0x80, 0x0B, 0x03, 0x80, 0x36, 0x03, 0xC1, 0xCC, 0x03, 0xFF, 0x38,
  0x01, 0xF8, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x08, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x7C,
  0x0F, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x87,
  0xE0, 0x1C, 0xFF, 0xC0, 0xCE, 0x0E, 0x06, 0xC0, 0x38, 0x74, 0x01, 0xC3,
  0xC0, 0x06, 0x1E, 0x00, 0x30, 0xE0, 0x01, 0xC7, 0x00, 0x0C, 0x30, 0x00,
  0x63, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E,
  0x38, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x03, 0x03, 0x80, 0xE0, 0x38, 0x1C,
  0x03, 0x03, 0x80, 0x30, 0x70, 0x07, 0x1E, 0x00, 0x73, 0x80, 0x07, 0x70,
  0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x0C, 0x01, 0xC0,
  0xE0, 0x1C, 0x07, 0x01, 0x80, 0x38, 0x18, 0x01, 0xC1, 0x80, 0x0E, 0x38,
  0x00, 0x73, 0x80, 0x03, 0xB0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x7E, 0x00, 0x63, 0xFF, 0x00, 0xCE, 0x0F,
  0x03, 0xB0, 0x0E, 0x07, 0x40, 0x0E, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x60, 0x60, 0x01, 0xC1, 0xC0, 0x03, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x70, 0x0E, 0x03, 0xC0, 0x18, 0x3C, 0x00, 0x31, 0xC0, 0x00, 0xE1,
  0xC0, 0x01, 0xC1, 0x80, 0x03, 0x83, 0x80, 0x37, 0x03, 0x00, 0xEC, 0x07,
  0x03, 0x98, 0x06, 0x0E, 0x70, 0x0E, 0x38, 0xE0, 0x0C, 0xC1, 0xC0, 0x1F,
  0x00, 0x00, 0x1C, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x38, 0x07, 0x87, 0x01, 0xC0, 0xE0,
  0xE0, 0x1C, 0x38, 0x03, 0x0E, 0x00, 0xE3, 0x80, 0x1D, 0xC0, 0x03, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x0C, 0x78, 0x1E, 0x06, 0x7E, 0x3F, 0x83, 0x63,
  0x90, 0xE3, 0xC0, 0xD0, 0x71, 0xE0, 0x70, 0x18, 0xE0, 0x38, 0x0C, 0x70,
  0x18, 0x0E, 0x30, 0x0C, 0x07, 0x18, 0x0E, 0x03, 0x9C, 0x07, 0x01, 0x8E,
  0x03, 0x80, 0xC7, 0x01, 0x80, 0x63, 0x00, 0xC0, 0x71, 0x80, 0x60, 0x38,
  0xC0, 0x70, 0x1C, 0xE0, 0x38, 0x0C, 0x70, 0x1C, 0x06, 0x38, 0x0C, 0x03,
  0x18, 0x06, 0x03, 0x8C, 0x03, 0x01, 0xC6, 0x03, 0x80, 0xE3, 0x01, 0xC0,
  0x63, 0x80, 0xE0, 0x31, 0xC0, 0x60, 0x18, 0x0E, 0x1F, 0x80, 0x73, 0xFF,
  0x03, 0x38, 0x38, 0x1B, 0x00, 0xE1, 0xD0, 0x07, 0x0F, 0x00, 0x18, 0x78,
  0x00, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xC0, 0x01, 0x8E, 0x00, 0x1C,
  0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC6,
  0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x07, 0x1C, 0x00, 0x38, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x01, 0xE0, 0x78, 0x1C, 0x00, 0xE1, 0xC0, 0x03, 0x0C,
  0x00, 0x1C, 0xE0, 0x00, 0xE6, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x00,
  0xDC, 0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x37, 0x00, 0x03, 0x98, 0x00, 0x18,
  0xC0, 0x01, 0xC7, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x70, 0x3C, 0x01, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0x03, 0x07, 0xE0, 0x03, 0x1F, 0xF8, 0x07, 0x38,
  0x3C, 0x07, 0x60, 0x1C, 0x07, 0xC0, 0x0E, 0x07, 0x80, 0x06, 0x07, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x3A, 0x00, 0x70, 0x3B, 0x81,
  0xE0, 0x39, 0xFF, 0xC0, 0x38, 0x7F, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x1C, 0x0F, 0xFC,
  0x60, 0x78, 0x19, 0x83, 0x80, 0x36, 0x1C, 0x00, 0x78, 0xE0, 0x00, 0xE3,
  0x00, 0x03, 0x9C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0x80, 0x00, 0xCE, 0x00,
  0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00, 0x06,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x8E, 0x00, 0x1E, 0x38,
  0x00, 0x70, 0x60, 0x02, 0xC1, 0xC0, 0x13, 0x03, 0xC1, 0xDC, 0x07, 0xFC,
  0x70, 0x07, 0xE1, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xF0, 0x1D, 0xC0, 0x00, 0x74,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0xC0, 0x3C, 0x07, 0x81, 0xC0, 0x07, 0x0E, 0x00, 0x08, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x88, 0x00, 0x0E, 0xF0, 0x00, 0x71, 0xE0, 0x03, 0xC3, 0xE0, 0x3E, 0x03,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x04, 0x07, 0x00, 0x70, 0x30,
  0x07, 0x01, 0x80, 0xE0, 0x1C, 0x0E, 0x00, 0xE1, 0xE0, 0x07, 0x1C, 0x00,
  0x3B, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x31, 0x80,
  0x03, 0x38, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x06, 0x30,
  0x00, 0x63, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x1C,
  0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0x8E, 0x00, 0x58, 0xE0, 0x0F,
  0x87, 0x01, 0xB8, 0x78, 0x33, 0x83, 0xFE, 0x38, 0x0F, 0x80, 0x00, 0x7F,
  0x80, 0x1B, 0xFC, 0x00, 0xE0, 0x30, 0x01, 0x81, 0xC0, 0x06, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x06, 0x00, 0x1C,
  0x18, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38,
  0x01, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x70, 0x07,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x1C, 0x1E, 0x00, 0x61, 0xF0, 0x01,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x0C, 0x0C, 0x70, 0x18, 0x18, 0xE0,
  0x30, 0x39, 0x80, 0x60, 0x73, 0x01, 0xC0, 0x66, 0x03, 0x80, 0xCC, 0x06,
  0x01, 0xB8, 0x0C, 0x03, 0x70, 0x18, 0x06, 0xC0, 0x30, 0x0D, 0x80, 0xE0,
  0x1B, 0x01, 0xC0, 0x76, 0x03, 0x00, 0xFC, 0x06, 0x01, 0xF8, 0x0C, 0x03,
  0x60, 0x18, 0x06, 0xC0, 0x70, 0x1D, 0x80, 0xE0, 0x3B, 0x01, 0xC0, 0x66,
  0x05, 0x81, 0xCC, 0x0B, 0x03, 0x18, 0x26, 0x0E, 0x38, 0xCE, 0x38, 0x7F,
  0x0F, 0xE0, 0x7C, 0x0F, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0xFC, 0x1F, 0xE0,
  0xFB, 0x86, 0x1C, 0x78, 0x63, 0x07, 0x78, 0x19, 0x80, 0xC8, 0x07, 0x40,
  0x30, 0x01, 0xD0, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00,
  0x30, 0x0B, 0x00, 0x0C, 0x02, 0xC0, 0x23, 0x01, 0xB0, 0x0C, 0xC0, 0x4E,
  0x0F, 0x30, 0x31, 0x87, 0x0E, 0x18, 0x67, 0x81, 0xFC, 0x1F, 0xC0, 0x3E,
  0x03, 0xC0, 0x00, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x03,
  0x00, 0x06, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x70, 0x02, 0xC0, 0xE0, 0x05,
  0x80, 0xE0, 0x17, 0x01, 0xE0, 0xCE, 0x01, 0xFF, 0x1C, 0x00, 0xFC, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x08, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x7C, 0x07, 0x80, 0x3F,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x06, 0x0F, 0xFF, 0x0C, 0x38,
  0x1F, 0xB8, 0x60, 0x07, 0xF1, 0xC0, 0x03, 0xC3, 0x00, 0x07, 0x06, 0x00,
  0x1C, 0x0C, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x18, 0x03, 0x80, 0x30, 0x0E, 0x00, 0x60, 0x38, 0x00, 0xE0,
  0xE0, 0x01, 0xC7, 0xF0, 0x01, 0x8C, 0xFE, 0x03, 0x18, 0x1F, 0xE6, 0x70,
  0x03, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C,
  0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0x0F, 0xE0, 0x03, 0x1C, 0x70,
  0x06, 0x18, 0x38, 0x06, 0x30, 0x18, 0x0C, 0x70, 0x0C, 0x1C, 0x60, 0x0E,
  0x38, 0x60, 0x07, 0xF0, 0xC0, 0x03, 0xE0,
};

const GFXglyph IBMPlexMono_LightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 10, 32, 28, 9, -32 },
  { 41, 11, 12, 28, 11, -34 },
  { 58, 27, 32, 28, 1, -32 },
  { 166, 26, 44, 28, 1, -38 },
  { 309, 31, 34, 28, -1, -33 },
  { 441, 27, 34, 28, 0, -33 },
  { 556, 5, 12, 28, 14, -34 },
  { 564, 16, 41, 28, 10, -35 },
  { 646, 16, 41, 28, 2, -35 },
  { 728, 23, 23, 28, 3, -25 },
  { 795, 22, 22, 28, 3, -25 },
  { 856, 9, 12, 28, 7, -5 },
  { 870, 13, 2, 28, 8, -15 },
  { 874, 6, 5, 28, 9, -5 },
  { 878, 26, 41, 28, 1, -35 },
  { 1012, 23, 34, 28, 3, -33 },
  { 1110, 22, 32, 28, 2, -32 },
  { 1198, 23, 33, 28, 2, -33 },
  { 1293, 23, 34, 28, 2, -33 },
  { 1391, 24, 32, 28, 1, -32 },
  { 1487, 24, 33, 28, 2, -32 },
  { 1586, 21, 33, 28, 3, -32 },
  { 1673, 22, 32, 28, 5, -32 },
  { 1761, 24, 34, 28, 2, -33 },
  { 1863, 21, 33, 28, 4, -33 },
  { 1950, 9, 25, 28, 9, -25 },
  { 1979, 11, 32, 28, 7, -25 },
  { 2023, 22, 26, 28, 4, -27 },
  { 2095, 24, 10, 28, 2, -19 },
  { 2125, 22, 26, 28, 2, -27 },
  { 2197, 19, 33, 28, 6, -33 },
  { 2276, 22, 38, 28, 3, -33 },
  { 2381, 24, 32, 28, 0, -32 },
  { 2477, 23, 32, 28, 2, -32 },
  { 2569, 22, 34, 28, 4, -33 },
  { 2663, 23, 32, 28, 3, -32 },
  { 2755, 25, 32, 28, 2, -32 },
  { 2855, 26, 32, 28, 2, -32 },
  { 2959, 23, 34, 28, 3, -33 },
  { 3057, 25, 32, 28, 2, -32 },
  { 3157, 25, 32, 28, 2, -32 },
  { 3257, 22, 33, 28, 3, -32 },
  { 3348, 27, 32, 28, 2, -32 },
  { 3456, 19, 32, 28, 4, -32 },
  { 3532, 26, 32, 28, 1, -32 },
  { 3636, 25, 32, 28, 2, -32 },
  { 3736, 23, 34, 28, 3, -33 },
  { 3834, 25, 32, 28, 2, -32 },
  { 3934, 23, 41, 28, 3, -33 },
  { 4052, 25, 32, 28, 2, -32 },
  { 4152, 26, 34, 28, 1, -33 },
  { 4263, 26, 32, 28, 4, -32 },
  { 4367, 23, 33, 28, 4, -32 },
  { 4462, 24, 32, 28, 5, -32 },
  { 4558, 26, 32, 28, 3, -32 },
  { 4662, 29, 32, 28, 0, -32 },
  { 4778, 26, 32, 28, 4, -32 },
  { 4882, 28, 32, 28, 0, -32 },
  { 4994, 19, 41, 28, 8, -35 },
  { 5092, 11, 41, 28, 9, -35 },
  { 5149, 19, 41, 28, 1, -35 },
  { 5247, 23, 18, 28, 3, -32 },
  { 5299, 22, 2, 28, 0, 5 },
  { 5305, 5, 8, 28, 11, -35 },
  { 5310, 21, 25, 28, 3, -24 },
  { 5376, 22, 35, 28, 3, -34 },
  { 5473, 19, 25, 28, 4, -24 },
  { 5533, 23, 35, 28, 3, -34 },
  { 5634, 20, 25, 28, 4, -24 },
  { 5697, 30, 44, 28, -1, -34 },
  { 5862, 23, 34, 28, 2, -24 },
  { 5960, 21, 34, 28, 3, -34 },
  { 6050, 20, 35, 28, 4, -34 },
  { 6138, 20, 45, 28, 4, -35 },
  { 6251, 23, 35, 28, 3, -34 },
  { 6352, 19, 35, 28, 5, -34 },
  { 6436, 25, 24, 28, 1, -24 },
  { 6511, 21, 24, 28, 3, -24 },
  { 6574, 21, 25, 28, 3, -24 },
  { 6640, 24, 33, 28, 1, -24 },
  { 6739, 22, 33, 28, 3, -24 },
  { 6830, 22, 24, 28, 5, -24 },
  { 6896, 22, 25, 28, 2, -24 },
  { 6965, 21, 33, 28, 4, -32 },
  { 7052, 20, 25, 28, 4, -24 },
  { 7115, 22, 24, 28, 3, -24 },
  { 7181, 23, 25, 28, 3, -24 },
  { 7253, 26, 25, 28, 1, -24 },
  { 7335, 23, 34, 28, 1, -24 },
  { 7433, 23, 25, 28, 2, -24 },
  { 7505, 21, 41, 28, 5, -35 },
  { 7613, 9, 41, 28, 10, -35 },
  { 7660, 21, 41, 28, 2, -35 },
  { 7768, 24, 9, 28, 2, -18 },
};

const GFXfont IBMPlexMono_LightItalic46pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic46pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic46pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _IBMPLEXMONO_LIGHTITALIC46PT7B_H_
