#ifndef _IBMPLEXMONO_LIGHTITALIC18PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x96, 0x92, 0x40, 0x6C, 0x4A, 0x55, 0x29, 0x00, 0x02, 0x40,
  0x90, 0x12, 0x02, 0x43, 0x9E, 0x12, 0x02, 0x40, 0x90, 0xF3, 0xC2, 0x40,
  0x88, 0x12, 0x06, 0x40, 0x02, 0x00, 0x80, 0xF8, 0x49, 0x22, 0x48, 0x82,
  0x40, 0x50, 0x0F, 0x01, 0x60, 0x48, 0x22, 0x48, 0xBA, 0x63, 0xE0, 0x20,
  0x08, 0x00, 0x1C, 0x32, 0x42, 0x42, 0x44, 0x48, 0x45, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x14, 0x42, 0x44, 0x44, 0x44, 0x44, 0x83, 0x80, 0x0F, 0x02,
  0x20, 0x42, 0x08, 0x41, 0x10, 0x22, 0x0F, 0x82, 0x60, 0x84, 0x10, 0x42,
  0x09, 0xE2, 0xA7, 0x98, 0xF8, 0x0C, 0x42, 0x08, 0x41, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x81, 0x04, 0x08, 0x10, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x82, 0x10, 0x42, 0x30, 0x04, 0x04, 0x02, 0x19, 0x33, 0xE0, 0xC0,
  0x90, 0xC4, 0x42, 0x00, 0x04, 0x02, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20,
  0x10, 0x10, 0x00, 0x6B, 0x48, 0xF8, 0xF0, 0x00, 0xC0, 0x20, 0x10, 0x04,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x0F, 0x18, 0xC8, 0x28, 0x14, 0x0A, 0x67, 0x23, 0x01,
  0x81, 0xC0, 0xA0, 0x48, 0x43, 0xC0, 0x0E, 0x1C, 0x34, 0x64, 0x04, 0x04,
  0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x1E, 0x10, 0x98, 0x20, 0x10,
  0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x0F, 0xF0, 0x1E, 0x10,
  0x90, 0x20, 0x10, 0x10, 0x18, 0x70, 0x04, 0x01, 0x00, 0xA0, 0x58, 0x47,
  0xC0, 0x00, 0x80, 0x60, 0x28, 0x12, 0x08, 0x84, 0x41, 0x10, 0x84, 0x41,
  0x3F, 0xF0, 0x10, 0x04, 0x02, 0x00, 0x3F, 0x90, 0x08, 0x04, 0x02, 0x02,
  0xF1, 0x8C, 0x02, 0x01, 0x00, 0xA0, 0x58, 0x43, 0xC0, 0x03, 0x0C, 0x18,
  0x30, 0x20, 0x5E, 0x61, 0xC1, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xFF, 0xC0,
  0xA0, 0x50, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x0C,
  0x00, 0x1F, 0x18, 0xC8, 0x28, 0x14, 0x09, 0x08, 0x78, 0xC6, 0x81, 0x40,
  0xE0, 0x58, 0x67, 0xC0, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x83, 0xC6, 0x7A,
  0x04, 0x04, 0x08, 0x30, 0xE0, 0x6C, 0x00, 0x00, 0xD8, 0x33, 0x00, 0x00,
  0x00, 0x64, 0xC8, 0x80, 0x01, 0x06, 0x08, 0x30, 0xC0, 0x80, 0x60, 0x10,
  0x0C, 0x02, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x40, 0x18, 0x02, 0x00,
  0xC0, 0x10, 0x1C, 0x10, 0x30, 0x60, 0x40, 0x00, 0x3E, 0x63, 0x41, 0x81,
  0x01, 0x02, 0x0C, 0x10, 0x10, 0x20, 0x00, 0x20, 0x60, 0x0F, 0x18, 0xC8,
  0x28, 0x14, 0xEA, 0x4D, 0x43, 0x22, 0x91, 0x48, 0xA7, 0xD1, 0x08, 0x02,
  0x00, 0xF8, 0x03, 0x02, 0x81, 0x41, 0x20, 0x90, 0x88, 0x44, 0x21, 0x3F,
  0x90, 0x50, 0x28, 0x18, 0x08, 0x3F, 0x10, 0xC8, 0x2C, 0x14, 0x0A, 0x09,
  0xF8, 0x82, 0x41, 0x60, 0xA0, 0x50, 0x6F, 0xE0, 0x0F, 0x08, 0xC8, 0x2C,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x90, 0x4C, 0x43, 0xC0, 0x3E,
  0x10, 0x88, 0x24, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x41, 0xA0, 0xB0, 0x50,
  0x4F, 0xC0, 0x3F, 0xC8, 0x02, 0x01, 0x80, 0x40, 0x10, 0x07, 0xF1, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x00, 0xFF, 0x00, 0x3F, 0xC8, 0x02, 0x01, 0x80,
  0x40, 0x10, 0x07, 0xF1, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x00,
  0x0F, 0x18, 0xC8, 0x28, 0x04, 0x02, 0x03, 0x01, 0x0F, 0x81, 0x40, 0x90,
  0x48, 0xE3, 0x90, 0x20, 0xC8, 0x26, 0x09, 0x02, 0x40, 0x90, 0x27, 0xF1,
  0x04, 0x41, 0x20, 0x48, 0x12, 0x04, 0x83, 0x00, 0x3F, 0xC1, 0x00, 0x40,
  0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0xFF,
  0x00, 0x1F, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x20, 0x88, 0xC7, 0x80, 0x20, 0x48, 0x22, 0x11, 0x88, 0x44, 0x12, 0x05,
  0x81, 0x90, 0x44, 0x10, 0x88, 0x22, 0x04, 0x81, 0x00, 0x20, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0x20, 0xD8, 0x35,
  0x19, 0x4E, 0x52, 0x95, 0x24, 0xCA, 0x22, 0x89, 0x20, 0x48, 0x12, 0x04,
  0x81, 0x00, 0x30, 0xCC, 0x25, 0x09, 0x42, 0x48, 0x92, 0x24, 0x91, 0x24,
  0x45, 0x21, 0x48, 0x52, 0x14, 0x83, 0x00, 0x0F, 0x18, 0xC8, 0x28, 0x14,
  0x0A, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xA0, 0x48, 0x43, 0xC0, 0x3F, 0x10,
  0x48, 0x2C, 0x14, 0x0A, 0x0D, 0xFC, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08,
  0x00, 0x0F, 0x18, 0xC8, 0x28, 0x14, 0x0A, 0x07, 0x03, 0x01, 0x81, 0xC0,
  0xA0, 0x48, 0x43, 0xC0, 0x48, 0x36, 0x0C, 0x3F, 0x10, 0x48, 0x2C, 0x14,
  0x0A, 0x0D, 0xFC, 0x88, 0x44, 0x22, 0x20, 0x90, 0x48, 0x10, 0x1F, 0x10,
  0xD0, 0x28, 0x04, 0x01, 0x80, 0x78, 0x02, 0x01, 0x00, 0xA0, 0x58, 0x67,
  0xC0, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x20, 0x00, 0x20, 0xC8, 0x26, 0x09, 0x02, 0x40,
  0x90, 0x24, 0x11, 0x04, 0x41, 0x20, 0x4C, 0x31, 0x08, 0x3C, 0x00, 0x80,
  0xC0, 0x60, 0x48, 0x24, 0x22, 0x11, 0x10, 0x88, 0x48, 0x24, 0x0C, 0x06,
  0x03, 0x00, 0x40, 0x50, 0x14, 0x05, 0x02, 0x4C, 0x93, 0x25, 0x4A, 0x54,
  0x95, 0x29, 0x4A, 0x53, 0x14, 0xC2, 0x00, 0x30, 0x22, 0x08, 0x42, 0x04,
  0xC0, 0x90, 0x0C, 0x01, 0x00, 0x50, 0x1A, 0x02, 0x20, 0x84, 0x20, 0x4C,
  0x08, 0x80, 0xE0, 0x64, 0x11, 0x08, 0x26, 0x09, 0x02, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x00, 0x3F, 0xE0, 0x08, 0x03, 0x00, 0xC0,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0F, 0xF8,
  0x1F, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x80, 0xF8, 0x82, 0x10, 0x84, 0x20, 0x84, 0x21, 0x04, 0x21,
  0x08, 0x21, 0x1F, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0xF8, 0x06, 0x05, 0x04, 0x82, 0x22, 0x12,
  0x06, 0x02, 0xFF, 0x80, 0x94, 0x1D, 0xB1, 0x90, 0x50, 0x28, 0x14, 0x0A,
  0x09, 0x8C, 0x7B, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0xF2, 0x89, 0x82,
  0x81, 0x40, 0xA0, 0x90, 0x58, 0x4B, 0xC0, 0x1E, 0x21, 0x41, 0x40, 0xC0,
  0x80, 0x41, 0x42, 0x3C, 0x00, 0x80, 0x40, 0x20, 0x11, 0xCB, 0x19, 0x05,
  0x02, 0x81, 0x40, 0xA0, 0xD8, 0xC7, 0xA0, 0x1E, 0x21, 0x41, 0x43, 0xFC,
  0x80, 0x41, 0x42, 0x3C, 0x01, 0xE0, 0x40, 0x08, 0x01, 0x03, 0xFE, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x81, 0x10, 0x12,
  0x01, 0x40, 0x18, 0x00, 0x1C, 0xB1, 0x90, 0x58, 0x28, 0x14, 0x0A, 0x0D,
  0x8C, 0x7A, 0x01, 0x00, 0x90, 0x87, 0x80, 0x30, 0x20, 0x20, 0x20, 0x2E,
  0x31, 0x61, 0x41, 0x41, 0x41, 0x41, 0x42, 0x82, 0x08, 0x30, 0x00, 0x0F,
  0x02, 0x04, 0x10, 0x20, 0x44, 0x99, 0x43, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x3F, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x44, 0xE4, 0x34,
  0x18, 0x20, 0x10, 0x08, 0x04, 0x02, 0xF3, 0x89, 0x84, 0x82, 0x46, 0x2C,
  0x12, 0x31, 0xA8, 0x60, 0xF8, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x44, 0x92, 0xC6, 0x00, 0x2D, 0xCD, 0x92, 0x45, 0x11, 0x44, 0x51, 0x14,
  0x49, 0x22, 0x88, 0x80, 0x2E, 0x31, 0x61, 0x41, 0x41, 0x41, 0x41, 0x42,
  0x82, 0x1E, 0x10, 0x90, 0x48, 0x18, 0x14, 0x0A, 0x04, 0x84, 0x3C, 0x00,
  0x2F, 0x28, 0x98, 0x28, 0x14, 0x0A, 0x09, 0x05, 0x84, 0xBC, 0x40, 0x20,
  0x10, 0x08, 0x00, 0x1C, 0xB1, 0x90, 0x50, 0x28, 0x14, 0x0A, 0x0D, 0x8C,
  0x7A, 0x01, 0x00, 0x80, 0x40, 0x60, 0xF7, 0x8C, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x00, 0x1E, 0x10, 0xD0, 0x0C, 0x03, 0xE0, 0x08,
  0x05, 0x86, 0x7C, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x88, 0xC5, 0x83, 0x00, 0x43, 0x82, 0x82, 0x82, 0x82,
  0x82, 0x84, 0x8C, 0xF4, 0xF1, 0x10, 0x48, 0x24, 0x12, 0x11, 0x08, 0x88,
  0x98, 0x78, 0x00, 0x44, 0xA2, 0x52, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x32,
  0xEE, 0x00, 0x19, 0xC4, 0xCF, 0x18, 0x82, 0x20, 0x41, 0x08, 0x23, 0x14,
  0xA4, 0x73, 0x00, 0x21, 0xA0, 0x90, 0x48, 0x24, 0x12, 0x09, 0x08, 0x8C,
  0x7A, 0x01, 0x01, 0x90, 0x87, 0x80, 0x3C, 0xA1, 0xD0, 0xC0, 0x80, 0x81,
  0x89, 0x05, 0xF2, 0x8F, 0x00, 0x0F, 0x08, 0x10, 0x10, 0x08, 0x08, 0x08,
  0xF0, 0x18, 0x08, 0x10, 0x20, 0x20, 0x20, 0x40, 0x7C, 0x24, 0x92, 0x92,
  0x49, 0x49, 0x24, 0x3E, 0x02, 0x04, 0x04, 0x08, 0x10, 0x18, 0x07, 0x18,
  0x10, 0x10, 0x10, 0x08, 0x08, 0x10, 0xF0, 0x30, 0xA4, 0x62, 0x50, 0xC0,
};

const GFXglyph IBMPlexMono_LightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 5, 5, 11, 4, -13 },
  { 10, 11, 13, 11, 0, -13 },
  { 28, 10, 17, 11, 0, -15 },
  { 50, 12, 13, 11, 0, -13 },
  { 70, 11, 13, 11, 0, -13 },
  { 88, 1, 5, 11, 6, -13 },
  { 89, 6, 16, 11, 4, -14 },
  { 101, 6, 16, 11, 1, -14 },
  { 113, 9, 9, 11, 1, -10 },
  { 124, 9, 9, 11, 1, -10 },
  { 135, 3, 5, 11, 3, -2 },
  { 137, 5, 1, 11, 3, -6 },
  { 138, 2, 2, 11, 4, -2 },
  { 139, 10, 16, 11, 1, -14 },
  { 159, 9, 13, 11, 1, -13 },
  { 174, 8, 13, 11, 1, -13 },
  { 187, 9, 13, 11, 1, -13 },
  { 202, 9, 13, 11, 1, -13 },
  { 217, 10, 13, 11, 0, -13 },
  { 234, 9, 13, 11, 1, -13 },
  { 249, 8, 13, 11, 1, -13 },
  { 262, 9, 13, 11, 2, -13 },
  { 277, 9, 13, 11, 1, -13 },
  { 292, 8, 13, 11, 2, -13 },
  { 305, 3, 10, 11, 4, -10 },
  { 309, 4, 13, 11, 3, -10 },
  { 316, 8, 10, 11, 2, -11 },
  { 326, 9, 5, 11, 1, -8 },
  { 332, 9, 10, 11, 1, -11 },
  { 344, 8, 13, 11, 2, -13 },
  { 357, 9, 15, 11, 1, -13 },
  { 374, 9, 13, 11, 0, -13 },
  { 389, 9, 13, 11, 1, -13 },
  { 404, 9, 13, 11, 1, -13 },
  { 419, 9, 13, 11, 1, -13 },
  { 434, 10, 13, 11, 1, -13 },
  { 451, 10, 13, 11, 1, -13 },
  { 468, 9, 13, 11, 1, -13 },
  { 483, 10, 13, 11, 1, -13 },
  { 500, 10, 13, 11, 1, -13 },
  { 517, 9, 13, 11, 1, -13 },
  { 532, 10, 13, 11, 1, -13 },
  { 549, 7, 13, 11, 2, -13 },
  { 561, 10, 13, 11, 1, -13 },
  { 578, 10, 13, 11, 1, -13 },
  { 595, 9, 13, 11, 1, -13 },
  { 610, 9, 13, 11, 1, -13 },
  { 625, 9, 16, 11, 1, -13 },
  { 643, 9, 13, 11, 1, -13 },
  { 658, 9, 13, 11, 1, -13 },
  { 673, 10, 13, 11, 2, -13 },
  { 690, 10, 13, 11, 1, -13 },
  { 707, 9, 13, 11, 2, -13 },
  { 722, 10, 13, 11, 1, -13 },
  { 739, 11, 13, 11, 0, -13 },
  { 757, 10, 13, 11, 2, -13 },
  { 774, 11, 13, 11, 0, -13 },
  { 792, 8, 16, 11, 3, -14 },
  { 808, 5, 16, 11, 3, -14 },
  { 818, 8, 16, 11, 0, -14 },
  { 834, 9, 7, 11, 1, -13 },
  { 842, 9, 1, 11, 0, 2 },
  { 844, 2, 3, 11, 4, -14 },
  { 845, 9, 9, 11, 1, -9 },
  { 856, 9, 13, 11, 1, -13 },
  { 871, 8, 9, 11, 1, -9 },
  { 880, 9, 13, 11, 1, -13 },
  { 895, 8, 9, 11, 1, -9 },
  { 904, 11, 17, 11, 0, -13 },
  { 928, 9, 13, 11, 1, -9 },
  { 943, 8, 13, 11, 1, -13 },
  { 956, 7, 13, 11, 2, -13 },
  { 968, 8, 17, 11, 1, -13 },
  { 985, 9, 13, 11, 1, -13 },
  { 1000, 7, 13, 11, 2, -13 },
  { 1012, 10, 9, 11, 0, -9 },
  { 1024, 8, 9, 11, 1, -9 },
  { 1033, 9, 9, 11, 1, -9 },
  { 1044, 9, 13, 11, 1, -9 },
  { 1059, 9, 13, 11, 1, -9 },
  { 1074, 9, 9, 11, 2, -9 },
  { 1085, 9, 9, 11, 1, -9 },
  { 1096, 9, 13, 11, 1, -13 },
  { 1111, 8, 9, 11, 2, -9 },
  { 1120, 9, 9, 11, 1, -9 },
  { 1131, 9, 9, 11, 1, -9 },
  { 1142, 11, 9, 11, 0, -9 },
  { 1155, 9, 13, 11, 1, -9 },
  { 1170, 9, 9, 11, 1, -9 },
  { 1181, 8, 16, 11, 2, -14 },
  { 1197, 3, 16, 11, 4, -14 },
  { 1203, 8, 16, 11, 1, -14 },
  { 1219, 9, 4, 11, 1, -7 },
};

const GFXfont IBMPlexMono_LightItalic18pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic18pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic18pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _IBMPLEXMONO_LIGHTITALIC18PT7B_H_
