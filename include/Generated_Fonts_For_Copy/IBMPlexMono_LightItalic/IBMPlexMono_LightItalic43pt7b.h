#ifndef _IBMPLEXMONO_LIGHTITALIC43PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C,
  0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0xF0, 0x30, 0xE6, 0x1D, 0xC3, 0xB8,
  0x66, 0x0C, 0xC1, 0x98, 0x73, 0x0E, 0xE1, 0xDC, 0x33, 0x06, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x80,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x60, 0x60,
  0x00, 0x30, 0x70, 0x00, 0x18, 0x38, 0x07, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F,
  0xF0, 0x0E, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x07, 0x00, 0x03, 0x83,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0, 0x3F, 0xE0, 0xFF, 0x9F, 0xE0,
  0x7F, 0x80, 0x30, 0x70, 0x00, 0x38, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C,
  0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x07, 0x00, 0x03,
  0x83, 0x00, 0x01, 0x81, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xF8, 0x03, 0xE3, 0x3C, 0x07, 0x86, 0x0E, 0x06, 0x06, 0x07,
  0x0E, 0x06, 0x04, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x04, 0x00,
  0x0C, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0F, 0x0C, 0x00, 0x07, 0x8C, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x19, 0xF0,
  0x00, 0x18, 0x78, 0x00, 0x18, 0x38, 0x00, 0x18, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x60, 0x30, 0x38,
  0xF0, 0x30, 0x70, 0x78, 0x60, 0xF0, 0x3E, 0x63, 0xE0, 0x0F, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x38, 0x0F, 0xF0, 0x01, 0x80, 0xE1,
  0xC0, 0x18, 0x0E, 0x06, 0x01, 0xC0, 0x60, 0x18, 0x1C, 0x07, 0x00, 0xC0,
  0xC0, 0x30, 0x06, 0x0C, 0x01, 0x80, 0x70, 0xE0, 0x0C, 0x03, 0x06, 0x00,
  0x60, 0x18, 0x60, 0x03, 0x00, 0xC6, 0x00, 0x18, 0x0C, 0x70, 0x00, 0x60,
  0xE3, 0x00, 0x03, 0xFE, 0x20, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x8E, 0x18, 0x00, 0x38, 0xC0, 0x60,
  0x01, 0x8E, 0x03, 0x00, 0x18, 0x60, 0x18, 0x01, 0xC3, 0x00, 0xC0, 0x0C,
  0x18, 0x06, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xE0, 0x30,
  0x18, 0x06, 0x01, 0x81, 0xC0, 0x60, 0x0E, 0x1C, 0x06, 0x00, 0x3F, 0xC0,
  0x70, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x38,
  0x3C, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x18, 0x00,
  0x70, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x1F, 0xDE, 0x00, 0x38, 0x78, 0x00, 0x38, 0x38, 0x00, 0x38, 0x0C, 0x00,
  0x18, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x0C, 0x05, 0xC0, 0x0F, 0x03, 0xE0, 0x05, 0x83, 0x30, 0x02,
  0x61, 0x9C, 0x02, 0x39, 0x87, 0x07, 0x0D, 0xC1, 0xFF, 0x07, 0xC0, 0x7E,
  0x01, 0xC0, 0x39, 0x8C, 0x67, 0x39, 0x8C, 0x63, 0x38, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x06, 0x03, 0xF8, 0x70,
  0xFB, 0xFB, 0xBF, 0x83, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xFC, 0x00, 0x0E, 0x60, 0x00, 0xE3, 0x80, 0x0E, 0x0C, 0x00, 0xE0, 0x70,
  0x0E, 0x01, 0x80, 0xE0, 0x0E, 0x02, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x0F, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70,
  0x60, 0xE0, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xF0, 0x78, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x0E, 0x00, 0x1C, 0x60, 0x00,
  0xE7, 0x00, 0x03, 0x38, 0x00, 0x19, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xE0,
  0x00, 0x36, 0x00, 0x03, 0xF0, 0x38, 0x1F, 0x81, 0xE0, 0xFC, 0x1F, 0x07,
  0xE0, 0x70, 0x3F, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00,
  0x07, 0x60, 0x00, 0x33, 0x00, 0x03, 0x9C, 0x00, 0x18, 0xE0, 0x01, 0xC3,
  0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x78, 0x3C, 0x01, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0E, 0x70, 0x01,
  0xC7, 0x00, 0x78, 0x70, 0x0F, 0x06, 0x01, 0xE0, 0x60, 0x18, 0x0E, 0x01,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x1E, 0x07,
  0x80, 0xE0, 0x0E, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC1,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x1E, 0x07, 0x80,
  0xE0, 0x0F, 0x07, 0x00, 0x1C, 0x08, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x73,
  0xC0, 0x03, 0x87, 0x80, 0x1C, 0x0F, 0x01, 0xE0, 0x1F, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x67, 0x00, 0x01, 0x8C, 0x00, 0x07,
  0x18, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x03,
  0x80, 0x0C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x70, 0x03, 0x01, 0xC0, 0x06, 0x07,
  0x00, 0x0C, 0x1C, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x7F, 0x00, 0x77, 0xFF, 0x01, 0xF0, 0x3E, 0x07, 0x80,
  0x38, 0x08, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x20,
  0x00, 0xE3, 0x80, 0x03, 0x07, 0x00, 0x1C, 0x0F, 0x01, 0xE0, 0x1F, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0xFE,
  0x03, 0xBF, 0xF8, 0x77, 0x03, 0xC7, 0xC0, 0x1E, 0x78, 0x00, 0xEF, 0x00,
  0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x0E, 0xE0, 0x00, 0xC6, 0x00, 0x1C, 0x70, 0x03, 0x83,
  0xC0, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x98, 0x00, 0x1D, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x60, 0x00, 0xE3, 0x00,
  0x07, 0x18, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3C, 0x07, 0x81, 0xC0,
  0x0F, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03,
  0x1C, 0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x80, 0x1C, 0x07,
  0x81, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xC0, 0x70, 0x1C, 0x00,
  0xE0, 0xE0, 0x01, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0x71, 0x80,
  0x03, 0x87, 0x00, 0x1E, 0x0F, 0x01, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0x03, 0xC1, 0xC0, 0x0E, 0x38,
  0x00, 0x67, 0x00, 0x06, 0x70, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xE6, 0x00, 0x1E,
  0x70, 0x03, 0xE3, 0xC0, 0xEC, 0x1F, 0xFD, 0xC0, 0x7F, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF8,
  0xF8, 0xF8, 0xF0, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x08, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE0, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80,
  0x00, 0x10, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xE0, 0xF0, 0xE0,
  0x0E, 0x70, 0x01, 0xB8, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x7F, 0x80, 0x1F, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x38, 0x0E, 0x00, 0xE0, 0xE0,
  0x03, 0x06, 0x00, 0x18, 0x70, 0x00, 0xE3, 0x00, 0x03, 0x18, 0x00, 0x19,
  0x80, 0xF9, 0xCC, 0x0F, 0xEC, 0x60, 0xE1, 0xE7, 0x0E, 0x07, 0x38, 0x60,
  0x19, 0x87, 0x00, 0xCC, 0x30, 0x0E, 0x61, 0x80, 0x63, 0x0C, 0x03, 0x38,
  0x60, 0x19, 0xC7, 0x00, 0xCC, 0x38, 0x0E, 0x61, 0xC0, 0x73, 0x06, 0x07,
  0x18, 0x30, 0x78, 0xC1, 0xFE, 0xC6, 0x07, 0xE6, 0x30, 0x08, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x33,
  0x80, 0x01, 0xCE, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x00, 0xC1, 0x80,
  0x07, 0x06, 0x00, 0x18, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x1C,
  0x07, 0x00, 0x70, 0x0C, 0x03, 0x80, 0x30, 0x0E, 0x00, 0xC0, 0x70, 0x03,
  0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x38, 0x00, 0xE0, 0xC0, 0x01, 0x87,
  0x00, 0x06, 0x18, 0x00, 0x18, 0xE0, 0x00, 0x73, 0x00, 0x01, 0xDC, 0x00,
  0x07, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x30, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x60, 0x07, 0x01, 0x80, 0x0E, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x60,
  0xE0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61, 0xC0,
  0x03, 0x87, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x70, 0x07, 0x81, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x38, 0x01, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x0E,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC7, 0x00, 0x03, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0x86, 0x00, 0x0E, 0x18, 0x00, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xF0, 0x78, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x18, 0x60, 0x00,
  0xE7, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x02, 0x18, 0x00, 0x38, 0xE0, 0x01, 0x87,
  0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x78, 0x3C, 0x01, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0x80, 0xF0, 0x18, 0x01, 0xC0,
  0xC0, 0x07, 0x06, 0x00, 0x18, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00,
  0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x33, 0x80, 0x03, 0x9C,
  0x00, 0x1C, 0xE0, 0x00, 0xE6, 0x00, 0x07, 0x30, 0x00, 0x39, 0x80, 0x01,
  0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x31, 0x80,
  0x03, 0x8C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x38, 0x01, 0xC1,
  0xC0, 0x3C, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0xF0,
  0x3C, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x86, 0x00, 0x0C, 0x70, 0x00, 0x63,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x1F, 0xF7, 0x01, 0xFF, 0xB8, 0x00, 0x19, 0xC0, 0x00, 0xCE, 0x00, 0x06,
  0x70, 0x00, 0x33, 0x80, 0x03, 0x8C, 0x00, 0x1C, 0x60, 0x01, 0xC3, 0x80,
  0x1E, 0x0E, 0x01, 0xB0, 0x78, 0x19, 0x81, 0xFF, 0x9C, 0x03, 0xF0, 0xE0,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70,
  0xE0, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80,
  0x01, 0x83, 0x00, 0x07, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x38, 0x00,
  0x30, 0x70, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x07,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60, 0x00, 0x60,
  0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x1C,
  0x00, 0x18, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x84, 0x00, 0x30, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x0E, 0x07, 0x83, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x03, 0x81, 0x80, 0x07, 0x80, 0xC0, 0x07, 0x80, 0xE0, 0x07,
  0x80, 0x70, 0x07, 0x80, 0x38, 0x07, 0x80, 0x1C, 0x07, 0x80, 0x0C, 0x07,
  0x80, 0x06, 0x07, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE7, 0xC0, 0x00, 0x67, 0xE0, 0x00, 0x37, 0x30, 0x00, 0x3F,
  0x1C, 0x00, 0x1F, 0x06, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x03,
  0x00, 0x70, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x00,
  0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xE0,
  0x7C, 0x01, 0xB0, 0x76, 0x01, 0xF8, 0x3B, 0x00, 0xDC, 0x19, 0x80, 0xCC,
  0x0C, 0x60, 0xE6, 0x06, 0x30, 0x63, 0x03, 0x18, 0x71, 0x83, 0x8C, 0x31,
  0xC1, 0xC3, 0x30, 0xE0, 0xC1, 0x98, 0x60, 0x60, 0xD8, 0x30, 0x30, 0x7C,
  0x18, 0x18, 0x1C, 0x0C, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x07, 0x06, 0x02,
  0x03, 0x03, 0x01, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x07, 0x00, 0x03, 0x80, 0x07, 0x80, 0x06,
  0x0F, 0x00, 0x0C, 0x3E, 0x00, 0x38, 0x7E, 0x00, 0x70, 0xFC, 0x00, 0xC1,
  0x98, 0x01, 0x83, 0x30, 0x03, 0x06, 0x70, 0x06, 0x1C, 0x60, 0x1C, 0x38,
  0xC0, 0x38, 0x71, 0x80, 0x60, 0xC3, 0x80, 0xC1, 0x83, 0x01, 0x83, 0x06,
  0x03, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x18, 0x30, 0x60, 0x30,
  0x60, 0xC0, 0x70, 0xC1, 0x80, 0x61, 0x87, 0x00, 0xC7, 0x0E, 0x01, 0xCE,
  0x1C, 0x03, 0x98, 0x30, 0x03, 0x30, 0x60, 0x06, 0x60, 0xC0, 0x0E, 0xC3,
  0x80, 0x0F, 0x87, 0x00, 0x1F, 0x0E, 0x00, 0x3C, 0x18, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x78, 0x0E, 0x00, 0xE0, 0xE0,
  0x03, 0x0E, 0x00, 0x1C, 0x60, 0x00, 0xE7, 0x00, 0x03, 0x38, 0x00, 0x19,
  0x80, 0x00, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x36, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xB0,
  0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x33, 0x00, 0x03,
  0x9C, 0x00, 0x18, 0xE0, 0x01, 0xC3, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x78,
  0x3C, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x18, 0x00, 0xF0, 0x30, 0x00, 0xE0, 0x60, 0x00, 0xE1, 0xC0, 0x01,
  0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x1C,
  0x30, 0x00, 0x30, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x06,
  0x00, 0x1C, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x78, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x0E,
  0x00, 0x1C, 0x60, 0x00, 0xE7, 0x00, 0x03, 0x38, 0x00, 0x19, 0x80, 0x00,
  0xDC, 0x00, 0x06, 0xE0, 0x00, 0x36, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xB0, 0x00, 0x1D,
  0x80, 0x00, 0xEC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x9C, 0x00,
  0x18, 0xE0, 0x01, 0xC3, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x78, 0x3C, 0x01,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x20, 0x03, 0x83, 0x80, 0x0E, 0x30, 0x00, 0x37, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x18, 0x00, 0xF0, 0x30,
  0x00, 0xE0, 0x60, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x30, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x06, 0x00, 0x3C, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x60, 0x03,
  0x00, 0xE0, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x38, 0x01, 0x80, 0x70,
  0x03, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x07, 0x03, 0x00, 0x0E, 0x06, 0x00,
  0x0C, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x04, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x38, 0xF0, 0x00, 0x70, 0x78,
  0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x71, 0xC0,
  0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x61, 0x80, 0x01,
  0x86, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x0E,
  0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x38,
  0xE0, 0x00, 0xE3, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x70, 0xE0,
  0x01, 0x81, 0x80, 0x0E, 0x07, 0x00, 0x70, 0x0E, 0x03, 0xC0, 0x3F, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x6E, 0x00, 0x03,
  0xB8, 0x00, 0x0C, 0x60, 0x00, 0x71, 0x80, 0x01, 0x86, 0x00, 0x0E, 0x1C,
  0x00, 0x30, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x38, 0x0C, 0x00,
  0xE0, 0x30, 0x07, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x60, 0x0E, 0x03, 0x80,
  0x38, 0x0C, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80, 0x06, 0x0E, 0x00, 0x18,
  0x30, 0x00, 0x61, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x38, 0x00, 0x0C, 0xC0,
  0x00, 0x37, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x30, 0x00, 0x03, 0x30, 0x00, 0x07, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x0C,
  0x70, 0x00, 0x0C, 0x70, 0x38, 0x0C, 0x60, 0x38, 0x1C, 0x60, 0x78, 0x18,
  0x60, 0x78, 0x18, 0x60, 0xF8, 0x18, 0x60, 0xD8, 0x38, 0x60, 0xCC, 0x30,
  0x61, 0x8C, 0x30, 0x61, 0x8C, 0x30, 0x63, 0x8C, 0x70, 0xE3, 0x0C, 0x60,
  0xE7, 0x0C, 0x60, 0xE6, 0x0C, 0x60, 0xC6, 0x0C, 0xE0, 0xCC, 0x0C, 0xC0,
  0xCC, 0x0C, 0xC0, 0xDC, 0x0C, 0xC0, 0xD8, 0x0D, 0xC0, 0xD8, 0x0F, 0x80,
  0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x60, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x06,
  0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0x30, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x1C, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x06, 0x07, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x98, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x80, 0x18, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xE6, 0x00, 0x0E, 0x30, 0x00, 0x61, 0xC0, 0x07, 0x06, 0x00, 0x70, 0x38,
  0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x80, 0x38, 0x38, 0x00, 0xC1, 0x80,
  0x07, 0x18, 0x00, 0x19, 0xC0, 0x00, 0xDC, 0x00, 0x03, 0x40, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x47, 0x18, 0xE3, 0x18, 0x63, 0x01,
  0xF8, 0x70, 0x7F, 0xE7, 0x0F, 0x07, 0x61, 0xC0, 0x16, 0x38, 0x00, 0xE3,
  0x00, 0x0E, 0x70, 0x00, 0xE6, 0x00, 0x0E, 0xE0, 0x00, 0xCE, 0x00, 0x0C,
  0xE0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x01,
  0x8C, 0x00, 0x38, 0xC0, 0x03, 0x8E, 0x00, 0x78, 0x60, 0x0B, 0x87, 0x83,
  0x38, 0x3F, 0xE3, 0xF0, 0xFC, 0x1F, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x3F, 0x01, 0xCF, 0xFC,
  0x19, 0xC1, 0xE1, 0xB0, 0x0E, 0x1A, 0x00, 0x73, 0xC0, 0x07, 0x38, 0x00,
  0x33, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x77, 0x00, 0x06, 0x60, 0x00, 0xE6, 0x00, 0x0E, 0x60,
  0x00, 0xCF, 0x00, 0x1C, 0xF0, 0x03, 0x8E, 0xC0, 0xF0, 0xC7, 0xFE, 0x0C,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1C, 0x0F, 0x07, 0x00, 0x61,
  0x80, 0x0E, 0x70, 0x00, 0x8C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x23, 0x00, 0x06, 0x60, 0x01, 0xCE, 0x00, 0x70, 0xC0, 0x1C, 0x1E,
  0x0F, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x1F,
  0x83, 0x01, 0xFF, 0x9C, 0x0F, 0x03, 0x70, 0x70, 0x07, 0x83, 0x80, 0x0E,
  0x0C, 0x00, 0x38, 0x70, 0x00, 0x61, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38,
  0x00, 0x30, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x70, 0xC0, 0x01, 0xC3, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x38, 0x01, 0x60,
  0x70, 0x0D, 0x81, 0xE0, 0xEE, 0x03, 0xFF, 0x38, 0x03, 0xF0, 0xC0, 0x00,
  0x7F, 0x00, 0x7F, 0xF8, 0x1E, 0x07, 0x87, 0x00, 0x71, 0x80, 0x06, 0x70,
  0x00, 0xCC, 0x00, 0x1B, 0x80, 0x07, 0x60, 0x03, 0xCC, 0x07, 0xF3, 0xFF,
  0xF0, 0x7F, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x06, 0x60, 0x00, 0xEE, 0x00, 0x30, 0xE0, 0x0E, 0x1E, 0x07, 0x81, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x02, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x0F,
  0x01, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x18, 0x1F, 0xF9, 0xC1, 0xE0, 0x6E,
  0x1C, 0x01, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x00, 0xC6, 0x00,
  0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x16, 0x0E, 0x01, 0xB0, 0x78, 0x3B, 0x81, 0xFF, 0x9C, 0x03,
  0xF0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC1, 0x80, 0x1C, 0x0F, 0x03, 0xC0, 0x3F, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0xFC, 0x0E, 0x3F, 0xC1, 0xCC, 0x1C, 0x3A, 0x01, 0xC6,
  0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C,
  0x00, 0x73, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x80, 0x0E, 0x70,
  0x01, 0xCE, 0x00, 0x39, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x19, 0xC0,
  0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x30, 0x18, 0x0F, 0x07, 0x03, 0x80, 0xE1, 0xC0, 0x18, 0x70, 0x03, 0x1C,
  0x00, 0x6E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x60, 0x1C, 0x0F, 0x01, 0x80, 0x38, 0x18, 0x01,
  0xC1, 0x80, 0x0E, 0x38, 0x00, 0x73, 0x80, 0x03, 0xB0, 0x00, 0x1F, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC3, 0xF0, 0x07, 0x3F, 0xF0,
  0x1D, 0xC1, 0xC0, 0x6C, 0x03, 0x81, 0xA0, 0x06, 0x07, 0x00, 0x18, 0x3C,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x0C, 0x00, 0xE0, 0x30, 0x0E,
  0x00, 0xC1, 0xF0, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xC0, 0x11,
  0x83, 0x80, 0x66, 0x07, 0x03, 0xD8, 0x0C, 0x1C, 0xE0, 0x38, 0xE3, 0x80,
  0x6E, 0x0E, 0x01, 0xF0, 0x30, 0x03, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x04, 0x18, 0x07, 0x0C, 0x07,
  0x06, 0x07, 0x07, 0x07, 0x03, 0x8E, 0x01, 0x8E, 0x00, 0xCE, 0x00, 0x7C,
  0x00, 0x1C, 0x00, 0x0C, 0xF0, 0x7C, 0x3B, 0xF1, 0xFC, 0x7C, 0x76, 0x38,
  0xD0, 0x68, 0x31, 0xC0, 0xE0, 0x63, 0x01, 0xC0, 0xC6, 0x03, 0x01, 0x9C,
  0x06, 0x03, 0x38, 0x1C, 0x06, 0x60, 0x38, 0x1C, 0xC0, 0x60, 0x31, 0x80,
  0xC0, 0x63, 0x01, 0x80, 0xCE, 0x03, 0x01, 0x9C, 0x0E, 0x03, 0x30, 0x1C,
  0x0E, 0x60, 0x30, 0x18, 0xC0, 0x60, 0x31, 0x80, 0xC0, 0x67, 0x01, 0x80,
  0xCE, 0x07, 0x03, 0x98, 0x0C, 0x07, 0x00, 0x0C, 0x3F, 0x03, 0x8F, 0xF0,
  0x73, 0x07, 0x0E, 0x80, 0x71, 0xA0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39,
  0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xC0, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x0C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x60, 0x01, 0x8C,
  0x00, 0x31, 0x80, 0x06, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0x03, 0xC1, 0xC0, 0x0C, 0x18, 0x00,
  0xE3, 0x80, 0x06, 0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6C, 0x00, 0x0E, 0xC0,
  0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xC6, 0x00, 0x38, 0x70, 0x07, 0x03,
  0xC0, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0x0F, 0xC0, 0x1C, 0xFF,
  0xC0, 0x67, 0x07, 0x81, 0xB0, 0x0E, 0x06, 0x80, 0x1C, 0x1C, 0x00, 0x70,
  0xE0, 0x00, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0,
  0x01, 0xC3, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x61, 0x80, 0x03,
  0x86, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x70, 0x01, 0xC3, 0xC0, 0x0E, 0x0E,
  0xC0, 0xF0, 0x31, 0xFF, 0x80, 0xC1, 0xF8, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x30,
  0x7F, 0xE7, 0x0F, 0x03, 0x71, 0xC0, 0x1E, 0x38, 0x00, 0xE3, 0x00, 0x0E,
  0x70, 0x00, 0x66, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00,
  0x3C, 0xC0, 0x03, 0x8E, 0x00, 0x58, 0x70, 0x0F, 0x87, 0x83, 0xB8, 0x3F,
  0xF3, 0x80, 0xFC, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0x80, 0x6E, 0x00, 0x07,
  0x40, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x01, 0xE0, 0x3C, 0x1C, 0x00, 0x70,
  0xC0, 0x02, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x07,
  0x3C, 0x00, 0x30, 0x78, 0x07, 0x81, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x04, 0x07, 0x00, 0xE0, 0x70, 0x1C, 0x07,
  0x07, 0x80, 0x60, 0xE0, 0x06, 0x3C, 0x00, 0x6F, 0x00, 0x07, 0xE0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xC0, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x0C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x60, 0x01, 0x8C,
  0x00, 0x31, 0x80, 0x06, 0x70, 0x01, 0xCE, 0x00, 0x39, 0x80, 0x07, 0x30,
  0x00, 0xC6, 0x00, 0x38, 0xC0, 0x0F, 0x1C, 0x01, 0xE3, 0x80, 0x5C, 0x38,
  0x33, 0x87, 0xFC, 0x60, 0x3F, 0x0C, 0x00, 0xFF, 0x00, 0x6F, 0xF0, 0x06,
  0x06, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0E, 0x00,
  0x30, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xC0,
  0x0E, 0x0C, 0x00, 0xE1, 0xC0, 0x0C, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x18,
  0x07, 0x01, 0x80, 0xE0, 0x18, 0x3C, 0x01, 0x8F, 0x80, 0x1F, 0xE0, 0x01,
  0xF8, 0x00, 0x18, 0x0C, 0x18, 0x60, 0x30, 0x71, 0x80, 0xC0, 0xC6, 0x03,
  0x03, 0x38, 0x1C, 0x0C, 0xC0, 0x60, 0x33, 0x01, 0x80, 0xCC, 0x06, 0x03,
  0x30, 0x18, 0x0C, 0xC0, 0xE0, 0x37, 0x03, 0x80, 0xD8, 0x0C, 0x03, 0x60,
  0x30, 0x0D, 0x80, 0xC0, 0x76, 0x03, 0x01, 0x98, 0x1C, 0x06, 0xE0, 0x70,
  0x3B, 0x82, 0xC0, 0xCE, 0x0B, 0x07, 0x18, 0x4C, 0x38, 0x7F, 0x3F, 0xC0,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0xF0, 0xFE, 0x0F, 0x31, 0xC7,
  0x3C, 0x33, 0x03, 0x70, 0x3B, 0x03, 0x20, 0x1A, 0x03, 0x00, 0x1C, 0x03,
  0x00, 0x1C, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x38, 0x00,
  0xC0, 0x78, 0x00, 0xC0, 0x58, 0x04, 0xC0, 0xDC, 0x1E, 0xC0, 0x8C, 0x78,
  0xE3, 0x8C, 0xF0, 0x7F, 0x0F, 0xC0, 0x3C, 0x07, 0x00, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0xC0, 0x03, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1,
  0x80, 0x06, 0x06, 0x00, 0x38, 0x18, 0x01, 0x60, 0x70, 0x07, 0x81, 0xC0,
  0x2E, 0x03, 0x83, 0x38, 0x07, 0xF8, 0xC0, 0x0F, 0xC3, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x18,
  0x01, 0xC0, 0xF8, 0x1E, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x1C, 0x3F, 0xFC, 0x71, 0xC0, 0xFD, 0x86, 0x00, 0x7E, 0x18, 0x00,
  0x70, 0x60, 0x03, 0x81, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x01, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x18, 0x1C, 0x00, 0x60, 0xE0, 0x01,
  0xC7, 0xFC, 0x07, 0x1B, 0xFF, 0x8C, 0xE0, 0xFF, 0xF3, 0x80, 0x3F, 0x80,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x00, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0x80, 0x0C, 0x3F, 0x00, 0x31, 0xCE, 0x00, 0xCE, 0x1C, 0x06, 0x30,
  0x30, 0x19, 0x80, 0x60, 0xC6, 0x01, 0xC7, 0x30, 0x03, 0xF8, 0xC0, 0x07,
  0x80,
};

const GFXglyph IBMPlexMono_LightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 30, 26, 9, -30 },
  { 31, 11, 11, 26, 10, -32 },
  { 47, 25, 30, 26, 1, -30 },
  { 141, 24, 38, 26, 1, -34 },
  { 255, 29, 30, 26, -1, -30 },
  { 364, 25, 30, 26, 0, -30 },
  { 458, 5, 11, 26, 13, -32 },
  { 465, 15, 39, 26, 9, -33 },
  { 539, 15, 39, 26, 2, -33 },
  { 613, 21, 21, 26, 3, -24 },
  { 669, 21, 20, 26, 3, -23 },
  { 722, 8, 12, 26, 6, -5 },
  { 734, 12, 2, 26, 7, -14 },
  { 737, 5, 5, 26, 9, -5 },
  { 741, 24, 39, 26, 1, -33 },
  { 858, 21, 30, 26, 3, -30 },
  { 937, 20, 30, 26, 2, -30 },
  { 1012, 22, 30, 26, 1, -30 },
  { 1095, 22, 30, 26, 1, -30 },
  { 1178, 23, 30, 26, 1, -30 },
  { 1265, 22, 30, 26, 2, -30 },
  { 1348, 20, 30, 26, 3, -30 },
  { 1423, 21, 30, 26, 5, -30 },
  { 1502, 22, 30, 26, 2, -30 },
  { 1585, 20, 30, 26, 4, -30 },
  { 1660, 8, 23, 26, 9, -23 },
  { 1683, 11, 30, 26, 6, -23 },
  { 1725, 20, 24, 26, 4, -25 },
  { 1785, 22, 10, 26, 2, -18 },
  { 1813, 21, 24, 26, 2, -25 },
  { 1876, 18, 30, 26, 6, -30 },
  { 1944, 21, 35, 26, 3, -30 },
  { 2036, 22, 30, 26, 0, -30 },
  { 2119, 22, 30, 26, 2, -30 },
  { 2202, 21, 30, 26, 4, -30 },
  { 2281, 21, 30, 26, 3, -30 },
  { 2360, 23, 30, 26, 2, -30 },
  { 2447, 24, 30, 26, 2, -30 },
  { 2537, 21, 30, 26, 3, -30 },
  { 2616, 23, 30, 26, 2, -30 },
  { 2703, 23, 30, 26, 2, -30 },
  { 2790, 20, 30, 26, 3, -30 },
  { 2865, 25, 30, 26, 2, -30 },
  { 2959, 17, 30, 26, 4, -30 },
  { 3023, 25, 30, 26, 1, -30 },
  { 3117, 23, 30, 26, 2, -30 },
  { 3204, 21, 30, 26, 3, -30 },
  { 3283, 23, 30, 26, 2, -30 },
  { 3370, 21, 38, 26, 3, -30 },
  { 3470, 23, 30, 26, 2, -30 },
  { 3557, 24, 30, 26, 1, -30 },
  { 3647, 24, 30, 26, 4, -30 },
  { 3737, 22, 30, 26, 3, -30 },
  { 3820, 22, 30, 26, 5, -30 },
  { 3903, 24, 30, 26, 3, -30 },
  { 3993, 27, 30, 26, 0, -30 },
  { 4095, 24, 30, 26, 4, -30 },
  { 4185, 26, 30, 26, 0, -30 },
  { 4283, 17, 39, 26, 8, -33 },
  { 4366, 11, 39, 26, 8, -33 },
  { 4420, 17, 39, 26, 1, -33 },
  { 4503, 21, 17, 26, 3, -30 },
  { 4548, 21, 2, 26, 0, 5 },
  { 4554, 5, 8, 26, 10, -33 },
  { 4559, 20, 22, 26, 3, -22 },
  { 4614, 20, 32, 26, 3, -32 },
  { 4694, 19, 22, 26, 3, -22 },
  { 4747, 22, 32, 26, 3, -32 },
  { 4835, 19, 22, 26, 3, -22 },
  { 4888, 28, 41, 26, -1, -32 },
  { 5032, 21, 31, 26, 2, -22 },
  { 5114, 19, 32, 26, 3, -32 },
  { 5190, 19, 31, 26, 4, -31 },
  { 5264, 20, 41, 26, 3, -32 },
  { 5367, 22, 32, 26, 3, -32 },
  { 5455, 17, 32, 26, 5, -32 },
  { 5523, 23, 22, 26, 1, -22 },
  { 5587, 19, 22, 26, 3, -22 },
  { 5640, 20, 22, 26, 3, -22 },
  { 5695, 22, 31, 26, 1, -22 },
  { 5781, 20, 31, 26, 3, -22 },
  { 5859, 21, 22, 26, 5, -22 },
  { 5917, 21, 22, 26, 2, -22 },
  { 5975, 20, 30, 26, 3, -30 },
  { 6050, 19, 22, 26, 4, -22 },
  { 6103, 20, 22, 26, 3, -22 },
  { 6158, 22, 22, 26, 2, -22 },
  { 6219, 24, 22, 26, 1, -22 },
  { 6285, 22, 31, 26, 1, -22 },
  { 6371, 22, 22, 26, 2, -22 },
  { 6432, 20, 39, 26, 5, -33 },
  { 6530, 9, 39, 26, 9, -33 },
  { 6574, 20, 39, 26, 2, -33 },
  { 6672, 22, 9, 26, 2, -17 },
};

const GFXfont IBMPlexMono_LightItalic43pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic43pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic43pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _IBMPLEXMONO_LIGHTITALIC43PT7B_H_
