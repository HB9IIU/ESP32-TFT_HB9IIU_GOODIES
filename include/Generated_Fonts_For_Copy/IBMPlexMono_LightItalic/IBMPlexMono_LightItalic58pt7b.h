#ifndef _IBMPLEXMONO_LIGHTITALIC58PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x03, 0xC0, 0x1C, 0x0E, 0x38, 0x1C,
  0x70, 0x39, 0xE0, 0xF3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38,
  0x1C, 0xF0, 0x79, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x3C, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x1F, 0xFE,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0xFF, 0xF0,
  0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xF8, 0x63, 0xF0, 0x07,
  0xC0, 0xC1, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x78, 0x07, 0x00, 0xE0, 0xF0,
  0x0E, 0x01, 0x81, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0F, 0x00,
  0x60, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x01, 0xF0, 0x30,
  0x00, 0x01, 0xF8, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1B, 0xFC,
  0x00, 0x00, 0x70, 0xF8, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x03, 0x00, 0xF0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x01, 0x80, 0x3C, 0x10, 0x03, 0x00, 0x78, 0xE0, 0x06, 0x00, 0xE1, 0xE0,
  0x1C, 0x03, 0xC1, 0xE0, 0x38, 0x0F, 0x01, 0xF0, 0x70, 0x7C, 0x01, 0xF8,
  0xC3, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3C,
  0x01, 0xFF, 0xE0, 0x00, 0x70, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0x1E, 0x03,
  0xC0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x70,
  0x00, 0x70, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x01, 0xC0,
  0x0E, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x38, 0x00, 0x03, 0xC1, 0xE0, 0x70,
  0x00, 0x03, 0xFF, 0xC1, 0xC0, 0x00, 0x03, 0xFE, 0x04, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0E, 0x0F, 0xFF, 0x00, 0x00, 0x38, 0x3E, 0x0F, 0x00, 0x00, 0xE0, 0x70,
  0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x0E, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x0F, 0x80,
  0x38, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xF8, 0x7C, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xE1, 0xFC, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x02, 0xF0, 0x00, 0x3E, 0x01, 0xFC,
  0x00, 0x0B, 0x80, 0xF7, 0x00, 0x02, 0xF0, 0x39, 0xC0, 0x01, 0x9C, 0x1C,
  0x78, 0x00, 0xC7, 0x8F, 0x0F, 0x00, 0x70, 0xE3, 0x83, 0xE0, 0x78, 0x3D,
  0xE0, 0x7F, 0xFC, 0x07, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3C, 0x00, 0x3C, 0xE3, 0x8E, 0x38, 0xE7, 0x9C, 0x71, 0xC7, 0x1C, 0xF3,
  0x8E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x01, 0x00, 0x0E, 0x00, 0x27,
  0x80, 0x38, 0x03, 0xDF, 0xC0, 0xE0, 0xFF, 0xBF, 0xE3, 0x9F, 0xF0, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x07, 0x00,
  0x01, 0xE0, 0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C,
  0xFF, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1C, 0xE0, 0x0F, 0x00, 0xEF, 0x00, 0xF8,
  0x07, 0x78, 0x0F, 0xC0, 0x7B, 0xC0, 0x7E, 0x03, 0xDE, 0x01, 0xE0, 0x1E,
  0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x1E,
  0x00, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xDC, 0x00, 0x01, 0xF3, 0x80, 0x00,
  0xFC, 0x70, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0x70,
  0x01, 0xF8, 0x0E, 0x00, 0x7E, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC1, 0x00, 0x00, 0x1E, 0x18, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x0F,
  0x80, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x78,
  0x03, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01,
  0xC0, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x07, 0xF0, 0x00, 0x1C, 0xFF, 0xF8, 0x00, 0xE7,
  0xFF, 0xF0, 0x03, 0xB8, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x3C, 0x00,
  0x0F, 0x01, 0x60, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x7F, 0x80, 0x1E, 0x3F, 0xFC, 0x03, 0x9F,
  0xFF, 0xC0, 0xF7, 0x80, 0xFC, 0x1D, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0x78,
  0xF8, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0E, 0xF0, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x70, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x01,
  0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x03,
  0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0xFC,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x39, 0xE0, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x1D, 0xC3, 0xF0,
  0x1E, 0x70, 0x7F, 0xFF, 0x38, 0x0F, 0xFF, 0x9E, 0x00, 0xFF, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x81, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0x80, 0xFC,
  0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0xF8,
  0x71, 0xC0, 0x3F, 0xE7, 0x1C, 0x07, 0xFE, 0x73, 0x80, 0xF8, 0x36, 0x38,
  0x1E, 0x01, 0xE3, 0x81, 0xC0, 0x0E, 0x38, 0x3C, 0x00, 0xE7, 0x83, 0x80,
  0x0E, 0x70, 0x38, 0x00, 0xE7, 0x03, 0x80, 0x0C, 0x70, 0x70, 0x01, 0xC7,
  0x07, 0x00, 0x1C, 0x70, 0x70, 0x01, 0xCF, 0x07, 0x00, 0x1C, 0xE0, 0x70,
  0x01, 0xCE, 0x07, 0x00, 0x38, 0xE0, 0x70, 0x03, 0x8E, 0x07, 0x00, 0x78,
  0xE0, 0x70, 0x07, 0x8E, 0x07, 0x00, 0xB8, 0xE0, 0x78, 0x1B, 0x8E, 0x03,
  0xFF, 0x78, 0xE0, 0x1F, 0xE7, 0x0E, 0x00, 0xFC, 0x70, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00,
  0x70, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x38, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x7C, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x0E, 0x00,
  0x07, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x1F, 0x07, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x03,
  0xC0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x04, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x30, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0x80, 0x1F,
  0x80, 0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x07, 0x00, 0x0F, 0xC0,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x02, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x0F,
  0xFF, 0x8E, 0x00, 0x7F, 0xFC, 0xF0, 0x03, 0xFF, 0xC7, 0x80, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F,
  0x03, 0xC0, 0x01, 0x70, 0x1F, 0x00, 0x3B, 0x80, 0x7E, 0x07, 0x9C, 0x01,
  0xFF, 0xF8, 0xE0, 0x07, 0xFF, 0x87, 0x00, 0x0F, 0xF0, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x70, 0x03, 0xE0, 0x00, 0x1C, 0x01, 0xF0, 0x00,
  0x07, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x03, 0x87, 0xC0,
  0x00, 0x00, 0xE3, 0xF8, 0x00, 0x00, 0x79, 0xEE, 0x00, 0x00, 0x1E, 0xF3,
  0xC0, 0x00, 0x07, 0xF8, 0x70, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x00, 0x7E,
  0x03, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xB8,
  0x1E, 0xE0, 0x03, 0xFC, 0x0E, 0x70, 0x01, 0xDC, 0x07, 0x38, 0x01, 0xCE,
  0x03, 0x9C, 0x00, 0xE7, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE3, 0x80, 0xF1,
  0xC0, 0xF1, 0xC0, 0x71, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38, 0x38, 0x38,
  0x70, 0x1C, 0x1C, 0x38, 0x38, 0x0E, 0x0E, 0x3C, 0x1C, 0x07, 0x07, 0x1C,
  0x0E, 0x07, 0x81, 0xDC, 0x0F, 0x03, 0x80, 0xEE, 0x07, 0x01, 0xC0, 0x7E,
  0x03, 0x80, 0xE0, 0x1F, 0x01, 0xC0, 0x70, 0x0F, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0x70, 0x3C, 0x03, 0x80, 0x78, 0x1C, 0x00, 0x80, 0x38, 0x0E, 0x00,
  0x40, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x00, 0x0E,
  0x07, 0xE0, 0x00, 0x3C, 0x0F, 0xC0, 0x00, 0x78, 0x1F, 0x80, 0x00, 0xE0,
  0x3F, 0x80, 0x01, 0xC0, 0xF7, 0x00, 0x03, 0x81, 0xCE, 0x00, 0x07, 0x03,
  0x9C, 0x00, 0x1E, 0x07, 0x3C, 0x00, 0x3C, 0x0E, 0x38, 0x00, 0x70, 0x1C,
  0x70, 0x00, 0xE0, 0x78, 0xE0, 0x01, 0xC0, 0xE0, 0xE0, 0x03, 0x81, 0xC1,
  0xC0, 0x0F, 0x03, 0x83, 0x80, 0x1E, 0x07, 0x07, 0x80, 0x38, 0x0E, 0x07,
  0x00, 0x70, 0x3C, 0x0E, 0x00, 0xE0, 0x70, 0x1C, 0x01, 0xC0, 0xE0, 0x1C,
  0x07, 0x81, 0xC0, 0x38, 0x0F, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xF0,
  0x38, 0x1E, 0x00, 0xE0, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x70, 0x03, 0x83,
  0xC0, 0xE0, 0x07, 0x87, 0x01, 0xC0, 0x07, 0x0E, 0x03, 0x80, 0x0E, 0x1C,
  0x0F, 0x00, 0x1E, 0x38, 0x1C, 0x00, 0x1C, 0x70, 0x38, 0x00, 0x39, 0xE0,
  0x70, 0x00, 0x73, 0x80, 0xE0, 0x00, 0xF7, 0x01, 0xC0, 0x00, 0xEE, 0x07,
  0x80, 0x01, 0xDC, 0x0E, 0x00, 0x03, 0xF8, 0x1C, 0x00, 0x03, 0xF0, 0x38,
  0x00, 0x07, 0xC0, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x38, 0x1C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x07, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0xC0,
  0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x01, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x78, 0x03,
  0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x40, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xF0,
  0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x07,
  0x80, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x70,
  0x07, 0x00, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x80, 0x03, 0x80, 0x38, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0xF0, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x7C, 0x03, 0xC1, 0xC0, 0x3E, 0x01,
  0xC0, 0xE0, 0x1F, 0x00, 0xE0, 0x70, 0x1F, 0x80, 0x70, 0x70, 0x0F, 0xC0,
  0x70, 0x38, 0x0E, 0xE0, 0x38, 0x1C, 0x07, 0x70, 0x1C, 0x0E, 0x07, 0x18,
  0x0E, 0x07, 0x03, 0x8C, 0x0E, 0x03, 0x81, 0xC6, 0x07, 0x01, 0xC1, 0xC3,
  0x83, 0x80, 0xE0, 0xE1, 0xC1, 0xC0, 0x70, 0xE0, 0xE1, 0xC0, 0x38, 0x70,
  0x70, 0xE0, 0x1C, 0x38, 0x38, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x0E, 0x1C,
  0x0E, 0x38, 0x07, 0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x8E, 0x01, 0xC7,
  0x01, 0xC7, 0x00, 0xE7, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x33, 0x80, 0x3B,
  0x80, 0x19, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x0E, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0x00, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0x80,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x3C, 0x01, 0xC0,
  0x03, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xC0, 0x1E,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x38, 0x80, 0x00, 0x00, 0xA0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x23, 0x8E, 0x3C, 0x70, 0xE3,
  0x86, 0x1C, 0x30, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x3C, 0x0F,
  0xFF, 0xC7, 0x83, 0xF0, 0x1C, 0xE0, 0xF8, 0x00, 0xDC, 0x1E, 0x00, 0x0B,
  0x87, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x87, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x2E, 0x1E, 0x00, 0x0F, 0xC1, 0xC0, 0x03, 0x78, 0x3C,
  0x00, 0xEE, 0x03, 0xE0, 0x79, 0xFE, 0x7F, 0xFE, 0x3F, 0x83, 0xFF, 0x83,
  0xF0, 0x1F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x3F, 0x80,
  0x0E, 0x1F, 0xFC, 0x03, 0xC7, 0xFF, 0xC0, 0x79, 0xE0, 0x7C, 0x0E, 0x70,
  0x07, 0xC1, 0xD8, 0x00, 0x78, 0x3A, 0x00, 0x07, 0x07, 0xC0, 0x00, 0xF1,
  0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x1E,
  0x3F, 0x00, 0x07, 0x87, 0xB0, 0x01, 0xE0, 0xE7, 0x80, 0xF8, 0x1C, 0x7F,
  0xFE, 0x03, 0x87, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFC, 0x07, 0xC0, 0xF8, 0x00,
  0xE0, 0x78, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x23, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x1E,
  0x03, 0xF0, 0x3E, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xF8, 0x0E,
  0x00, 0x7F, 0xF0, 0x70, 0x0F, 0xFF, 0xE3, 0x80, 0xFC, 0x07, 0xBC, 0x0F,
  0x80, 0x0D, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x0E,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x37, 0x01, 0xE0, 0x01, 0x38, 0x0F, 0x00,
  0x3B, 0xC0, 0x3E, 0x07, 0x9E, 0x00, 0xFF, 0xF8, 0xE0, 0x03, 0xFF, 0x87,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x07, 0xE0, 0x3E, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x9C,
  0x00, 0x1F, 0xC7, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x78,
  0x00, 0x07, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0xF0,
  0x1F, 0x80, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x00, 0x07, 0xC0, 0xE0, 0x00,
  0x00, 0x0F, 0x83, 0x80, 0x00, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xC1, 0xC0, 0x3F, 0xFF, 0x8E, 0x03, 0xF0,
  0x1C, 0xF0, 0x3E, 0x00, 0x37, 0x81, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1F, 0x07, 0x80,
  0x01, 0xF0, 0x3C, 0x00, 0x0B, 0x80, 0xF0, 0x00, 0xDC, 0x07, 0x80, 0x1C,
  0xE0, 0x1F, 0x03, 0xCF, 0x00, 0x7F, 0xFC, 0x78, 0x01, 0xFF, 0xC3, 0x80,
  0x03, 0xF8, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x10, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xE0, 0x1F, 0xC0, 0x7E, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x03, 0xF8, 0x01, 0xC3, 0xFF, 0x80, 0x71, 0xFF, 0xF0,
  0x1C, 0xF0, 0x7C, 0x0F, 0x70, 0x07, 0x83, 0xD8, 0x01, 0xE0, 0xEC, 0x00,
  0x38, 0x3A, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x02, 0x00,
  0xE0, 0x03, 0x80, 0x70, 0x07, 0xC0, 0x38, 0x07, 0xC0, 0x3C, 0x07, 0x80,
  0x1E, 0x0F, 0x80, 0x0E, 0x0F, 0x80, 0x07, 0x0F, 0x00, 0x03, 0x8F, 0x00,
  0x01, 0xDF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x10, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x1F, 0x80, 0x03, 0x87, 0xFF, 0x00, 0x1C, 0x7F, 0xFC, 0x01,
  0xE7, 0x81, 0xF0, 0x0F, 0x70, 0x07, 0x80, 0x77, 0x00, 0x1E, 0x03, 0xB0,
  0x00, 0xF0, 0x1F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x7E, 0x00, 0x1C, 0x1F, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x9E, 0x07, 0x80, 0x0E,
  0xE0, 0x1C, 0x00, 0xF7, 0x00, 0xF0, 0x1F, 0x38, 0x03, 0x81, 0xF1, 0xC0,
  0x1E, 0x1E, 0x1E, 0x00, 0x71, 0xE0, 0xF0, 0x03, 0xDE, 0x07, 0x00, 0x0F,
  0xE0, 0x38, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x06, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0xFC, 0x1C,
  0x03, 0xE0, 0x78, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xC1, 0xF0, 0x03, 0x87,
  0x80, 0x07, 0x1E, 0x00, 0x0E, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x07, 0x1F, 0xC3, 0xFC,
  0x07, 0x3F, 0xE3, 0xFE, 0x07, 0x61, 0xE7, 0x1F, 0x07, 0xC0, 0xEC, 0x0F,
  0x07, 0x80, 0xE8, 0x07, 0x0F, 0x00, 0x78, 0x07, 0x0F, 0x00, 0xF0, 0x07,
  0x0E, 0x00, 0xF0, 0x07, 0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x0E,
  0x0E, 0x00, 0xE0, 0x0E, 0x1C, 0x00, 0xE0, 0x0E, 0x1C, 0x00, 0xE0, 0x0E,
  0x1C, 0x01, 0xC0, 0x0E, 0x1C, 0x01, 0xC0, 0x1E, 0x1C, 0x01, 0xC0, 0x1C,
  0x1C, 0x01, 0xC0, 0x1C, 0x38, 0x01, 0xC0, 0x1C, 0x38, 0x01, 0xC0, 0x1C,
  0x38, 0x03, 0x80, 0x1C, 0x38, 0x03, 0x80, 0x3C, 0x38, 0x03, 0x80, 0x38,
  0x38, 0x03, 0x80, 0x38, 0x78, 0x03, 0x80, 0x38, 0x70, 0x03, 0x80, 0x38,
  0x70, 0x07, 0x00, 0x38, 0x70, 0x07, 0x00, 0x78, 0x70, 0x07, 0x00, 0x70,
  0x70, 0x07, 0x00, 0x70, 0xF0, 0x07, 0x00, 0x70, 0x00, 0x03, 0xF8, 0x01,
  0xC3, 0xFF, 0x80, 0x71, 0xFF, 0xF0, 0x1C, 0xF0, 0x7C, 0x0F, 0x70, 0x07,
  0x83, 0xD8, 0x01, 0xE0, 0xEC, 0x00, 0x38, 0x3A, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x01,
  0xF0, 0x1F, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x0E, 0x1F, 0xFC, 0x00, 0xF1, 0xFF, 0xF0,
  0x07, 0x9E, 0x07, 0xC0, 0x39, 0xC0, 0x1F, 0x01, 0xD8, 0x00, 0x78, 0x0E,
  0x80, 0x01, 0xC0, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x38, 0x3C, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x0F,
  0xC0, 0x01, 0xE0, 0x7B, 0x00, 0x1E, 0x03, 0x9E, 0x03, 0xE0, 0x1C, 0x7F,
  0xFE, 0x00, 0xE1, 0xFF, 0xE0, 0x07, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x1C, 0x0F, 0xFF, 0xE3, 0x83,
  0xF0, 0x1E, 0xF0, 0xF8, 0x00, 0xDE, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0xF1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x0F, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x3E, 0x1E, 0x00, 0x0D, 0xC1, 0xE0, 0x01, 0xB8, 0x3C, 0x00, 0xEF, 0x03,
  0xE0, 0x79, 0xE0, 0x3F, 0xFE, 0x38, 0x03, 0xFF, 0x87, 0x00, 0x1F, 0xC0,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0x80, 0x39, 0xE0, 0x00, 0x0F, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x3A, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0xFE, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x40, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x20, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0x3F,
  0x80, 0x7E, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x06, 0x00, 0xF0, 0x01, 0xE0, 0x1C, 0x00,
  0xF8, 0x03, 0x80, 0x3E, 0x00, 0x70, 0x1F, 0x00, 0x0E, 0x07, 0xC0, 0x03,
  0xC3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x0E, 0x7C, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0xF1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x78, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x01, 0x70, 0xF0, 0x00, 0xFC, 0x3C, 0x00, 0x6F, 0x07, 0x80, 0x33, 0x81,
  0xF8, 0x3C, 0xE0, 0x3F, 0xFE, 0x38, 0x07, 0xFE, 0x0E, 0x00, 0x7F, 0x04,
  0x00, 0x7F, 0xE0, 0x00, 0xDF, 0xF8, 0x00, 0x7B, 0xFF, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x00,
  0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x1C, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x07, 0xC0, 0x0E, 0x01,
  0xF0, 0x01, 0xC0, 0xFC, 0x00, 0x78, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x30, 0x38,
  0x03, 0x81, 0xE0, 0xE0, 0x0E, 0x03, 0x87, 0x00, 0x70, 0x0E, 0x1C, 0x01,
  0xC0, 0x38, 0x70, 0x07, 0x00, 0x71, 0xC0, 0x1C, 0x01, 0xC7, 0x00, 0x70,
  0x07, 0x1C, 0x01, 0xC0, 0x1C, 0xE0, 0x0E, 0x00, 0x73, 0x80, 0x38, 0x01,
  0xCE, 0x00, 0xE0, 0x07, 0x38, 0x03, 0x80, 0x1C, 0xE0, 0x0E, 0x00, 0x73,
  0x80, 0x38, 0x01, 0xDC, 0x01, 0xC0, 0x0E, 0x70, 0x07, 0x00, 0x39, 0xC0,
  0x1C, 0x00, 0xE7, 0x00, 0x70, 0x03, 0x9C, 0x01, 0xC0, 0x0E, 0x70, 0x07,
  0x00, 0x73, 0x80, 0x38, 0x01, 0xCE, 0x00, 0xE0, 0x0F, 0x38, 0x03, 0x80,
  0x38, 0xE0, 0x1E, 0x01, 0xE3, 0x80, 0x5C, 0x07, 0x0F, 0x03, 0x70, 0x3C,
  0x3E, 0x39, 0xE1, 0xE0, 0x7F, 0xC3, 0xFF, 0x00, 0xFE, 0x0F, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x7C, 0xF0, 0xF1, 0xE0, 0xFC, 0x38, 0xE0,
  0x78, 0xF8, 0x1C, 0x60, 0x1C, 0xF0, 0x0E, 0x60, 0x0E, 0x60, 0x03, 0x30,
  0x07, 0x00, 0x01, 0x90, 0x03, 0x80, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x03, 0x80,
  0x1F, 0x00, 0x01, 0xC0, 0x0B, 0x80, 0x08, 0xE0, 0x0C, 0xC0, 0x0E, 0x70,
  0x06, 0x70, 0x1F, 0x38, 0x06, 0x38, 0x1E, 0x1E, 0x07, 0x1C, 0x3E, 0x0F,
  0x0F, 0x0F, 0x7E, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x2E, 0x03, 0xC0, 0x03, 0x70, 0x0E, 0x00, 0x37, 0x80, 0x78,
  0x03, 0xB8, 0x03, 0xF0, 0x79, 0xC0, 0x0F, 0xFF, 0x8E, 0x00, 0x3F, 0xF8,
  0x70, 0x00, 0x7F, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x06, 0x00, 0x07, 0x80, 0x78, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xC1, 0xFF, 0xFE, 0x0E,
  0x0F, 0x03, 0xFC, 0xF0, 0xE0, 0x03, 0xF7, 0x07, 0x00, 0x03, 0xF8, 0x70,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x78, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x02, 0x00, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x0E, 0x1F,
  0xFC, 0x00, 0x70, 0xEF, 0xFE, 0x03, 0x8F, 0x07, 0xFF, 0x8E, 0x70, 0x03,
  0xFF, 0xE3, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x18, 0x1F, 0xE0, 0x00,
  0x70, 0xFF, 0xC0, 0x03, 0x87, 0x87, 0x80, 0x0E, 0x1C, 0x0F, 0x00, 0x30,
  0xE0, 0x1C, 0x01, 0xC3, 0x80, 0x78, 0x0E, 0x1C, 0x00, 0xF0, 0x38, 0x70,
  0x01, 0xE3, 0xC3, 0x80, 0x03, 0xFE, 0x0E, 0x00, 0x0F, 0xF0, 0x18, 0x00,
  0x0F, 0x80,
};

const GFXglyph IBMPlexMono_LightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 11, 40, 35, 12, -40 },
  { 56, 15, 15, 35, 13, -43 },
  { 85, 35, 40, 35, 1, -40 },
  { 260, 31, 54, 35, 2, -47 },
  { 470, 39, 42, 35, -1, -41 },
  { 675, 34, 42, 35, 0, -41 },
  { 854, 6, 15, 35, 18, -43 },
  { 866, 20, 52, 35, 13, -44 },
  { 996, 20, 52, 35, 3, -44 },
  { 1126, 30, 29, 35, 3, -32 },
  { 1235, 28, 29, 35, 4, -32 },
  { 1337, 12, 16, 35, 8, -7 },
  { 1361, 16, 3, 35, 10, -19 },
  { 1367, 7, 6, 35, 12, -6 },
  { 1373, 32, 52, 35, 2, -44 },
  { 1581, 29, 42, 35, 4, -41 },
  { 1734, 27, 40, 35, 3, -40 },
  { 1869, 30, 41, 35, 2, -41 },
  { 2023, 29, 42, 35, 2, -41 },
  { 2176, 31, 40, 35, 1, -40 },
  { 2331, 30, 41, 35, 3, -40 },
  { 2485, 27, 41, 35, 4, -40 },
  { 2624, 29, 40, 35, 6, -40 },
  { 2769, 30, 42, 35, 3, -41 },
  { 2927, 26, 41, 35, 6, -41 },
  { 3061, 11, 31, 35, 12, -31 },
  { 3104, 15, 40, 35, 8, -31 },
  { 3179, 28, 32, 35, 5, -34 },
  { 3291, 30, 14, 35, 3, -25 },
  { 3344, 28, 32, 35, 3, -34 },
  { 3456, 24, 41, 35, 8, -41 },
  { 3579, 28, 47, 35, 4, -41 },
  { 3744, 30, 40, 35, 0, -40 },
  { 3894, 29, 40, 35, 3, -40 },
  { 4039, 28, 42, 35, 5, -41 },
  { 4186, 29, 40, 35, 3, -40 },
  { 4331, 31, 40, 35, 3, -40 },
  { 4486, 32, 40, 35, 3, -40 },
  { 4646, 29, 42, 35, 4, -41 },
  { 4799, 31, 40, 35, 3, -40 },
  { 4954, 31, 40, 35, 3, -40 },
  { 5109, 28, 41, 35, 4, -40 },
  { 5253, 34, 40, 35, 3, -40 },
  { 5423, 24, 40, 35, 5, -40 },
  { 5543, 33, 40, 35, 2, -40 },
  { 5708, 31, 40, 35, 3, -40 },
  { 5863, 29, 42, 35, 4, -41 },
  { 6016, 31, 40, 35, 3, -40 },
  { 6171, 29, 51, 35, 4, -41 },
  { 6356, 31, 40, 35, 3, -40 },
  { 6511, 31, 42, 35, 2, -41 },
  { 6674, 31, 40, 35, 6, -40 },
  { 6829, 29, 41, 35, 5, -40 },
  { 6978, 29, 40, 35, 7, -40 },
  { 7123, 33, 40, 35, 3, -40 },
  { 7288, 37, 40, 35, 0, -40 },
  { 7473, 33, 40, 35, 5, -40 },
  { 7638, 35, 40, 35, 0, -40 },
  { 7813, 24, 52, 35, 10, -44 },
  { 7969, 14, 52, 35, 11, -44 },
  { 8060, 24, 52, 35, 1, -44 },
  { 8216, 29, 23, 35, 4, -40 },
  { 8300, 28, 3, 35, 0, 6 },
  { 8311, 6, 11, 35, 14, -45 },
  { 8320, 27, 32, 35, 4, -31 },
  { 8428, 27, 44, 35, 4, -43 },
  { 8577, 25, 32, 35, 5, -31 },
  { 8677, 29, 44, 35, 4, -43 },
  { 8837, 26, 32, 35, 4, -31 },
  { 8941, 38, 55, 35, -1, -43 },
  { 9203, 29, 43, 35, 2, -31 },
  { 9359, 26, 43, 35, 4, -43 },
  { 9499, 25, 44, 35, 5, -43 },
  { 9637, 25, 55, 35, 5, -43 },
  { 9809, 29, 44, 35, 4, -43 },
  { 9969, 23, 44, 35, 7, -43 },
  { 10096, 32, 31, 35, 1, -31 },
  { 10220, 26, 31, 35, 4, -31 },
  { 10321, 27, 32, 35, 4, -31 },
  { 10429, 29, 43, 35, 2, -31 },
  { 10585, 27, 43, 35, 4, -31 },
  { 10731, 27, 30, 35, 7, -30 },
  { 10833, 28, 32, 35, 3, -31 },
  { 10945, 27, 41, 35, 5, -40 },
  { 11084, 26, 31, 35, 5, -30 },
  { 11185, 27, 30, 35, 4, -30 },
  { 11287, 30, 31, 35, 3, -30 },
  { 11404, 33, 32, 35, 1, -31 },
  { 11536, 29, 42, 35, 2, -30 },
  { 11689, 29, 32, 35, 3, -31 },
  { 11805, 26, 52, 35, 7, -44 },
  { 11974, 12, 52, 35, 12, -44 },
  { 12052, 26, 52, 35, 3, -44 },
  { 12221, 30, 12, 35, 3, -24 },
};

const GFXfont IBMPlexMono_LightItalic58pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic58pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic58pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _IBMPLEXMONO_LIGHTITALIC58PT7B_H_
