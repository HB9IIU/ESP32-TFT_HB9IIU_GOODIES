#ifndef _IBMPLEXMONO_LIGHTITALIC25PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x21, 0x08, 0xC6, 0x21, 0x08, 0x00, 0x01, 0x9C, 0xE0,
  0x45, 0x1C, 0xF3, 0xCA, 0x28, 0x80, 0x00, 0x8C, 0x03, 0x10, 0x04, 0x20,
  0x08, 0xC0, 0x31, 0x00, 0x42, 0x0F, 0x8F, 0x83, 0x10, 0x04, 0x60, 0x08,
  0x83, 0xF1, 0xF0, 0x46, 0x01, 0x88, 0x03, 0x10, 0x04, 0x60, 0x18, 0x80,
  0x33, 0x00, 0x00, 0x80, 0x04, 0x00, 0x20, 0x0F, 0xC1, 0x9B, 0x98, 0x84,
  0x84, 0x04, 0x20, 0x21, 0x01, 0x88, 0x07, 0xC0, 0x0F, 0x80, 0x26, 0x01,
  0x18, 0x08, 0x40, 0x42, 0x84, 0x36, 0x21, 0x19, 0x38, 0x7F, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x00, 0x07, 0x80, 0x84, 0x60, 0x84, 0x10, 0xC2, 0x08,
  0xC1, 0x04, 0x40, 0x86, 0x40, 0x42, 0x60, 0x1E, 0x20, 0x00, 0x00, 0x01,
  0x1E, 0x01, 0x91, 0x81, 0x90, 0x40, 0x88, 0x20, 0x84, 0x10, 0xC2, 0x18,
  0x41, 0x18, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x08, 0x40, 0x20, 0xC0, 0x40,
  0x80, 0x81, 0x01, 0x06, 0x03, 0x08, 0x02, 0x30, 0x3F, 0x80, 0xC6, 0x01,
  0x04, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x28, 0xF0, 0x51, 0x31, 0x14, 0x3C,
  0x30, 0x5F, 0xA8, 0x01, 0x81, 0x01, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x03, 0x03, 0x03, 0x07, 0x00, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x04,
  0x31, 0xFD, 0x78, 0x3E, 0x00, 0xE0, 0x0D, 0x00, 0xC4, 0x0C, 0x30, 0xC0,
  0x80, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x33, 0x66, 0x4C, 0x80, 0xFE, 0x7F,
  0x80, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x00, 0x07, 0xC1, 0x86, 0x30, 0x36, 0x03, 0x40, 0x14,
  0x01, 0xC0, 0x1C, 0x63, 0x86, 0x38, 0x03, 0x80, 0x28, 0x02, 0x80, 0x68,
  0x04, 0xC0, 0xC6, 0x18, 0x3E, 0x00, 0x01, 0xC0, 0x68, 0x0C, 0x81, 0x88,
  0x21, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x07, 0xC0, 0xE1, 0x84,
  0x04, 0x60, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x00, 0xFF, 0xE0,
  0x07, 0xC0, 0xE1, 0x8C, 0x04, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x0C, 0x0F, 0x80, 0x06, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x13, 0x01,
  0x8C, 0x18, 0x3F, 0x00, 0x00, 0x30, 0x03, 0x80, 0x2C, 0x03, 0x40, 0x32,
  0x03, 0x10, 0x30, 0x83, 0x0C, 0x10, 0x61, 0x02, 0x10, 0x11, 0x80, 0x8F,
  0xFF, 0x80, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0F, 0xF8, 0x40, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0xF8, 0x28, 0x61, 0x81,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x13, 0x01, 0x8C, 0x18, 0x1F, 0x00,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02, 0x7C, 0xD0,
  0xDC, 0x0F, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xF0, 0x33, 0x0C, 0x3E, 0x00,
  0xFF, 0xFC, 0x03, 0x80, 0x68, 0x04, 0x80, 0xC0, 0x18, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x00, 0x07, 0xE0, 0x61, 0x86, 0x06, 0x60, 0x13, 0x00, 0x98, 0x0C,
  0xC0, 0x43, 0x04, 0x07, 0xC1, 0xC3, 0x18, 0x0C, 0x80, 0x2C, 0x01, 0x60,
  0x1B, 0x00, 0x8C, 0x1C, 0x1F, 0x80, 0x0F, 0x83, 0x06, 0x60, 0x24, 0x03,
  0x40, 0x3C, 0x03, 0xC0, 0x34, 0x06, 0x60, 0xA1, 0xF6, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x70, 0x00, 0x39, 0xCC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xCE, 0x70, 0x1C, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x31, 0x86, 0x10, 0xC2, 0x00, 0x00, 0x10, 0x07, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x80, 0xE0, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x04, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x20, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x08, 0x00, 0x1F,
  0x86, 0x19, 0x81, 0xE0, 0x30, 0x06, 0x00, 0x80, 0x30, 0x78, 0x18, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x30, 0x00, 0x07,
  0xC1, 0x86, 0x30, 0x22, 0x03, 0x60, 0x14, 0x3B, 0x44, 0x7C, 0xC2, 0xC8,
  0x28, 0x82, 0x88, 0x29, 0x86, 0x88, 0x68, 0x8C, 0x8F, 0x48, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0xF0, 0x00, 0xC0, 0x07, 0x00, 0x78, 0x02, 0xC0,
  0x32, 0x01, 0x10, 0x18, 0x80, 0x86, 0x0C, 0x30, 0x41, 0x86, 0x0C, 0x3F,
  0xE3, 0x01, 0x10, 0x09, 0x80, 0x68, 0x03, 0xC0, 0x18, 0x1F, 0xE0, 0x81,
  0x84, 0x04, 0x20, 0x33, 0x01, 0x98, 0x08, 0xC0, 0xC4, 0x04, 0x3F, 0xC1,
  0x03, 0x18, 0x0C, 0xC0, 0x26, 0x03, 0x20, 0x19, 0x00, 0x88, 0x0C, 0xFF,
  0x80, 0x07, 0xC0, 0x82, 0x10, 0x32, 0x01, 0x60, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x4C, 0x06, 0x40, 0xC6,
  0x18, 0x1F, 0x00, 0x1F, 0xC0, 0xC1, 0x84, 0x04, 0x20, 0x31, 0x01, 0x98,
  0x04, 0xC0, 0x66, 0x03, 0x20, 0x19, 0x00, 0xC8, 0x04, 0xC0, 0x26, 0x03,
  0x30, 0x11, 0x01, 0x88, 0x18, 0xFF, 0x00, 0x1F, 0xFC, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x3F, 0xF0, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x3F, 0xF0, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x07, 0xC1, 0x86, 0x30, 0x32,
  0x01, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x3E, 0x80, 0x28,
  0x06, 0x80, 0x6C, 0x06, 0xC0, 0xC6, 0x14, 0x3E, 0x40, 0x18, 0x0C, 0x40,
  0x21, 0x00, 0x8C, 0x02, 0x30, 0x18, 0xC0, 0x62, 0x01, 0x88, 0x04, 0x3F,
  0xF1, 0x80, 0x46, 0x03, 0x18, 0x0C, 0x40, 0x31, 0x00, 0x84, 0x02, 0x30,
  0x08, 0xC0, 0x60, 0x1F, 0xFC, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x88, 0x08, 0x81, 0x8C, 0x30, 0x7E, 0x00, 0x18,
  0x0E, 0x20, 0x30, 0x40, 0xC0, 0x83, 0x03, 0x0C, 0x06, 0x30, 0x0C, 0xC0,
  0x13, 0x00, 0x2F, 0x00, 0x72, 0x01, 0xC6, 0x03, 0x04, 0x06, 0x0C, 0x08,
  0x08, 0x10, 0x18, 0x20, 0x10, 0xC0, 0x30, 0x18, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x03, 0x00, 0xFF, 0xC0, 0x18, 0x0C, 0xE0, 0x73, 0x83, 0xCA, 0x0A,
  0x2C, 0x68, 0x91, 0x22, 0x49, 0x99, 0xE6, 0x63, 0x11, 0x0C, 0x44, 0x21,
  0x11, 0x04, 0x40, 0x33, 0x00, 0xCC, 0x02, 0x20, 0x08, 0x80, 0x20, 0x18,
  0x0C, 0x70, 0x21, 0xC0, 0x8D, 0x02, 0x34, 0x18, 0x98, 0x62, 0x21, 0x88,
  0x84, 0x23, 0x11, 0x8C, 0x46, 0x13, 0x10, 0x4C, 0x41, 0xB1, 0x02, 0x84,
  0x0A, 0x30, 0x38, 0xC0, 0xE0, 0x07, 0xC1, 0x86, 0x30, 0x36, 0x03, 0x40,
  0x14, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x28, 0x02, 0x80,
  0x68, 0x04, 0xC0, 0xC6, 0x18, 0x3E, 0x00, 0x1F, 0xF0, 0x80, 0xC4, 0x02,
  0x20, 0x13, 0x00, 0x98, 0x04, 0xC0, 0x64, 0x06, 0x3F, 0xE1, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x07,
  0xC1, 0x86, 0x30, 0x32, 0x03, 0x40, 0x14, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x28, 0x02, 0x80, 0x68, 0x04, 0xC0, 0xC6, 0x18, 0x3E,
  0x00, 0xC0, 0x06, 0x20, 0x2C, 0x01, 0x80, 0x1F, 0xF0, 0x80, 0xC4, 0x02,
  0x20, 0x13, 0x00, 0x98, 0x04, 0xC0, 0x64, 0x06, 0x3F, 0xE1, 0x08, 0x18,
  0x60, 0xC3, 0x06, 0x08, 0x20, 0x61, 0x01, 0x08, 0x0C, 0xC0, 0x60, 0x07,
  0xE0, 0xC1, 0xCC, 0x02, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x40, 0x1B, 0x00, 0x8C,
  0x18, 0x3F, 0x80, 0x7F, 0xFE, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x30, 0x19, 0x00,
  0x88, 0x04, 0xC0, 0x26, 0x03, 0x30, 0x19, 0x00, 0xC8, 0x04, 0x40, 0x26,
  0x01, 0x30, 0x19, 0x80, 0xC8, 0x04, 0x40, 0x23, 0x03, 0x08, 0x30, 0x3E,
  0x00, 0x80, 0x1E, 0x01, 0xB0, 0x09, 0x80, 0xC4, 0x06, 0x20, 0x61, 0x03,
  0x08, 0x10, 0x61, 0x83, 0x08, 0x18, 0xC0, 0x44, 0x02, 0x60, 0x12, 0x00,
  0xB0, 0x07, 0x00, 0x38, 0x00, 0x20, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00,
  0x62, 0x10, 0xCC, 0x61, 0x18, 0xC2, 0x33, 0xCC, 0x45, 0x98, 0x89, 0x21,
  0x22, 0x42, 0x45, 0x85, 0x8A, 0x0A, 0x14, 0x1C, 0x28, 0x30, 0x70, 0xE0,
  0xC0, 0x18, 0x03, 0x08, 0x06, 0x0C, 0x0C, 0x04, 0x18, 0x06, 0x30, 0x02,
  0x20, 0x03, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x06, 0xC0, 0x0C,
  0x40, 0x08, 0x60, 0x10, 0x20, 0x30, 0x30, 0x60, 0x10, 0xC0, 0x18, 0xC0,
  0x0D, 0x80, 0x66, 0x01, 0x08, 0x0C, 0x30, 0x60, 0x43, 0x01, 0x88, 0x02,
  0x60, 0x0F, 0x00, 0x38, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x1F, 0xFE, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF,
  0xF8, 0x0F, 0xE1, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0xFC, 0x00, 0x82, 0x08, 0x10, 0x41,
  0x04, 0x18, 0x20, 0x82, 0x0C, 0x10, 0x41, 0x04, 0x08, 0x20, 0x82, 0x0C,
  0x10, 0x0F, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x00, 0x21, 0xFC, 0x00, 0x03, 0x00, 0x78, 0x04,
  0x80, 0xCC, 0x18, 0x41, 0x04, 0x20, 0x66, 0x02, 0xC0, 0x38, 0x01, 0xFF,
  0xF0, 0x99, 0x22, 0x1F, 0x26, 0x15, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0xA0,
  0x14, 0x02, 0x80, 0xD0, 0x1A, 0x07, 0x61, 0x43, 0xCE, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x09, 0xE3, 0x43, 0x70, 0x2C, 0x05, 0x80,
  0xA0, 0x14, 0x03, 0x80, 0x70, 0x1E, 0x02, 0xC0, 0xD4, 0x32, 0x7C, 0x00,
  0x0F, 0x86, 0x19, 0x81, 0xA0, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x0B, 0x03, 0x30, 0xC3, 0xE0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x30, 0x02, 0x1F, 0x23, 0x0A, 0x60, 0x64, 0x06, 0xC0, 0x68, 0x04,
  0x80, 0x48, 0x04, 0x80, 0xC8, 0x0C, 0x81, 0xCC, 0x2C, 0x7C, 0x80, 0x0F,
  0x82, 0x0C, 0x80, 0xA0, 0x1C, 0x07, 0x87, 0x3F, 0x84, 0x00, 0x80, 0x18,
  0x0F, 0x03, 0x30, 0xC3, 0xE0, 0x00, 0x7F, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x1F, 0xFE, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x82, 0x00, 0x42, 0x00, 0x26,
  0x00, 0x16, 0x00, 0x0C, 0x00, 0x0F, 0x91, 0x85, 0x30, 0x32, 0x03, 0x60,
  0x34, 0x02, 0x40, 0x24, 0x02, 0x40, 0x64, 0x06, 0x40, 0xE6, 0x14, 0x1E,
  0x40, 0x04, 0x00, 0xC0, 0x08, 0xC1, 0x87, 0xE0, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x09, 0xE1, 0x46, 0x70, 0x6C, 0x0D, 0x81, 0xA0,
  0x34, 0x04, 0x80, 0xB0, 0x16, 0x06, 0xC0, 0xD0, 0x1A, 0x02, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x18, 0xC6, 0x19, 0x02, 0xC0,
  0x70, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x61, 0x86, 0x20, 0x64, 0x06, 0x80, 0x70, 0x10,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x27, 0xC2, 0x86, 0x70,
  0x66, 0x06, 0x60, 0x44, 0x0C, 0x43, 0x04, 0xC0, 0xCC, 0x0C, 0x41, 0x86,
  0x68, 0x2C, 0x83, 0x80, 0xFC, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x23, 0x0C, 0x84,
  0x26, 0x0B, 0x03, 0x00, 0x2E, 0x73, 0x9C, 0x58, 0x42, 0xC6, 0x14, 0x30,
  0xA1, 0x0D, 0x08, 0x78, 0x42, 0xC2, 0x14, 0x30, 0xA1, 0x85, 0x08, 0x68,
  0x43, 0x00, 0x27, 0x85, 0x19, 0xC1, 0xB0, 0x36, 0x06, 0x80, 0xD0, 0x12,
  0x02, 0xC0, 0x58, 0x1B, 0x03, 0x40, 0x68, 0x08, 0x0F, 0x86, 0x19, 0x81,
  0xA0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0B, 0x03, 0x30,
  0xC3, 0xE0, 0x13, 0xC3, 0x43, 0x38, 0x13, 0x01, 0x30, 0x12, 0x01, 0x20,
  0x16, 0x01, 0x60, 0x36, 0x02, 0x60, 0x65, 0x0C, 0x4F, 0x8C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x1F, 0x26, 0x15, 0x81, 0xA0, 0x3C, 0x07,
  0x00, 0xE0, 0x14, 0x02, 0x80, 0xD0, 0x1A, 0x07, 0x61, 0x67, 0xC8, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0xF9, 0xF0, 0xA0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x00, 0x0F, 0xC1, 0x83, 0x30, 0x13, 0x00, 0x30, 0x01, 0x80, 0x0F,
  0xC0, 0x06, 0x00, 0x20, 0x02, 0x40, 0x2E, 0x04, 0x1F, 0x80, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0xFF, 0xF0, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x21, 0x0C, 0x13, 0x03, 0x60, 0x18, 0x00,
  0x20, 0x2C, 0x05, 0x81, 0xB0, 0x34, 0x06, 0x80, 0x90, 0x16, 0x02, 0xC0,
  0xD8, 0x1B, 0x0F, 0x31, 0x43, 0xC8, 0xF0, 0x62, 0x04, 0x40, 0x98, 0x13,
  0x02, 0x60, 0x48, 0x19, 0x03, 0x20, 0x44, 0x11, 0x84, 0x33, 0x07, 0x80,
  0x21, 0x19, 0x08, 0x48, 0x42, 0xC2, 0x16, 0x30, 0xA1, 0x85, 0x08, 0x28,
  0x41, 0x42, 0x1E, 0x10, 0xB1, 0x8D, 0x94, 0x47, 0x1C, 0x00, 0x0E, 0x3C,
  0x36, 0xCD, 0x85, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x43, 0x01, 0x86, 0x03, 0x14, 0x32, 0x2D, 0x87, 0x8E, 0x00, 0x10,
  0x13, 0x01, 0x30, 0x33, 0x03, 0x20, 0x32, 0x02, 0x20, 0x26, 0x02, 0x60,
  0x66, 0x06, 0x61, 0xE3, 0x14, 0x1E, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0xC3,
  0x07, 0xE0, 0x1F, 0x19, 0x87, 0xC8, 0x0C, 0x40, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x18, 0x21, 0x81, 0x18, 0x0D, 0xFE, 0x6C, 0x3E, 0x00,
  0x07, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02,
  0x00, 0xC3, 0xE0, 0x06, 0x00, 0x40, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x7E, 0x00, 0x08, 0x42, 0x31, 0x08, 0x42,
  0x31, 0x88, 0x42, 0x11, 0x8C, 0x42, 0x10, 0x8C, 0x60, 0x0F, 0xC0, 0x0C,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x60,
  0x01, 0xF0, 0x60, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x0F, 0xC0, 0x1C, 0x09, 0x30, 0xD0, 0x84, 0x82,
  0x6C, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 17, 15, 5, -17 },
  { 12, 6, 7, 15, 6, -19 },
  { 18, 15, 17, 15, 0, -17 },
  { 50, 13, 23, 15, 1, -20 },
  { 88, 17, 17, 15, -1, -17 },
  { 125, 15, 17, 15, 0, -17 },
  { 157, 2, 7, 15, 8, -19 },
  { 159, 9, 22, 15, 5, -19 },
  { 184, 9, 22, 15, 1, -19 },
  { 209, 13, 12, 15, 1, -14 },
  { 229, 12, 11, 15, 2, -13 },
  { 246, 4, 7, 15, 4, -3 },
  { 250, 7, 1, 15, 4, -8 },
  { 251, 3, 3, 15, 5, -3 },
  { 253, 14, 22, 15, 1, -19 },
  { 292, 12, 17, 15, 2, -17 },
  { 318, 12, 17, 15, 1, -17 },
  { 344, 13, 17, 15, 1, -17 },
  { 372, 13, 17, 15, 1, -17 },
  { 400, 13, 17, 15, 1, -17 },
  { 428, 13, 17, 15, 1, -17 },
  { 456, 11, 17, 15, 2, -17 },
  { 480, 12, 17, 15, 3, -17 },
  { 506, 13, 17, 15, 1, -17 },
  { 534, 12, 17, 15, 2, -17 },
  { 560, 5, 14, 15, 5, -14 },
  { 569, 6, 18, 15, 4, -14 },
  { 583, 12, 14, 15, 2, -15 },
  { 604, 13, 6, 15, 1, -11 },
  { 614, 12, 14, 15, 1, -15 },
  { 635, 11, 17, 15, 3, -17 },
  { 659, 12, 20, 15, 2, -17 },
  { 689, 13, 17, 15, 0, -17 },
  { 717, 13, 17, 15, 1, -17 },
  { 745, 12, 17, 15, 2, -17 },
  { 771, 13, 17, 15, 1, -17 },
  { 799, 14, 17, 15, 1, -17 },
  { 829, 14, 17, 15, 1, -17 },
  { 859, 12, 17, 15, 2, -17 },
  { 885, 14, 17, 15, 1, -17 },
  { 915, 14, 17, 15, 1, -17 },
  { 945, 12, 17, 15, 2, -17 },
  { 971, 15, 17, 15, 1, -17 },
  { 1003, 10, 17, 15, 2, -17 },
  { 1025, 14, 17, 15, 1, -17 },
  { 1055, 14, 17, 15, 1, -17 },
  { 1085, 12, 17, 15, 2, -17 },
  { 1111, 13, 17, 15, 1, -17 },
  { 1139, 12, 21, 15, 2, -17 },
  { 1171, 13, 17, 15, 1, -17 },
  { 1199, 13, 17, 15, 1, -17 },
  { 1227, 14, 17, 15, 2, -17 },
  { 1257, 13, 17, 15, 2, -17 },
  { 1285, 13, 17, 15, 3, -17 },
  { 1313, 15, 17, 15, 1, -17 },
  { 1345, 16, 17, 15, 0, -17 },
  { 1379, 14, 17, 15, 2, -17 },
  { 1409, 15, 17, 15, 0, -17 },
  { 1441, 11, 22, 15, 4, -19 },
  { 1472, 6, 22, 15, 5, -19 },
  { 1489, 11, 22, 15, 0, -19 },
  { 1520, 12, 10, 15, 2, -17 },
  { 1535, 12, 1, 15, 0, 3 },
  { 1537, 3, 5, 15, 6, -20 },
  { 1539, 11, 13, 15, 2, -13 },
  { 1557, 11, 19, 15, 2, -19 },
  { 1584, 11, 13, 15, 2, -13 },
  { 1602, 12, 19, 15, 2, -19 },
  { 1631, 11, 13, 15, 2, -13 },
  { 1649, 16, 24, 15, 0, -19 },
  { 1697, 12, 18, 15, 1, -13 },
  { 1724, 11, 19, 15, 2, -19 },
  { 1751, 11, 19, 15, 2, -19 },
  { 1778, 11, 24, 15, 2, -19 },
  { 1811, 12, 19, 15, 2, -19 },
  { 1840, 10, 19, 15, 3, -19 },
  { 1864, 13, 13, 15, 1, -13 },
  { 1886, 11, 13, 15, 2, -13 },
  { 1904, 11, 13, 15, 2, -13 },
  { 1922, 12, 18, 15, 1, -13 },
  { 1949, 11, 18, 15, 2, -13 },
  { 1974, 12, 13, 15, 3, -13 },
  { 1994, 12, 13, 15, 1, -13 },
  { 2014, 12, 17, 15, 2, -17 },
  { 2040, 11, 13, 15, 2, -13 },
  { 2058, 11, 13, 15, 2, -13 },
  { 2076, 13, 13, 15, 1, -13 },
  { 2098, 15, 13, 15, 0, -13 },
  { 2123, 12, 18, 15, 1, -13 },
  { 2150, 13, 13, 15, 1, -13 },
  { 2172, 11, 22, 15, 3, -19 },
  { 2203, 5, 22, 15, 5, -19 },
  { 2217, 12, 22, 15, 1, -19 },
  { 2250, 13, 5, 15, 1, -10 },
};

const GFXfont IBMPlexMono_LightItalic25pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic25pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _IBMPLEXMONO_LIGHTITALIC25PT7B_H_
