#ifndef _IBMPLEXMONO_LIGHTITALIC62PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0x78, 0x00, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E,
  0x78, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C,
  0xF0, 0x3C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE1,
  0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0x87, 0x3F, 0x80, 0x0F, 0x81, 0xC1, 0xF0, 0x07, 0x80, 0x60, 0x3E,
  0x03, 0xC0, 0x18, 0x07, 0xC0, 0xF0, 0x0E, 0x00, 0xE0, 0x78, 0x03, 0x80,
  0x20, 0x1E, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x00, 0x78, 0x03, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x7C, 0x07, 0x00, 0x00, 0x0F,
  0x81, 0xC0, 0x00, 0x01, 0xF0, 0x60, 0x00, 0x00, 0x7F, 0x38, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0C, 0x7F, 0x00, 0x00, 0x07, 0x07,
  0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x0F, 0x06, 0x00, 0x30, 0x03, 0xC3,
  0xC0, 0x1C, 0x01, 0xE0, 0xF8, 0x07, 0x00, 0xF8, 0x1F, 0x01, 0xC0, 0x7C,
  0x03, 0xF0, 0x70, 0x3E, 0x00, 0x7F, 0x1C, 0x7F, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x1F,
  0xFF, 0x00, 0x01, 0xC0, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x07, 0x00, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x80, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x00, 0x70, 0x38, 0x00,
  0x1C, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80,
  0x38, 0x1C, 0x00, 0x01, 0xF0, 0x7C, 0x1E, 0x00, 0x00, 0x7F, 0xFC, 0x1E,
  0x00, 0x00, 0x1F, 0xF8, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x80, 0xFF,
  0xC0, 0x00, 0x03, 0xC0, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x7C, 0x00,
  0x01, 0xC0, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x03, 0x80, 0x01, 0xE0,
  0x70, 0x01, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x70, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0x07, 0xC0, 0x1C,
  0x00, 0x07, 0xFF, 0xC0, 0x1C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x1F, 0xF9, 0xF0, 0x00, 0x07, 0xE3, 0xFE, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x04,
  0xF0, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x07, 0x70, 0x00, 0x17,
  0x80, 0xE7, 0x00, 0x01, 0x3C, 0x0E, 0x78, 0x00, 0x33, 0xC1, 0xC7, 0x80,
  0x07, 0x1E, 0x3C, 0x3C, 0x00, 0xE1, 0xE3, 0x81, 0xF0, 0x3C, 0x0F, 0x78,
  0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3C, 0x00, 0x1C, 0x73, 0xCF, 0x3C, 0xE3, 0x8E, 0x79, 0xE7, 0x9C, 0x71,
  0xCF, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x01, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x1C,
  0x01, 0xFF, 0xF0, 0x38, 0x3F, 0xE7, 0xFC, 0x73, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x07, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0x00, 0x01, 0xC0, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x01,
  0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x7B, 0xC0, 0x1E, 0x00, 0xF7, 0x80, 0x7E, 0x01, 0xEF, 0x00,
  0xFC, 0x03, 0xDE, 0x03, 0xF0, 0x0F, 0x38, 0x07, 0xE0, 0x1E, 0xF0, 0x07,
  0x80, 0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF8, 0x70, 0x00, 0x1F, 0x83,
  0x80, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xF0, 0x0F, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x02, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F,
  0x05, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x20, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x03,
  0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x83,
  0xFC, 0x00, 0x07, 0x1F, 0xFF, 0x00, 0x07, 0x3F, 0xFF, 0xC0, 0x07, 0x78,
  0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x10, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x3F, 0xC0, 0x07, 0x87, 0xFF, 0xC0, 0x3C, 0xFF, 0xFF, 0x01, 0xCF,
  0x00, 0xFC, 0x1E, 0xE0, 0x01, 0xF0, 0xEC, 0x00, 0x07, 0x8F, 0xC0, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x1F,
  0x80, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xDE, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0x80, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F,
  0x38, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x78, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0xDE, 0x3E, 0x00, 0x19, 0xC3, 0xF8, 0x0F, 0x3C, 0x1F, 0xFF, 0xE3, 0x80,
  0x7F, 0xFC, 0x78, 0x01, 0xFE, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x0F, 0x87, 0x80, 0x01, 0xE3, 0xC0, 0x00,
  0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF1, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xE0,
  0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x1C, 0x38, 0x01, 0xF8, 0x71, 0xE0, 0x1F, 0xF1, 0xC7, 0x00, 0xFF,
  0xE7, 0x1C, 0x07, 0xC1, 0xDC, 0x70, 0x1E, 0x01, 0xF3, 0xC0, 0xF0, 0x07,
  0x8E, 0x03, 0x80, 0x0E, 0x38, 0x1E, 0x00, 0x38, 0xE0, 0x70, 0x00, 0xE3,
  0x81, 0xC0, 0x03, 0x9E, 0x0F, 0x00, 0x1E, 0x78, 0x3C, 0x00, 0x71, 0xC0,
  0xE0, 0x01, 0xC7, 0x03, 0x80, 0x07, 0x1C, 0x0E, 0x00, 0x1C, 0x70, 0x38,
  0x00, 0xF1, 0xC0, 0xE0, 0x03, 0xCF, 0x03, 0x80, 0x0E, 0x3C, 0x0E, 0x00,
  0x78, 0xE0, 0x38, 0x01, 0xE3, 0x80, 0xE0, 0x0B, 0x8E, 0x03, 0xC0, 0x6E,
  0x38, 0x07, 0x87, 0x78, 0xE0, 0x1F, 0xF9, 0xC3, 0x80, 0x3F, 0xC7, 0x0E,
  0x00, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x71,
  0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x07,
  0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x60, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x0F,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x61,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0xFC, 0xF0, 0x03, 0xFF, 0xF3, 0xC0, 0x0F, 0xFF, 0xCE,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x06, 0xE0, 0x3E, 0x00, 0x73, 0x80, 0x7E, 0x07, 0x8E, 0x00,
  0xFF, 0xFC, 0x78, 0x01, 0xFF, 0xE1, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3C, 0x00,
  0x00, 0x70, 0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x40, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x02, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF8, 0x01, 0xC0,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0x3F,
  0xC0, 0x00, 0x00, 0xE7, 0xDE, 0x00, 0x00, 0x0E, 0xF8, 0xE0, 0x00, 0x01,
  0xFF, 0x0F, 0x00, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0x80,
  0x00, 0x1F, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x3B, 0x80, 0xEE, 0x00, 0x0F, 0x70, 0x1C, 0xE0, 0x01,
  0xDE, 0x03, 0x9C, 0x00, 0x73, 0xC0, 0x73, 0x80, 0x1E, 0x70, 0x1E, 0x78,
  0x03, 0x8E, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x70, 0xE0, 0x1C, 0x38, 0x0E,
  0x1C, 0x07, 0x0F, 0x01, 0xC3, 0xC1, 0xE1, 0xE0, 0x38, 0x38, 0x38, 0x38,
  0x0F, 0x07, 0x0F, 0x07, 0x01, 0xE0, 0xE1, 0xC0, 0xE0, 0x38, 0x1E, 0x70,
  0x1C, 0x07, 0x01, 0xDE, 0x07, 0x80, 0xE0, 0x3B, 0x80, 0xF0, 0x1C, 0x07,
  0xF0, 0x1C, 0x07, 0x80, 0x7C, 0x03, 0x80, 0xF0, 0x0F, 0x00, 0x70, 0x1C,
  0x01, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x70, 0x03, 0x00, 0x78,
  0x0E, 0x00, 0x40, 0x0E, 0x03, 0xC0, 0x10, 0x01, 0xC0, 0x78, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0x80, 0xFC, 0x00, 0x01, 0xC0, 0x7E, 0x00, 0x01, 0xE0,
  0x7F, 0x00, 0x00, 0xF0, 0x3F, 0xC0, 0x00, 0x78, 0x1D, 0xE0, 0x00, 0x38,
  0x0E, 0x70, 0x00, 0x1C, 0x07, 0x38, 0x00, 0x0E, 0x03, 0x9E, 0x00, 0x0F,
  0x03, 0xCF, 0x00, 0x07, 0x81, 0xE3, 0x80, 0x03, 0xC0, 0xE1, 0xC0, 0x01,
  0xC0, 0x70, 0xF0, 0x00, 0xE0, 0x38, 0x38, 0x00, 0x70, 0x1C, 0x1C, 0x00,
  0x78, 0x1E, 0x0F, 0x00, 0x3C, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x01, 0xC0,
  0x0E, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x78, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0xC0, 0xF0, 0x0E, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x38, 0x03,
  0xC0, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x07, 0x00,
  0x3C, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x03, 0xC0, 0x07, 0x07, 0x81, 0xC0,
  0x03, 0x83, 0x80, 0xE0, 0x01, 0xE1, 0xC0, 0x70, 0x00, 0x70, 0xE0, 0x38,
  0x00, 0x38, 0xF0, 0x3C, 0x00, 0x1E, 0x78, 0x1E, 0x00, 0x0F, 0x3C, 0x0E,
  0x00, 0x03, 0x9C, 0x07, 0x00, 0x01, 0xCE, 0x03, 0x80, 0x00, 0xF7, 0x01,
  0xC0, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x0F, 0xE0,
  0x70, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x3E, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x01,
  0xF0, 0x0E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x08, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x07, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x02,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x1F, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x1E, 0x00, 0x70, 0x70, 0x07, 0xC0, 0x1E, 0x0E, 0x00, 0xF8,
  0x03, 0x81, 0xC0, 0x3F, 0x00, 0x70, 0x38, 0x07, 0x70, 0x0E, 0x07, 0x00,
  0xEE, 0x03, 0xC0, 0xE0, 0x39, 0xC0, 0x70, 0x1C, 0x07, 0x38, 0x0E, 0x03,
  0x81, 0xC7, 0x01, 0xC0, 0xF0, 0x38, 0xE0, 0x78, 0x1E, 0x0F, 0x1C, 0x0E,
  0x03, 0x81, 0xC3, 0x81, 0xC0, 0x70, 0x38, 0x70, 0x38, 0x0E, 0x0E, 0x0E,
  0x0E, 0x01, 0xC1, 0xC1, 0xC1, 0xC0, 0x38, 0x78, 0x38, 0x38, 0x07, 0x0E,
  0x07, 0x07, 0x00, 0xE1, 0xC0, 0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x38, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0x73, 0xC0, 0x38, 0xE0, 0x1E, 0x70, 0x07, 0x38,
  0x03, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x70, 0x03,
  0x9C, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0x73, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x07, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x61, 0xC3, 0xC3, 0x87, 0x87, 0x0E,
  0x0E, 0x1C, 0x1C, 0x30, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xC3, 0xC0,
  0x7F, 0xFF, 0x1E, 0x07, 0xE0, 0x3C, 0xF0, 0x7C, 0x00, 0x77, 0x07, 0xC0,
  0x01, 0xB8, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x1C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x7C, 0x3C, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x2F, 0x07, 0x80, 0x03,
  0x70, 0x1E, 0x00, 0x73, 0x80, 0xFC, 0x0F, 0x1F, 0xE3, 0xFF, 0xF0, 0xFF,
  0x0F, 0xFF, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x00, 0x1E,
  0x1F, 0xFE, 0x00, 0xE1, 0xFF, 0xF8, 0x07, 0x1E, 0x07, 0xE0, 0x39, 0xC0,
  0x0F, 0x81, 0xD8, 0x00, 0x3C, 0x1E, 0x80, 0x00, 0xE0, 0xFC, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x07,
  0x83, 0xB0, 0x00, 0x7C, 0x1D, 0xC0, 0x07, 0xC1, 0xE7, 0x80, 0xFC, 0x0F,
  0x1F, 0xFF, 0xC0, 0x78, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0xF0,
  0x00, 0x0F, 0x3C, 0x00, 0x01, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x08, 0xF0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F,
  0xE0, 0x38, 0x00, 0x7F, 0xF8, 0x38, 0x01, 0xFF, 0xFC, 0x78, 0x03, 0xF0,
  0x1E, 0x78, 0x07, 0xC0, 0x07, 0x78, 0x0F, 0x80, 0x01, 0x70, 0x0F, 0x00,
  0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0B, 0x80, 0x78, 0x00,
  0x1F, 0x80, 0x78, 0x00, 0x37, 0x80, 0x3C, 0x00, 0xE7, 0x80, 0x3F, 0x03,
  0xC7, 0x00, 0x1F, 0xFF, 0x87, 0x00, 0x0F, 0xFF, 0x07, 0x00, 0x01, 0xFC,
  0x08, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0xFC, 0x07, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7C, 0xE0, 0x00,
  0x1F, 0x3C, 0x00, 0x1F, 0xC7, 0x80, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0C, 0xF0,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x81, 0xC0, 0x00, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0xFB, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x1C,
  0x01, 0xFF, 0xFC, 0x78, 0x07, 0xE0, 0x3C, 0xF0, 0x1F, 0x00, 0x1D, 0xE0,
  0x7C, 0x00, 0x0B, 0xC0, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x05, 0xC0, 0x78, 0x00, 0x1B,
  0x80, 0xF0, 0x00, 0x6F, 0x00, 0xF0, 0x01, 0x9E, 0x01, 0xF8, 0x1F, 0x3C,
  0x01, 0xFF, 0xF8, 0x70, 0x01, 0xFF, 0xE0, 0xE0, 0x00, 0x7F, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x10,
  0x00, 0x07, 0x80, 0x30, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xF8,
  0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x0F, 0xC0, 0x03, 0x83, 0xFF, 0x00, 0x78, 0xFF, 0xFC, 0x07,
  0x9E, 0x07, 0xC0, 0x79, 0x80, 0x3E, 0x07, 0x30, 0x01, 0xE0, 0x76, 0x00,
  0x0E, 0x07, 0x40, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E,
  0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x87, 0x80, 0x00, 0x38, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x01, 0x00, 0x3C, 0x00, 0x70, 0x07, 0x00,
  0x1E, 0x00, 0xE0, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x00,
  0xF0, 0x7C, 0x00, 0x1C, 0x1F, 0x00, 0x03, 0x87, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x1E, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x80, 0x01,
  0xC0, 0x18, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x38, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x7C, 0x3C,
  0x00, 0x07, 0xC7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xDC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x1F, 0xC0, 0x01, 0xE0, 0xFF, 0xE0, 0x03, 0xC7, 0xFF, 0xE0,
  0x07, 0x9E, 0x07, 0xE0, 0x0E, 0x70, 0x03, 0xC0, 0x1C, 0xC0, 0x03, 0xC0,
  0x3B, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0,
  0x01, 0xF0, 0x03, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x7C, 0x00, 0x0E, 0x07,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x23, 0x80, 0xF0, 0x00, 0xE7, 0x00, 0xE0,
  0x03, 0xDE, 0x01, 0xE0, 0x0F, 0x3C, 0x01, 0xC0, 0x3C, 0x78, 0x03, 0xC0,
  0xF0, 0xE0, 0x03, 0x83, 0xC1, 0xC0, 0x07, 0x8F, 0x03, 0x80, 0x07, 0x3C,
  0x0F, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0x00,
  0xE0, 0x01, 0xC0, 0x70, 0x01, 0xF0, 0x38, 0x03, 0xE0, 0x3C, 0x03, 0xE0,
  0x1E, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x07, 0x07, 0xC0, 0x03, 0x87, 0xC0,
  0x03, 0xC7, 0x80, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0xE7, 0xF8, 0x3F,
  0xE0, 0x39, 0xFF, 0x1F, 0xF8, 0x1E, 0xC3, 0xC6, 0x1F, 0x07, 0x60, 0x7B,
  0x03, 0xC1, 0xD0, 0x0F, 0x80, 0x70, 0x78, 0x03, 0xC0, 0x1C, 0x1E, 0x00,
  0xF0, 0x07, 0x07, 0x00, 0x38, 0x01, 0xC3, 0xC0, 0x1E, 0x00, 0x70, 0xF0,
  0x07, 0x80, 0x3C, 0x38, 0x01, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x03, 0x83,
  0x80, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x78, 0x01, 0xC0, 0x0E,
  0x1C, 0x00, 0xF0, 0x07, 0x87, 0x00, 0x38, 0x01, 0xE1, 0xC0, 0x0E, 0x00,
  0x70, 0x70, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x07, 0x0F, 0x00, 0x38,
  0x01, 0xC3, 0x80, 0x1E, 0x00, 0xF0, 0xE0, 0x07, 0x00, 0x3C, 0x38, 0x01,
  0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x00, 0xE1, 0xE0,
  0x07, 0x00, 0x38, 0x70, 0x03, 0xC0, 0x1E, 0x1C, 0x00, 0xE0, 0x07, 0x87,
  0x00, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x38, 0x3F, 0xF0, 0x07, 0x8F, 0xFF, 0xC0,
  0x79, 0xE0, 0x7C, 0x07, 0x98, 0x03, 0xE0, 0x73, 0x00, 0x1E, 0x07, 0x60,
  0x00, 0xE0, 0x74, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x3C,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x3C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x78, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xF0, 0x1F, 0x80,
  0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xC3, 0xFF, 0xC0, 0x07, 0x8F, 0xFF,
  0xC0, 0x0E, 0x3C, 0x0F, 0xC0, 0x1C, 0xE0, 0x07, 0xC0, 0x3B, 0x00, 0x07,
  0x80, 0xF4, 0x00, 0x07, 0x01, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x0F, 0x01, 0xD8, 0x00, 0x3E, 0x07, 0xB8, 0x00, 0xF8, 0x0F, 0x3C, 0x07,
  0xE0, 0x1E, 0x3F, 0xFF, 0x80, 0x3C, 0x3F, 0xFC, 0x00, 0x70, 0x1F, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFF, 0xC1, 0xC0, 0x7F, 0xFF, 0x1E, 0x07, 0xE0, 0x3C, 0xF0, 0x7C,
  0x00, 0x77, 0x87, 0xC0, 0x00, 0xBC, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x02, 0xE0, 0xF0, 0x00,
  0x3F, 0x07, 0x80, 0x03, 0x78, 0x1E, 0x00, 0x73, 0x80, 0xFC, 0x0F, 0x1C,
  0x03, 0xFF, 0xF0, 0xE0, 0x0F, 0xFF, 0x07, 0x00, 0x0F, 0xE0, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xEF,
  0xFF, 0x8F, 0xFF, 0x80, 0x0E, 0x78, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01,
  0xEC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x78, 0xFC, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x08, 0x01, 0xE0, 0x01, 0xE0,
  0x0F, 0x00, 0x1F, 0x00, 0x70, 0x03, 0xE0, 0x03, 0x80, 0x3E, 0x00, 0x3C,
  0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0xF8,
  0x00, 0x03, 0x9F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78,
  0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xF0, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x87, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x3E, 0x1C, 0x00, 0x0B, 0xC3, 0xC0, 0x03, 0x70, 0x78,
  0x00, 0xCE, 0x0F, 0x80, 0x39, 0xC0, 0xF8, 0x1E, 0x78, 0x0F, 0xFF, 0x8F,
  0x00, 0xFF, 0xE1, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x6F,
  0xFC, 0x00, 0x1E, 0xFF, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x01, 0xE0, 0x7E, 0x00, 0x1C, 0x3F,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x06, 0x0E, 0x00, 0x70, 0x1E, 0x0E, 0x00, 0x70, 0x0E,
  0x0E, 0x00, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0x0F, 0x0E, 0x00, 0xF0, 0x07,
  0x1E, 0x00, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x07,
  0x1C, 0x00, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x07, 0x1C, 0x01, 0xE0, 0x07,
  0x3C, 0x01, 0xC0, 0x07, 0x38, 0x01, 0xC0, 0x07, 0x38, 0x01, 0xC0, 0x07,
  0x38, 0x01, 0xC0, 0x07, 0x38, 0x01, 0xC0, 0x0F, 0x38, 0x03, 0xC0, 0x0F,
  0x78, 0x03, 0x80, 0x0E, 0x70, 0x03, 0x80, 0x0E, 0x70, 0x03, 0x80, 0x0E,
  0x70, 0x03, 0x80, 0x1E, 0x70, 0x03, 0x80, 0x1C, 0x70, 0x07, 0x80, 0x1C,
  0x70, 0x07, 0x80, 0x3C, 0xF0, 0x07, 0x80, 0x38, 0xF0, 0x0F, 0x80, 0x78,
  0xF0, 0x1B, 0x80, 0xF0, 0x70, 0x3B, 0x81, 0xF0, 0x78, 0x73, 0xC3, 0xE0,
  0x7F, 0xE1, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0x3C, 0x1C, 0x3E, 0x07, 0xE1, 0xC3, 0x81, 0xE1, 0xF8,
  0x1C, 0x70, 0x0E, 0x3E, 0x01, 0xC6, 0x00, 0xE3, 0x80, 0x0E, 0xC0, 0x0F,
  0x20, 0x00, 0xEC, 0x00, 0xF0, 0x00, 0x0E, 0xC0, 0x0E, 0x00, 0x00, 0xF8,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x00,
  0xE0, 0x03, 0x60, 0x00, 0x0E, 0x00, 0x67, 0x00, 0x10, 0xE0, 0x06, 0x70,
  0x07, 0x8E, 0x00, 0xE7, 0x00, 0xF8, 0xE0, 0x1C, 0x70, 0x3E, 0x0F, 0x01,
  0xC7, 0x87, 0xC0, 0x78, 0x78, 0x39, 0xF0, 0x07, 0xFF, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x78, 0x07, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x07, 0xE0, 0x1E, 0x00,
  0x0B, 0xC0, 0x3C, 0x00, 0x27, 0x00, 0x7C, 0x01, 0xCE, 0x00, 0x7E, 0x0F,
  0x1C, 0x00, 0x7F, 0xFC, 0x78, 0x00, 0x7F, 0xF0, 0xF0, 0x00, 0x3F, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x10, 0x00, 0x07, 0x80, 0x30, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x1C,
  0x0F, 0xFF, 0xF0, 0x38, 0x3E, 0x07, 0xF8, 0xF0, 0x70, 0x00, 0xFD, 0xE1,
  0xE0, 0x00, 0x7F, 0x83, 0x80, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x30, 0x00, 0x1E, 0x00, 0x60,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x04, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x38, 0x01, 0xF0, 0x00,
  0x70, 0x07, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01,
  0xC1, 0xFC, 0x00, 0x03, 0x87, 0xFF, 0xC0, 0x07, 0x0E, 0x3F, 0xF8, 0x0F,
  0x1C, 0x0F, 0xFF, 0x9E, 0x78, 0x01, 0xFF, 0xF8, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x03,
  0xFC, 0x00, 0x07, 0x07, 0xFE, 0x00, 0x0F, 0x0F, 0x0F, 0x00, 0x0E, 0x1E,
  0x07, 0x80, 0x1E, 0x1C, 0x03, 0xC0, 0x1C, 0x38, 0x01, 0xC0, 0x3C, 0x38,
  0x01, 0xE0, 0x78, 0x70, 0x00, 0xF0, 0xF0, 0x70, 0x00, 0x7F, 0xE0, 0xE0,
  0x00, 0x3F, 0xC0, 0x60, 0x00, 0x1F, 0x80,
};

const GFXglyph IBMPlexMono_LightItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 12, 43, 37, 13, -43 },
  { 66, 16, 16, 37, 14, -46 },
  { 98, 37, 43, 37, 1, -43 },
  { 297, 34, 57, 37, 2, -50 },
  { 540, 41, 45, 37, -1, -44 },
  { 771, 36, 45, 37, 0, -44 },
  { 974, 6, 16, 37, 19, -46 },
  { 986, 21, 56, 37, 14, -47 },
  { 1133, 22, 56, 37, 3, -47 },
  { 1287, 31, 31, 37, 4, -34 },
  { 1408, 30, 31, 37, 4, -34 },
  { 1525, 12, 16, 37, 9, -7 },
  { 1549, 18, 3, 37, 10, -20 },
  { 1556, 7, 7, 37, 13, -7 },
  { 1563, 34, 56, 37, 2, -47 },
  { 1801, 31, 45, 37, 4, -44 },
  { 1976, 29, 43, 37, 3, -43 },
  { 2132, 32, 44, 37, 2, -44 },
  { 2308, 32, 45, 37, 2, -44 },
  { 2488, 33, 43, 37, 1, -43 },
  { 2666, 32, 44, 37, 3, -43 },
  { 2842, 29, 44, 37, 4, -43 },
  { 3002, 30, 43, 37, 7, -43 },
  { 3164, 32, 45, 37, 3, -44 },
  { 3344, 28, 44, 37, 6, -44 },
  { 3498, 11, 33, 37, 13, -33 },
  { 3544, 15, 42, 37, 9, -33 },
  { 3623, 29, 35, 37, 6, -36 },
  { 3750, 32, 14, 37, 3, -26 },
  { 3806, 30, 35, 37, 3, -36 },
  { 3938, 26, 44, 37, 8, -44 },
  { 4081, 30, 51, 37, 4, -44 },
  { 4273, 32, 43, 37, 0, -43 },
  { 4445, 31, 43, 37, 3, -43 },
  { 4612, 30, 45, 37, 5, -44 },
  { 4781, 31, 43, 37, 4, -43 },
  { 4948, 34, 43, 37, 3, -43 },
  { 5131, 34, 43, 37, 3, -43 },
  { 5314, 30, 45, 37, 5, -44 },
  { 5483, 33, 43, 37, 3, -43 },
  { 5661, 33, 43, 37, 3, -43 },
  { 5839, 30, 44, 37, 4, -43 },
  { 6004, 36, 43, 37, 3, -43 },
  { 6198, 26, 43, 37, 5, -43 },
  { 6338, 35, 43, 37, 2, -43 },
  { 6527, 33, 43, 37, 3, -43 },
  { 6705, 31, 45, 37, 4, -44 },
  { 6880, 33, 43, 37, 3, -43 },
  { 7058, 31, 55, 37, 4, -44 },
  { 7272, 33, 43, 37, 3, -43 },
  { 7450, 34, 45, 37, 2, -44 },
  { 7642, 34, 43, 37, 6, -43 },
  { 7825, 31, 44, 37, 5, -43 },
  { 7996, 32, 43, 37, 7, -43 },
  { 8168, 35, 43, 37, 4, -43 },
  { 8357, 39, 43, 37, 0, -43 },
  { 8567, 34, 43, 37, 6, -43 },
  { 8750, 38, 43, 37, 0, -43 },
  { 8955, 25, 56, 37, 11, -47 },
  { 9130, 15, 56, 37, 12, -47 },
  { 9235, 26, 56, 37, 1, -47 },
  { 9417, 31, 24, 37, 4, -43 },
  { 9510, 30, 3, 37, 0, 7 },
  { 9522, 7, 11, 37, 15, -48 },
  { 9532, 29, 34, 37, 4, -33 },
  { 9656, 29, 47, 37, 4, -46 },
  { 9827, 27, 34, 37, 5, -33 },
  { 9942, 32, 47, 37, 4, -46 },
  { 10130, 27, 34, 37, 5, -33 },
  { 10245, 40, 59, 37, -1, -46 },
  { 10540, 31, 46, 37, 2, -33 },
  { 10719, 28, 46, 37, 4, -46 },
  { 10880, 27, 48, 37, 5, -47 },
  { 11042, 27, 59, 37, 5, -46 },
  { 11242, 31, 47, 37, 4, -46 },
  { 11425, 25, 47, 37, 7, -46 },
  { 11572, 34, 33, 37, 1, -33 },
  { 11713, 28, 33, 37, 4, -33 },
  { 11829, 29, 34, 37, 4, -33 },
  { 11953, 31, 45, 37, 2, -33 },
  { 12128, 29, 45, 37, 4, -33 },
  { 12292, 30, 32, 37, 7, -32 },
  { 12412, 30, 34, 37, 3, -33 },
  { 12540, 29, 44, 37, 5, -43 },
  { 12700, 27, 33, 37, 6, -32 },
  { 12812, 28, 32, 37, 5, -32 },
  { 12924, 32, 33, 37, 3, -32 },
  { 13056, 36, 34, 37, 1, -33 },
  { 13209, 31, 45, 37, 2, -32 },
  { 13384, 31, 34, 37, 3, -33 },
  { 13516, 29, 56, 37, 7, -47 },
  { 13719, 12, 56, 37, 13, -47 },
  { 13803, 28, 56, 37, 3, -47 },
  { 13999, 32, 12, 37, 3, -25 },
};

const GFXfont IBMPlexMono_LightItalic62pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic62pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic62pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _IBMPLEXMONO_LIGHTITALIC62PT7B_H_
