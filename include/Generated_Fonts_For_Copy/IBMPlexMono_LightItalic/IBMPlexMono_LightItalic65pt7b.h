#ifndef _IBMPLEXMONO_LIGHTITALIC65PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC0, 0xFC,
  0x07, 0xC0, 0x00, 0x1C, 0x07, 0x8E, 0x03, 0x8F, 0x01, 0xC7, 0x81, 0xE3,
  0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x1C, 0x78, 0x0E, 0x3C, 0x0F,
  0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x01, 0xE3, 0x80, 0xE3, 0xC0, 0x71, 0xE0,
  0x78, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x07, 0xFF,
  0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x20, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x0E, 0x7F, 0x80, 0x0F, 0xC0,
  0xE0, 0xFC, 0x01, 0xF0, 0x0E, 0x03, 0xE0, 0x1E, 0x00, 0xC0, 0x1E, 0x03,
  0xC0, 0x1C, 0x00, 0xD0, 0x3C, 0x01, 0xC0, 0x08, 0x03, 0xC0, 0x1C, 0x00,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x78, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x30, 0x00, 0x00, 0x0F, 0xE7,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xE3, 0xF8,
  0x00, 0x00, 0x0E, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0xF0, 0x20, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x38, 0x01, 0xE0, 0xF0,
  0x03, 0x80, 0x3C, 0x0F, 0x80, 0x38, 0x07, 0xC0, 0x7E, 0x03, 0x80, 0xF8,
  0x03, 0xF0, 0x38, 0x1F, 0x00, 0x1F, 0xE3, 0x0F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0x00,
  0x3E, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x00, 0xF0, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x78, 0x00,
  0x38, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0,
  0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x3C, 0x00, 0x03, 0x80, 0x1E,
  0x07, 0x00, 0x00, 0x78, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x78,
  0x00, 0x00, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0x07, 0xFE, 0x03, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0E, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x80, 0xFF,
  0xF8, 0x00, 0x00, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0xF0,
  0x00, 0x07, 0x03, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x78, 0x00, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00,
  0x07, 0x83, 0xE0, 0x07, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0xFC, 0xF8, 0x00, 0x00, 0xFC, 0xFF,
  0x80, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x06, 0xF0,
  0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0xE7, 0x00, 0x00, 0x9C,
  0x03, 0x9E, 0x00, 0x06, 0x78, 0x1C, 0x78, 0x00, 0x18, 0xE0, 0xF0, 0xF0,
  0x00, 0xC3, 0xC3, 0x83, 0xE0, 0x07, 0x07, 0x9E, 0x07, 0xC0, 0x78, 0x1E,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x38,
  0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0x78, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x4E, 0x00, 0x38, 0x00, 0xEF, 0xE0, 0x1C, 0x03, 0xFF, 0xFE,
  0x0E, 0x1F, 0xFC, 0x7F, 0xE7, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x01, 0xE0, 0x0E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x7F, 0x7F, 0xFF,
  0xFF, 0x7E, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xE7, 0xC0,
  0x1E, 0x00, 0xF3, 0xC0, 0x1F, 0x80, 0x79, 0xE0, 0x1F, 0xC0, 0x3C, 0xF0,
  0x0F, 0xE0, 0x1E, 0x78, 0x07, 0xE0, 0x0F, 0x3C, 0x01, 0xE0, 0x07, 0x9E,
  0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03,
  0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x03, 0xF0, 0xF0, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0xF8, 0x0E, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x7E, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x18, 0x00, 0x78, 0x00, 0x40, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x40,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x1F, 0xE0, 0x00, 0x1E, 0x3F, 0xFE, 0x00, 0x07, 0x9F, 0xFF,
  0xE0, 0x01, 0xCE, 0x01, 0xFC, 0x00, 0x76, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x04, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0xC0, 0x03,
  0xC7, 0xFF, 0xE0, 0x1E, 0x3F, 0xFF, 0xC0, 0x79, 0xE0, 0x1F, 0x83, 0xCE,
  0x00, 0x1F, 0x0F, 0x60, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x79, 0xF8, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0xF8, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x03, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x0D, 0xE3,
  0xC0, 0x00, 0x7F, 0x0F, 0x80, 0x03, 0xBC, 0x1F, 0xC0, 0x7D, 0xF0, 0x3F,
  0xFF, 0xC7, 0x80, 0x3F, 0xFE, 0x3E, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x81, 0xFE, 0x0F,
  0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x03,
  0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x07, 0xF0, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3C, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x3F, 0x0F, 0x0E,
  0x00, 0xFF, 0xCF, 0x0E, 0x01, 0xFF, 0xCF, 0x1E, 0x03, 0xE0, 0x6E, 0x1C,
  0x03, 0xC0, 0x2E, 0x1C, 0x07, 0x80, 0x1E, 0x1C, 0x07, 0x00, 0x1E, 0x3C,
  0x0F, 0x00, 0x1E, 0x3C, 0x0E, 0x00, 0x1E, 0x38, 0x0E, 0x00, 0x1C, 0x38,
  0x1E, 0x00, 0x1C, 0x38, 0x1E, 0x00, 0x1C, 0x78, 0x1C, 0x00, 0x1C, 0x78,
  0x1C, 0x00, 0x3C, 0x78, 0x3C, 0x00, 0x3C, 0x70, 0x3C, 0x00, 0x38, 0x70,
  0x3C, 0x00, 0x38, 0x70, 0x3C, 0x00, 0x38, 0x70, 0x3C, 0x00, 0x78, 0x70,
  0x3C, 0x00, 0x78, 0xF0, 0x3C, 0x00, 0xF8, 0xF0, 0x3C, 0x00, 0xF0, 0xF0,
  0x1C, 0x01, 0x70, 0xF0, 0x1E, 0x03, 0x70, 0xF0, 0x1F, 0x8E, 0x70, 0xF0,
  0x0F, 0xFC, 0xF0, 0xF0, 0x07, 0xF8, 0xF0, 0x70, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3C, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1E, 0x00,
  0x03, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x08, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x7F,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x10, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0xF0, 0x01,
  0xFF, 0xF8, 0xF0, 0x01, 0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xE0, 0x3C, 0x00, 0x0D, 0xE0, 0x3E, 0x00, 0x39, 0xE0, 0x1F, 0xC0,
  0xF1, 0xC0, 0x0F, 0xFF, 0xE1, 0xC0, 0x03, 0xFF, 0xC3, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1E,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x80,
  0x00, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x3E, 0x00, 0x00, 0x01, 0xC1, 0xF8, 0x00, 0x00, 0x0F, 0x0F,
  0xE0, 0x00, 0x00, 0x3C, 0x7F, 0xC0, 0x00, 0x00, 0xF3, 0xEF, 0x00, 0x00,
  0x03, 0xDF, 0x3E, 0x00, 0x00, 0x0F, 0xF8, 0x78, 0x00, 0x00, 0x3F, 0xC1,
  0xE0, 0x00, 0x01, 0xFE, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0x00, 0x00,
  0x1F, 0x80, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x07, 0x70, 0x00, 0x3B, 0xC0, 0x7B, 0x80, 0x03,
  0xDE, 0x03, 0xDE, 0x00, 0x1C, 0xE0, 0x1E, 0x70, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x1E, 0x38, 0x07, 0x1C, 0x00, 0xE3, 0xC0, 0x38, 0xF0, 0x0F, 0x1E,
  0x03, 0xC3, 0x80, 0x70, 0xF0, 0x1E, 0x1C, 0x07, 0x07, 0x00, 0xF0, 0xF0,
  0x78, 0x38, 0x07, 0x07, 0x83, 0x81, 0xC0, 0x38, 0x1C, 0x3C, 0x1E, 0x01,
  0xC0, 0xE1, 0xC0, 0xF0, 0x1E, 0x07, 0x9C, 0x07, 0x80, 0xF0, 0x1D, 0xE0,
  0x38, 0x07, 0x80, 0xEE, 0x01, 0xC0, 0x38, 0x07, 0xF0, 0x0E, 0x01, 0xC0,
  0x3F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x3C,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x04,
  0x00, 0x70, 0x0E, 0x00, 0x40, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x3F, 0x00,
  0x00, 0x3C, 0x07, 0xF0, 0x00, 0x07, 0x80, 0xFE, 0x00, 0x00, 0xE0, 0x1D,
  0xC0, 0x00, 0x1C, 0x03, 0xBC, 0x00, 0x03, 0x80, 0xF7, 0x80, 0x00, 0xF0,
  0x1E, 0xF0, 0x00, 0x1E, 0x03, 0xCE, 0x00, 0x03, 0xC0, 0x71, 0xE0, 0x00,
  0x70, 0x0E, 0x3C, 0x00, 0x0E, 0x01, 0xC3, 0x80, 0x01, 0xC0, 0x78, 0x70,
  0x00, 0x78, 0x0F, 0x0F, 0x00, 0x0F, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0x38,
  0x1C, 0x00, 0x38, 0x07, 0x03, 0xC0, 0x07, 0x00, 0xE0, 0x78, 0x00, 0xE0,
  0x3C, 0x07, 0x00, 0x3C, 0x07, 0x80, 0xE0, 0x07, 0x80, 0xF0, 0x1E, 0x00,
  0xF0, 0x1C, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x80, 0x70, 0x1E, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x78,
  0x01, 0xC0, 0x78, 0x0E, 0x00, 0x3C, 0x0E, 0x01, 0xC0, 0x07, 0x81, 0xC0,
  0x38, 0x00, 0x70, 0x38, 0x0F, 0x00, 0x0F, 0x0F, 0x01, 0xE0, 0x01, 0xE1,
  0xE0, 0x3C, 0x00, 0x3C, 0x3C, 0x07, 0x00, 0x03, 0x87, 0x00, 0xE0, 0x00,
  0x78, 0xE0, 0x3C, 0x00, 0x0F, 0x1C, 0x07, 0x80, 0x00, 0xE7, 0x80, 0xF0,
  0x00, 0x1C, 0xF0, 0x1E, 0x00, 0x03, 0xDE, 0x03, 0x80, 0x00, 0x7B, 0x80,
  0x70, 0x00, 0x07, 0x70, 0x1E, 0x00, 0x00, 0xFE, 0x03, 0xC0, 0x00, 0x1F,
  0xC0, 0x78, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x01, 0xF0, 0x07,
  0x80, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x1F,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x7F, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xE7, 0xC0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03,
  0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x08, 0x00, 0x03,
  0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x00, 0x80,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x40, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0xF8, 0x01, 0xC0, 0xF0, 0x07, 0xC0, 0x0E, 0x07, 0x80,
  0x7F, 0x00, 0xF0, 0x3C, 0x03, 0xF8, 0x07, 0x81, 0xE0, 0x1D, 0xC0, 0x38,
  0x0E, 0x01, 0xEE, 0x01, 0xC0, 0x70, 0x0E, 0x70, 0x1E, 0x03, 0x80, 0xF3,
  0x80, 0xF0, 0x1C, 0x07, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0xE0, 0x38, 0x07,
  0x03, 0x87, 0x03, 0xC0, 0x38, 0x1C, 0x38, 0x1E, 0x03, 0xC1, 0xE1, 0xC0,
  0xE0, 0x1E, 0x0E, 0x0E, 0x07, 0x00, 0xF0, 0x70, 0x70, 0x78, 0x07, 0x87,
  0x03, 0xC3, 0xC0, 0x38, 0x38, 0x0E, 0x1C, 0x01, 0xC3, 0xC0, 0x70, 0xE0,
  0x0E, 0x1C, 0x03, 0x8F, 0x00, 0x71, 0xE0, 0x1C, 0x78, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x1C, 0x70, 0x07, 0x1C, 0x00, 0xE7, 0x80, 0x39, 0xE0, 0x07,
  0x38, 0x01, 0xCF, 0x00, 0x3B, 0xC0, 0x0E, 0x70, 0x03, 0xDC, 0x00, 0x73,
  0x80, 0x1E, 0xE0, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1F,
  0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x10, 0xF0, 0x78,
  0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x07, 0x06, 0x00, 0x0F, 0xE0,
  0x1E, 0x00, 0xFF, 0xF8, 0x38, 0x03, 0xFF, 0xF8, 0xF0, 0x0F, 0xC0, 0x79,
  0xE0, 0x3E, 0x00, 0x3B, 0xC0, 0xF0, 0x00, 0x37, 0x83, 0xC0, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7E, 0x07, 0x80, 0x01,
  0xBC, 0x0F, 0x80, 0x07, 0x78, 0x0F, 0x80, 0x1C, 0xF0, 0x0F, 0xC0, 0xF1,
  0xFE, 0x1F, 0xFF, 0xC3, 0xFC, 0x0F, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0xC0, 0x01,
  0xC1, 0xFF, 0xE0, 0x07, 0x87, 0xFF, 0xE0, 0x0F, 0x1E, 0x07, 0xE0, 0x1E,
  0x70, 0x03, 0xE0, 0x3D, 0x80, 0x03, 0xE0, 0x76, 0x00, 0x03, 0xC0, 0xE8,
  0x00, 0x07, 0x83, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78,
  0x7C, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x3E, 0x07, 0x30, 0x00, 0xF8, 0x0E, 0x3C, 0x07, 0xE0, 0x3C,
  0x3F, 0xFF, 0x80, 0x78, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x80,
  0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x43, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x08, 0xF0,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x3C, 0x38, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x00,
  0xF8, 0x0F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x3F, 0xC0, 0x78, 0x00, 0x7F, 0xF8, 0x3C, 0x00, 0xFF, 0xFE, 0x1E,
  0x00, 0xFC, 0x07, 0x8E, 0x00, 0xF8, 0x00, 0x67, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01,
  0xF0, 0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x07, 0xE0, 0x3C, 0x00, 0x02, 0xE0, 0x1E, 0x00, 0x03, 0x70, 0x0F,
  0x80, 0x03, 0x78, 0x03, 0xE0, 0x07, 0x3C, 0x00, 0xFC, 0x0F, 0x1E, 0x00,
  0x3F, 0xFF, 0x0F, 0x00, 0x0F, 0xFF, 0x07, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x78, 0x3E,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F,
  0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3F, 0x1E, 0x00, 0x0F, 0xF0, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x47, 0x80, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x07, 0x80, 0x0F, 0xFF, 0x83, 0xC0, 0x0F, 0xFF, 0xE1, 0xC0, 0x0F,
  0xC0, 0x78, 0xE0, 0x0F, 0x80, 0x06, 0xF0, 0x0F, 0x00, 0x01, 0xF8, 0x0F,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00,
  0x5E, 0x03, 0xC0, 0x00, 0x6E, 0x01, 0xF0, 0x00, 0x67, 0x00, 0x7C, 0x00,
  0xE7, 0x80, 0x1F, 0x81, 0xE3, 0xC0, 0x07, 0xFF, 0xE1, 0xE0, 0x01, 0xFF,
  0xE0, 0xF0, 0x00, 0x3F, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x10,
  0x00, 0x03, 0xC0, 0x0C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0xC0, 0x0F,
  0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0xFE, 0x00, 0x78, 0x3F, 0xF8,
  0x07, 0x8F, 0xFF, 0xC0, 0x71, 0xE0, 0x7E, 0x0F, 0x38, 0x01, 0xE0, 0xF3,
  0x00, 0x1F, 0x0F, 0x60, 0x00, 0xF0, 0xFC, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x78, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C,
  0x70, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x04, 0x00, 0x70,
  0x00, 0x60, 0x07, 0x00, 0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x78,
  0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0xE0, 0x7C, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x07, 0x80,
  0x3E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x01,
  0xFC, 0x00, 0x07, 0x03, 0xFF, 0x80, 0x03, 0x87, 0xFF, 0xE0, 0x03, 0xC7,
  0x80, 0xF8, 0x01, 0xE7, 0x00, 0x3E, 0x00, 0xF7, 0x00, 0x0F, 0x00, 0x7B,
  0x00, 0x07, 0x80, 0x3B, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0xE0, 0x1F,
  0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x1E, 0x03, 0xF0, 0x00, 0x0E, 0x0F, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x08, 0xF0, 0x1E, 0x00, 0x0E, 0x70, 0x07, 0x80, 0x1F, 0x38, 0x03, 0xC0,
  0x1F, 0x3C, 0x00, 0xF0, 0x1F, 0x1E, 0x00, 0x78, 0x1F, 0x0F, 0x00, 0x1E,
  0x1E, 0x07, 0x80, 0x0F, 0x1E, 0x03, 0x80, 0x03, 0xDE, 0x01, 0xC0, 0x01,
  0xFE, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x10, 0x07, 0x00, 0x06, 0x03, 0xC0, 0x03, 0xC0,
  0xF0, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x03, 0x80, 0x78,
  0x01, 0xE0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x9F,
  0x00, 0x01, 0xCF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x3F, 0x00, 0xE3, 0xFC, 0x0F, 0xF0,
  0x1C, 0xFF, 0xC3, 0xFF, 0x03, 0xB8, 0x78, 0xE1, 0xE0, 0xF4, 0x07, 0xB0,
  0x1E, 0x1F, 0x80, 0xF4, 0x03, 0xC3, 0xE0, 0x0F, 0x00, 0x78, 0x78, 0x01,
  0xE0, 0x0F, 0x0F, 0x00, 0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x00, 0x3C, 0x78,
  0x01, 0xE0, 0x07, 0x0F, 0x00, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x00, 0x1C,
  0x38, 0x00, 0xE0, 0x07, 0x87, 0x00, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x80,
  0x1E, 0x3C, 0x00, 0xF0, 0x03, 0x87, 0x80, 0x1C, 0x00, 0x70, 0xF0, 0x03,
  0x80, 0x0E, 0x1C, 0x00, 0x70, 0x03, 0xC3, 0x80, 0x0E, 0x00, 0x78, 0x70,
  0x03, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0x01, 0xC3, 0xC0, 0x0E, 0x00, 0x38,
  0x78, 0x01, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x01, 0xE1, 0xC0, 0x07, 0x00,
  0x3C, 0x38, 0x01, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x00, 0xE1, 0xE0, 0x07,
  0x00, 0x1C, 0x3C, 0x00, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x00, 0xF0, 0xE0,
  0x03, 0x80, 0x1E, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0xFE, 0x00,
  0x78, 0x3F, 0xF8, 0x07, 0x0F, 0xFF, 0xC0, 0x71, 0xE0, 0x7E, 0x0F, 0x38,
  0x01, 0xE0, 0xF3, 0x00, 0x1F, 0x0F, 0x60, 0x00, 0xF0, 0xFC, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x1C, 0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x78, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xE0, 0x1F, 0xC0, 0x00, 0xF0, 0x7F, 0xF8, 0x00, 0x78,
  0x7F, 0xFE, 0x00, 0x3C, 0x78, 0x1F, 0x80, 0x1E, 0x70, 0x03, 0xE0, 0x0F,
  0x60, 0x00, 0xF8, 0x07, 0x60, 0x00, 0x3C, 0x07, 0xA0, 0x00, 0x1E, 0x03,
  0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0x73, 0x00, 0x0F, 0x80, 0x38, 0xF0,
  0x1F, 0x80, 0x3C, 0x3F, 0xFF, 0x80, 0x1E, 0x0F, 0xFF, 0x00, 0x0F, 0x01,
  0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x7F, 0xF8, 0x3C,
  0x03, 0xFF, 0xF8, 0x70, 0x0F, 0xC0, 0x78, 0xE0, 0x3E, 0x00, 0x1B, 0xC0,
  0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E, 0x1E,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F,
  0x83, 0xC0, 0x00, 0x2E, 0x07, 0x80, 0x00, 0xDC, 0x0F, 0x80, 0x03, 0x78,
  0x0F, 0x80, 0x1C, 0xF0, 0x0F, 0xC0, 0xF1, 0xE0, 0x0F, 0xFF, 0xC3, 0xC0,
  0x0F, 0xFF, 0x07, 0x00, 0x07, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0x7F,
  0xFC, 0x1F, 0xFE, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0x3C, 0xC0, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7E,
  0x00, 0xFE, 0x03, 0xE0, 0x00, 0xFC, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0x83, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC4, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xE3,
  0xE0, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x7C, 0x0F, 0xF0, 0x07, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x20, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x78, 0x3F, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x07, 0x1F, 0x80,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x38, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C,
  0x78, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x1F, 0x0F, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x6F, 0x0F, 0x80, 0x0C,
  0xF0, 0x78, 0x01, 0xCE, 0x07, 0xE0, 0x78, 0xE0, 0x3F, 0xFF, 0x1E, 0x01,
  0xFF, 0xE1, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x33, 0xFF,
  0x80, 0x01, 0xEF, 0xFE, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x01,
  0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xE0,
  0x03, 0x80, 0x1F, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x78, 0x0F, 0xC0, 0x01,
  0xE1, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x06, 0x07, 0x00, 0x38, 0x07, 0x87,
  0x80, 0x1C, 0x03, 0xC3, 0xC0, 0x0E, 0x00, 0xE1, 0xC0, 0x07, 0x00, 0x70,
  0xE0, 0x07, 0x80, 0x38, 0x70, 0x03, 0xC0, 0x1E, 0x38, 0x01, 0xC0, 0x0F,
  0x3C, 0x00, 0xE0, 0x07, 0x9E, 0x00, 0x70, 0x01, 0xCF, 0x00, 0x38, 0x00,
  0xE7, 0x00, 0x3C, 0x00, 0x73, 0x80, 0x1E, 0x00, 0x79, 0xC0, 0x0E, 0x00,
  0x3C, 0xE0, 0x07, 0x00, 0x1E, 0xF0, 0x03, 0x80, 0x0F, 0x78, 0x01, 0xC0,
  0x07, 0xB8, 0x01, 0xE0, 0x03, 0x9C, 0x00, 0xF0, 0x01, 0xCE, 0x00, 0x78,
  0x00, 0xE7, 0x00, 0x38, 0x00, 0xF7, 0x80, 0x1C, 0x00, 0x7B, 0xC0, 0x0E,
  0x00, 0x39, 0xC0, 0x0F, 0x00, 0x1C, 0xE0, 0x07, 0x80, 0x1E, 0x70, 0x03,
  0xC0, 0x0E, 0x38, 0x01, 0xE0, 0x0F, 0x1C, 0x01, 0x70, 0x07, 0x8E, 0x00,
  0xB8, 0x07, 0x87, 0x00, 0xDC, 0x03, 0xC3, 0xC0, 0xCE, 0x03, 0xC1, 0xF0,
  0xC7, 0x87, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xF3, 0xC1, 0xE1, 0xE0, 0x7E,
  0x1E, 0x1C, 0x07, 0x87, 0xC0, 0x71, 0xC0, 0x3C, 0xFC, 0x03, 0x8C, 0x00,
  0xE7, 0x80, 0x1E, 0x60, 0x07, 0x10, 0x00, 0x76, 0x00, 0x38, 0x00, 0x03,
  0xB0, 0x01, 0xC0, 0x00, 0x1D, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x04, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x07,
  0x00, 0x1B, 0xC0, 0x00, 0x38, 0x00, 0xCE, 0x00, 0x31, 0xC0, 0x0E, 0x70,
  0x07, 0xCE, 0x00, 0x63, 0x80, 0x7C, 0x78, 0x07, 0x1C, 0x0F, 0xC3, 0xC0,
  0x70, 0xF0, 0xF8, 0x0F, 0x07, 0x03, 0x9F, 0x80, 0x7F, 0xF8, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0x70, 0x0F, 0x00, 0x03, 0xF0, 0x0F, 0x00,
  0x06, 0xF0, 0x07, 0x80, 0x0E, 0xF0, 0x07, 0xC0, 0x1C, 0xF0, 0x07, 0xE0,
  0x78, 0xE0, 0x03, 0xFF, 0xF0, 0xE0, 0x01, 0xFF, 0xE1, 0xE0, 0x00, 0x3F,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x20, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0x80, 0x7F, 0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xE1, 0xE0, 0x78,
  0x0F, 0xFC, 0xE0, 0x78, 0x00, 0x7F, 0xF0, 0x38, 0x00, 0x0F, 0xF8, 0x3C,
  0x00, 0x01, 0xF8, 0x1C, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00, 0xF8, 0x07,
  0x00, 0x00, 0xF8, 0x03, 0x80, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x00,
  0xE0, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x1C, 0x03, 0xE0, 0x00,
  0x0E, 0x03, 0xE0, 0x00, 0x07, 0x03, 0xFE, 0x00, 0x03, 0xC3, 0xFF, 0xF0,
  0x01, 0xE1, 0xE3, 0xFF, 0xC0, 0x70, 0xE0, 0x3F, 0xFE, 0x38, 0x70, 0x01,
  0xFF, 0xFC, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x80,
  0xFF, 0x80, 0x00, 0xF0, 0x7F, 0xF0, 0x00, 0x38, 0x3E, 0x3E, 0x00, 0x0E,
  0x0E, 0x03, 0xC0, 0x07, 0x07, 0x80, 0xF0, 0x01, 0xC1, 0xC0, 0x1E, 0x00,
  0xE0, 0xE0, 0x03, 0xC0, 0x78, 0x38, 0x00, 0xF0, 0x1C, 0x1C, 0x00, 0x1F,
  0x1F, 0x07, 0x00, 0x03, 0xFF, 0x83, 0xC0, 0x00, 0x7F, 0xC0, 0x60, 0x00,
  0x07, 0xC0, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 13, 45, 39, 13, -45 },
  { 75, 17, 17, 39, 15, -48 },
  { 112, 39, 45, 39, 1, -45 },
  { 332, 36, 61, 39, 2, -53 },
  { 607, 43, 47, 39, -1, -46 },
  { 860, 38, 47, 39, 0, -46 },
  { 1084, 7, 17, 39, 20, -48 },
  { 1099, 23, 58, 39, 14, -49 },
  { 1266, 23, 58, 39, 3, -49 },
  { 1433, 33, 32, 39, 4, -36 },
  { 1565, 32, 31, 39, 4, -35 },
  { 1689, 13, 17, 39, 9, -7 },
  { 1717, 18, 3, 39, 11, -21 },
  { 1724, 8, 7, 39, 13, -7 },
  { 1731, 36, 58, 39, 2, -49 },
  { 1992, 33, 47, 39, 4, -46 },
  { 2186, 30, 45, 39, 3, -45 },
  { 2355, 33, 46, 39, 2, -46 },
  { 2545, 33, 47, 39, 2, -46 },
  { 2739, 35, 45, 39, 1, -45 },
  { 2936, 34, 46, 39, 3, -45 },
  { 3132, 30, 46, 39, 4, -45 },
  { 3305, 32, 45, 39, 7, -45 },
  { 3485, 34, 47, 39, 3, -46 },
  { 3685, 30, 46, 39, 6, -46 },
  { 3858, 13, 35, 39, 13, -35 },
  { 3915, 17, 45, 39, 9, -35 },
  { 4011, 31, 36, 39, 6, -38 },
  { 4151, 34, 16, 39, 3, -28 },
  { 4219, 31, 36, 39, 3, -38 },
  { 4359, 27, 46, 39, 9, -46 },
  { 4515, 32, 53, 39, 4, -46 },
  { 4727, 34, 45, 39, 0, -45 },
  { 4919, 33, 45, 39, 3, -45 },
  { 5105, 32, 47, 39, 5, -46 },
  { 5293, 32, 45, 39, 4, -45 },
  { 5473, 34, 45, 39, 4, -45 },
  { 5665, 35, 45, 39, 4, -45 },
  { 5862, 32, 47, 39, 5, -46 },
  { 6050, 35, 45, 39, 3, -45 },
  { 6247, 35, 45, 39, 3, -45 },
  { 6444, 31, 46, 39, 4, -45 },
  { 6623, 38, 45, 39, 3, -45 },
  { 6837, 26, 45, 39, 6, -45 },
  { 6984, 37, 45, 39, 2, -45 },
  { 7193, 35, 45, 39, 3, -45 },
  { 7390, 33, 47, 39, 4, -46 },
  { 7584, 34, 45, 39, 4, -45 },
  { 7776, 33, 57, 39, 4, -46 },
  { 8012, 34, 45, 39, 4, -45 },
  { 8204, 35, 47, 39, 2, -46 },
  { 8410, 36, 45, 39, 6, -45 },
  { 8613, 33, 46, 39, 5, -45 },
  { 8803, 33, 45, 39, 8, -45 },
  { 8989, 37, 45, 39, 4, -45 },
  { 9198, 41, 45, 39, 0, -45 },
  { 9429, 36, 45, 39, 6, -45 },
  { 9632, 39, 45, 39, 0, -45 },
  { 9852, 27, 58, 39, 11, -49 },
  { 10048, 16, 58, 39, 12, -49 },
  { 10164, 27, 58, 39, 1, -49 },
  { 10360, 31, 26, 39, 5, -45 },
  { 10461, 32, 3, 39, 0, 7 },
  { 10473, 8, 12, 39, 15, -50 },
  { 10485, 31, 35, 39, 4, -34 },
  { 10621, 31, 49, 39, 4, -48 },
  { 10811, 28, 35, 39, 5, -34 },
  { 10934, 33, 49, 39, 4, -48 },
  { 11137, 29, 35, 39, 5, -34 },
  { 11264, 42, 62, 39, -1, -48 },
  { 11590, 33, 48, 39, 2, -34 },
  { 11788, 28, 48, 39, 5, -48 },
  { 11956, 28, 50, 39, 6, -49 },
  { 12131, 29, 63, 39, 5, -49 },
  { 12360, 33, 49, 39, 4, -48 },
  { 12563, 26, 49, 39, 7, -48 },
  { 12723, 35, 34, 39, 2, -34 },
  { 12872, 28, 34, 39, 5, -34 },
  { 12991, 29, 35, 39, 5, -34 },
  { 13118, 33, 47, 39, 2, -34 },
  { 13312, 31, 47, 39, 4, -34 },
  { 13495, 32, 34, 39, 7, -34 },
  { 13631, 30, 35, 39, 4, -34 },
  { 13763, 30, 46, 39, 5, -45 },
  { 13936, 28, 35, 39, 6, -34 },
  { 14059, 30, 34, 39, 5, -34 },
  { 14187, 33, 35, 39, 4, -34 },
  { 14332, 37, 35, 39, 1, -34 },
  { 14494, 32, 48, 39, 2, -34 },
  { 14686, 33, 35, 39, 3, -34 },
  { 14831, 29, 58, 39, 8, -49 },
  { 15042, 13, 58, 39, 14, -49 },
  { 15137, 30, 58, 39, 3, -49 },
  { 15355, 34, 13, 39, 3, -26 },
};

const GFXfont IBMPlexMono_LightItalic65pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic65pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic65pt7bGlyphs,
  0x20, 0x7E, 85
};

#endif // _IBMPLEXMONO_LIGHTITALIC65PT7B_H_
