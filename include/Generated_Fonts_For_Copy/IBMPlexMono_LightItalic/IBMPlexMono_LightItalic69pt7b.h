#ifndef _IBMPLEXMONO_LIGHTITALIC69PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0x00, 0x1E, 0x03, 0xC7, 0x80, 0xE1, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07,
  0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x38, 0x0F, 0x1E, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0x87, 0x01, 0xE3, 0xC0,
  0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x81,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xE1, 0xE7, 0xF8, 0x00, 0xFE, 0x07, 0x03, 0xF0, 0x03, 0xE0, 0x1C, 0x07,
  0xE0, 0x1F, 0x00, 0x70, 0x07, 0xC0, 0x78, 0x01, 0xC0, 0x0E, 0x03, 0xE0,
  0x07, 0x00, 0x30, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00,
  0x03, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x00, 0x1F, 0x01,
  0xC0, 0x00, 0x00, 0x7F, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x1C, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0x9F, 0xF0, 0x00, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0x00, 0x70,
  0x0F, 0x80, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x7C, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x1F, 0x02, 0x00, 0x0E, 0x00,
  0x78, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0xF8, 0x01, 0xC0, 0x0F, 0x81, 0xF0,
  0x07, 0x00, 0x7C, 0x03, 0xE0, 0x1C, 0x03, 0xF0, 0x0F, 0xE0, 0x70, 0x3F,
  0x80, 0x1F, 0xF3, 0xC7, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0x00, 0x1C, 0x00, 0x78, 0x07,
  0x80, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x81, 0xE0, 0x00,
  0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0x00,
  0x70, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x0F, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x78, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x07,
  0xC0, 0xF0, 0x00, 0x00, 0x78, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xE0,
  0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x00, 0x1E, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xCF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x33, 0xC0, 0x00, 0x0F, 0x80, 0x1D, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x78,
  0x00, 0x06, 0xF0, 0x1F, 0x3C, 0x00, 0x03, 0x7C, 0x0F, 0x1E, 0x00, 0x03,
  0x1E, 0x0F, 0x0F, 0x80, 0x03, 0x8F, 0x87, 0x83, 0xE0, 0x03, 0x83, 0xC7,
  0x80, 0xFC, 0x07, 0xC1, 0xF7, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x71, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x78, 0x00, 0x37,
  0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0x01, 0xE0, 0x3F, 0xDF, 0xFC, 0x38, 0x7F,
  0xF8, 0x7F, 0xF7, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x3D, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x01, 0xF7, 0x80, 0x1E, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1E, 0xF8, 0x07,
  0xF0, 0x07, 0xBE, 0x01, 0xFC, 0x01, 0xEF, 0x00, 0x7F, 0x00, 0x7B, 0xC0,
  0x0F, 0x80, 0x3E, 0xF0, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1F,
  0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xBC, 0x00, 0x00, 0x3F,
  0x9E, 0x00, 0x00, 0x3F, 0x0E, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x3F,
  0x07, 0x80, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x04, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x1F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x40, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x80, 0x00, 0x00, 0xF8, 0x30, 0x00, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFA, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xF8, 0x00, 0x03, 0xC7, 0xFF, 0xE0,
  0x00, 0x71, 0xFF, 0xFE, 0x00, 0x0E, 0x7F, 0xFF, 0xE0, 0x01, 0xDE, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0x78, 0x7F,
  0xFC, 0x01, 0xF3, 0xFF, 0xFE, 0x03, 0xCF, 0xFF, 0xFE, 0x0F, 0x3E, 0x01,
  0xFE, 0x1E, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7C, 0xF6, 0x00, 0x00,
  0x79, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x03, 0xFC,
  0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0x80,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x78,
  0x7C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x07, 0x8F, 0x80,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0xDE, 0x7C, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x1E, 0xF0, 0xFF, 0x00, 0xFB, 0xC0, 0xFF, 0xFF, 0xE7, 0x80, 0xFF, 0xFF,
  0x9E, 0x00, 0x7F, 0xFC, 0x3C, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xFC, 0x0F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF1, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x7E, 0x0E, 0x3C,
  0x00, 0xFF, 0x8F, 0x1E, 0x01, 0xFF, 0xE7, 0x8F, 0x00, 0xFF, 0xFB, 0xC7,
  0x00, 0xFC, 0x1D, 0xC7, 0x80, 0xF8, 0x02, 0xE3, 0xC0, 0x78, 0x00, 0xF1,
  0xE0, 0x78, 0x00, 0x78, 0xE0, 0x3C, 0x00, 0x3C, 0xF0, 0x1C, 0x00, 0x1E,
  0x78, 0x1E, 0x00, 0x0E, 0x3C, 0x0F, 0x00, 0x07, 0x1E, 0x07, 0x80, 0x03,
  0x8F, 0x03, 0x80, 0x03, 0xC7, 0x01, 0xC0, 0x01, 0xE7, 0x81, 0xE0, 0x00,
  0xF3, 0xC0, 0xF0, 0x00, 0x71, 0xE0, 0x78, 0x00, 0x38, 0xF0, 0x3C, 0x00,
  0x3C, 0x78, 0x1E, 0x00, 0x1E, 0x38, 0x0F, 0x00, 0x1F, 0x1C, 0x07, 0x80,
  0x0F, 0x8E, 0x03, 0xC0, 0x0F, 0x87, 0x00, 0xF0, 0x0D, 0xC3, 0x80, 0x7C,
  0x0E, 0xE1, 0xC0, 0x3F, 0xFE, 0xF0, 0xE0, 0x0F, 0xFE, 0x78, 0x70, 0x03,
  0xFE, 0x3C, 0x38, 0x00, 0xFE, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xE0,
  0x00, 0x3F, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x7C, 0x78, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xF8,
  0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x40, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x02, 0x07, 0x80, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x00, 0x78, 0x3E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7E, 0x01,
  0xE0, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xF3, 0xE0, 0x01, 0xFF,
  0xF8, 0xF8, 0x00, 0x7F, 0xFE, 0x3C, 0x00, 0x3F, 0xFF, 0x8F, 0x00, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0D, 0xE0, 0x3F, 0x00, 0x0E,
  0x78, 0x07, 0xF8, 0x0F, 0x9C, 0x00, 0xFF, 0xFF, 0xCF, 0x00, 0x1F, 0xFF,
  0xE3, 0xC0, 0x03, 0xFF, 0xE0, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x04, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x1F,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0xFC, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x3E, 0xF0, 0x00, 0x00, 0x1F, 0x7C,
  0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x78, 0x00, 0x00, 0x1F, 0xF0, 0x7C, 0x00,
  0x00, 0x1F, 0xE0, 0x3C, 0x00, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xF7, 0x00, 0x03,
  0xDE, 0x01, 0xEE, 0x00, 0x07, 0xBC, 0x03, 0x9E, 0x00, 0x1E, 0x78, 0x0F,
  0x3C, 0x00, 0x38, 0xE0, 0x1E, 0x38, 0x00, 0xF1, 0xC0, 0x3C, 0x78, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xE0, 0x1E, 0x1E, 0x01,
  0xC1, 0xC0, 0x38, 0x3C, 0x07, 0x83, 0xC0, 0xF0, 0x70, 0x0F, 0x07, 0x81,
  0xC0, 0xE0, 0x1E, 0x07, 0x07, 0x83, 0xC0, 0x3C, 0x0E, 0x1E, 0x07, 0x80,
  0x78, 0x1E, 0x38, 0x0F, 0x00, 0xE0, 0x3C, 0xF0, 0x1E, 0x03, 0xC0, 0x39,
  0xC0, 0x38, 0x07, 0x80, 0x77, 0x80, 0x70, 0x0F, 0x00, 0xFE, 0x01, 0xE0,
  0x1E, 0x01, 0xF8, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x70, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x07, 0x80, 0x08, 0x00, 0xF0, 0x0F, 0x00, 0x10, 0x01, 0xE0, 0x1E, 0x00,
  0x40, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x00,
  0x03, 0xC0, 0x3F, 0x80, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x1F,
  0xE0, 0x00, 0x07, 0x80, 0xF7, 0x80, 0x00, 0x38, 0x07, 0xBC, 0x00, 0x03,
  0xC0, 0x3D, 0xE0, 0x00, 0x1E, 0x01, 0xC7, 0x00, 0x00, 0xF0, 0x0E, 0x3C,
  0x00, 0x07, 0x80, 0xF1, 0xE0, 0x00, 0x3C, 0x07, 0x8F, 0x00, 0x01, 0xC0,
  0x3C, 0x38, 0x00, 0x1E, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x0E, 0x0F, 0x00,
  0x07, 0x80, 0x70, 0x78, 0x00, 0x3C, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x3C,
  0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x0F, 0x01, 0xC0, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0x3C, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x1C, 0x00, 0x78,
  0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x78,
  0x00, 0x70, 0x3C, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x1C, 0x00, 0x1E, 0x0F,
  0x00, 0xE0, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x78, 0x00,
  0x1E, 0x1C, 0x03, 0xC0, 0x00, 0xF1, 0xE0, 0x1E, 0x00, 0x03, 0x8F, 0x00,
  0xE0, 0x00, 0x1E, 0x78, 0x07, 0x00, 0x00, 0xF3, 0xC0, 0x78, 0x00, 0x07,
  0x9E, 0x03, 0xC0, 0x00, 0x1E, 0xE0, 0x1E, 0x00, 0x00, 0xF7, 0x00, 0xF0,
  0x00, 0x07, 0xF8, 0x07, 0x00, 0x00, 0x1F, 0xC0, 0x38, 0x00, 0x00, 0xFE,
  0x03, 0xC0, 0x00, 0x07, 0xF0, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x1F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x1F,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x7E, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1E, 0xF8, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x10,
  0x00, 0x07, 0xC0, 0x0C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x7E, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x0C, 0x00, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xE0, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x07, 0x00, 0x1F, 0x00, 0x3C, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x1C, 0x00,
  0xFC, 0x00, 0xE0, 0x38, 0x03, 0xF8, 0x03, 0xC0, 0x70, 0x07, 0x70, 0x07,
  0x81, 0xE0, 0x1E, 0xE0, 0x0E, 0x03, 0xC0, 0x3D, 0xC0, 0x1C, 0x07, 0x80,
  0x73, 0x80, 0x78, 0x0F, 0x01, 0xE7, 0x00, 0xF0, 0x1E, 0x03, 0x8F, 0x01,
  0xC0, 0x3C, 0x0F, 0x1E, 0x03, 0x80, 0x78, 0x1C, 0x3C, 0x0F, 0x00, 0xE0,
  0x38, 0x38, 0x1E, 0x01, 0xC0, 0xF0, 0x70, 0x38, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x07, 0x07, 0x81, 0xC1, 0xE0, 0x0E, 0x0E, 0x03, 0x83, 0xC0, 0x3C,
  0x1C, 0x07, 0x07, 0x00, 0x78, 0x78, 0x0E, 0x0E, 0x00, 0xF0, 0xE0, 0x1C,
  0x3C, 0x01, 0xE3, 0xC0, 0x38, 0x78, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x07,
  0x9E, 0x00, 0xF1, 0xC0, 0x0E, 0x3C, 0x01, 0xE7, 0x80, 0x1C, 0x70, 0x03,
  0xCF, 0x00, 0x39, 0xE0, 0x07, 0x9C, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00,
  0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x1D, 0xE0, 0x07, 0xB8, 0x00,
  0x3B, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00, 0x0F, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x00, 0x71, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x00, 0xF2, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x10, 0x70, 0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0E,
  0x0F, 0x07, 0x06, 0x00, 0x07, 0xF8, 0x07, 0x80, 0x1F, 0xFF, 0x03, 0x80,
  0x1F, 0xFF, 0xC3, 0xC0, 0x1F, 0xFF, 0xF1, 0xE0, 0x1F, 0xC0, 0x7C, 0xF0,
  0x1F, 0x80, 0x07, 0x78, 0x1F, 0x00, 0x01, 0xBC, 0x1F, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0xE1, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x37, 0x81, 0xF0, 0x00, 0x33, 0xC0, 0x7C,
  0x00, 0x79, 0xC0, 0x3F, 0x80, 0xF9, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0x83,
  0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x7F, 0x80, 0x03, 0xC0, 0xFF, 0xF0, 0x01, 0xE1,
  0xFF, 0xFC, 0x00, 0xF1, 0xFF, 0xFF, 0x00, 0x79, 0xF0, 0x1F, 0xC0, 0x79,
  0xE0, 0x03, 0xE0, 0x3C, 0xC0, 0x00, 0xF8, 0x1E, 0xC0, 0x00, 0x3C, 0x0F,
  0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x0F, 0x83, 0xD8, 0x00, 0x0F, 0x81, 0xEE, 0x00,
  0x1F, 0xC0, 0xF3, 0xE0, 0x3F, 0xC0, 0x78, 0xFF, 0xFF, 0xC0, 0x3C, 0x3F,
  0xFF, 0x80, 0x3C, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x61, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x21, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0x80, 0x78, 0x00, 0x1F, 0xFE, 0x07, 0x80, 0x07,
  0xFF, 0xF8, 0x78, 0x00, 0xFF, 0xFF, 0xC7, 0x00, 0x1F, 0xC0, 0x3C, 0x70,
  0x03, 0xF0, 0x00, 0xEF, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0xEF, 0x00, 0x3E, 0x00, 0x1C,
  0xF0, 0x01, 0xF8, 0x0F, 0x8F, 0x00, 0x1F, 0xFF, 0xF0, 0xE0, 0x00, 0xFF,
  0xFE, 0x1E, 0x00, 0x03, 0xFF, 0xC1, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3E, 0x3C, 0x00,
  0x01, 0xF8, 0x78, 0x00, 0x1F, 0xE0, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x21, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xC0, 0x07, 0xFF, 0xC0, 0xF0,
  0x03, 0xFF, 0xFC, 0x3C, 0x01, 0xFF, 0xFF, 0x8E, 0x00, 0xFE, 0x01, 0xE7,
  0x80, 0x7E, 0x00, 0x1D, 0xE0, 0x3E, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x00,
  0x7E, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0xF0, 0x00,
  0x06, 0xF0, 0x3E, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x01, 0xDE, 0x01, 0xF8,
  0x00, 0xE7, 0x80, 0x3F, 0x81, 0xF1, 0xE0, 0x0F, 0xFF, 0xFC, 0x78, 0x01,
  0xFF, 0xFC, 0x1E, 0x00, 0x1F, 0xFE, 0x0F, 0x00, 0x01, 0xFC, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x80, 0x00, 0x1F, 0x00, 0x70, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x1F, 0xC0, 0x03, 0xC1, 0xFF, 0xC0, 0x1E, 0x0F, 0xFF, 0xC0,
  0x78, 0x7F, 0xFF, 0x01, 0xE3, 0xC0, 0xFE, 0x07, 0x9C, 0x00, 0xFC, 0x1E,
  0xE0, 0x01, 0xF0, 0x7B, 0x00, 0x03, 0xC3, 0xF8, 0x00, 0x0F, 0x0F, 0x40,
  0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x38, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x40, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0xFC, 0x01, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x7E, 0x00, 0x1E, 0x03,
  0xF0, 0x00, 0x70, 0x3F, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x0F, 0x0F, 0xC0,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x03, 0xC0,
  0x0F, 0x80, 0x07, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x1F, 0x80, 0x3C, 0x00,
  0x1F, 0x80, 0x78, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x1F, 0x81, 0xE0, 0x00,
  0x1F, 0x83, 0x80, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x1F, 0x9E, 0x00, 0x00,
  0x1F, 0xBC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0xFE, 0x00, 0x07, 0x81, 0xFF, 0xE0, 0x01, 0xE0, 0xFF, 0xFC, 0x00,
  0x78, 0xFF, 0xFF, 0x80, 0x1E, 0x7C, 0x07, 0xF0, 0x07, 0x9C, 0x00, 0x7C,
  0x01, 0xEE, 0x00, 0x0F, 0x00, 0xF7, 0x00, 0x03, 0xC0, 0x3D, 0x80, 0x00,
  0xF0, 0x0F, 0xC0, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x1E,
  0x00, 0x1F, 0x80, 0x07, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x7F, 0xC0, 0x00,
  0xF0, 0x7F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x02, 0x78, 0x07, 0x80,
  0x03, 0xDE, 0x00, 0xF0, 0x01, 0xF7, 0x80, 0x3C, 0x00, 0xFD, 0xE0, 0x07,
  0x80, 0x7C, 0x78, 0x01, 0xE0, 0x3E, 0x1C, 0x00, 0x3C, 0x1F, 0x0F, 0x00,
  0x0F, 0x0F, 0x83, 0xC0, 0x01, 0xE7, 0xC0, 0xF0, 0x00, 0x7F, 0xE0, 0x3C,
  0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x04, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0xF8,
  0x1E, 0x00, 0x3F, 0x03, 0xC0, 0x1F, 0x80, 0x78, 0x07, 0xE0, 0x0E, 0x01,
  0xF8, 0x03, 0xC0, 0xFC, 0x00, 0x78, 0x3F, 0x00, 0x0F, 0x0F, 0xC0, 0x01,
  0xE7, 0xF0, 0x00, 0x39, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x0F,
  0xC0, 0x3C, 0x7F, 0xC1, 0xFF, 0x01, 0xE7, 0xFE, 0x1F, 0xFC, 0x0F, 0x7F,
  0xF9, 0xFF, 0xF0, 0x7B, 0x87, 0xCE, 0x0F, 0x83, 0xB0, 0x1E, 0xE0, 0x3C,
  0x1D, 0x00, 0x76, 0x01, 0xE1, 0xF8, 0x03, 0xE0, 0x0F, 0x0F, 0x80, 0x1E,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0xE0, 0x03, 0xC0, 0x07, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x78, 0x00, 0xF0, 0x01, 0xC3, 0xC0, 0x07, 0x00, 0x1E, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x00, 0x38,
  0x78, 0x00, 0xF0, 0x01, 0xC3, 0xC0, 0x07, 0x80, 0x0E, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0xF0, 0x01, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x00, 0x3C, 0x38,
  0x00, 0xF0, 0x01, 0xC3, 0xC0, 0x07, 0x80, 0x0E, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0xF0, 0x01, 0xC0, 0x07, 0x87, 0x80, 0x0E, 0x00, 0x3C, 0x38, 0x00,
  0xF0, 0x01, 0xE1, 0xC0, 0x07, 0x80, 0x0E, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0xF0, 0x01, 0xC0, 0x07, 0x87, 0x80, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x70,
  0x01, 0xE1, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x7F, 0x00, 0x1E,
  0x07, 0xFF, 0x00, 0x78, 0x3F, 0xFF, 0x01, 0xE1, 0xFF, 0xFC, 0x07, 0x8F,
  0x03, 0xF8, 0x1E, 0x70, 0x03, 0xF0, 0x7B, 0x80, 0x07, 0xC1, 0xEC, 0x00,
  0x0F, 0x0F, 0x60, 0x00, 0x3C, 0x3D, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xF0, 0x0F, 0xF0, 0x00, 0x1E, 0x07, 0xFF, 0x80, 0x03,
  0xC3, 0xFF, 0xF8, 0x00, 0x78, 0xFF, 0xFF, 0x80, 0x0F, 0x3E, 0x03, 0xF8,
  0x03, 0xCF, 0x00, 0x1F, 0x00, 0x79, 0x80, 0x01, 0xF0, 0x0F, 0x60, 0x00,
  0x1E, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0x7C, 0x07, 0xB0, 0x00, 0x1F, 0x00, 0xF7, 0x00, 0x0F, 0xE0, 0x1E, 0x7C,
  0x07, 0xF8, 0x03, 0xC7, 0xFF, 0xFE, 0x00, 0x78, 0x7F, 0xFF, 0x00, 0x1E,
  0x07, 0xFF, 0xC0, 0x03, 0xC0, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x07, 0x80, 0x0F, 0xFF,
  0x03, 0xC0, 0x1F, 0xFF, 0xE1, 0xE0, 0x1F, 0xFF, 0xF8, 0xE0, 0x1F, 0xC0,
  0x3C, 0xF0, 0x1F, 0x80, 0x07, 0x78, 0x1F, 0x00, 0x01, 0xFC, 0x1F, 0x00,
  0x00, 0x7E, 0x0F, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x1F,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x37, 0x81, 0xF0, 0x00, 0x3B,
  0xC0, 0x7C, 0x00, 0x39, 0xE0, 0x1F, 0x80, 0xF8, 0xF0, 0x0F, 0xFF, 0xF8,
  0x70, 0x03, 0xFF, 0xF8, 0x78, 0x00, 0x7F, 0xF8, 0x3C, 0x00, 0x0F, 0xE0,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xE0, 0x01, 0xC7, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x00, 0x7B, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0x80,
  0x01, 0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0C, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x82, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x0F, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x07, 0xE0, 0x03,
  0xC0, 0x0F, 0xE0, 0x01, 0xE0, 0x0F, 0xC0, 0x00, 0xF0, 0x1F, 0xC0, 0x00,
  0x78, 0x3F, 0x80, 0x00, 0x78, 0x3F, 0x80, 0x00, 0x3C, 0x7F, 0x00, 0x00,
  0x1E, 0x7F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7E, 0x0F, 0x00, 0x01,
  0xBC, 0x1F, 0x00, 0x03, 0x78, 0x1E, 0x00, 0x0C, 0xF0, 0x3E, 0x00, 0x73,
  0xC0, 0x7F, 0x03, 0xE7, 0x80, 0x7F, 0xFF, 0x8F, 0x00, 0x7F, 0xFE, 0x1E,
  0x00, 0x7F, 0xF8, 0x3C, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0C, 0xFF, 0xF0, 0x00, 0x3E, 0xFF, 0xF0, 0x00, 0x1E, 0xFF, 0xF0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3E, 0x03, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x78, 0x07, 0x80, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x01,
  0xF0, 0x07, 0x80, 0x03, 0xE0, 0x07, 0x00, 0x07, 0xC0, 0x07, 0x00, 0x0F,
  0x80, 0x0F, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x7F, 0x00, 0x0F, 0x01, 0xFC,
  0x00, 0x0F, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x1C,
  0x01, 0x81, 0xE0, 0x07, 0x80, 0x78, 0x38, 0x00, 0xF0, 0x0F, 0x07, 0x00,
  0x1E, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0x1C, 0x3C, 0x00, 0x70, 0x03, 0xC7,
  0x80, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC0, 0x0F, 0x1C, 0x00, 0x78, 0x01,
  0xE3, 0x80, 0x0F, 0x00, 0x1C, 0x70, 0x01, 0xC0, 0x03, 0x9E, 0x00, 0x38,
  0x00, 0x73, 0xC0, 0x07, 0x00, 0x0E, 0x78, 0x01, 0xE0, 0x01, 0xCE, 0x00,
  0x3C, 0x00, 0x79, 0xC0, 0x07, 0x80, 0x0F, 0x38, 0x00, 0xE0, 0x01, 0xEF,
  0x00, 0x1C, 0x00, 0x3D, 0xE0, 0x03, 0x80, 0x07, 0xBC, 0x00, 0xF0, 0x00,
  0xE7, 0x00, 0x1E, 0x00, 0x1C, 0xE0, 0x03, 0xC0, 0x07, 0x9C, 0x00, 0x70,
  0x00, 0xF3, 0x80, 0x0E, 0x00, 0x1E, 0xF0, 0x03, 0xC0, 0x07, 0x9E, 0x00,
  0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x00, 0x1E, 0x70, 0x01, 0xE0, 0x07, 0x8E,
  0x00, 0x7C, 0x00, 0xF1, 0xE0, 0x0F, 0x80, 0x3C, 0x3C, 0x03, 0x70, 0x0F,
  0x87, 0x80, 0xEF, 0x03, 0xE0, 0xF8, 0x79, 0xF0, 0xFC, 0x1F, 0xFE, 0x3F,
  0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x01,
  0xFC, 0xF0, 0x78, 0x3E, 0x03, 0xF0, 0xF0, 0xF0, 0x1E, 0x0F, 0xC0, 0x78,
  0xE0, 0x1E, 0x1F, 0x80, 0x79, 0xC0, 0x0F, 0x3E, 0x00, 0x79, 0x80, 0x0F,
  0x18, 0x00, 0x3B, 0x80, 0x0F, 0x00, 0x00, 0x3B, 0x00, 0x0F, 0x00, 0x00,
  0x3B, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00,
  0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x01, 0xDC, 0x00, 0x10, 0xF0, 0x01, 0x9C, 0x00, 0x70, 0xF0,
  0x03, 0x9C, 0x00, 0xF8, 0xF0, 0x03, 0x1E, 0x03, 0xF0, 0xF0, 0x07, 0x1E,
  0x07, 0xC0, 0xF8, 0x0F, 0x1E, 0x1F, 0x80, 0x7C, 0x3E, 0x1F, 0x3F, 0x00,
  0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x5E, 0x00, 0xF8,
  0x00, 0x1B, 0xC0, 0x0F, 0x00, 0x06, 0x78, 0x01, 0xF0, 0x03, 0xCF, 0x00,
  0x3F, 0x81, 0xF3, 0xC0, 0x03, 0xFF, 0xFC, 0x78, 0x00, 0x3F, 0xFF, 0x0F,
  0x00, 0x03, 0xFF, 0xC1, 0xE0, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x10, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x7F, 0xFF, 0x00,
  0xF0, 0x3F, 0xFF, 0xF8, 0x3C, 0x1F, 0xFF, 0xFF, 0x8F, 0x07, 0xC0, 0x7F,
  0xFF, 0xC3, 0xE0, 0x01, 0xFF, 0xE0, 0xF0, 0x00, 0x0F, 0xF8, 0x38, 0x00,
  0x00, 0xFC, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0x80, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xF0,
  0x00, 0x38, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x00, 0x70, 0x3E, 0x00, 0x00, 0x1C, 0x1F, 0xF0, 0x00, 0x07, 0x8F,
  0xFF, 0xE0, 0x01, 0xE3, 0xFF, 0xFF, 0xC0, 0x78, 0xF0, 0xFF, 0xFF, 0x8E,
  0x3C, 0x03, 0xFF, 0xFF, 0x8F, 0x00, 0x0F, 0xFF, 0xE3, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x60, 0x1F, 0xF0, 0x00, 0x07, 0x03, 0xFF, 0x80, 0x00,
  0xF0, 0x7F, 0xFC, 0x00, 0x0E, 0x0F, 0xC7, 0xE0, 0x01, 0xE0, 0xF0, 0x1F,
  0x00, 0x1C, 0x1E, 0x01, 0xF0, 0x03, 0xC1, 0xC0, 0x0F, 0x80, 0x78, 0x3C,
  0x00, 0x7C, 0x0F, 0x83, 0x80, 0x03, 0xE1, 0xF0, 0x78, 0x00, 0x3F, 0xFE,
  0x07, 0x00, 0x01, 0xFF, 0xC0, 0x70, 0x00, 0x0F, 0xF8, 0x0B, 0x00, 0x00,
  0x3E, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 14, 48, 41, 14, -48 },
  { 85, 18, 18, 41, 16, -51 },
  { 126, 42, 48, 41, 1, -48 },
  { 378, 38, 64, 41, 2, -56 },
  { 682, 46, 50, 41, -1, -49 },
  { 970, 41, 50, 41, 0, -49 },
  { 1227, 7, 18, 41, 21, -51 },
  { 1243, 24, 62, 41, 15, -52 },
  { 1429, 24, 62, 41, 4, -52 },
  { 1615, 35, 34, 41, 4, -38 },
  { 1764, 33, 34, 41, 5, -38 },
  { 1905, 13, 19, 41, 10, -8 },
  { 1936, 20, 4, 41, 11, -23 },
  { 1946, 8, 7, 41, 14, -7 },
  { 1953, 38, 62, 41, 2, -52 },
  { 2248, 34, 50, 41, 5, -49 },
  { 2461, 33, 48, 41, 3, -48 },
  { 2659, 36, 49, 41, 2, -49 },
  { 2880, 35, 50, 41, 2, -49 },
  { 3099, 37, 48, 41, 1, -48 },
  { 3321, 35, 49, 41, 4, -48 },
  { 3536, 31, 49, 41, 5, -48 },
  { 3726, 33, 48, 41, 8, -48 },
  { 3924, 36, 50, 41, 3, -49 },
  { 4149, 31, 49, 41, 7, -49 },
  { 4339, 13, 36, 41, 14, -36 },
  { 4398, 17, 47, 41, 10, -36 },
  { 4498, 33, 39, 41, 6, -41 },
  { 4659, 35, 17, 41, 4, -30 },
  { 4734, 33, 39, 41, 3, -41 },
  { 4895, 29, 49, 41, 9, -49 },
  { 5073, 33, 57, 41, 5, -49 },
  { 5309, 36, 48, 41, 0, -48 },
  { 5525, 34, 48, 41, 4, -48 },
  { 5729, 33, 50, 41, 6, -49 },
  { 5936, 35, 48, 41, 4, -48 },
  { 6146, 37, 48, 41, 4, -48 },
  { 6368, 37, 48, 41, 4, -48 },
  { 6590, 34, 50, 41, 5, -49 },
  { 6803, 37, 48, 41, 3, -48 },
  { 7025, 38, 48, 41, 3, -48 },
  { 7253, 34, 49, 41, 4, -48 },
  { 7462, 40, 48, 41, 4, -48 },
  { 7702, 28, 48, 41, 6, -48 },
  { 7870, 39, 48, 41, 2, -48 },
  { 8104, 37, 48, 41, 3, -48 },
  { 8326, 34, 50, 41, 5, -49 },
  { 8539, 36, 48, 41, 4, -48 },
  { 8755, 34, 62, 41, 5, -49 },
  { 9019, 36, 48, 41, 4, -48 },
  { 9235, 38, 50, 41, 2, -49 },
  { 9473, 37, 48, 41, 7, -48 },
  { 9695, 35, 49, 41, 5, -48 },
  { 9910, 35, 48, 41, 8, -48 },
  { 10120, 39, 48, 41, 4, -48 },
  { 10354, 44, 48, 41, 0, -48 },
  { 10618, 39, 48, 41, 6, -48 },
  { 10852, 42, 48, 41, 0, -48 },
  { 11104, 28, 62, 41, 12, -52 },
  { 11321, 17, 62, 41, 13, -52 },
  { 11453, 29, 62, 41, 1, -52 },
  { 11678, 34, 27, 41, 5, -48 },
  { 11793, 33, 4, 41, 0, 7 },
  { 11810, 8, 13, 41, 16, -54 },
  { 11823, 33, 37, 41, 4, -36 },
  { 11976, 33, 52, 41, 4, -51 },
  { 12191, 30, 37, 41, 5, -36 },
  { 12330, 36, 52, 41, 4, -51 },
  { 12564, 31, 37, 41, 5, -36 },
  { 12708, 44, 66, 41, -1, -51 },
  { 13071, 34, 51, 41, 3, -36 },
  { 13288, 30, 51, 41, 5, -51 },
  { 13480, 30, 53, 41, 6, -52 },
  { 13679, 31, 67, 41, 5, -52 },
  { 13939, 34, 52, 41, 5, -51 },
  { 14160, 27, 52, 41, 8, -51 },
  { 14336, 37, 36, 41, 2, -36 },
  { 14503, 30, 36, 41, 5, -36 },
  { 14638, 32, 37, 41, 5, -36 },
  { 14786, 35, 50, 41, 2, -36 },
  { 15005, 33, 50, 41, 4, -36 },
  { 15212, 33, 36, 41, 8, -36 },
  { 15361, 33, 37, 41, 4, -36 },
  { 15514, 33, 49, 41, 5, -48 },
  { 15717, 31, 37, 41, 6, -36 },
  { 15861, 32, 36, 41, 5, -36 },
  { 16005, 35, 37, 41, 4, -36 },
  { 16167, 40, 37, 41, 1, -36 },
  { 16352, 35, 51, 41, 2, -36 },
  { 16576, 34, 37, 41, 4, -36 },
  { 16734, 32, 62, 41, 8, -52 },
  { 16982, 14, 62, 41, 14, -52 },
  { 17091, 32, 62, 41, 3, -52 },
  { 17339, 36, 14, 41, 3, -28 },
};

const GFXfont IBMPlexMono_LightItalic69pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic69pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic69pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _IBMPLEXMONO_LIGHTITALIC69PT7B_H_
