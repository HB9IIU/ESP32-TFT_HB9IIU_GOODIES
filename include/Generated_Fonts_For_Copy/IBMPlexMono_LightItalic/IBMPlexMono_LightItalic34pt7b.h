#ifndef _IBMPLEXMONO_LIGHTITALIC34PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0x81,
  0x02, 0x04, 0x10, 0x00, 0x00, 0x00, 0x07, 0x1E, 0x3C, 0x70, 0x61, 0xB1,
  0x98, 0xCC, 0x64, 0x36, 0x1B, 0x09, 0x8C, 0xC6, 0x00, 0x00, 0x30, 0xC0,
  0x06, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x10, 0x00, 0xC3, 0x00, 0x0C, 0x30,
  0x01, 0x82, 0x03, 0xF8, 0x7F, 0x3F, 0x87, 0xF0, 0x10, 0x40, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x02, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x18, 0x0F, 0xC1,
  0xFC, 0xFC, 0x3F, 0x80, 0xC3, 0x00, 0x08, 0x30, 0x01, 0x86, 0x00, 0x18,
  0x60, 0x01, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1E, 0x67, 0x83,
  0x0C, 0x30, 0xC1, 0x83, 0x18, 0x20, 0x03, 0x04, 0x00, 0x60, 0x80, 0x0C,
  0x30, 0x01, 0xC6, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x4F, 0x00, 0x18, 0x60, 0x03, 0x0E, 0x00, 0x60, 0xC0, 0x08, 0x19, 0x01,
  0x07, 0x30, 0x20, 0xC7, 0x0C, 0x38, 0x79, 0x9E, 0x03, 0xFF, 0x80, 0x1F,
  0xC0, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x06,
  0x0F, 0xE0, 0x18, 0x18, 0x60, 0x20, 0x60, 0x40, 0xC0, 0xC0, 0x83, 0x03,
  0x01, 0x0C, 0x06, 0x06, 0x10, 0x0C, 0x0C, 0x60, 0x18, 0x19, 0x80, 0x18,
  0x66, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xFC, 0x00, 0x67, 0x0C, 0x01, 0x8C, 0x18, 0x03, 0x30, 0x10, 0x0C, 0x60,
  0x60, 0x30, 0xC0, 0xC0, 0x41, 0x81, 0x81, 0x83, 0x06, 0x06, 0x07, 0x1C,
  0x18, 0x07, 0xF0, 0x60, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03,
  0x87, 0x00, 0x70, 0x30, 0x06, 0x03, 0x00, 0x60, 0x10, 0x06, 0x03, 0x00,
  0x60, 0x30, 0x03, 0x03, 0x00, 0x30, 0x60, 0x01, 0x8E, 0x00, 0xFB, 0xC0,
  0x38, 0xF0, 0x07, 0x0C, 0x00, 0x60, 0x60, 0x0E, 0x06, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0xC0, 0x18, 0x3C, 0x02, 0xC6, 0x60, 0x2C, 0x67, 0x0C,
  0x6C, 0x3F, 0xC7, 0xC1, 0xF0, 0x38, 0x33, 0x26, 0x66, 0x66, 0xC0, 0x00,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x04, 0x06, 0x07, 0xC3, 0x0E,
  0xFD, 0x7E, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xCC, 0x00, 0xC6,
  0x00, 0xC1, 0x80, 0xE0, 0xC0, 0xE0, 0x30, 0x20, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1C, 0x73, 0x8E, 0x31,
  0xC6, 0x10, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8,
  0x01, 0xFF, 0x01, 0xC1, 0xC1, 0x80, 0x61, 0x80, 0x19, 0xC0, 0x0C, 0xC0,
  0x06, 0x60, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x38, 0x3E,
  0x1C, 0x1E, 0x0E, 0x1F, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x03,
  0x30, 0x01, 0x8C, 0x01, 0x86, 0x01, 0xC1, 0xC1, 0xC0, 0xFF, 0xC0, 0x1F,
  0x80, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0x30, 0x0E, 0x30, 0x1C,
  0x30, 0x38, 0x20, 0x30, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x78, 0x38, 0x06, 0x0C, 0x01,
  0x86, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0x81,
  0xC1, 0xE1, 0xC0, 0x30, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC8,
  0x00, 0xCE, 0x00, 0xE3, 0xC1, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x06, 0x30, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x18,
  0x18, 0x0C, 0x06, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x30, 0x40, 0x0C,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0xF8, 0x0D, 0xFF, 0x07, 0x83, 0xC3, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x98, 0x01, 0xCE, 0x01,
  0xC3, 0x81, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x39, 0xF0, 0x37, 0xFC, 0x7C, 0x0E, 0x78, 0x06, 0x70, 0x03, 0x60,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0x60, 0x06, 0x60,
  0x0C, 0x78, 0x38, 0x3F, 0xF0, 0x0F, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0xC0,
  0x07, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83,
  0x81, 0xC3, 0x80, 0x31, 0x80, 0x19, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03,
  0x18, 0x03, 0x0E, 0x07, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xC1, 0xC3, 0x80,
  0x31, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x01, 0xD8,
  0x00, 0xCE, 0x00, 0xE3, 0x81, 0xE0, 0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xF0,
  0x0F, 0xFC, 0x1C, 0x0E, 0x30, 0x06, 0x70, 0x03, 0x60, 0x03, 0x60, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x78, 0x36,
  0x3F, 0xEC, 0x0F, 0x8C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1C, 0x73,
  0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3C, 0xF3, 0x80,
  0x07, 0x07, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x60, 0x40, 0xC0, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x08, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x3E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x07,
  0xC0, 0x7F, 0xC3, 0x83, 0x98, 0x06, 0xC0, 0x1F, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x01, 0xF0, 0x0F, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x01, 0xC1, 0xC1,
  0x80, 0x61, 0xC0, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x60, 0xF3, 0x30, 0xFD,
  0x90, 0xE2, 0x98, 0x60, 0xCC, 0x60, 0x66, 0x30, 0x33, 0x18, 0x19, 0x88,
  0x0C, 0x8C, 0x04, 0xC6, 0x06, 0x63, 0x03, 0x30, 0xC3, 0x98, 0x7E, 0xCC,
  0x1E, 0x66, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x40,
  0x00, 0xD8, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01,
  0x86, 0x00, 0x60, 0x80, 0x30, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xE0, 0x30, 0x3F, 0xFC, 0x1F, 0xFF, 0x86, 0x00, 0x61, 0x80, 0x18,
  0xC0, 0x06, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x07, 0x0F,
  0xFC, 0x0F, 0xFF, 0x06, 0x01, 0xC3, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x0C,
  0x60, 0x0E, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x8C, 0x03, 0x87, 0xFF,
  0x03, 0xFF, 0xC3, 0x80, 0x71, 0x80, 0x18, 0xC0, 0x06, 0x60, 0x03, 0x30,
  0x01, 0x98, 0x01, 0xD8, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0xE3, 0xFF, 0xE1,
  0xFF, 0xC0, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x03, 0x18, 0x03,
  0x30, 0x01, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x04, 0xC0, 0x0E, 0xC0, 0x0C, 0x60, 0x18, 0x70, 0x70, 0x3F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0x03, 0x83, 0x00, 0x61, 0x80,
  0x38, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x1C, 0xC0, 0x0C, 0xC0, 0x06,
  0x60, 0x03, 0x30, 0x03, 0x98, 0x01, 0x8C, 0x01, 0xC6, 0x01, 0xC6, 0x03,
  0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF1, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x1C,
  0x07, 0x38, 0x03, 0x30, 0x03, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFE, 0xC0, 0xFE, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xE0, 0x2C, 0x70,
  0x6C, 0x3F, 0xC8, 0x1F, 0x18, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x18,
  0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30,
  0x03, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0xFF, 0xFC, 0x7F, 0xFF, 0x18, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x10, 0x06,
  0x18, 0x03, 0x06, 0x03, 0x83, 0x83, 0x80, 0xFF, 0x80, 0x1F, 0x00, 0x0C,
  0x00, 0x71, 0x80, 0x1C, 0x18, 0x03, 0x81, 0x80, 0x70, 0x18, 0x0E, 0x01,
  0x81, 0xC0, 0x18, 0x38, 0x03, 0x07, 0x00, 0x30, 0xE0, 0x03, 0x1C, 0x00,
  0x33, 0x80, 0x03, 0x7C, 0x00, 0x3E, 0xC0, 0x07, 0xC6, 0x00, 0x78, 0x60,
  0x07, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x80, 0x60, 0x18, 0x0E, 0x01,
  0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07,
  0x8D, 0x00, 0xF1, 0xB0, 0x36, 0x36, 0x0C, 0x86, 0xC1, 0xB0, 0xC8, 0x66,
  0x11, 0x8C, 0xC6, 0x33, 0x18, 0xC2, 0xC3, 0x18, 0x78, 0x43, 0x0E, 0x18,
  0x61, 0xC3, 0x08, 0x10, 0x63, 0x04, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x21,
  0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6,
  0x00, 0x10, 0x1E, 0x00, 0xC7, 0x80, 0x31, 0xE0, 0x08, 0x78, 0x06, 0x1B,
  0x01, 0x84, 0xC0, 0x63, 0x30, 0x18, 0xC4, 0x06, 0x31, 0x81, 0x8C, 0x60,
  0xC3, 0x18, 0x30, 0x83, 0x0C, 0x60, 0xC3, 0x18, 0x30, 0xC6, 0x0C, 0x31,
  0x81, 0x98, 0x60, 0x66, 0x10, 0x19, 0x8C, 0x02, 0x63, 0x00, 0xD8, 0xC0,
  0x36, 0x30, 0x0D, 0x0C, 0x01, 0xC2, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xFF,
  0x01, 0xC1, 0xC1, 0x80, 0x61, 0x80, 0x19, 0xC0, 0x0C, 0xC0, 0x06, 0x60,
  0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x03, 0x30, 0x01,
  0x8C, 0x01, 0x86, 0x01, 0xC1, 0xC1, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x0F,
  0xFE, 0x03, 0xFF, 0xC1, 0x80, 0x38, 0x60, 0x06, 0x18, 0x00, 0xC6, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x07, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x38,
  0xC0, 0x1C, 0x3F, 0xFE, 0x0F, 0xFE, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC1, 0xC1,
  0x80, 0x61, 0x80, 0x19, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x03, 0x30, 0x01, 0x8C, 0x01, 0x86,
  0x01, 0xC3, 0xC1, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x03, 0x80, 0x00, 0xC1,
  0x80, 0x31, 0xC0, 0x1D, 0xC0, 0x07, 0xC0, 0x01, 0x80, 0x0F, 0xFE, 0x03,
  0xFF, 0xC1, 0x80, 0x38, 0x60, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x07, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x38, 0xC0, 0x1C,
  0x3F, 0xFE, 0x0F, 0xFE, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x60, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0xC0, 0x18, 0x30, 0x07, 0x0C, 0x00,
  0xC3, 0x00, 0x38, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3C, 0x0E, 0x06, 0x00,
  0x61, 0x80, 0x06, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x31, 0x00, 0x0E,
  0x60, 0x01, 0x86, 0x00, 0x70, 0xF0, 0x3C, 0x07, 0xFF, 0x00, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x30, 0x01, 0x98,
  0x00, 0xCC, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x19, 0x80, 0x0C,
  0xC0, 0x06, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xCC, 0x00,
  0x66, 0x00, 0x33, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30,
  0x07, 0x18, 0x03, 0x0C, 0x03, 0x87, 0x03, 0x81, 0xFF, 0x80, 0x3F, 0x80,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xD8, 0x00, 0x64, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x04,
  0x06, 0x03, 0x07, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x61, 0x80, 0x30, 0xC0,
  0x18, 0xC0, 0x04, 0x60, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x90, 0x00,
  0x32, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x07, 0x06, 0x60, 0xE1,
  0x8C, 0x3C, 0x31, 0x87, 0x86, 0x31, 0xB0, 0xC6, 0x32, 0x30, 0xC4, 0x46,
  0x19, 0x88, 0xC2, 0x31, 0x18, 0x4C, 0x26, 0x09, 0x86, 0xC3, 0x20, 0xD8,
  0x6C, 0x1B, 0x0D, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x01, 0xE0,
  0x0C, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0x60, 0x07, 0x00, 0xC0, 0x38, 0x03,
  0x00, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x31, 0x80, 0x00, 0xCE,
  0x00, 0x01, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0xE0, 0x60, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x0E,
  0x06, 0x00, 0x18, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xEC, 0x00, 0x19, 0x80,
  0x06, 0x18, 0x01, 0x83, 0x00, 0x70, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xE0,
  0xC0, 0x0C, 0x38, 0x01, 0x8E, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x60, 0x30, 0x08,
  0x04, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x01, 0x00, 0x80,
  0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C, 0x06,
  0x07, 0xFC, 0x1F, 0xE0, 0x80, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x83, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x36, 0x00, 0x33, 0x00, 0x30, 0xC0, 0x18, 0x60, 0x18, 0x18, 0x18, 0x0C,
  0x18, 0x06, 0x0C, 0x01, 0x8C, 0x00, 0xCC, 0x00, 0x3E, 0x00, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCC, 0x66, 0x33, 0x03, 0xE3, 0x0F, 0xF3, 0x1C, 0x1B,
  0x38, 0x0A, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0x60, 0x2C,
  0x70, 0x6C, 0x3F, 0xCF, 0x1F, 0x0F, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0xF8, 0x19, 0xFE,
  0x1B, 0x0E, 0x1C, 0x07, 0x38, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x20, 0x03, 0x60, 0x03, 0x60, 0x07, 0x60, 0x06, 0x60, 0x0E,
  0x70, 0x0C, 0x58, 0x38, 0xCF, 0xF0, 0xC7, 0xE0, 0x03, 0xE0, 0x3F, 0xE1,
  0xC1, 0x8C, 0x03, 0x60, 0x05, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0x00, 0x6E, 0x03, 0x1C, 0x18,
  0x3F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x07, 0xC6, 0x0F, 0xF3, 0x0E,
  0x0D, 0x8E, 0x01, 0xC6, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x19,
  0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x01,
  0xC3, 0x01, 0x61, 0xC1, 0xB0, 0x7F, 0x98, 0x1F, 0x18, 0x00, 0x03, 0xF0,
  0x1F, 0xF8, 0x70, 0x71, 0x80, 0x36, 0x00, 0x68, 0x01, 0xF0, 0x07, 0x60,
  0x7C, 0xFF, 0xE1, 0xFC, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xD8, 0x01,
  0xB8, 0x06, 0x38, 0x38, 0x3F, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x40, 0x60, 0x01, 0x81, 0x80, 0x0F, 0x06, 0x00, 0x0E, 0x18,
  0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xF1, 0x83, 0xFC, 0xC3, 0x83, 0x63, 0x80, 0x71, 0x80, 0x31, 0x80,
  0x18, 0xC0, 0x0C, 0x60, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0xC6, 0x00, 0x63, 0x00, 0x70, 0xC0, 0x58, 0x70, 0x6C, 0x1F, 0xE6,
  0x07, 0xC6, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC2, 0x00, 0xC3, 0x81,
  0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x7C, 0x19, 0xFC, 0x36,
  0x1C, 0x70, 0x18, 0xE0, 0x33, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x03,
  0x30, 0x06, 0x60, 0x0D, 0x80, 0x13, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x30, 0x06, 0xC0, 0x18, 0x00, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x08, 0x18, 0x38, 0x60, 0xE0, 0xC7, 0x01, 0x9C, 0x03, 0x70,
  0x07, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC1, 0x01, 0x83, 0x03, 0x03, 0x06, 0x03, 0x0C, 0x03, 0x18,
  0x03, 0x60, 0x03, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x31, 0xF0, 0x19,
  0xFE, 0x0D, 0x87, 0x07, 0x01, 0x82, 0x80, 0x43, 0x80, 0x61, 0x80, 0x30,
  0xC0, 0x30, 0x60, 0x70, 0x31, 0xE0, 0x11, 0x80, 0x18, 0x40, 0x0C, 0x30,
  0x36, 0x0C, 0x3B, 0x06, 0x39, 0x81, 0xB8, 0x80, 0xF8, 0xC0, 0x30, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x46, 0x06, 0x30, 0xE1, 0x8E, 0x18, 0xE0,
  0xDC, 0x07, 0xC0, 0x1C, 0x00, 0x1B, 0xC7, 0x8D, 0xFB, 0xF3, 0x46, 0x8C,
  0xE1, 0xC3, 0x30, 0x60, 0xCC, 0x18, 0x33, 0x06, 0x0D, 0x81, 0x83, 0x60,
  0x40, 0xD8, 0x30, 0x26, 0x0C, 0x19, 0x83, 0x06, 0x60, 0xC1, 0x90, 0x30,
  0x6C, 0x08, 0x1B, 0x06, 0x04, 0xC1, 0x83, 0x30, 0x60, 0xC0, 0x18, 0xF8,
  0x33, 0xF8, 0x6C, 0x38, 0xE0, 0x31, 0xC0, 0x67, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x1B, 0x00, 0x26, 0x00, 0xCC, 0x01,
  0x98, 0x03, 0x30, 0x06, 0x60, 0x0D, 0x80, 0x30, 0x03, 0xF0, 0x07, 0xFC,
  0x1E, 0x0E, 0x18, 0x06, 0x30, 0x03, 0x70, 0x03, 0x60, 0x03, 0x60, 0x03,
  0x60, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0x60, 0x0C,
  0x60, 0x1C, 0x38, 0x38, 0x3F, 0xF0, 0x0F, 0xC0, 0x0C, 0x7C, 0x06, 0x7F,
  0x83, 0x61, 0xC1, 0x40, 0x71, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x06, 0x30,
  0x03, 0x18, 0x01, 0x88, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x73, 0x00, 0x31,
  0x80, 0x38, 0xE0, 0x18, 0x58, 0x38, 0x67, 0xF8, 0x31, 0xF8, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xE3, 0x0F, 0xF3, 0x1C, 0x1B, 0x38, 0x07, 0x30, 0x07,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0x60, 0x2C, 0x70, 0x6C, 0x3F, 0xCC,
  0x1F, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0xFE, 0x3F, 0xFE, 0x7F, 0x06, 0xC0, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x1C, 0x0F, 0x18, 0x02,
  0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x80, 0x06, 0xC0, 0x0E, 0x70, 0x1C,
  0x3F, 0xF8, 0x0F, 0xE0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x04, 0x08, 0x1E, 0x18, 0x78, 0x18, 0xE0, 0x1B, 0xC0,
  0x1F, 0x00, 0x1E, 0x00, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x1B, 0x00, 0x26,
  0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x0D, 0x80, 0x13, 0x00,
  0x66, 0x00, 0xCC, 0x03, 0x98, 0x07, 0x30, 0x16, 0x70, 0x4C, 0x7F, 0xB0,
  0x7C, 0x60, 0x7E, 0x03, 0x7C, 0x07, 0x8C, 0x03, 0x0C, 0x03, 0x0C, 0x03,
  0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x03, 0x18, 0x06, 0x18, 0x06,
  0x18, 0x0E, 0x18, 0x1C, 0x18, 0x38, 0x10, 0x70, 0x31, 0xE0, 0x3F, 0xC0,
  0x1E, 0x00, 0x30, 0x61, 0x18, 0x30, 0xC8, 0x10, 0x64, 0x08, 0x36, 0x0C,
  0x0B, 0x06, 0x05, 0x83, 0x06, 0xC1, 0x83, 0x40, 0x81, 0xA0, 0x40, 0xF0,
  0x60, 0x78, 0x30, 0x3C, 0x18, 0x36, 0x0C, 0x1B, 0x0E, 0x19, 0x8F, 0x1C,
  0xFC, 0xFC, 0x3C, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x7C, 0x7E, 0x0E, 0xCE,
  0x33, 0x86, 0x83, 0x20, 0x68, 0x30, 0x07, 0x03, 0x00, 0x70, 0x30, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x04, 0x06, 0x00, 0xC0,
  0xA0, 0x0C, 0x0A, 0x06, 0x41, 0xB1, 0xC6, 0x33, 0x70, 0x7E, 0x3E, 0x03,
  0xC1, 0xC0, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x21, 0x80,
  0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x18, 0x01, 0x0C,
  0x01, 0x86, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0x70, 0xC0, 0x58, 0x30, 0x58,
  0x1F, 0xEC, 0x07, 0xC6, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x82, 0x01,
  0xC3, 0x81, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0x8F, 0xFC,
  0xCC, 0x0F, 0xC6, 0x01, 0xE2, 0x00, 0xE1, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x81, 0x80, 0x63,
  0x80, 0x33, 0xF0, 0x19, 0xFF, 0xC4, 0xC7, 0xFE, 0x60, 0x3F, 0x00, 0x00,
  0xFE, 0x03, 0xFC, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x70, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x06, 0x0C,
  0x18, 0x20, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83, 0x06, 0x08,
  0x30, 0x60, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x04, 0x18,
  0x30, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x3F, 0x80, 0xFF, 0x03, 0x80, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x1F, 0xE0, 0x3F, 0x80,
  0x00, 0x1E, 0x00, 0x9F, 0x80, 0xDC, 0xE0, 0x6C, 0x38, 0x6C, 0x0E, 0x66,
  0x03, 0xF2, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_LightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 7, 24, 20, 7, -24 },
  { 22, 9, 9, 20, 8, -25 },
  { 33, 20, 24, 20, 1, -24 },
  { 93, 19, 30, 20, 1, -27 },
  { 165, 23, 24, 20, -1, -24 },
  { 234, 20, 24, 20, 0, -24 },
  { 294, 4, 9, 20, 10, -25 },
  { 299, 12, 31, 20, 7, -26 },
  { 346, 12, 31, 20, 2, -26 },
  { 393, 17, 17, 20, 2, -19 },
  { 430, 17, 16, 20, 2, -18 },
  { 464, 6, 9, 20, 5, -4 },
  { 471, 9, 2, 20, 6, -11 },
  { 474, 4, 4, 20, 7, -4 },
  { 476, 19, 31, 20, 1, -26 },
  { 550, 17, 24, 20, 2, -24 },
  { 601, 16, 24, 20, 2, -24 },
  { 649, 18, 24, 20, 1, -24 },
  { 703, 17, 24, 20, 1, -24 },
  { 754, 18, 24, 20, 1, -24 },
  { 808, 17, 24, 20, 2, -24 },
  { 859, 16, 24, 20, 2, -24 },
  { 907, 16, 24, 20, 4, -24 },
  { 955, 17, 24, 20, 2, -24 },
  { 1006, 16, 24, 20, 3, -24 },
  { 1054, 6, 18, 20, 7, -18 },
  { 1068, 8, 23, 20, 5, -18 },
  { 1091, 16, 19, 20, 3, -20 },
  { 1129, 17, 9, 20, 2, -15 },
  { 1149, 16, 19, 20, 2, -20 },
  { 1187, 14, 24, 20, 5, -24 },
  { 1229, 17, 28, 20, 2, -24 },
  { 1289, 18, 24, 20, 0, -24 },
  { 1343, 17, 24, 20, 2, -24 },
  { 1394, 16, 24, 20, 3, -24 },
  { 1442, 17, 24, 20, 2, -24 },
  { 1493, 18, 24, 20, 2, -24 },
  { 1547, 18, 24, 20, 2, -24 },
  { 1601, 16, 24, 20, 3, -24 },
  { 1649, 18, 24, 20, 2, -24 },
  { 1703, 19, 24, 20, 1, -24 },
  { 1760, 17, 24, 20, 2, -24 },
  { 1811, 20, 24, 20, 2, -24 },
  { 1871, 14, 24, 20, 3, -24 },
  { 1913, 19, 24, 20, 1, -24 },
  { 1970, 18, 24, 20, 2, -24 },
  { 2024, 17, 24, 20, 2, -24 },
  { 2075, 18, 24, 20, 2, -24 },
  { 2129, 17, 30, 20, 2, -24 },
  { 2193, 18, 24, 20, 2, -24 },
  { 2247, 19, 24, 20, 1, -24 },
  { 2304, 19, 24, 20, 3, -24 },
  { 2361, 17, 24, 20, 3, -24 },
  { 2412, 17, 24, 20, 4, -24 },
  { 2463, 19, 24, 20, 2, -24 },
  { 2520, 22, 24, 20, 0, -24 },
  { 2586, 19, 24, 20, 3, -24 },
  { 2643, 21, 24, 20, 0, -24 },
  { 2706, 14, 31, 20, 6, -26 },
  { 2761, 9, 31, 20, 6, -26 },
  { 2796, 14, 31, 20, 1, -26 },
  { 2851, 17, 13, 20, 2, -24 },
  { 2879, 16, 2, 20, 0, 3 },
  { 2883, 4, 6, 20, 8, -26 },
  { 2886, 16, 18, 20, 2, -18 },
  { 2922, 16, 25, 20, 2, -25 },
  { 2972, 14, 18, 20, 3, -18 },
  { 3004, 17, 25, 20, 2, -25 },
  { 3058, 15, 18, 20, 3, -18 },
  { 3092, 22, 32, 20, -1, -25 },
  { 3180, 17, 25, 20, 1, -18 },
  { 3234, 15, 25, 20, 2, -25 },
  { 3281, 15, 25, 20, 3, -25 },
  { 3328, 15, 33, 20, 3, -26 },
  { 3390, 17, 25, 20, 2, -25 },
  { 3444, 13, 25, 20, 4, -25 },
  { 3485, 18, 18, 20, 1, -18 },
  { 3526, 15, 18, 20, 2, -18 },
  { 3560, 16, 18, 20, 2, -18 },
  { 3596, 17, 25, 20, 1, -18 },
  { 3650, 16, 25, 20, 2, -18 },
  { 3700, 16, 18, 20, 4, -18 },
  { 3736, 16, 18, 20, 2, -18 },
  { 3772, 16, 24, 20, 3, -24 },
  { 3820, 15, 18, 20, 3, -18 },
  { 3854, 16, 18, 20, 2, -18 },
  { 3890, 17, 18, 20, 2, -18 },
  { 3929, 20, 18, 20, 0, -18 },
  { 3974, 17, 25, 20, 1, -18 },
  { 4028, 17, 18, 20, 2, -18 },
  { 4067, 15, 31, 20, 4, -26 },
  { 4126, 7, 31, 20, 7, -26 },
  { 4154, 15, 31, 20, 2, -26 },
  { 4213, 17, 7, 20, 2, -14 },
};

const GFXfont IBMPlexMono_LightItalic34pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic34pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic34pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _IBMPLEXMONO_LIGHTITALIC34PT7B_H_
