#ifndef _IBMPLEXMONO_LIGHTITALIC56PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x00, 0x38, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x3D, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0,
  0xE7, 0x07, 0xBC, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x01, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xF1, 0xCF, 0xC0, 0x3E, 0x06,
  0x0F, 0x80, 0xF0, 0x18, 0x0F, 0x07, 0x80, 0x60, 0x1C, 0x1C, 0x03, 0x80,
  0x20, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0xC0, 0x00,
  0x3C, 0x03, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x1E, 0x06, 0x00, 0x00, 0x7C, 0x18, 0x00, 0x00, 0xFC,
  0x60, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x1F, 0x80, 0x00, 0x0C, 0x1F,
  0x00, 0x00, 0x30, 0x3C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x84, 0x00, 0xE0, 0x1E, 0x38, 0x03,
  0x80, 0x70, 0xF0, 0x0C, 0x03, 0xC3, 0xE0, 0x30, 0x1E, 0x07, 0xC0, 0xC0,
  0xF8, 0x0F, 0xE7, 0x1F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xF0, 0x0F, 0xFF, 0x00, 0x07, 0x00, 0x7C, 0x1E, 0x00, 0x1C, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x01, 0xC0, 0x06, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x38, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x0E, 0x07, 0x00,
  0x07, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x0F,
  0x07, 0x00, 0x00, 0xF0, 0x78, 0x38, 0x00, 0x03, 0xFF, 0xC1, 0xC0, 0x00,
  0x07, 0xFE, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x81, 0xFF, 0x00, 0x00, 0x1C, 0x1F,
  0xFE, 0x00, 0x00, 0xE0, 0xF8, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0xC0, 0x00, 0xE0, 0x70, 0x03, 0x00, 0x07, 0x03, 0x80,
  0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1E, 0x00, 0xE0,
  0x01, 0xE0, 0xF0, 0x07, 0x00, 0x07, 0xFF, 0x80, 0x38, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03,
  0x80, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x0F, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x07, 0x80,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x7F, 0xCF, 0x80, 0x00, 0x7E, 0xFF, 0x80, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x70, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0xE0, 0x09, 0xE0, 0x00, 0x78, 0x07, 0xF0, 0x00, 0x7C, 0x07, 0x38, 0x00,
  0x2F, 0x03, 0x9C, 0x00, 0x33, 0x83, 0x8F, 0x00, 0x19, 0xE1, 0xC3, 0x80,
  0x18, 0x71, 0xC1, 0xF0, 0x3C, 0x3D, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x1F,
  0xFC, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0xE0, 0x00, 0x1C, 0xF3, 0x8E, 0x38,
  0xE3, 0x8E, 0x71, 0xC7, 0x1C, 0x71, 0xCE, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x03, 0x00, 0x38, 0x00, 0x9F, 0x01, 0xC0, 0x7F, 0xFF, 0x0E,
  0x1F, 0xF1, 0xFF, 0x77, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x80, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x70, 0x0F, 0x00, 0xEF, 0x01, 0xF0, 0x0E, 0xF0, 0x1F, 0x01, 0xEF,
  0x01, 0xF0, 0x1E, 0xE0, 0x1E, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7D, 0xC0, 0x00,
  0x3E, 0x70, 0x00, 0x1F, 0x1C, 0x00, 0x0F, 0x87, 0x00, 0x0F, 0xC3, 0xC0,
  0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x38, 0x01, 0xF0, 0x0E, 0x00, 0x38, 0x03,
  0x80, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x01, 0xE0, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0xF0, 0x18, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x04, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC1,
  0xFC, 0x00, 0x0E, 0x3F, 0xFC, 0x00, 0x77, 0xFF, 0xF0, 0x03, 0xF8, 0x0F,
  0xC0, 0x1F, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x02, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x20, 0x00, 0x07, 0x07, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x78, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x1F, 0xC0, 0x1C, 0x7F, 0xF8, 0x1E, 0x7F,
  0xFE, 0x0E, 0x78, 0x0F, 0x87, 0x60, 0x03, 0xE7, 0x60, 0x00, 0x7B, 0xE0,
  0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x0F,
  0x38, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x1F,
  0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x38, 0x70, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xF8, 0x0F,
  0xC0, 0x1E, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x3E, 0x03, 0x80, 0x00,
  0x70, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x71,
  0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x1E, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x01, 0xE1, 0xC0,
  0x00, 0x38, 0xF0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x9C, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x7E, 0x3C, 0x00, 0x37, 0x0F,
  0xC0, 0x79, 0xC1, 0xFF, 0xFC, 0xE0, 0x1F, 0xFE, 0x38, 0x01, 0xFC, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0x83, 0xF0, 0xFC, 0x7F, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3E, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x0F, 0xC3, 0xE0, 0x07, 0xCF,
  0x00, 0x07, 0x9E, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0x81, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x1F, 0x0E,
  0x30, 0x0F, 0xF9, 0xCE, 0x03, 0xFF, 0x31, 0xC0, 0xF8, 0x36, 0x38, 0x1C,
  0x03, 0xC7, 0x07, 0x80, 0x39, 0xC0, 0xE0, 0x07, 0x38, 0x1C, 0x00, 0xE7,
  0x07, 0x00, 0x1C, 0xE0, 0xE0, 0x03, 0x1C, 0x1C, 0x00, 0xE7, 0x83, 0x80,
  0x1C, 0xE0, 0xF0, 0x03, 0x9C, 0x1C, 0x00, 0x73, 0x83, 0x80, 0x0E, 0x70,
  0x70, 0x03, 0x8E, 0x0E, 0x00, 0x71, 0xC1, 0xC0, 0x1E, 0x38, 0x1C, 0x07,
  0xC7, 0x03, 0xC1, 0xB8, 0xE0, 0x7F, 0xE7, 0x1C, 0x07, 0xFD, 0xC3, 0x80,
  0x7E, 0x38, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x38, 0x00, 0x7C, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00,
  0x07, 0x81, 0xE0, 0x01, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0x78,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x07, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x80,
  0x7E, 0x07, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x3C, 0x01, 0xF8, 0x03, 0x80, 0x07, 0xC0, 0x38, 0x00, 0x1E, 0x03,
  0x80, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0x7C, 0x07, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x3F, 0xFC, 0xF0, 0x03, 0xFF, 0xCF, 0x00, 0x7F,
  0xF8, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x17, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x6E, 0x01, 0xF0,
  0x1C, 0xE0, 0x0F, 0xFF, 0x8E, 0x00, 0x7F, 0xF0, 0xE0, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x01, 0xC0, 0x1F, 0x00,
  0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x70, 0x1F, 0x00,
  0x00, 0x38, 0x1F, 0x00, 0x00, 0x1C, 0x1F, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x0F, 0x1F, 0x80, 0x00, 0x07, 0x9F, 0xC0, 0x00, 0x03, 0x9E, 0xF0,
  0x00, 0x01, 0xDE, 0x38, 0x00, 0x00, 0xFE, 0x1E, 0x00, 0x00, 0x7E, 0x07,
  0x00, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xEE, 0x00, 0x1D,
  0xC1, 0xDC, 0x00, 0x77, 0x03, 0xB8, 0x00, 0xEE, 0x07, 0x38, 0x03, 0x9C,
  0x0E, 0x70, 0x07, 0x38, 0x1C, 0xE0, 0x1C, 0x70, 0x70, 0xC0, 0x71, 0xE0,
  0xE1, 0xC0, 0xE3, 0x81, 0xC3, 0x83, 0x87, 0x03, 0x87, 0x07, 0x0E, 0x07,
  0x06, 0x1C, 0x1C, 0x0E, 0x0E, 0x70, 0x38, 0x38, 0x1C, 0xE0, 0xF0, 0x70,
  0x3B, 0x81, 0xC0, 0xE0, 0x3F, 0x03, 0x81, 0xC0, 0x7C, 0x07, 0x03, 0x80,
  0xF0, 0x0E, 0x07, 0x01, 0xE0, 0x1C, 0x1C, 0x01, 0x80, 0x78, 0x38, 0x03,
  0x00, 0xE0, 0x70, 0x04, 0x01, 0xC0, 0xE0, 0x10, 0x03, 0x81, 0xC0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x1C, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0x81, 0xFC, 0x00, 0x0E,
  0x07, 0x70, 0x00, 0x38, 0x1D, 0xC0, 0x00, 0xE0, 0x77, 0x80, 0x03, 0x81,
  0xCE, 0x00, 0x1E, 0x07, 0x38, 0x00, 0x70, 0x38, 0xE0, 0x01, 0xC0, 0xE1,
  0xC0, 0x07, 0x03, 0x87, 0x00, 0x1C, 0x0E, 0x1C, 0x00, 0x70, 0x38, 0x78,
  0x03, 0xC0, 0xE0, 0xE0, 0x0E, 0x07, 0x83, 0x80, 0x38, 0x1C, 0x0E, 0x00,
  0xE0, 0x70, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x0E, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x0E,
  0x00, 0xE0, 0x70, 0x38, 0x03, 0xC1, 0xC0, 0xE0, 0x07, 0x0F, 0x03, 0x80,
  0x1C, 0x38, 0x1E, 0x00, 0x70, 0xE0, 0x70, 0x00, 0xE3, 0x81, 0xC0, 0x03,
  0x8E, 0x07, 0x00, 0x0E, 0x38, 0x1C, 0x00, 0x3D, 0xE0, 0x70, 0x00, 0x77,
  0x03, 0xC0, 0x01, 0xDC, 0x0E, 0x00, 0x07, 0x70, 0x38, 0x00, 0x0F, 0xC0,
  0xE0, 0x00, 0x3F, 0x03, 0x80, 0x00, 0xFC, 0x0E, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0x80, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0x00, 0x03, 0xE0, 0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x80, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0x80, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x01, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x70, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x3C, 0x01, 0xC0, 0x01,
  0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x04, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x40, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x0F, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x38, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x38, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0,
  0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x0E, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x07, 0x80, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0,
  0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x03, 0xC0, 0x38, 0x38, 0x07, 0xC0, 0x38,
  0x38, 0x07, 0xC0, 0x38, 0x38, 0x07, 0xC0, 0x38, 0x38, 0x0E, 0xC0, 0x70,
  0x38, 0x0E, 0xC0, 0x70, 0x38, 0x1C, 0xC0, 0x70, 0x38, 0x1C, 0xE0, 0x70,
  0x38, 0x38, 0xE0, 0xE0, 0x38, 0x38, 0xE0, 0xE0, 0x38, 0x30, 0xE0, 0xE0,
  0x38, 0x70, 0xE0, 0xE0, 0x30, 0x70, 0xE1, 0xC0, 0x30, 0xE0, 0xE1, 0xC0,
  0x70, 0xE0, 0xE1, 0xC0, 0x70, 0xC0, 0xE1, 0x80, 0x71, 0xC0, 0x63, 0x80,
  0x71, 0xC0, 0x63, 0x80, 0x73, 0x80, 0x63, 0x80, 0x73, 0x80, 0x63, 0x00,
  0x73, 0x00, 0x77, 0x00, 0x77, 0x00, 0x77, 0x00, 0x77, 0x00, 0x77, 0x00,
  0x7E, 0x00, 0x76, 0x00, 0x6E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x70, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03,
  0x80, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x04, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x0F,
  0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x1E, 0x01, 0xC0,
  0x03, 0x80, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x00, 0x70, 0x0F, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x61, 0xE1, 0xC3, 0xC3, 0x87, 0x07, 0x0E, 0x0C,
  0x1C, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x3C, 0x07, 0xFF, 0xE7, 0x81,
  0xF8, 0x1C, 0xE0, 0x78, 0x00, 0xDC, 0x1E, 0x00, 0x0B, 0x83, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07,
  0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x01, 0xF0, 0x78, 0x00,
  0x2E, 0x0F, 0x00, 0x0D, 0xC0, 0xF0, 0x03, 0x78, 0x1F, 0x83, 0xCF, 0xF1,
  0xFF, 0xF0, 0xFC, 0x1F, 0xFC, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x0F,
  0xC0, 0x0E, 0x1F, 0xFC, 0x03, 0x8F, 0xFF, 0x80, 0xE7, 0x81, 0xF0, 0x3B,
  0x80, 0x1E, 0x0E, 0xC0, 0x07, 0x83, 0xE0, 0x00, 0xE1, 0xD0, 0x00, 0x3C,
  0x78, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x1C, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0xE3, 0xE0, 0x00, 0x78, 0xE8, 0x00, 0x3C, 0x3B, 0x00,
  0x1F, 0x0E, 0x70, 0x1F, 0x83, 0x8F, 0xFF, 0xC0, 0xE1, 0xFF, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7C, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x78, 0x00,
  0x1C, 0x38, 0x00, 0x05, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x31,
  0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x0F, 0x00, 0x3C, 0x03, 0xE0, 0x7E, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x3F, 0x81, 0xC0,
  0x0F, 0xFF, 0x0E, 0x00, 0xFF, 0xFC, 0x70, 0x0F, 0xC0, 0xF7, 0x80, 0xF8,
  0x01, 0xBC, 0x0F, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x38, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x5C, 0x07, 0x80, 0x06, 0xE0, 0x1E, 0x00, 0x67, 0x00, 0xFC, 0x0E,
  0x78, 0x03, 0xFF, 0xE3, 0x80, 0x0F, 0xFE, 0x1C, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7E,
  0x03, 0xE0, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x3C, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xEF,
  0x00, 0x01, 0xE7, 0x00, 0x01, 0xF3, 0x80, 0x07, 0xF1, 0xC0, 0x7F, 0xE1,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x21, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x0F, 0x00,
  0x1F, 0x03, 0xE0, 0x3E, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x40, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x00, 0x7C, 0x70,
  0x00, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x00, 0x1F, 0x70, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x87, 0x00, 0xFF, 0xFC, 0x70,
  0x1F, 0x81, 0xEF, 0x03, 0xC0, 0x06, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E,
  0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x38, 0x78, 0x00, 0x03, 0x87, 0x80, 0x00, 0x78, 0x38,
  0x00, 0x07, 0x83, 0x80, 0x00, 0xF8, 0x38, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xF0, 0x3C, 0x00, 0x37, 0x01, 0xE0, 0x06, 0x70, 0x1F, 0x81, 0xC7, 0x00,
  0xFF, 0xFC, 0xF0, 0x07, 0xFF, 0x0E, 0x00, 0x1F, 0xC0, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x20, 0x00, 0x78, 0x07, 0x00,
  0x0F, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x7E, 0x00, 0x70, 0xFF, 0xC0, 0x38, 0xFF, 0xF0,
  0x3C, 0xE0, 0xFC, 0x1C, 0xC0, 0x1E, 0x0E, 0xC0, 0x07, 0x07, 0x40, 0x03,
  0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x0F, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x02, 0x00, 0xE0,
  0x07, 0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x3E, 0x01, 0xC0, 0x7C, 0x01, 0xC0,
  0xF0, 0x01, 0xC1, 0xE0, 0x01, 0xC7, 0xC0, 0x03, 0x8F, 0x80, 0x03, 0x9E,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x10, 0x00, 0xE0, 0x1C, 0x00, 0xF0,
  0x1F, 0x00, 0x70, 0x07, 0xC0, 0x38, 0x01, 0xF0, 0x1C, 0x00, 0x7C, 0x0E,
  0x00, 0x1F, 0x07, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0x80, 0x00, 0x3D,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x3F, 0x00, 0x07, 0x0F, 0xFC, 0x00, 0xE3, 0xFF, 0xE0,
  0x0E, 0x78, 0x1F, 0x00, 0xE6, 0x00, 0xF0, 0x0E, 0xC0, 0x07, 0x80, 0xF8,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0x81, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x1C,
  0x00, 0x3C, 0x03, 0x80, 0x0F, 0x80, 0x38, 0x03, 0xE0, 0x03, 0x81, 0xF8,
  0x00, 0x38, 0x7C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07,
  0x03, 0xC0, 0x02, 0x70, 0x1C, 0x00, 0x67, 0x01, 0xE0, 0x0F, 0x70, 0x0E,
  0x01, 0xE7, 0x00, 0xF0, 0x3C, 0xF0, 0x07, 0x07, 0x8E, 0x00, 0x79, 0xF0,
  0xE0, 0x03, 0xBE, 0x0E, 0x00, 0x3F, 0xC0, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x01, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x1F, 0x07, 0x00,
  0x78, 0x0E, 0x03, 0xE0, 0x1C, 0x0F, 0x80, 0x38, 0x3C, 0x00, 0x71, 0xF0,
  0x01, 0xE7, 0xC0, 0x03, 0x9E, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x0E, 0x7F, 0x87, 0xF0, 0x1D,
  0xFF, 0x1F, 0xF0, 0x3B, 0x0E, 0x71, 0xE0, 0x7C, 0x1F, 0x81, 0xE1, 0xD0,
  0x1F, 0x01, 0xC3, 0xC0, 0x3C, 0x03, 0x87, 0x80, 0x70, 0x07, 0x0E, 0x00,
  0xE0, 0x0C, 0x1C, 0x01, 0xC0, 0x38, 0x38, 0x07, 0x00, 0x70, 0xE0, 0x0E,
  0x00, 0xE1, 0xC0, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x03, 0x87, 0x00, 0x70,
  0x07, 0x0E, 0x00, 0xE0, 0x1C, 0x1C, 0x03, 0x80, 0x38, 0x70, 0x07, 0x00,
  0x70, 0xE0, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x03,
  0x87, 0x00, 0x70, 0x0E, 0x0E, 0x01, 0xC0, 0x1C, 0x38, 0x03, 0x80, 0x38,
  0x70, 0x07, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0x07, 0x07, 0x00, 0xE0, 0x0E, 0x1C, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0x87, 0xFE, 0x03, 0xC7, 0xFF, 0x81, 0xC7, 0x07,
  0xE0, 0xE6, 0x00, 0xF0, 0x76, 0x00, 0x38, 0x3A, 0x00, 0x1C, 0x1E, 0x00,
  0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xC3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x78,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x3D, 0xC0, 0x00,
  0x0F, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x07, 0x80, 0x7C, 0x0F, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3C, 0x7F, 0xF0, 0x03, 0x8F,
  0xFF, 0x80, 0x39, 0xE0, 0x7C, 0x03, 0xB8, 0x01, 0xE0, 0x3B, 0x00, 0x1E,
  0x07, 0xE0, 0x00, 0xE0, 0x74, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x78,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x38, 0x3E, 0x00, 0x07, 0x83, 0xA0, 0x00, 0xF0, 0x3B, 0x00,
  0x1F, 0x03, 0x9C, 0x07, 0xE0, 0x38, 0xFF, 0xFC, 0x03, 0x87, 0xFF, 0x00,
  0x78, 0x1F, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFE, 0x1C, 0x07, 0xFF,
  0xE3, 0x81, 0xF8, 0x1E, 0xF0, 0x7C, 0x00, 0xDC, 0x1E, 0x00, 0x0F, 0x83,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x78, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x2E, 0x0F, 0x00, 0x0D, 0xC0, 0xF0, 0x03, 0x38, 0x1F, 0x81,
  0xCF, 0x01, 0xFF, 0xF1, 0xC0, 0x1F, 0xFC, 0x38, 0x00, 0xFE, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xF8,
  0x3F, 0xEF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0x80, 0x39, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xF8,
  0x0F, 0xE0, 0x78, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x20,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE2, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x07,
  0x1E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x1F, 0xC0, 0x3E, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x01, 0x00, 0x70, 0x01, 0xE0, 0x1C,
  0x00, 0xF8, 0x07, 0x00, 0xF8, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x7C, 0x00,
  0x38, 0x3E, 0x00, 0x0E, 0x3E, 0x00, 0x03, 0x9F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x07, 0x8E, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x71, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x78, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x87, 0x00, 0x03, 0xC3, 0x80, 0x02, 0xE1, 0xE0, 0x01, 0x70, 0xF0, 0x01,
  0x78, 0x3C, 0x03, 0xB8, 0x1F, 0x03, 0x9C, 0x07, 0xFF, 0x8E, 0x01, 0xFF,
  0x87, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xBF, 0xF0, 0x00, 0xEF,
  0xFC, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x07,
  0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00,
  0x3C, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x38, 0x0F, 0x80, 0x1C,
  0x07, 0xC0, 0x07, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x60, 0x60, 0x0E, 0x07, 0x87,
  0x00, 0x70, 0x1C, 0x38, 0x03, 0x80, 0xE1, 0xC0, 0x18, 0x03, 0x0E, 0x01,
  0xC0, 0x1C, 0x70, 0x0E, 0x00, 0xE3, 0x00, 0x70, 0x07, 0x38, 0x03, 0x80,
  0x39, 0xC0, 0x1C, 0x01, 0xCE, 0x00, 0xE0, 0x0E, 0x70, 0x0E, 0x00, 0x73,
  0x80, 0x70, 0x03, 0x98, 0x03, 0x80, 0x1D, 0xC0, 0x1C, 0x01, 0xCE, 0x00,
  0xE0, 0x0E, 0x70, 0x07, 0x00, 0x73, 0x80, 0x70, 0x03, 0x9C, 0x03, 0x80,
  0x1C, 0xC0, 0x1C, 0x01, 0xCE, 0x00, 0xE0, 0x0E, 0x70, 0x07, 0x00, 0x73,
  0x80, 0x78, 0x07, 0x1C, 0x03, 0xC0, 0x38, 0xE0, 0x3E, 0x03, 0x87, 0x03,
  0x70, 0x3C, 0x3C, 0x39, 0xC3, 0xC0, 0xFF, 0x8F, 0xFC, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xFE, 0x03,
  0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xE7, 0x0F, 0x1E, 0x0F, 0x87, 0x1C,
  0x0F, 0x1E, 0x03, 0x98, 0x07, 0x3C, 0x03, 0xB8, 0x07, 0x30, 0x03, 0xB0,
  0x07, 0x00, 0x03, 0xA0, 0x07, 0x00, 0x03, 0xA0, 0x07, 0x00, 0x03, 0xE0,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x05, 0x80, 0x00, 0xE0, 0x0D, 0xC0,
  0x08, 0xE0, 0x0D, 0xC0, 0x18, 0xE0, 0x19, 0xC0, 0x7C, 0xE0, 0x39, 0xC0,
  0xF0, 0xE0, 0x31, 0xE3, 0xE0, 0xF0, 0xF0, 0xE7, 0xC0, 0x7F, 0xE0, 0xFF,
  0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x0E, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78,
  0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0x01, 0xC0,
  0x01, 0xF0, 0x1E, 0x00, 0x17, 0x01, 0xE0, 0x03, 0x70, 0x0F, 0x00, 0x6F,
  0x00, 0xF8, 0x1C, 0xE0, 0x07, 0xFF, 0x8E, 0x00, 0x3F, 0xF0, 0xE0, 0x00,
  0xFC, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x07, 0x07, 0xFF, 0xF0, 0x70, 0xF0, 0x1F, 0xCF, 0x0E,
  0x00, 0x3F, 0xE1, 0xC0, 0x00, 0xFE, 0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x78, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x02, 0x00, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x00, 0x78,
  0x00, 0x70, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x03,
  0x87, 0xFE, 0x00, 0x38, 0xFF, 0xFF, 0x03, 0x8E, 0x0F, 0xFF, 0x1C, 0xE0,
  0x0F, 0xFF, 0x8E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x02, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x30, 0x3F, 0xC0, 0x01, 0xC3, 0xFF, 0x00, 0x1C, 0x3C, 0x7C,
  0x00, 0xE3, 0xC0, 0xE0, 0x0E, 0x1C, 0x07, 0x80, 0x71, 0xC0, 0x1E, 0x07,
  0x0E, 0x00, 0x78, 0x70, 0xE0, 0x01, 0xFF, 0x87, 0x00, 0x07, 0xF8, 0x10,
  0x00, 0x1F, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 11, 39, 34, 12, -39 },
  { 55, 14, 15, 34, 13, -41 },
  { 82, 34, 39, 34, 1, -39 },
  { 248, 30, 53, 34, 2, -46 },
  { 447, 38, 41, 34, -1, -40 },
  { 642, 33, 41, 34, 0, -40 },
  { 812, 6, 15, 34, 17, -41 },
  { 824, 20, 51, 34, 12, -43 },
  { 952, 19, 51, 34, 3, -43 },
  { 1074, 29, 28, 34, 3, -31 },
  { 1176, 27, 27, 34, 4, -31 },
  { 1268, 11, 15, 34, 8, -6 },
  { 1289, 16, 3, 34, 9, -19 },
  { 1295, 6, 6, 34, 12, -6 },
  { 1300, 31, 51, 34, 2, -43 },
  { 1498, 28, 41, 34, 4, -40 },
  { 1642, 26, 39, 34, 3, -39 },
  { 1769, 28, 40, 34, 2, -40 },
  { 1909, 28, 41, 34, 2, -40 },
  { 2053, 30, 39, 34, 1, -39 },
  { 2200, 29, 40, 34, 3, -39 },
  { 2345, 25, 40, 34, 4, -39 },
  { 2470, 27, 39, 34, 6, -39 },
  { 2602, 29, 41, 34, 3, -40 },
  { 2751, 26, 40, 34, 5, -40 },
  { 2881, 10, 30, 34, 12, -30 },
  { 2919, 14, 39, 34, 8, -30 },
  { 2988, 27, 31, 34, 5, -33 },
  { 3093, 29, 14, 34, 3, -24 },
  { 3144, 27, 31, 34, 3, -33 },
  { 3249, 23, 40, 34, 8, -40 },
  { 3364, 27, 46, 34, 4, -40 },
  { 3520, 29, 39, 34, 0, -39 },
  { 3662, 28, 39, 34, 3, -39 },
  { 3799, 27, 41, 34, 5, -40 },
  { 3938, 28, 39, 34, 3, -39 },
  { 4075, 30, 39, 34, 3, -39 },
  { 4222, 30, 39, 34, 3, -39 },
  { 4369, 28, 41, 34, 4, -40 },
  { 4513, 30, 39, 34, 3, -39 },
  { 4660, 31, 39, 34, 2, -39 },
  { 4812, 27, 40, 34, 4, -39 },
  { 4947, 33, 39, 34, 3, -39 },
  { 5108, 23, 39, 34, 5, -39 },
  { 5221, 31, 39, 34, 2, -39 },
  { 5373, 30, 39, 34, 3, -39 },
  { 5520, 28, 41, 34, 4, -40 },
  { 5664, 29, 39, 34, 3, -39 },
  { 5806, 28, 50, 34, 4, -40 },
  { 5981, 29, 39, 34, 3, -39 },
  { 6123, 30, 41, 34, 2, -40 },
  { 6277, 31, 39, 34, 5, -39 },
  { 6429, 29, 40, 34, 4, -39 },
  { 6574, 29, 39, 34, 6, -39 },
  { 6716, 32, 39, 34, 3, -39 },
  { 6872, 35, 39, 34, 0, -39 },
  { 7043, 32, 39, 34, 5, -39 },
  { 7199, 34, 39, 34, 0, -39 },
  { 7365, 23, 51, 34, 10, -43 },
  { 7512, 13, 51, 34, 11, -43 },
  { 7595, 23, 51, 34, 1, -43 },
  { 7742, 27, 22, 34, 4, -39 },
  { 7817, 27, 3, 34, 0, 6 },
  { 7828, 7, 10, 34, 13, -43 },
  { 7837, 27, 31, 34, 3, -30 },
  { 7942, 26, 42, 34, 4, -41 },
  { 8079, 25, 31, 34, 4, -30 },
  { 8176, 29, 42, 34, 3, -41 },
  { 8329, 25, 31, 34, 4, -30 },
  { 8426, 36, 53, 34, -1, -41 },
  { 8665, 28, 42, 34, 2, -30 },
  { 8812, 25, 41, 34, 4, -41 },
  { 8941, 24, 43, 34, 5, -42 },
  { 9070, 25, 54, 34, 4, -42 },
  { 9239, 28, 42, 34, 4, -41 },
  { 9386, 23, 42, 34, 6, -41 },
  { 9507, 31, 30, 34, 1, -30 },
  { 9624, 25, 30, 34, 4, -30 },
  { 9718, 26, 31, 34, 4, -30 },
  { 9819, 28, 41, 34, 2, -30 },
  { 9963, 27, 41, 34, 3, -30 },
  { 10102, 27, 29, 34, 6, -29 },
  { 10200, 27, 31, 34, 3, -30 },
  { 10305, 26, 40, 34, 4, -39 },
  { 10435, 25, 30, 34, 5, -29 },
  { 10529, 26, 29, 34, 4, -29 },
  { 10624, 29, 30, 34, 3, -29 },
  { 10733, 32, 31, 34, 1, -30 },
  { 10857, 28, 41, 34, 2, -29 },
  { 11001, 28, 31, 34, 3, -30 },
  { 11110, 26, 51, 34, 6, -43 },
  { 11276, 11, 51, 34, 12, -43 },
  { 11347, 25, 51, 34, 3, -43 },
  { 11507, 29, 11, 34, 3, -23 },
};

const GFXfont IBMPlexMono_LightItalic56pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic56pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic56pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _IBMPLEXMONO_LIGHTITALIC56PT7B_H_
