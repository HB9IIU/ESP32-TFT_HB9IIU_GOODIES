#ifndef _IBMPLEXMONO_LIGHTITALIC21PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x33, 0x22, 0x22, 0x00, 0x06, 0xE0, 0x4A, 0x73, 0x39,
  0x48, 0x01, 0x30, 0x11, 0x00, 0x88, 0x04, 0x80, 0x44, 0x1E, 0x3C, 0x12,
  0x01, 0x10, 0x08, 0x87, 0xCF, 0x04, 0x40, 0x22, 0x03, 0x20, 0x11, 0x00,
  0x98, 0x00, 0x01, 0x00, 0x40, 0x3E, 0x19, 0x32, 0x22, 0xC4, 0x19, 0x01,
  0x20, 0x34, 0x01, 0xE0, 0x12, 0x02, 0x20, 0x84, 0x10, 0xA2, 0x36, 0x4C,
  0x3E, 0x01, 0x00, 0x40, 0x00, 0x1E, 0x0C, 0x88, 0x62, 0x11, 0x08, 0x48,
  0x42, 0x40, 0x89, 0x03, 0xC8, 0x00, 0x00, 0x01, 0xE0, 0x2C, 0xC1, 0x21,
  0x08, 0x84, 0x42, 0x31, 0x08, 0x88, 0x1C, 0x00, 0x07, 0x80, 0x8C, 0x10,
  0x41, 0x04, 0x10, 0x40, 0x84, 0x08, 0x83, 0x70, 0x44, 0x0C, 0x20, 0x83,
  0x08, 0x11, 0xC3, 0x94, 0x4A, 0x38, 0x60, 0x69, 0x25, 0x80, 0x06, 0x10,
  0x41, 0x06, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x40, 0x80, 0xC0, 0x18, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x83, 0x04, 0x10, 0x43, 0x00, 0x02, 0x00, 0x40, 0x10,
  0x42, 0x17, 0x5C, 0x1C, 0x03, 0x80, 0x90, 0x23, 0x0C, 0x20, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00, 0x20, 0x0C, 0x01, 0x00,
  0x20, 0x00, 0x36, 0x64, 0x80, 0xFC, 0x7C, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x00, 0x0F, 0x83,
  0x18, 0xC1, 0x10, 0x16, 0x02, 0x80, 0x51, 0x9A, 0x23, 0xC0, 0x58, 0x0B,
  0x01, 0x20, 0x44, 0x08, 0xC6, 0x0F, 0x80, 0x07, 0x03, 0x41, 0xB0, 0x88,
  0x42, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x0F, 0xFC, 0x0F, 0x84, 0x32, 0x04, 0x81, 0x00, 0x40, 0x10, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x0F, 0xF8, 0x0F, 0x84, 0x32,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x18, 0x78, 0x01, 0x80, 0x20, 0x08, 0x02,
  0x80, 0xB0, 0x43, 0xE0, 0x00, 0x60, 0x14, 0x07, 0x80, 0xA0, 0x24, 0x08,
  0x82, 0x10, 0xC2, 0x30, 0xC4, 0x11, 0x02, 0x3F, 0xF8, 0x08, 0x01, 0x00,
  0x60, 0x1F, 0xE2, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x0B, 0xC1, 0x84,
  0x40, 0xC0, 0x08, 0x01, 0x00, 0x68, 0x08, 0x82, 0x0F, 0x80, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0x10, 0x08, 0x06, 0xF1, 0x42, 0x60, 0x50, 0x1C, 0x07,
  0x03, 0x40, 0x98, 0x43, 0xE0, 0x7F, 0xE8, 0x09, 0x03, 0x40, 0x40, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x00, 0x0F, 0x83, 0x08, 0x81, 0x90, 0x12, 0x06, 0x40, 0x8C, 0x20,
  0x78, 0x30, 0x88, 0x0A, 0x01, 0x40, 0x28, 0x0C, 0x83, 0x0F, 0x80, 0x1F,
  0x08, 0x64, 0x0B, 0x03, 0x80, 0xE0, 0x38, 0x09, 0x0E, 0x3D, 0x80, 0x40,
  0x20, 0x18, 0x0C, 0x06, 0x06, 0x00, 0x33, 0x00, 0x00, 0x00, 0x06, 0xE0,
  0x18, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x98, 0xC4, 0x40, 0x00, 0x40, 0x60,
  0x70, 0x30, 0x30, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x04,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x20, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x0C, 0x0C, 0x0C, 0x0E, 0x06, 0x02, 0x00, 0x3E, 0x31,
  0xB0, 0x50, 0x30, 0x10, 0x08, 0x0C, 0x38, 0x30, 0x10, 0x08, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x0F, 0x83, 0x08, 0xC1, 0x10, 0x12, 0x3E, 0x88, 0x92,
  0x12, 0x42, 0x48, 0x49, 0x0B, 0x23, 0x44, 0x48, 0xF8, 0x80, 0x10, 0x03,
  0x00, 0x3F, 0x00, 0x01, 0x80, 0x50, 0x0A, 0x03, 0x40, 0x48, 0x19, 0x82,
  0x30, 0xC2, 0x10, 0x43, 0xF8, 0x81, 0x10, 0x24, 0x06, 0x80, 0xE0, 0x08,
  0x3F, 0x88, 0x12, 0x04, 0x81, 0x20, 0x48, 0x16, 0x09, 0xFC, 0x40, 0x90,
  0x14, 0x05, 0x01, 0xC0, 0xF0, 0x6F, 0xF0, 0x0F, 0x0C, 0x22, 0x05, 0x00,
  0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x02, 0x81, 0x10,
  0xC3, 0xC0, 0x1F, 0x06, 0x18, 0x81, 0x10, 0x32, 0x02, 0x40, 0x48, 0x1B,
  0x03, 0x60, 0x48, 0x09, 0x01, 0x20, 0x64, 0x09, 0x86, 0x3F, 0x80, 0x3F,
  0xE6, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0xFE, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x3F, 0xE0, 0x3F, 0xF3, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x07, 0xFC, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x00, 0x0F, 0x0C, 0x26, 0x0D, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x87, 0xA0, 0x28, 0x0A, 0x06, 0x81, 0x30,
  0xC7, 0xD0, 0x30, 0x24, 0x04, 0x80, 0x90, 0x32, 0x06, 0xC0, 0x98, 0x13,
  0xFE, 0x40, 0x48, 0x09, 0x03, 0x20, 0x4C, 0x09, 0x01, 0x20, 0x20, 0x3F,
  0xE0, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x3F, 0xE0, 0x0F, 0xC4, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0xC1,
  0x10, 0xC3, 0xC0, 0x30, 0x33, 0x06, 0x20, 0xC2, 0x18, 0x23, 0x02, 0x60,
  0x6C, 0x07, 0xC0, 0x72, 0x06, 0x20, 0x43, 0x04, 0x10, 0xC1, 0x8C, 0x08,
  0x80, 0xC0, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40,
  0x40, 0xC0, 0xC0, 0x80, 0xFF, 0x30, 0x33, 0x06, 0x30, 0xE3, 0x8A, 0x49,
  0xA4, 0x92, 0x4A, 0x44, 0x64, 0x44, 0x44, 0x44, 0xC0, 0x48, 0x04, 0x80,
  0xC8, 0x08, 0x80, 0x80, 0x30, 0x27, 0x04, 0xA0, 0x94, 0x12, 0x86, 0xD8,
  0x91, 0x12, 0x22, 0x44, 0x48, 0x49, 0x0B, 0x21, 0x48, 0x39, 0x03, 0x20,
  0x60, 0x0F, 0x83, 0x18, 0xC1, 0x10, 0x16, 0x02, 0x80, 0x50, 0x1A, 0x03,
  0xC0, 0x58, 0x0B, 0x01, 0x20, 0x44, 0x08, 0xC6, 0x0F, 0x80, 0x3F, 0xC6,
  0x0C, 0x80, 0x90, 0x12, 0x02, 0x40, 0xC8, 0x13, 0xFC, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x00, 0x0F, 0x83, 0x18, 0xC1, 0x10,
  0x16, 0x02, 0x80, 0x50, 0x1A, 0x03, 0xC0, 0x58, 0x0B, 0x01, 0x20, 0x44,
  0x08, 0xC6, 0x0F, 0x80, 0x60, 0x04, 0x40, 0x50, 0x0C, 0x00, 0x3F, 0xC6,
  0x0C, 0x80, 0x90, 0x12, 0x02, 0x40, 0xC8, 0x13, 0xFC, 0x46, 0x08, 0x41,
  0x08, 0x20, 0x84, 0x11, 0x83, 0x20, 0x20, 0x0F, 0x86, 0x0C, 0x80, 0xB0,
  0x06, 0x00, 0x40, 0x0E, 0x00, 0x78, 0x00, 0x80, 0x18, 0x01, 0x00, 0x28,
  0x0D, 0x83, 0x0F, 0x80, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x60, 0x50, 0x14, 0x05, 0x03, 0x40, 0xF0, 0x2C, 0x0A, 0x02, 0x80,
  0xA0, 0x68, 0x1A, 0x04, 0x81, 0x30, 0x87, 0xC0, 0xC0, 0x28, 0x09, 0x01,
  0x20, 0x64, 0x08, 0x83, 0x18, 0x41, 0x18, 0x22, 0x04, 0x40, 0x90, 0x12,
  0x02, 0x80, 0x50, 0x0C, 0x00, 0x60, 0x14, 0x01, 0x40, 0x34, 0x02, 0x46,
  0x24, 0x62, 0x46, 0x64, 0xA4, 0x4A, 0x45, 0x24, 0x52, 0x47, 0x28, 0xE2,
  0x8A, 0x18, 0xC1, 0x80, 0x10, 0x18, 0xC0, 0x82, 0x08, 0x10, 0xC0, 0x4C,
  0x02, 0x40, 0x0C, 0x00, 0x40, 0x05, 0x00, 0x68, 0x06, 0x20, 0x21, 0x02,
  0x04, 0x30, 0x23, 0x01, 0x80, 0x80, 0x34, 0x06, 0x40, 0xC6, 0x08, 0x21,
  0x02, 0x30, 0x12, 0x01, 0x40, 0x18, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x20, 0x03, 0xFF, 0x80, 0x1F, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0xF8,
  0x84, 0x20, 0x84, 0x21, 0x04, 0x21, 0x08, 0x41, 0x08, 0x42, 0x08, 0x42,
  0x1F, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x3F, 0x00, 0x06, 0x02,
  0x81, 0xB0, 0x44, 0x21, 0x10, 0x2C, 0x0A, 0x03, 0xFF, 0xC0, 0xB5, 0x1E,
  0x4C, 0x56, 0x0D, 0x03, 0x40, 0xB0, 0x2C, 0x0B, 0x02, 0xC3, 0x90, 0xE3,
  0xCC, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x09, 0xE2, 0x8C, 0xC1, 0x20,
  0x58, 0x14, 0x05, 0x01, 0x40, 0xD0, 0x26, 0x13, 0x78, 0x1E, 0x30, 0x90,
  0x30, 0x08, 0x04, 0x02, 0x01, 0x02, 0x81, 0x61, 0x0F, 0x00, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x20, 0x04, 0x3C, 0x8C, 0x53, 0x06, 0x40, 0x48, 0x1B,
  0x02, 0x60, 0x4C, 0x09, 0x87, 0x10, 0xE1, 0xEC, 0x1F, 0x10, 0xD0, 0x30,
  0x38, 0x37, 0xE2, 0x01, 0x02, 0x81, 0xE1, 0x0F, 0x00, 0x00, 0xF8, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x0F, 0xF8, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x10, 0x80, 0xC4,
  0x03, 0x20, 0x0F, 0x00, 0x30, 0x00, 0x1E, 0x4C, 0x56, 0x0D, 0x01, 0x40,
  0xB0, 0x2C, 0x0B, 0x02, 0xC1, 0x90, 0xA3, 0xD0, 0x04, 0x01, 0x20, 0x87,
  0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x09, 0xE2, 0x88, 0xC3, 0x20,
  0x48, 0x36, 0x09, 0x02, 0x40, 0x90, 0x24, 0x0B, 0x06, 0x0C, 0x06, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x21, 0x19,
  0x90, 0xB0, 0x70, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x04, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x11, 0x08, 0xC4, 0x32, 0x0F,
  0x03, 0x00, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x4F, 0x0A, 0x31,
  0x82, 0x20, 0xCC, 0x11, 0x0C, 0x26, 0x04, 0xC2, 0x88, 0x90, 0xA6, 0x18,
  0xFC, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04,
  0x06, 0x22, 0x19, 0x30, 0xA0, 0x60, 0x2E, 0x63, 0x39, 0x23, 0x12, 0x21,
  0x22, 0x36, 0x22, 0x42, 0x24, 0x22, 0x44, 0x24, 0x42, 0xC4, 0x60, 0x27,
  0x8A, 0x23, 0x0C, 0x81, 0x20, 0xD8, 0x24, 0x09, 0x02, 0x40, 0x90, 0x2C,
  0x18, 0x0F, 0x0C, 0x22, 0x05, 0x01, 0x40, 0x50, 0x1C, 0x05, 0x03, 0x40,
  0x98, 0x43, 0xE0, 0x27, 0x8A, 0x33, 0x04, 0x81, 0x60, 0x50, 0x14, 0x05,
  0x03, 0x40, 0x98, 0x4D, 0xE2, 0x00, 0x80, 0x20, 0x08, 0x00, 0x1E, 0x4C,
  0x56, 0x0D, 0x01, 0x40, 0xF0, 0x2C, 0x0B, 0x02, 0xC1, 0x90, 0xE3, 0xD8,
  0x04, 0x01, 0x00, 0x40, 0x10, 0xF9, 0xC3, 0x81, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x1F, 0x8C, 0x32, 0x00, 0x80,
  0x30, 0x07, 0xC0, 0x08, 0x02, 0x80, 0x90, 0x63, 0xE0, 0x08, 0x04, 0x02,
  0x03, 0x0F, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x32, 0x21,
  0x60, 0xC0, 0x40, 0xA0, 0x50, 0x28, 0x3C, 0x14, 0x0A, 0x05, 0x06, 0x83,
  0x63, 0x9E, 0x80, 0xE0, 0x90, 0x48, 0x24, 0x16, 0x0A, 0x05, 0x04, 0x82,
  0x42, 0x26, 0x1C, 0x00, 0x62, 0x48, 0x45, 0x18, 0xA2, 0x14, 0x42, 0x88,
  0x71, 0x1C, 0x22, 0x8C, 0x52, 0x91, 0x9C, 0x00, 0x0C, 0x73, 0x49, 0x43,
  0x10, 0x21, 0x02, 0x00, 0x20, 0x02, 0x0C, 0x60, 0x8A, 0x3C, 0xA4, 0x71,
  0x80, 0x20, 0x48, 0x12, 0x04, 0x83, 0x60, 0x90, 0x24, 0x09, 0x06, 0x42,
  0x98, 0xE3, 0xD0, 0x04, 0x01, 0x21, 0x87, 0xC0, 0x3E, 0x64, 0x39, 0x03,
  0x20, 0x80, 0x20, 0x08, 0x06, 0x01, 0x84, 0x60, 0x9F, 0x8A, 0x1E, 0x00,
  0x07, 0xC1, 0x00, 0x40, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x04, 0x1E,
  0x08, 0xC0, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x20, 0x08, 0x03, 0xE0,
  0x18, 0x84, 0x21, 0x08, 0xC4, 0x21, 0x08, 0x46, 0x21, 0x08, 0x42, 0x30,
  0x1F, 0x00, 0x40, 0x10, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x0C, 0x00,
  0xF0, 0xC0, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x08, 0x02, 0x0F, 0x80,
  0x38, 0x29, 0x89, 0x19, 0x41, 0xC0,
};

const GFXglyph IBMPlexMono_LightItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 15, 13, 4, -15 },
  { 9, 5, 6, 13, 5, -16 },
  { 13, 13, 15, 13, 0, -15 },
  { 38, 11, 19, 13, 1, -17 },
  { 65, 14, 15, 13, 0, -15 },
  { 92, 12, 15, 13, 0, -15 },
  { 115, 3, 6, 13, 6, -16 },
  { 118, 7, 19, 13, 5, -16 },
  { 135, 7, 19, 13, 1, -16 },
  { 152, 11, 10, 13, 1, -12 },
  { 166, 11, 11, 13, 1, -12 },
  { 182, 4, 5, 13, 3, -2 },
  { 185, 6, 1, 13, 3, -7 },
  { 186, 3, 2, 13, 4, -2 },
  { 187, 11, 19, 13, 1, -16 },
  { 214, 11, 15, 13, 1, -15 },
  { 235, 10, 15, 13, 1, -15 },
  { 254, 10, 15, 13, 1, -15 },
  { 273, 10, 15, 13, 1, -15 },
  { 292, 11, 15, 13, 0, -15 },
  { 313, 11, 15, 13, 1, -15 },
  { 334, 10, 15, 13, 1, -15 },
  { 353, 11, 15, 13, 2, -15 },
  { 374, 11, 15, 13, 1, -15 },
  { 395, 10, 15, 13, 2, -15 },
  { 414, 4, 11, 13, 4, -11 },
  { 420, 5, 14, 13, 3, -11 },
  { 429, 10, 12, 13, 2, -12 },
  { 444, 11, 5, 13, 1, -9 },
  { 451, 10, 12, 13, 1, -12 },
  { 466, 9, 15, 13, 3, -15 },
  { 483, 11, 17, 13, 1, -15 },
  { 507, 11, 15, 13, 0, -15 },
  { 528, 10, 15, 13, 1, -15 },
  { 547, 10, 15, 13, 2, -15 },
  { 566, 11, 15, 13, 1, -15 },
  { 587, 11, 15, 13, 1, -15 },
  { 608, 12, 15, 13, 1, -15 },
  { 631, 10, 15, 13, 2, -15 },
  { 650, 11, 15, 13, 1, -15 },
  { 671, 11, 15, 13, 1, -15 },
  { 692, 10, 15, 13, 1, -15 },
  { 711, 12, 15, 13, 1, -15 },
  { 734, 8, 15, 13, 2, -15 },
  { 749, 12, 15, 13, 1, -15 },
  { 772, 11, 15, 13, 1, -15 },
  { 793, 11, 15, 13, 1, -15 },
  { 814, 11, 15, 13, 1, -15 },
  { 835, 11, 19, 13, 1, -15 },
  { 862, 11, 15, 13, 1, -15 },
  { 883, 11, 15, 13, 1, -15 },
  { 904, 11, 15, 13, 2, -15 },
  { 925, 10, 15, 13, 2, -15 },
  { 944, 11, 15, 13, 2, -15 },
  { 965, 12, 15, 13, 1, -15 },
  { 988, 13, 15, 13, 0, -15 },
  { 1013, 12, 15, 13, 2, -15 },
  { 1036, 13, 15, 13, 0, -15 },
  { 1061, 8, 19, 13, 4, -16 },
  { 1080, 5, 19, 13, 4, -16 },
  { 1092, 9, 19, 13, 0, -16 },
  { 1114, 10, 8, 13, 2, -15 },
  { 1124, 10, 1, 13, 0, 2 },
  { 1126, 2, 4, 13, 5, -17 },
  { 1127, 10, 11, 13, 1, -11 },
  { 1141, 10, 16, 13, 1, -16 },
  { 1161, 9, 11, 13, 2, -11 },
  { 1174, 11, 16, 13, 1, -16 },
  { 1196, 9, 11, 13, 2, -11 },
  { 1209, 13, 20, 13, 0, -16 },
  { 1242, 10, 15, 13, 1, -11 },
  { 1261, 10, 16, 13, 1, -16 },
  { 1281, 9, 16, 13, 2, -16 },
  { 1299, 9, 20, 13, 2, -16 },
  { 1322, 11, 16, 13, 1, -16 },
  { 1344, 9, 16, 13, 2, -16 },
  { 1362, 12, 11, 13, 0, -11 },
  { 1379, 10, 11, 13, 1, -11 },
  { 1393, 10, 11, 13, 1, -11 },
  { 1407, 10, 15, 13, 1, -11 },
  { 1426, 10, 15, 13, 1, -11 },
  { 1445, 10, 11, 13, 2, -11 },
  { 1459, 10, 11, 13, 1, -11 },
  { 1473, 9, 15, 13, 2, -15 },
  { 1490, 9, 11, 13, 2, -11 },
  { 1503, 9, 11, 13, 2, -11 },
  { 1516, 11, 11, 13, 1, -11 },
  { 1532, 12, 11, 13, 0, -11 },
  { 1549, 10, 15, 13, 1, -11 },
  { 1568, 11, 11, 13, 1, -11 },
  { 1584, 10, 19, 13, 2, -16 },
  { 1608, 5, 19, 13, 4, -16 },
  { 1620, 10, 19, 13, 1, -16 },
  { 1644, 11, 4, 13, 1, -8 },
};

const GFXfont IBMPlexMono_LightItalic21pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic21pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic21pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _IBMPLEXMONO_LIGHTITALIC21PT7B_H_
