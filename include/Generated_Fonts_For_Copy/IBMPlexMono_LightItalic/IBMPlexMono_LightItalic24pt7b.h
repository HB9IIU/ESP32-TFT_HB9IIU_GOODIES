#ifndef _IBMPLEXMONO_LIGHTITALIC24PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x23, 0x18, 0x84, 0x21, 0x10, 0x00, 0x03, 0x9C, 0xC0,
  0xCF, 0x2C, 0xA2, 0x8A, 0x60, 0x01, 0x88, 0x02, 0x30, 0x04, 0x40, 0x08,
  0x80, 0x23, 0x00, 0x46, 0x0F, 0x8F, 0x82, 0x30, 0x04, 0x40, 0x18, 0x83,
  0xE3, 0xE0, 0x44, 0x01, 0x88, 0x02, 0x30, 0x04, 0x40, 0x18, 0x80, 0x23,
  0x00, 0x00, 0x80, 0x0C, 0x01, 0xF0, 0x32, 0x63, 0x11, 0x90, 0x80, 0x84,
  0x04, 0x60, 0x32, 0x00, 0xF0, 0x01, 0xE0, 0x04, 0xC0, 0x22, 0x02, 0x18,
  0x10, 0xC0, 0x84, 0xC4, 0x63, 0x26, 0x0F, 0xC0, 0x18, 0x00, 0x80, 0x00,
  0x0F, 0x03, 0x11, 0x06, 0x20, 0x84, 0x20, 0x88, 0x21, 0x90, 0x21, 0x30,
  0x23, 0x20, 0x1E, 0x40, 0x00, 0x00, 0x00, 0x70, 0x0D, 0x88, 0x19, 0x08,
  0x11, 0x08, 0x23, 0x08, 0x63, 0x08, 0x41, 0x10, 0x80, 0xE0, 0x03, 0xC0,
  0x31, 0x80, 0x82, 0x02, 0x0C, 0x08, 0x30, 0x20, 0x80, 0xC2, 0x01, 0x10,
  0x3F, 0x81, 0x88, 0x04, 0x30, 0x30, 0x40, 0xC1, 0x83, 0x06, 0x1C, 0x14,
  0x98, 0x9E, 0x3C, 0x30, 0x6D, 0x25, 0x80, 0x03, 0x83, 0x03, 0x03, 0x01,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x03, 0x00,
  0x80, 0x40, 0x20, 0x08, 0x06, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x80, 0x60,
  0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x08,
  0x04, 0x04, 0x04, 0x06, 0x06, 0x0C, 0x00, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x06, 0x23, 0xDF, 0xF0, 0x1C, 0x01, 0xE0, 0x09, 0x00, 0x8C, 0x08,
  0x20, 0x81, 0x80, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x41, 0xFF, 0xC1,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x00, 0x19, 0x8C, 0x46, 0x23, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x00, 0x0F, 0x81, 0x84, 0x20, 0x26, 0x02, 0x40, 0x2C, 0x03, 0xC0,
  0x2C, 0x62, 0x8E, 0x28, 0x02, 0x80, 0x68, 0x06, 0x80, 0x48, 0x0C, 0xC0,
  0x84, 0x30, 0x3E, 0x00, 0x03, 0x80, 0xD0, 0x36, 0x08, 0xC2, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x30, 0xFF, 0xE0, 0x07, 0xC1, 0x86, 0x30, 0x32, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x00, 0xFF, 0xE0, 0x07, 0xC1, 0x86, 0x30, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x0C, 0x0F, 0x00, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x80, 0x46, 0x18, 0x3F, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x14, 0x01, 0x20, 0x13, 0x01, 0x98, 0x18, 0x81, 0x84, 0x18, 0x20, 0x81,
  0x08, 0x18, 0x80, 0xC7, 0xFF, 0xC0, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x0F, 0xF8, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0xF0, 0x38, 0x61, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x33, 0x01,
  0x0C, 0x18, 0x3F, 0x00, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x01, 0x00, 0x60,
  0x18, 0x02, 0x7C, 0xF0, 0xD8, 0x0B, 0x01, 0xC0, 0x38, 0x05, 0x00, 0xA0,
  0x32, 0x0C, 0x3E, 0x00, 0xFF, 0xF0, 0x0E, 0x01, 0x40, 0x68, 0x08, 0x03,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x41, 0x84, 0x04, 0x60, 0x23, 0x01,
  0x90, 0x08, 0xC0, 0xC3, 0x0C, 0x0F, 0x81, 0x83, 0x18, 0x09, 0x80, 0x6C,
  0x03, 0x60, 0x13, 0x01, 0x8C, 0x18, 0x3F, 0x00, 0x0F, 0x86, 0x09, 0x81,
  0xA0, 0x1C, 0x03, 0x80, 0x70, 0x1A, 0x03, 0x61, 0xE7, 0xC8, 0x03, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x70, 0x00, 0x33, 0x30, 0x00, 0x00,
  0x00, 0xEE, 0xC0, 0x0C, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8C,
  0x30, 0x86, 0x10, 0xC0, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x06, 0x00, 0x80, 0x00, 0x1F, 0x08, 0x24, 0x07, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x0E, 0x1E, 0x06, 0x01, 0x00, 0x40, 0x00, 0x00, 0x03, 0x01,
  0xC0, 0x30, 0x00, 0x0F, 0x83, 0x08, 0xC0, 0x90, 0x14, 0x02, 0x87, 0x51,
  0x1E, 0x43, 0x88, 0x73, 0x0E, 0x61, 0x4C, 0x29, 0x8D, 0x12, 0xA3, 0xB4,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x1F, 0x80, 0x00, 0xC0, 0x1C, 0x01, 0x40,
  0x34, 0x02, 0x60, 0x66, 0x04, 0x20, 0xC2, 0x0C, 0x20, 0x82, 0x18, 0x21,
  0xFF, 0x30, 0x32, 0x03, 0x60, 0x14, 0x01, 0xC0, 0x10, 0x1F, 0xC1, 0x02,
  0x10, 0x13, 0x01, 0x30, 0x13, 0x03, 0x20, 0x32, 0x06, 0x3F, 0x86, 0x06,
  0x60, 0x26, 0x03, 0x40, 0x24, 0x02, 0x40, 0x6C, 0x0C, 0xFF, 0x80, 0x07,
  0xC1, 0x86, 0x30, 0x22, 0x03, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x04, 0x40, 0xC6, 0x18, 0x3E,
  0x00, 0x1F, 0xC1, 0x06, 0x10, 0x31, 0x01, 0x30, 0x13, 0x01, 0x30, 0x12,
  0x01, 0x20, 0x12, 0x01, 0x60, 0x36, 0x03, 0x60, 0x24, 0x06, 0x40, 0x44,
  0x18, 0xFF, 0x00, 0x1F, 0xF8, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x3F, 0xF1, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xE1, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x07,
  0xC1, 0x86, 0x30, 0x22, 0x03, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x3E, 0x84, 0x68, 0x04, 0x80, 0x48, 0x0C, 0xC1, 0x46, 0x1C, 0x3E,
  0xC0, 0x10, 0x08, 0x80, 0xCC, 0x06, 0x60, 0x23, 0x01, 0x10, 0x08, 0x80,
  0x44, 0x06, 0x7F, 0xF3, 0x01, 0x98, 0x08, 0x80, 0x44, 0x02, 0x20, 0x33,
  0x01, 0x98, 0x0C, 0xC0, 0x40, 0x1F, 0xF8, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x09, 0x03, 0x20, 0x46, 0x18, 0x7C, 0x00, 0x10, 0x0C, 0x40,
  0x61, 0x03, 0x0C, 0x18, 0x30, 0xC0, 0xC6, 0x02, 0x30, 0x09, 0x80, 0x2E,
  0x01, 0xEC, 0x07, 0x10, 0x18, 0x60, 0x40, 0x81, 0x03, 0x04, 0x04, 0x30,
  0x18, 0xC0, 0x20, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xFF,
  0xC0, 0x30, 0x19, 0xC0, 0xCA, 0x0A, 0x50, 0xF2, 0xC5, 0x92, 0x69, 0x92,
  0x4C, 0xA2, 0x47, 0x12, 0x11, 0x90, 0x8C, 0x80, 0x4C, 0x02, 0x60, 0x12,
  0x00, 0x90, 0x0C, 0x80, 0x60, 0x18, 0x08, 0xC0, 0xCF, 0x06, 0x68, 0x22,
  0x41, 0x12, 0x08, 0x98, 0x44, 0x46, 0x62, 0x33, 0x11, 0x90, 0xC8, 0x82,
  0x44, 0x12, 0x20, 0xD3, 0x03, 0x98, 0x1C, 0x80, 0xC0, 0x0F, 0x81, 0x84,
  0x20, 0x26, 0x02, 0x40, 0x2C, 0x03, 0xC0, 0x2C, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x68, 0x06, 0x80, 0x48, 0x0C, 0xC0, 0x84, 0x30, 0x3E, 0x00, 0x1F,
  0xE0, 0x80, 0x84, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0x80, 0x44, 0x06,
  0x3F, 0xC1, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x0F, 0x81, 0x84, 0x20, 0x26, 0x02, 0x40, 0x24, 0x03,
  0xC0, 0x2C, 0x02, 0x80, 0x28, 0x02, 0x80, 0x68, 0x06, 0x80, 0x48, 0x0C,
  0xC0, 0x84, 0x30, 0x3E, 0x00, 0xC0, 0x04, 0x60, 0x68, 0x03, 0x00, 0x1F,
  0xE0, 0x80, 0x84, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0x80, 0x44, 0x06,
  0x3F, 0xC1, 0x18, 0x18, 0x40, 0xC3, 0x04, 0x18, 0x20, 0x41, 0x03, 0x08,
  0x08, 0xC0, 0x60, 0x07, 0xC0, 0xC1, 0x8C, 0x06, 0x40, 0x02, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x13, 0x01, 0x8C, 0x18, 0x3F, 0x00, 0xFF, 0xF8, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x20,
  0x12, 0x03, 0x60, 0x36, 0x02, 0x60, 0x24, 0x02, 0x40, 0x24, 0x06, 0xC0,
  0x6C, 0x04, 0xC0, 0x48, 0x04, 0x80, 0xC8, 0x0C, 0x80, 0x8C, 0x10, 0x3E,
  0x00, 0x80, 0x38, 0x02, 0x80, 0x6C, 0x04, 0xC0, 0x44, 0x0C, 0x40, 0x84,
  0x18, 0x41, 0x04, 0x30, 0x62, 0x06, 0x60, 0x24, 0x02, 0xC0, 0x28, 0x03,
  0x80, 0x30, 0x00, 0x20, 0x04, 0x80, 0x32, 0x00, 0x98, 0x02, 0x60, 0x09,
  0x8C, 0x66, 0x31, 0x11, 0x44, 0x45, 0x11, 0x34, 0xC4, 0x92, 0x12, 0x48,
  0x51, 0xA1, 0x47, 0x87, 0x0C, 0x18, 0x30, 0xE0, 0xC0, 0x18, 0x06, 0x10,
  0x18, 0x30, 0x20, 0x20, 0x80, 0x63, 0x00, 0x4C, 0x00, 0xB0, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x1A, 0x00, 0x66, 0x01, 0x84, 0x02, 0x0C, 0x0C,
  0x08, 0x30, 0x18, 0xC0, 0x18, 0xC0, 0x0D, 0x00, 0x66, 0x03, 0x08, 0x18,
  0x30, 0x40, 0x43, 0x01, 0x18, 0x06, 0x40, 0x0A, 0x00, 0x38, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x1F,
  0xFE, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xF0, 0x0F, 0xC2, 0x01, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xFE, 0x00, 0x84, 0x21,
  0x04, 0x21, 0x08, 0x21, 0x08, 0x43, 0x08, 0x42, 0x10, 0x42, 0x10, 0x80,
  0x0F, 0xC0, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x08, 0xFE, 0x00, 0x03, 0x00, 0xE0, 0x36, 0x04, 0x41, 0x0C, 0x60, 0x98,
  0x12, 0x01, 0x80, 0x20, 0xFF, 0xF0, 0xB5, 0x0F, 0xB1, 0x87, 0x20, 0x26,
  0x02, 0x40, 0x24, 0x06, 0x40, 0x6C, 0x06, 0x40, 0x44, 0x0C, 0x61, 0x43,
  0xE7, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x19, 0xE3, 0xC6,
  0x60, 0x6C, 0x0D, 0x00, 0xA0, 0x3C, 0x07, 0x80, 0xA0, 0x16, 0x06, 0xA1,
  0x93, 0xC0, 0x0F, 0x8C, 0x36, 0x05, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x80, 0xF0, 0x26, 0x30, 0xF8, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x3E, 0xC3, 0x0E, 0x20, 0x23, 0x01, 0x10, 0x08, 0x80,
  0x44, 0x06, 0x60, 0x31, 0x01, 0x08, 0x18, 0x61, 0x41, 0xF6, 0x00, 0x0F,
  0x86, 0x19, 0x81, 0x20, 0x3C, 0x0D, 0x07, 0x3F, 0x04, 0x00, 0x80, 0xD8,
  0x19, 0x86, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x07, 0xFF, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x02, 0x08, 0x02, 0x30, 0x02, 0x60, 0x02, 0x80, 0x03, 0x00, 0x00,
  0x0F, 0xB1, 0x87, 0x20, 0x26, 0x02, 0x40, 0x24, 0x02, 0x40, 0x6C, 0x06,
  0x40, 0x44, 0x0C, 0x61, 0x43, 0xE4, 0x00, 0xC0, 0x08, 0x00, 0x8C, 0x30,
  0x7E, 0x00, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x79, 0xA3,
  0x70, 0x58, 0x14, 0x05, 0x01, 0x40, 0xF0, 0x3C, 0x0A, 0x02, 0x80, 0xA0,
  0x60, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x20,
  0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x86, 0x28, 0x98, 0x16,
  0x03, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x42, 0x08, 0x21, 0x02, 0x20, 0x2C, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x67, 0x86, 0x8C, 0x70, 0x46,
  0x04, 0x40, 0xC4, 0x18, 0xCE, 0x0D, 0x80, 0xCC, 0x38, 0x46, 0x86, 0xC8,
  0x30, 0xFC, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08,
  0x0C, 0x06, 0x03, 0x01, 0x04, 0x8C, 0x4C, 0x68, 0x18, 0x00, 0x2E, 0x73,
  0x94, 0xD8, 0xC6, 0x84, 0x24, 0x21, 0x21, 0x09, 0x08, 0x58, 0xC2, 0x86,
  0x34, 0x21, 0x21, 0x09, 0x08, 0x40, 0x27, 0x9A, 0x37, 0x05, 0x81, 0x40,
  0x50, 0x14, 0x0F, 0x03, 0xC0, 0xA0, 0x28, 0x0A, 0x06, 0x0F, 0x06, 0x19,
  0x81, 0x60, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0x80, 0xD0, 0x11, 0x04,
  0x1F, 0x00, 0x33, 0xC3, 0xC6, 0x30, 0x33, 0x03, 0x20, 0x12, 0x03, 0x60,
  0x36, 0x02, 0x40, 0x26, 0x06, 0x50, 0xC4, 0xF0, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x00, 0x0F, 0xB1, 0x87, 0x20, 0x26, 0x02, 0x40, 0x24,
  0x02, 0x40, 0x6C, 0x06, 0x40, 0x44, 0x0C, 0x61, 0x43, 0xE4, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0xF9, 0xE3, 0xC0, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x00, 0x0F,
  0xC1, 0x86, 0x30, 0x32, 0x00, 0x30, 0x01, 0xF0, 0x01, 0xC0, 0x06, 0x00,
  0x24, 0x06, 0xE0, 0xC3, 0xF8, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC1,
  0xFF, 0xC2, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x04, 0x21,
  0xCC, 0xC1, 0xB0, 0x38, 0x00, 0x60, 0x6C, 0x09, 0x01, 0x20, 0x24, 0x04,
  0x81, 0xB0, 0x36, 0x04, 0xC0, 0x98, 0x71, 0x0A, 0x3E, 0xC0, 0xF0, 0x46,
  0x0C, 0xC1, 0x98, 0x32, 0x06, 0x40, 0xC8, 0x11, 0x06, 0x60, 0x8C, 0x21,
  0x18, 0x3C, 0x00, 0x21, 0x11, 0x08, 0x98, 0xC6, 0xC4, 0x34, 0x21, 0xA1,
  0x0D, 0x08, 0x48, 0x42, 0xC6, 0x36, 0x51, 0x32, 0x98, 0xE7, 0x80, 0x0E,
  0x38, 0xE9, 0x36, 0x38, 0x40, 0x61, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0xC5, 0x03, 0x14, 0x64, 0xD3, 0x1E, 0x30, 0x30, 0x33, 0x02, 0x20,
  0x22, 0x02, 0x20, 0x22, 0x06, 0x60, 0x66, 0x04, 0x60, 0x46, 0x1C, 0x21,
  0x41, 0xEC, 0x00, 0xC0, 0x08, 0x01, 0x8C, 0x30, 0x7E, 0x00, 0x1F, 0x12,
  0x0D, 0x20, 0x22, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x84, 0x30, 0x26,
  0x02, 0xFE, 0x2C, 0x3E, 0x07, 0xE0, 0x80, 0x30, 0x06, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x83, 0xE0, 0x06, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xE0, 0x08, 0xC4, 0x21,
  0x08, 0xC6, 0x21, 0x08, 0x46, 0x31, 0x08, 0x42, 0x31, 0x08, 0x00, 0x0F,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x20, 0x04, 0x00,
  0xC0, 0x07, 0x83, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x0F, 0xC0, 0x1C, 0x19, 0x20, 0x90, 0x84, 0x86, 0x48, 0x1C,
  0x00,
};

const GFXglyph IBMPlexMono_LightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 17, 14, 5, -17 },
  { 12, 6, 6, 14, 6, -18 },
  { 17, 15, 17, 14, 0, -17 },
  { 49, 13, 21, 14, 1, -19 },
  { 84, 16, 17, 14, 0, -17 },
  { 118, 14, 17, 14, 0, -17 },
  { 148, 3, 6, 14, 7, -18 },
  { 151, 9, 21, 14, 5, -18 },
  { 175, 9, 21, 14, 1, -18 },
  { 199, 13, 12, 14, 1, -13 },
  { 219, 11, 11, 14, 2, -13 },
  { 235, 5, 7, 14, 3, -3 },
  { 240, 7, 1, 14, 4, -8 },
  { 241, 3, 3, 14, 5, -3 },
  { 243, 13, 21, 14, 1, -18 },
  { 278, 12, 17, 14, 2, -17 },
  { 304, 11, 17, 14, 1, -17 },
  { 328, 12, 17, 14, 1, -17 },
  { 354, 12, 17, 14, 1, -17 },
  { 380, 13, 17, 14, 0, -17 },
  { 408, 13, 17, 14, 1, -17 },
  { 436, 11, 17, 14, 2, -17 },
  { 460, 11, 17, 14, 3, -17 },
  { 484, 13, 17, 14, 1, -17 },
  { 512, 11, 17, 14, 2, -17 },
  { 536, 4, 13, 14, 5, -13 },
  { 543, 6, 17, 14, 3, -13 },
  { 556, 12, 13, 14, 2, -14 },
  { 576, 13, 5, 14, 1, -10 },
  { 585, 12, 13, 14, 1, -14 },
  { 605, 10, 17, 14, 3, -17 },
  { 627, 11, 20, 14, 2, -17 },
  { 655, 12, 17, 14, 0, -17 },
  { 681, 12, 17, 14, 1, -17 },
  { 707, 12, 17, 14, 2, -17 },
  { 733, 12, 17, 14, 1, -17 },
  { 759, 13, 17, 14, 1, -17 },
  { 787, 13, 17, 14, 1, -17 },
  { 815, 12, 17, 14, 2, -17 },
  { 841, 13, 17, 14, 1, -17 },
  { 869, 13, 17, 14, 1, -17 },
  { 897, 11, 17, 14, 2, -17 },
  { 921, 14, 17, 14, 1, -17 },
  { 951, 10, 17, 14, 2, -17 },
  { 973, 13, 17, 14, 1, -17 },
  { 1001, 13, 17, 14, 1, -17 },
  { 1029, 12, 17, 14, 2, -17 },
  { 1055, 13, 17, 14, 1, -17 },
  { 1083, 12, 21, 14, 2, -17 },
  { 1115, 13, 17, 14, 1, -17 },
  { 1143, 13, 17, 14, 1, -17 },
  { 1171, 13, 17, 14, 2, -17 },
  { 1199, 12, 17, 14, 2, -17 },
  { 1225, 12, 17, 14, 3, -17 },
  { 1251, 14, 17, 14, 1, -17 },
  { 1281, 15, 17, 14, 0, -17 },
  { 1313, 14, 17, 14, 2, -17 },
  { 1343, 15, 17, 14, 0, -17 },
  { 1375, 10, 21, 14, 4, -18 },
  { 1402, 5, 21, 14, 5, -18 },
  { 1416, 10, 21, 14, 0, -18 },
  { 1443, 11, 9, 14, 2, -17 },
  { 1456, 12, 1, 14, 0, 3 },
  { 1458, 2, 4, 14, 6, -18 },
  { 1459, 12, 12, 14, 1, -12 },
  { 1477, 11, 18, 14, 2, -18 },
  { 1502, 10, 12, 14, 2, -12 },
  { 1517, 13, 18, 14, 1, -18 },
  { 1547, 11, 12, 14, 2, -12 },
  { 1564, 15, 23, 14, 0, -18 },
  { 1608, 12, 17, 14, 1, -12 },
  { 1634, 10, 18, 14, 2, -18 },
  { 1657, 11, 18, 14, 2, -18 },
  { 1682, 11, 23, 14, 2, -18 },
  { 1714, 12, 18, 14, 2, -18 },
  { 1741, 9, 18, 14, 3, -18 },
  { 1762, 13, 12, 14, 1, -12 },
  { 1782, 10, 12, 14, 2, -12 },
  { 1797, 11, 12, 14, 2, -12 },
  { 1814, 12, 17, 14, 1, -12 },
  { 1840, 12, 17, 14, 1, -12 },
  { 1866, 11, 12, 14, 3, -12 },
  { 1883, 12, 12, 14, 1, -12 },
  { 1901, 11, 17, 14, 2, -17 },
  { 1925, 11, 12, 14, 2, -12 },
  { 1942, 11, 12, 14, 2, -12 },
  { 1959, 13, 12, 14, 1, -12 },
  { 1979, 14, 12, 14, 0, -12 },
  { 2000, 12, 17, 14, 1, -12 },
  { 2026, 12, 12, 14, 1, -12 },
  { 2044, 11, 21, 14, 3, -18 },
  { 2073, 5, 21, 14, 5, -18 },
  { 2087, 11, 21, 14, 1, -18 },
  { 2116, 13, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_LightItalic24pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic24pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic24pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _IBMPLEXMONO_LIGHTITALIC24PT7B_H_
