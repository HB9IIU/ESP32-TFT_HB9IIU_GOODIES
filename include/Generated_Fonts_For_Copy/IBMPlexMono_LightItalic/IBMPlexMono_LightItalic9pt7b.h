#ifndef _IBMPLEXMONO_LIGHTITALIC9PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0x20, 0xF0, 0x29, 0xB5, 0x14, 0xDA, 0x80, 0x11, 0x9A, 0xC1,
  0xD5, 0xC8, 0x66, 0xA7, 0x16, 0xAA, 0x60, 0x32, 0x95, 0x49, 0xFC, 0xC0,
  0x6A, 0x49, 0x26, 0x22, 0x11, 0x22, 0x2C, 0x4D, 0x6A, 0x44, 0xF4, 0x40,
  0x60, 0xE0, 0x80, 0x08, 0x84, 0x42, 0x21, 0x10, 0x79, 0x9D, 0x9E, 0x33,
  0x98, 0x42, 0x7C, 0x3A, 0x42, 0x26, 0x78, 0x3A, 0x4C, 0x29, 0x38, 0x09,
  0x95, 0x2F, 0x88, 0x3A, 0x1C, 0x98, 0xB8, 0x2C, 0xE9, 0x9E, 0xF9, 0x24,
  0x48, 0x3A, 0x4D, 0x98, 0xB8, 0x79, 0x9E, 0x2C, 0xC0, 0x80, 0x60, 0x05,
  0x00, 0x16, 0x84, 0x20, 0x78, 0x3E, 0x41, 0x82, 0x6C, 0x00, 0x79, 0x24,
  0x04, 0x79, 0xFD, 0xE8, 0xE0, 0x11, 0x94, 0xA7, 0x44, 0x7A, 0x5D, 0x18,
  0xF8, 0x69, 0x88, 0xBE, 0xE9, 0x99, 0x9E, 0x7A, 0x1F, 0x08, 0x78, 0x7A,
  0x1F, 0x08, 0x40, 0x69, 0x8B, 0x9E, 0x4A, 0x5F, 0x19, 0x48, 0x79, 0x08,
  0x42, 0x78, 0x71, 0x22, 0xAE, 0x4D, 0x46, 0x18, 0x92, 0x60, 0x92, 0x49,
  0xC0, 0x4A, 0xEF, 0x58, 0xC8, 0x4B, 0x5B, 0x59, 0x48, 0x79, 0x99, 0x9E,
  0x7A, 0x52, 0xF8, 0x40, 0x79, 0x99, 0x9E, 0x52, 0x7A, 0x52, 0xF9, 0x48,
  0x32, 0x58, 0x38, 0xB8, 0xFA, 0x10, 0x84, 0x20, 0x99, 0x99, 0xAE, 0x9C,
  0xA9, 0x4C, 0x20, 0x8E, 0xB5, 0x6A, 0x50, 0x4D, 0x43, 0x08, 0x52, 0x60,
  0x9C, 0x98, 0x84, 0x20, 0x78, 0x44, 0xC8, 0x7C, 0x72, 0x49, 0x26, 0xAA,
  0xA5, 0x71, 0x22, 0x22, 0x2E, 0x26, 0x99, 0xF0, 0xC0, 0xF9, 0xAA, 0xD0,
  0x88, 0xE9, 0x99, 0xE0, 0x69, 0x8A, 0xC0, 0x11, 0xF9, 0xAA, 0xE0, 0x69,
  0xEA, 0xF0, 0x1C, 0x47, 0x88, 0x20, 0x8A, 0x28, 0x40, 0x3A, 0x65, 0x27,
  0x49, 0x80, 0x88, 0xE9, 0xAA, 0xA0, 0x20, 0xC4, 0x4B, 0x40, 0x10, 0xE2,
  0x22, 0xAC, 0x40, 0x88, 0xE9, 0xED, 0xA0, 0xC4, 0x44, 0xAB, 0x40, 0xBF,
  0x6B, 0x5A, 0x80, 0xE9, 0xAA, 0xA0, 0x69, 0x9A, 0xE0, 0x72, 0x63, 0x1F,
  0x42, 0x00, 0xF9, 0xAA, 0xE2, 0x20, 0xD6, 0x48, 0x80, 0x32, 0x5C, 0x2F,
  0x00, 0x4F, 0x48, 0xB4, 0x99, 0xAE, 0xE0, 0x99, 0x9A, 0xC0, 0xED, 0x6B,
  0x55, 0x00, 0x3F, 0x49, 0xDD, 0x00, 0x4A, 0x65, 0x27, 0x49, 0x80, 0x7C,
  0x4C, 0xAF, 0x80, 0x34, 0x2C, 0x44, 0x86, 0x6A, 0xAA, 0x30, 0x88, 0x36,
  0x10, 0x9C, 0x6C, 0x80,
};

const GFXglyph IBMPlexMono_LightItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 2, -6 },
  { 3, 2, 2, 5, 2, -7 },
  { 4, 6, 6, 5, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 6, 6, 5, 0, -6 },
  { 19, 5, 6, 5, 0, -6 },
  { 23, 1, 2, 5, 3, -7 },
  { 24, 3, 8, 5, 2, -7 },
  { 27, 4, 8, 5, 0, -7 },
  { 31, 4, 4, 5, 1, -5 },
  { 33, 4, 5, 5, 1, -5 },
  { 36, 2, 2, 5, 1, -1 },
  { 37, 3, 1, 5, 1, -3 },
  { 38, 1, 1, 5, 2, -1 },
  { 39, 5, 8, 5, 0, -7 },
  { 44, 4, 6, 5, 1, -6 },
  { 47, 5, 6, 5, 0, -6 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 5, 6, 5, 0, -6 },
  { 59, 5, 6, 5, 0, -6 },
  { 63, 5, 6, 5, 0, -6 },
  { 67, 4, 6, 5, 1, -6 },
  { 70, 4, 6, 5, 1, -6 },
  { 73, 5, 6, 5, 0, -6 },
  { 77, 4, 6, 5, 1, -6 },
  { 80, 2, 5, 5, 2, -5 },
  { 82, 3, 6, 5, 1, -5 },
  { 85, 4, 5, 5, 1, -5 },
  { 88, 5, 3, 5, 0, -4 },
  { 90, 5, 5, 5, 0, -5 },
  { 94, 4, 6, 5, 1, -6 },
  { 97, 4, 7, 5, 1, -6 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 5, 6, 5, 0, -6 },
  { 109, 4, 6, 5, 1, -6 },
  { 112, 4, 6, 5, 1, -6 },
  { 115, 5, 6, 5, 0, -6 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 4, 6, 5, 1, -6 },
  { 126, 5, 6, 5, 0, -6 },
  { 130, 5, 6, 5, 0, -6 },
  { 134, 4, 6, 5, 1, -6 },
  { 137, 6, 6, 5, 0, -6 },
  { 142, 3, 6, 5, 1, -6 },
  { 145, 5, 6, 5, 0, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 4, 6, 5, 1, -6 },
  { 156, 5, 6, 5, 0, -6 },
  { 160, 4, 8, 5, 1, -6 },
  { 164, 5, 6, 5, 0, -6 },
  { 168, 5, 6, 5, 0, -6 },
  { 172, 5, 6, 5, 1, -6 },
  { 176, 4, 6, 5, 1, -6 },
  { 179, 5, 6, 5, 1, -6 },
  { 183, 5, 6, 5, 1, -6 },
  { 187, 6, 6, 5, 0, -6 },
  { 192, 5, 6, 5, 1, -6 },
  { 196, 5, 6, 5, 0, -6 },
  { 200, 3, 8, 5, 2, -7 },
  { 203, 2, 8, 5, 2, -7 },
  { 205, 4, 8, 5, 0, -7 },
  { 209, 4, 4, 5, 1, -6 },
  { 211, 4, 1, 5, 0, 1 },
  { 212, 1, 2, 5, 2, -8 },
  { 213, 4, 5, 5, 1, -5 },
  { 216, 4, 7, 5, 1, -7 },
  { 220, 4, 5, 5, 1, -5 },
  { 223, 4, 7, 5, 1, -7 },
  { 227, 4, 5, 5, 1, -5 },
  { 230, 6, 9, 5, 0, -7 },
  { 237, 5, 7, 5, 0, -5 },
  { 242, 4, 7, 5, 1, -7 },
  { 246, 4, 7, 5, 1, -7 },
  { 250, 4, 9, 5, 1, -7 },
  { 255, 4, 7, 5, 1, -7 },
  { 259, 4, 7, 5, 1, -7 },
  { 263, 5, 5, 5, 0, -5 },
  { 267, 4, 5, 5, 1, -5 },
  { 270, 4, 5, 5, 1, -5 },
  { 273, 5, 7, 5, 0, -5 },
  { 278, 4, 7, 5, 1, -5 },
  { 282, 4, 5, 5, 1, -5 },
  { 285, 5, 5, 5, 0, -5 },
  { 289, 4, 6, 5, 1, -6 },
  { 292, 4, 5, 5, 1, -5 },
  { 295, 4, 5, 5, 1, -5 },
  { 298, 5, 5, 5, 0, -5 },
  { 302, 5, 5, 5, 0, -5 },
  { 306, 5, 7, 5, 0, -5 },
  { 311, 5, 5, 5, 0, -5 },
  { 315, 4, 8, 5, 1, -7 },
  { 319, 2, 8, 5, 2, -7 },
  { 321, 5, 8, 5, 0, -7 },
  { 326, 5, 2, 5, 0, -4 },
};

const GFXfont IBMPlexMono_LightItalic9pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic9pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _IBMPLEXMONO_LIGHTITALIC9PT7B_H_
