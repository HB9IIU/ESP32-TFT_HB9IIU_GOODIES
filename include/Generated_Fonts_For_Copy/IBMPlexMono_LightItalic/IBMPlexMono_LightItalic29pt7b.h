#ifndef _IBMPLEXMONO_LIGHTITALIC29PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x21, 0x86, 0x18, 0x61, 0x84, 0x10, 0xC2, 0x08, 0x20, 0x00,
  0x00, 0x03, 0x8E, 0x38, 0x66, 0x8D, 0x1E, 0x3C, 0x58, 0xA3, 0x46, 0x00,
  0x63, 0x00, 0x10, 0x80, 0x0C, 0x20, 0x03, 0x18, 0x00, 0x84, 0x00, 0x61,
  0x01, 0xF8, 0xFC, 0xFC, 0x3F, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x21, 0x00,
  0x18, 0xC0, 0x7C, 0x3F, 0x3F, 0x0F, 0xC0, 0xC6, 0x00, 0x21, 0x80, 0x08,
  0x40, 0x06, 0x30, 0x01, 0x0C, 0x00, 0xC2, 0x00, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x03, 0xF0, 0x0F, 0xFC, 0x1C, 0x4E, 0x18, 0x43, 0x30, 0xC2,
  0x30, 0x80, 0x30, 0x80, 0x38, 0x80, 0x1E, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x01, 0x1C, 0x01, 0x0C, 0x01, 0x0C, 0x01, 0x0C, 0x83, 0x0C, 0xC2, 0x1C,
  0x72, 0x38, 0x3F, 0xF0, 0x0F, 0xC0, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x30, 0x7E, 0x06, 0x0C, 0x20, 0x41, 0x83, 0x08, 0x18, 0x31,
  0x81, 0x02, 0x30, 0x10, 0x22, 0x01, 0x86, 0x40, 0x0F, 0xCC, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x13, 0xF8, 0x02, 0x31, 0x80, 0x66, 0x08, 0x0C,
  0x40, 0x80, 0x84, 0x08, 0x10, 0x41, 0x83, 0x06, 0x30, 0x60, 0x7F, 0x0C,
  0x03, 0xC0, 0x01, 0xF0, 0x03, 0xFC, 0x01, 0x87, 0x01, 0x81, 0x80, 0xC0,
  0xC0, 0x60, 0x60, 0x10, 0x30, 0x0C, 0x10, 0x02, 0x18, 0x0F, 0xF8, 0x0E,
  0xF0, 0x0C, 0x30, 0x0C, 0x08, 0x06, 0x06, 0x03, 0x01, 0x85, 0x80, 0xC3,
  0xC0, 0xB3, 0x30, 0xCD, 0x9F, 0xC7, 0x83, 0xC1, 0x80, 0x6D, 0x2D, 0xB6,
  0x00, 0xC0, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01,
  0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x03,
  0x00, 0x80, 0x40, 0x60, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x03, 0x8C, 0x77, 0xFF, 0x83, 0xF0, 0x07, 0x00, 0x36, 0x01,
  0x88, 0x0C, 0x30, 0x60, 0x41, 0x81, 0x80, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x1C, 0xE3, 0x0C, 0x61,
  0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x03, 0xE0,
  0x3F, 0xE1, 0xC1, 0x8E, 0x03, 0x30, 0x0D, 0x80, 0x16, 0x00, 0x58, 0x01,
  0xC0, 0x0F, 0x0C, 0x3C, 0x38, 0xF0, 0xC3, 0xC0, 0x0F, 0x00, 0x6C, 0x01,
  0xB0, 0x0C, 0xC0, 0x31, 0x83, 0x87, 0xFC, 0x07, 0xC0, 0x00, 0xE0, 0x07,
  0x80, 0x3E, 0x03, 0xD8, 0x1C, 0x60, 0xE1, 0x01, 0x04, 0x08, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x0F, 0xF0,
  0x38, 0x70, 0xC0, 0x31, 0x80, 0x66, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x01, 0xF0,
  0x0F, 0xF8, 0x38, 0x30, 0xC0, 0x31, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x0C, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x60, 0x0C, 0xC0, 0x18, 0xE0, 0xE0, 0xFF, 0x80, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x60, 0x0C, 0x80, 0x31, 0x00,
  0xC6, 0x01, 0x0C, 0x04, 0x18, 0x10, 0x20, 0x60, 0x41, 0x80, 0x86, 0x03,
  0x08, 0x06, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x09, 0xF0, 0x2F, 0xF0, 0xE1, 0xC6, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xA0, 0x0C, 0xC0, 0x33, 0x83, 0x87, 0xFC, 0x07,
  0xC0, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x06, 0xF8, 0x6F, 0xF3, 0xC1, 0xD8, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x33, 0x07, 0x1F, 0xF0, 0x3F, 0x00, 0x7F, 0xFD,
  0xFF, 0xF4, 0x00, 0x90, 0x06, 0xC0, 0x13, 0x00, 0xC0, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x01, 0xF8, 0x0F,
  0xF8, 0x38, 0x38, 0xC0, 0x31, 0x80, 0x22, 0x00, 0x44, 0x01, 0x8C, 0x02,
  0x0C, 0x1C, 0x0F, 0xE0, 0x3F, 0xC1, 0xC0, 0xC6, 0x00, 0xCC, 0x00, 0xB0,
  0x03, 0x60, 0x06, 0xE0, 0x1C, 0xE0, 0x70, 0xFF, 0xC0, 0xFE, 0x00, 0x07,
  0xC0, 0xFF, 0x8E, 0x0C, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x03, 0xB8, 0x3C, 0xFF, 0x63, 0xE6, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x19, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x73, 0x80, 0x06, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x0C, 0x18, 0x60, 0xC3, 0x00, 0x00,
  0x08, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x04, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xBF, 0xFE, 0x10, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x06, 0x00, 0x20, 0x00, 0x0F, 0x81, 0xFE, 0x30, 0x66,
  0x03, 0xC0, 0x34, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x0F, 0x80,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x78, 0x03,
  0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xC1, 0x86, 0x03, 0x30, 0x0C, 0xC0, 0x16,
  0x1E, 0xD8, 0xFF, 0x63, 0x1D, 0x18, 0x24, 0x40, 0xB1, 0x02, 0xCC, 0x1B,
  0x30, 0x68, 0xC3, 0xA1, 0x94, 0x87, 0xD3, 0x0C, 0x0C, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x40,
  0x06, 0xC0, 0x09, 0x80, 0x33, 0x00, 0x46, 0x01, 0x84, 0x02, 0x08, 0x0C,
  0x10, 0x10, 0x30, 0x60, 0x60, 0xFF, 0xC3, 0xFF, 0x84, 0x03, 0x18, 0x02,
  0x30, 0x06, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x30, 0x0F, 0xF8, 0x1F, 0xF8,
  0x60, 0x30, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xC4, 0x01, 0x88, 0x06, 0x30,
  0x18, 0x7F, 0xE0, 0xFF, 0xC1, 0x80, 0xE3, 0x00, 0xC4, 0x01, 0x98, 0x03,
  0x30, 0x06, 0x60, 0x0C, 0xC0, 0x71, 0xFF, 0xC7, 0xFF, 0x00, 0x01, 0xF0,
  0x0F, 0xF0, 0x38, 0x70, 0xC0, 0x63, 0x00, 0x46, 0x00, 0x58, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x06, 0x20, 0x0C, 0x60, 0x30, 0xE0, 0xC0, 0xFF, 0x00, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0xC1, 0x03, 0x8C, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00,
  0x4C, 0x01, 0x20, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x00,
  0x64, 0x01, 0xB0, 0x0E, 0xC0, 0x33, 0x03, 0x8F, 0xFC, 0x3F, 0xC0, 0x1F,
  0xFE, 0x3F, 0xFC, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF, 0xC7, 0xFF,
  0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xC1, 0x86, 0x03, 0x30, 0x04,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x1F, 0xB0, 0x7E,
  0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0x60, 0x31, 0xC3, 0x43, 0xFB,
  0x07, 0xCC, 0x08, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x02, 0x18, 0x06,
  0x10, 0x06, 0x10, 0x06, 0x30, 0x06, 0x30, 0x06, 0x3F, 0xFC, 0x3F, 0xFC,
  0x30, 0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x08, 0x60, 0x08,
  0x40, 0x18, 0x40, 0x18, 0xC0, 0x18, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x30, 0x18, 0xC0, 0x61, 0x87, 0x07, 0xF8, 0x07, 0xC0, 0x18, 0x03, 0x10,
  0x06, 0x30, 0x0C, 0x30, 0x18, 0x30, 0x30, 0x30, 0xE0, 0x31, 0xC0, 0x23,
  0x80, 0x67, 0x00, 0x6F, 0x00, 0x79, 0x80, 0x71, 0x80, 0x60, 0x80, 0x40,
  0xC0, 0xC0, 0x40, 0xC0, 0x60, 0xC0, 0x20, 0xC0, 0x30, 0x80, 0x30, 0x80,
  0x18, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0xFF, 0xFF, 0xF0, 0x1C, 0x03, 0x1C, 0x07, 0x1C, 0x0F, 0x14,
  0x0B, 0x16, 0x1B, 0x36, 0x12, 0x32, 0x32, 0x32, 0x66, 0x23, 0x46, 0x21,
  0xC6, 0x21, 0x86, 0x61, 0x84, 0x61, 0x04, 0x60, 0x0C, 0x40, 0x0C, 0x40,
  0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0x0C, 0x03, 0x1E,
  0x03, 0x1E, 0x03, 0x1A, 0x02, 0x1A, 0x02, 0x13, 0x06, 0x13, 0x06, 0x31,
  0x06, 0x31, 0x86, 0x31, 0x84, 0x31, 0x84, 0x20, 0x8C, 0x20, 0xCC, 0x60,
  0xCC, 0x60, 0x4C, 0x60, 0x48, 0x60, 0x68, 0x40, 0x78, 0x40, 0x38, 0xC0,
  0x38, 0x03, 0xE0, 0x3F, 0xE1, 0xC1, 0x8E, 0x03, 0x30, 0x0D, 0x80, 0x16,
  0x00, 0x58, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x6C, 0x01, 0xB0, 0x0C, 0xC0, 0x31, 0x83, 0x87, 0xFC, 0x07, 0xC0,
  0x1F, 0xF0, 0x3F, 0xF8, 0xC0, 0x31, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC,
  0x01, 0x90, 0x02, 0x60, 0x0C, 0xC0, 0x39, 0xFF, 0xE3, 0xFF, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xC1, 0x8E, 0x03, 0x30, 0x0D, 0x80,
  0x16, 0x00, 0x58, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x6C, 0x01, 0xB0, 0x0C, 0xC0, 0x31, 0x83, 0x87, 0xFC, 0x07,
  0xC0, 0x06, 0x08, 0x0C, 0x60, 0x1B, 0x80, 0x7C, 0x00, 0xC0, 0x1F, 0xF0,
  0x3F, 0xF8, 0xC0, 0x31, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x90,
  0x02, 0x60, 0x0C, 0xC0, 0x39, 0xFF, 0xE3, 0xFF, 0x06, 0x18, 0x08, 0x30,
  0x30, 0x30, 0x60, 0x60, 0xC0, 0x61, 0x80, 0xC3, 0x00, 0xC4, 0x01, 0x80,
  0x03, 0xF0, 0x0F, 0xFC, 0x1C, 0x0E, 0x18, 0x03, 0x30, 0x02, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x80, 0x0C, 0xC0, 0x1C, 0x70, 0x38,
  0x3F, 0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x06, 0x60, 0x0C,
  0xC0, 0x19, 0x80, 0x23, 0x00, 0xC4, 0x01, 0x88, 0x03, 0x30, 0x06, 0x60,
  0x0C, 0xC0, 0x11, 0x80, 0x62, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x04,
  0x60, 0x18, 0xC0, 0x30, 0xC1, 0xC1, 0xFF, 0x00, 0xFC, 0x00, 0xC0, 0x06,
  0x80, 0x0D, 0x00, 0x33, 0x00, 0x66, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x30,
  0x18, 0x20, 0x60, 0x40, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0x40, 0x09, 0x80, 0x12, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x60, 0x01, 0x60, 0x03, 0x60, 0x03, 0x60, 0x02, 0x60, 0x02, 0x41, 0x86,
  0x43, 0x86, 0x42, 0x84, 0x42, 0x84, 0x46, 0x8C, 0xC4, 0x8C, 0xCC, 0x88,
  0xC8, 0x88, 0xD8, 0x98, 0xD8, 0xD8, 0xD0, 0xD0, 0xB0, 0xD0, 0xA0, 0xF0,
  0xE0, 0xF0, 0xE0, 0x60, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0x60, 0x30, 0x18,
  0x18, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x11, 0x80, 0x06, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0x30, 0x01, 0x8C, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x18, 0x08, 0x0C, 0x03, 0x06, 0x00, 0x43, 0x00,
  0x18, 0xC0, 0x07, 0xC0, 0x06, 0x60, 0x0C, 0x60, 0x18, 0x30, 0x30, 0x30,
  0x30, 0x10, 0x60, 0x18, 0xC0, 0x09, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xFF, 0x0F, 0xF0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x20, 0x20,
  0x20, 0x30, 0x10, 0x10, 0x10, 0x18, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x04,
  0x04, 0x04, 0x06, 0x02, 0x02, 0x02, 0x03, 0x0F, 0xE1, 0xFC, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0xFE, 0x1F, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x36,
  0x01, 0x88, 0x04, 0x30, 0x30, 0xC1, 0x81, 0x0C, 0x06, 0x20, 0x09, 0x80,
  0x3C, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xF0, 0xD9, 0x32, 0x0F, 0x88, 0xFE,
  0x4E, 0x0E, 0xC0, 0x36, 0x01, 0xE0, 0x0B, 0x00, 0x58, 0x02, 0xC0, 0x34,
  0x01, 0xB0, 0x1D, 0x80, 0xCE, 0x1A, 0x3F, 0x9C, 0xF8, 0xE0, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x1E, 0x0D, 0xFC,
  0x3C, 0x38, 0xA0, 0x63, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x80, 0x26, 0x00,
  0x90, 0x06, 0x40, 0x1B, 0x80, 0xCF, 0x0F, 0x37, 0xF8, 0xCF, 0x80, 0x07,
  0xC0, 0xFF, 0x0E, 0x0C, 0x60, 0x36, 0x01, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0xB0, 0x0C, 0xC0, 0xC7, 0x0C, 0x1F, 0xC0, 0x7C, 0x00,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x83,
  0xE3, 0x0F, 0xE4, 0x38, 0x28, 0xC0, 0x31, 0x80, 0x66, 0x00, 0xCC, 0x01,
  0x98, 0x02, 0x30, 0x0C, 0x40, 0x18, 0xC0, 0x31, 0x80, 0xE3, 0x86, 0x83,
  0xF9, 0x03, 0xE6, 0x00, 0x07, 0xE0, 0x7F, 0x8E, 0x06, 0x40, 0x36, 0x01,
  0xA0, 0x7B, 0xFF, 0x9F, 0xE0, 0xC0, 0x06, 0x00, 0x30, 0x06, 0xC0, 0x67,
  0x0E, 0x1F, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x81, 0x80, 0x30, 0x40, 0x0E, 0x10, 0x01, 0xCC, 0x00, 0x3B,
  0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x07, 0xC6, 0x1F, 0xC8, 0x70, 0x51,
  0x80, 0x63, 0x00, 0xCC, 0x01, 0x98, 0x02, 0x30, 0x04, 0x60, 0x18, 0x80,
  0x31, 0x80, 0x63, 0x01, 0xC7, 0x0D, 0x07, 0xF2, 0x07, 0xCC, 0x00, 0x18,
  0x00, 0x31, 0x00, 0xC3, 0x83, 0x83, 0xFE, 0x01, 0xF0, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC7, 0x86, 0x7E, 0x34,
  0x39, 0xC0, 0xCC, 0x06, 0x60, 0x36, 0x01, 0xB0, 0x09, 0x80, 0x4C, 0x06,
  0x40, 0x32, 0x01, 0xB0, 0x0D, 0x80, 0x4C, 0x06, 0x00, 0x01, 0x80, 0x0E,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x04,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x82, 0x04,
  0x18, 0x63, 0x83, 0x38, 0x17, 0x80, 0xF0, 0x07, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xE0,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x20, 0x43, 0x86, 0x0E, 0x30,
  0x39, 0x80, 0xEC, 0x03, 0xC0, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x78, 0x1B, 0xF8, 0x34, 0x38,
  0x70, 0x30, 0xC0, 0x61, 0x00, 0x86, 0x07, 0x0C, 0x78, 0x19, 0xC0, 0x33,
  0x02, 0x42, 0x0C, 0x86, 0x3F, 0x06, 0xE6, 0x0F, 0x8C, 0x0C, 0x00, 0xFF,
  0x0F, 0xE0, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x21, 0x87, 0x10,
  0xE1, 0x3C, 0x37, 0x03, 0xE0, 0x18, 0x00, 0x37, 0x1C, 0x7F, 0x7C, 0xA7,
  0x89, 0x86, 0x16, 0x08, 0x2C, 0x10, 0x58, 0x61, 0xB0, 0xC3, 0x41, 0x86,
  0x82, 0x0B, 0x04, 0x16, 0x18, 0x2C, 0x30, 0xD0, 0x61, 0xA0, 0x83, 0x00,
  0x31, 0xE1, 0x9F, 0x8D, 0x0E, 0x70, 0x33, 0x01, 0x98, 0x0D, 0x80, 0x6C,
  0x02, 0x60, 0x13, 0x01, 0x90, 0x0C, 0x80, 0x6C, 0x03, 0x60, 0x13, 0x01,
  0x80, 0x07, 0xC0, 0xFF, 0x8E, 0x0E, 0xE0, 0x36, 0x00, 0xA0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x05, 0x80, 0x66, 0x0E, 0x1F, 0xE0,
  0x7C, 0x00, 0x18, 0xF0, 0x37, 0xF0, 0x78, 0x70, 0xA0, 0x61, 0x80, 0x66,
  0x00, 0xCC, 0x01, 0x98, 0x02, 0x30, 0x04, 0x40, 0x18, 0x80, 0x33, 0x80,
  0xC7, 0x87, 0x8D, 0xFE, 0x19, 0xF0, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x8C, 0x7F, 0x23, 0x82, 0x98,
  0x06, 0x60, 0x1B, 0x00, 0x6C, 0x01, 0x30, 0x04, 0xC0, 0x32, 0x00, 0xCC,
  0x03, 0x30, 0x1C, 0xE1, 0xB1, 0xFC, 0x83, 0xE6, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0xFE, 0x7F, 0xF3, 0xF0, 0x58,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x00, 0x07, 0xE0,
  0xFF, 0x8E, 0x06, 0x40, 0x22, 0x00, 0x18, 0x00, 0xFC, 0x03, 0xFC, 0x00,
  0xF0, 0x00, 0x80, 0x05, 0x00, 0x2E, 0x07, 0x3F, 0xF0, 0x7E, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xC1,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x81, 0x82, 0x1E, 0x18, 0xE0, 0x6F, 0x01, 0xF0, 0x07, 0x00, 0x60, 0x16,
  0x03, 0x40, 0x34, 0x03, 0x40, 0x3C, 0x02, 0xC0, 0x2C, 0x06, 0x80, 0x68,
  0x06, 0x80, 0xEC, 0x14, 0xC3, 0x4F, 0xEC, 0x7C, 0xC0, 0xF8, 0x1B, 0xE0,
  0x21, 0x80, 0x86, 0x03, 0x18, 0x0C, 0x40, 0x21, 0x01, 0x84, 0x06, 0x30,
  0x18, 0xC0, 0xC3, 0x07, 0x0C, 0x38, 0x23, 0xC0, 0xFC, 0x03, 0xC0, 0x00,
  0x61, 0x8D, 0x86, 0x16, 0x18, 0x50, 0x41, 0x41, 0x05, 0x04, 0x1C, 0x30,
  0x70, 0xC1, 0x83, 0x0E, 0x08, 0x38, 0x60, 0xE1, 0x86, 0x8B, 0x3B, 0xEF,
  0xCF, 0x1E, 0x00, 0x07, 0x0F, 0x07, 0xCF, 0x87, 0x6C, 0x66, 0x14, 0x34,
  0x0A, 0x08, 0x06, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x60, 0xC0,
  0x30, 0x70, 0x58, 0x78, 0xC4, 0x6C, 0xC3, 0xE3, 0xC0, 0xE1, 0xC0, 0x18,
  0x04, 0x60, 0x31, 0x00, 0xC4, 0x03, 0x10, 0x0C, 0xC0, 0x23, 0x00, 0x8C,
  0x06, 0x20, 0x18, 0x80, 0x62, 0x03, 0x8C, 0x14, 0x30, 0xF0, 0xFE, 0xC1,
  0xF3, 0x00, 0x0C, 0x00, 0x72, 0x01, 0x8C, 0x1E, 0x1F, 0xF0, 0x3F, 0x00,
  0x0F, 0x86, 0x3F, 0xEC, 0xC1, 0xF9, 0x80, 0x62, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x30, 0x60, 0x23, 0x80, 0x47, 0xF8,
  0xC9, 0xFF, 0xB0, 0x3E, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x0C, 0x30, 0x82, 0x08, 0x61, 0x86, 0x10, 0x41, 0x0C,
  0x30, 0xC2, 0x08, 0x21, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC3, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x82, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xFC, 0x07, 0xE0,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0x03, 0xF8, 0x00, 0x0E, 0x02, 0x7E,
  0x04, 0xCE, 0x1B, 0x0E, 0x64, 0x0F, 0x98, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 6, 20, 17, 6, -20 },
  { 16, 7, 8, 17, 7, -21 },
  { 23, 18, 20, 17, 0, -20 },
  { 68, 16, 26, 17, 1, -23 },
  { 120, 20, 20, 17, -1, -20 },
  { 170, 17, 20, 17, 0, -20 },
  { 213, 3, 8, 17, 9, -21 },
  { 216, 10, 26, 17, 6, -22 },
  { 249, 10, 26, 17, 2, -22 },
  { 282, 14, 14, 17, 2, -16 },
  { 307, 14, 14, 17, 2, -16 },
  { 332, 6, 7, 17, 4, -3 },
  { 338, 8, 2, 17, 5, -10 },
  { 340, 3, 3, 17, 6, -3 },
  { 342, 16, 26, 17, 1, -22 },
  { 394, 14, 20, 17, 2, -20 },
  { 429, 14, 20, 17, 1, -20 },
  { 464, 15, 20, 17, 1, -20 },
  { 502, 15, 20, 17, 1, -20 },
  { 540, 15, 20, 17, 1, -20 },
  { 578, 14, 20, 17, 2, -20 },
  { 613, 13, 20, 17, 2, -20 },
  { 646, 14, 20, 17, 3, -20 },
  { 681, 15, 20, 17, 1, -20 },
  { 719, 13, 20, 17, 3, -20 },
  { 752, 5, 15, 17, 6, -15 },
  { 762, 7, 19, 17, 4, -15 },
  { 779, 13, 16, 17, 3, -17 },
  { 805, 14, 8, 17, 2, -13 },
  { 819, 14, 16, 17, 1, -17 },
  { 847, 12, 20, 17, 4, -20 },
  { 877, 14, 23, 17, 2, -20 },
  { 918, 15, 20, 17, 0, -20 },
  { 956, 15, 20, 17, 1, -20 },
  { 994, 15, 20, 17, 2, -20 },
  { 1032, 14, 20, 17, 2, -20 },
  { 1067, 15, 20, 17, 2, -20 },
  { 1105, 15, 20, 17, 2, -20 },
  { 1143, 14, 20, 17, 2, -20 },
  { 1178, 16, 20, 17, 1, -20 },
  { 1218, 16, 20, 17, 1, -20 },
  { 1258, 14, 20, 17, 2, -20 },
  { 1293, 16, 20, 17, 2, -20 },
  { 1333, 11, 20, 17, 3, -20 },
  { 1361, 16, 20, 17, 1, -20 },
  { 1401, 16, 20, 17, 1, -20 },
  { 1441, 14, 20, 17, 2, -20 },
  { 1476, 15, 20, 17, 2, -20 },
  { 1514, 14, 25, 17, 2, -20 },
  { 1558, 15, 20, 17, 2, -20 },
  { 1596, 16, 20, 17, 1, -20 },
  { 1636, 16, 20, 17, 3, -20 },
  { 1676, 15, 20, 17, 2, -20 },
  { 1714, 15, 20, 17, 3, -20 },
  { 1752, 16, 20, 17, 2, -20 },
  { 1792, 18, 20, 17, 0, -20 },
  { 1837, 16, 20, 17, 3, -20 },
  { 1877, 18, 20, 17, 0, -20 },
  { 1922, 12, 26, 17, 5, -22 },
  { 1961, 8, 26, 17, 5, -22 },
  { 1987, 11, 26, 17, 1, -22 },
  { 2023, 14, 11, 17, 2, -20 },
  { 2043, 14, 2, 17, 0, 3 },
  { 2047, 3, 5, 17, 7, -22 },
  { 2049, 13, 15, 17, 2, -15 },
  { 2074, 14, 21, 17, 2, -21 },
  { 2111, 13, 15, 17, 2, -15 },
  { 2136, 15, 21, 17, 2, -21 },
  { 2176, 13, 15, 17, 2, -15 },
  { 2201, 18, 27, 17, 0, -21 },
  { 2262, 15, 21, 17, 1, -15 },
  { 2302, 13, 21, 17, 2, -21 },
  { 2337, 13, 22, 17, 2, -22 },
  { 2373, 13, 28, 17, 2, -22 },
  { 2419, 15, 21, 17, 2, -21 },
  { 2459, 12, 21, 17, 3, -21 },
  { 2491, 15, 15, 17, 1, -15 },
  { 2520, 13, 15, 17, 2, -15 },
  { 2545, 13, 15, 17, 2, -15 },
  { 2570, 15, 21, 17, 1, -15 },
  { 2610, 14, 21, 17, 2, -15 },
  { 2647, 14, 15, 17, 3, -15 },
  { 2674, 13, 15, 17, 2, -15 },
  { 2699, 14, 20, 17, 2, -20 },
  { 2734, 12, 15, 17, 3, -15 },
  { 2757, 14, 15, 17, 2, -15 },
  { 2784, 14, 15, 17, 2, -15 },
  { 2811, 17, 15, 17, 0, -15 },
  { 2843, 14, 21, 17, 1, -15 },
  { 2880, 15, 15, 17, 1, -15 },
  { 2909, 14, 26, 17, 3, -22 },
  { 2955, 6, 26, 17, 6, -22 },
  { 2975, 14, 26, 17, 1, -22 },
  { 3021, 15, 6, 17, 1, -12 },
};

const GFXfont IBMPlexMono_LightItalic29pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic29pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _IBMPLEXMONO_LIGHTITALIC29PT7B_H_
