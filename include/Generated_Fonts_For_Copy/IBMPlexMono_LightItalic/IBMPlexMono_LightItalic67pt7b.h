#ifndef _IBMPLEXMONO_LIGHTITALIC67PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xE0, 0x7F, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xC7, 0x80, 0xE1, 0xE0,
  0x38, 0x78, 0x1E, 0x1C, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1C,
  0x3C, 0x07, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x3C, 0x78, 0x0F, 0x1E,
  0x03, 0x87, 0x80, 0xE1, 0xE0, 0x78, 0x70, 0x1E, 0x3C, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE1, 0xCF, 0xF0, 0x00, 0xF8, 0x0E,
  0x0F, 0xC0, 0x0F, 0x80, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x38, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0x08, 0x03, 0xC0, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x18,
  0x00, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0x01,
  0xF8, 0x70, 0x00, 0x00, 0x07, 0xF3, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0x8F, 0xE0, 0x00, 0x00, 0x1C, 0x1F, 0x80,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x06, 0x01, 0xF0, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x07, 0x80, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x07, 0xC0, 0x80, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0xF8, 0x01, 0xC0, 0x1E, 0x03, 0xE0, 0x1C, 0x01, 0xF0, 0x1F, 0x80, 0xE0,
  0x1F, 0x00, 0x7F, 0x07, 0x03, 0xF0, 0x00, 0xFE, 0x38, 0x7F, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x07, 0x00, 0x01,
  0xC0, 0x03, 0xC0, 0x78, 0x00, 0x0E, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x70, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xE0, 0xF8,
  0x1C, 0x00, 0x00, 0x0F, 0xFF, 0x81, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3C, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xC1, 0xF0, 0x3C, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x03, 0x80, 0x00, 0x1C,
  0x0F, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x00, 0x1E, 0x03,
  0x80, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x00, 0x0E, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0x07, 0xC1, 0xF0, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x00, 0x7F, 0xE3, 0xE0, 0x00, 0x03, 0xF1, 0xFF, 0x00, 0x00,
  0x0F, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0xB8, 0x00, 0x02, 0xF0,
  0x0E, 0x78, 0x00, 0x0D, 0xE0, 0x3C, 0xF0, 0x00, 0x19, 0xE0, 0x71, 0xE0,
  0x00, 0x63, 0xC1, 0xE1, 0xE0, 0x01, 0xC3, 0xC3, 0x83, 0xE0, 0x07, 0x03,
  0x8F, 0x03, 0xF0, 0x3E, 0x07, 0xBC, 0x03, 0xFF, 0xF8, 0x07, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x1C, 0xF3, 0xCF,
  0x3C, 0xE3, 0x9E, 0x79, 0xE7, 0x9C, 0x73, 0xCF, 0x3C, 0xF3, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x7C, 0x00, 0xE0, 0x0F, 0xFF, 0xE0, 0x78, 0x1F, 0xF3, 0xFF, 0x1E, 0x7F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xA0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3E, 0x7F, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x07, 0xCF, 0x00, 0x7C, 0x01, 0xE7, 0xC0, 0x3F, 0x00, 0x79,
  0xF0, 0x0F, 0xC0, 0x1E, 0x78, 0x03, 0xF0, 0x07, 0x9E, 0x00, 0xFC, 0x01,
  0xE7, 0x80, 0x3E, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x0F, 0xC7, 0x80, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x02,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x01, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x60, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x30, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0xFF, 0x00, 0x00, 0x38, 0x7F, 0xFC, 0x00, 0x0F, 0x3F, 0xFF, 0xE0,
  0x01, 0xEF, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x20, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1F,
  0x80, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0xF0,
  0x01, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0x00, 0x1E, 0x1F, 0xFF,
  0x80, 0xF9, 0xFF, 0xFF, 0x03, 0xCF, 0x80, 0xFE, 0x0F, 0x70, 0x00, 0x7C,
  0x7B, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xC7, 0x00, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x01, 0xF1, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x7C, 0x1C,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01,
  0xE3, 0xE0, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x3E,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x6F,
  0x1F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0x78, 0x3F, 0x80, 0x7D, 0xF0,
  0x3F, 0xFF, 0xE3, 0xC0, 0x1F, 0xFF, 0x8F, 0x80, 0x0F, 0xF8, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x7E, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C,
  0x3C, 0x00, 0x7E, 0x1E, 0x1C, 0x00, 0xFF, 0x8F, 0x0E, 0x00, 0xFF, 0xE7,
  0x8F, 0x00, 0xF8, 0x3B, 0x87, 0x80, 0xF0, 0x05, 0xC3, 0x80, 0x70, 0x01,
  0xE1, 0xC0, 0x78, 0x00, 0xF0, 0xE0, 0x38, 0x00, 0x78, 0xF0, 0x3C, 0x00,
  0x3C, 0x78, 0x1E, 0x00, 0x1C, 0x3C, 0x0E, 0x00, 0x0E, 0x1C, 0x07, 0x00,
  0x07, 0x0E, 0x07, 0x80, 0x03, 0x8F, 0x03, 0xC0, 0x03, 0xC7, 0x81, 0xE0,
  0x01, 0xE3, 0xC0, 0xF0, 0x00, 0xF1, 0xE0, 0x70, 0x00, 0x70, 0xE0, 0x38,
  0x00, 0x38, 0x70, 0x1C, 0x00, 0x3C, 0x38, 0x0E, 0x00, 0x1E, 0x1C, 0x07,
  0x00, 0x1F, 0x0E, 0x03, 0x80, 0x0F, 0x8F, 0x01, 0xE0, 0x0F, 0x87, 0x80,
  0xF0, 0x0D, 0xC3, 0xC0, 0x3C, 0x0C, 0xE1, 0xE0, 0x1F, 0xFE, 0xF0, 0x70,
  0x07, 0xFE, 0x78, 0x38, 0x01, 0xFE, 0x3C, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0xF8, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x04, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0xF0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0x9E, 0x00, 0x1F, 0xFF, 0x8F, 0x00,
  0x0F, 0xFF, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0xDE, 0x01, 0xF0, 0x01, 0xCF, 0x00, 0x7E, 0x03, 0xC7,
  0x00, 0x1F, 0xFF, 0xC7, 0x80, 0x07, 0xFF, 0xC3, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x1F, 0x80,
  0x00, 0x00, 0x78, 0x7E, 0x00, 0x00, 0x00, 0xF1, 0xFE, 0x00, 0x00, 0x01,
  0xC7, 0xFC, 0x00, 0x00, 0x07, 0x9F, 0x3C, 0x00, 0x00, 0x0F, 0x7C, 0x78,
  0x00, 0x00, 0x1F, 0xF0, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x00,
  0x7F, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1D, 0xE0,
  0x00, 0x7F, 0x80, 0x77, 0x80, 0x03, 0xDE, 0x03, 0xCE, 0x00, 0x0F, 0x78,
  0x0F, 0x38, 0x00, 0x79, 0xC0, 0x3C, 0xF0, 0x01, 0xC7, 0x00, 0xF3, 0xC0,
  0x0F, 0x3C, 0x03, 0x87, 0x00, 0x78, 0xF0, 0x0E, 0x1C, 0x01, 0xE3, 0xC0,
  0x38, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x38, 0x38, 0x07, 0x83, 0x81,
  0xE0, 0xE0, 0x1E, 0x0E, 0x07, 0x07, 0x80, 0x70, 0x3C, 0x3C, 0x1E, 0x01,
  0xC0, 0xF1, 0xE0, 0x78, 0x07, 0x01, 0xC7, 0x01, 0xE0, 0x3C, 0x07, 0x3C,
  0x07, 0x00, 0xF0, 0x1E, 0xE0, 0x1C, 0x03, 0xC0, 0x3F, 0x80, 0xF0, 0x0E,
  0x00, 0xFC, 0x03, 0xC0, 0x38, 0x03, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0x80,
  0x3C, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x78,
  0x01, 0x80, 0x1E, 0x01, 0xE0, 0x04, 0x00, 0x78, 0x07, 0x00, 0x10, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x01, 0xFC,
  0x00, 0x00, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0x01, 0xFE, 0x00, 0x00, 0xE0,
  0x1F, 0xE0, 0x00, 0x0E, 0x01, 0xCE, 0x00, 0x01, 0xE0, 0x1C, 0xF0, 0x00,
  0x1E, 0x03, 0xCF, 0x00, 0x01, 0xE0, 0x3C, 0xF0, 0x00, 0x1E, 0x03, 0xC7,
  0x00, 0x01, 0xC0, 0x3C, 0x78, 0x00, 0x1C, 0x03, 0x87, 0x80, 0x03, 0xC0,
  0x38, 0x38, 0x00, 0x3C, 0x07, 0x83, 0x80, 0x03, 0xC0, 0x78, 0x3C, 0x00,
  0x3C, 0x07, 0x83, 0xC0, 0x03, 0x80, 0x78, 0x1C, 0x00, 0x38, 0x07, 0x01,
  0xE0, 0x07, 0x80, 0x70, 0x1E, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x07, 0x80,
  0xF0, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0xF0, 0x1E, 0x00,
  0x78, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x38, 0x0E, 0x01,
  0xE0, 0x03, 0xC0, 0xE0, 0x1C, 0x00, 0x3C, 0x1E, 0x01, 0xC0, 0x03, 0xC1,
  0xE0, 0x3C, 0x00, 0x1C, 0x1E, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x3C, 0x00,
  0x1E, 0x1E, 0x03, 0xC0, 0x00, 0xE1, 0xC0, 0x38, 0x00, 0x0F, 0x3C, 0x03,
  0x80, 0x00, 0xF3, 0xC0, 0x78, 0x00, 0x0F, 0x3C, 0x07, 0x80, 0x00, 0x73,
  0xC0, 0x78, 0x00, 0x07, 0xBC, 0x07, 0x80, 0x00, 0x7B, 0x80, 0x70, 0x00,
  0x07, 0xF8, 0x07, 0x00, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x03, 0xF8, 0x0F,
  0x00, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0x40, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x04, 0x00, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x07, 0xC7,
  0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x70, 0x03, 0xE0, 0x07,
  0x81, 0xC0, 0x0F, 0x80, 0x1C, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x3C, 0x01,
  0xF8, 0x03, 0xC0, 0xF0, 0x07, 0xE0, 0x0F, 0x03, 0xC0, 0x3F, 0x80, 0x38,
  0x0F, 0x00, 0xEE, 0x00, 0xE0, 0x3C, 0x07, 0xBC, 0x07, 0x80, 0xF0, 0x1C,
  0x70, 0x1E, 0x03, 0x80, 0x71, 0xC0, 0x70, 0x0E, 0x03, 0xC7, 0x01, 0xC0,
  0x38, 0x0E, 0x1C, 0x0F, 0x00, 0xE0, 0x78, 0x70, 0x3C, 0x03, 0x81, 0xC1,
  0xC0, 0xE0, 0x0E, 0x07, 0x07, 0x03, 0x80, 0x78, 0x3C, 0x1C, 0x1E, 0x01,
  0xE0, 0xE0, 0x70, 0x78, 0x07, 0x87, 0x81, 0xC1, 0xC0, 0x1E, 0x1C, 0x07,
  0x07, 0x00, 0x78, 0xF0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x07,
  0x0E, 0x01, 0xE3, 0x80, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E,
  0x78, 0x01, 0xCF, 0x00, 0x39, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C,
  0xE0, 0x03, 0x9C, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x03, 0xDC, 0x00, 0x3B,
  0xC0, 0x0F, 0xF0, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x01,
  0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x70, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x05,
  0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x3F, 0xFE, 0x0E, 0x00, 0xFF, 0xFF, 0x1E,
  0x01, 0xFC, 0x07, 0x9E, 0x03, 0xE0, 0x01, 0xDE, 0x07, 0xC0, 0x00, 0xDE,
  0x07, 0x80, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x0D, 0xE0,
  0x3C, 0x00, 0x19, 0xE0, 0x3E, 0x00, 0x39, 0xE0, 0x1F, 0x81, 0xF1, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFE, 0x07, 0xFF, 0x80, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x7F, 0x80, 0x03, 0xC1, 0xFF, 0xE0, 0x03, 0x87, 0xFF, 0xF0,
  0x07, 0x8F, 0x81, 0xF8, 0x07, 0x9C, 0x00, 0x7C, 0x07, 0x98, 0x00, 0x3C,
  0x07, 0xB0, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x1E, 0x07, 0x40, 0x00, 0x0F,
  0x0F, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0x7C, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x01, 0xF0,
  0x7B, 0x00, 0x03, 0xE0, 0x7B, 0x80, 0x07, 0xC0, 0x79, 0xE0, 0x3F, 0x80,
  0x70, 0xFF, 0xFF, 0x00, 0xF0, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x20, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x43, 0x80, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x3F, 0xFE, 0x0F, 0x00,
  0x3F, 0xFF, 0xC3, 0xC0, 0x1F, 0xC0, 0x78, 0xE0, 0x0F, 0x80, 0x07, 0x78,
  0x07, 0xC0, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x2E, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x0D, 0xE0, 0x0F, 0x00,
  0x06, 0x78, 0x03, 0xE0, 0x03, 0x9E, 0x00, 0x7E, 0x03, 0xC7, 0x80, 0x0F,
  0xFF, 0xE1, 0xC0, 0x01, 0xFF, 0xE0, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x7E, 0x1E, 0x00, 0x0F, 0xF0,
  0x70, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x23, 0xC0, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0,
  0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x07, 0x80, 0x0F, 0xFF, 0x83, 0xC0, 0x1F, 0xFF, 0xE1, 0xE0,
  0x1F, 0xC0, 0x78, 0xE0, 0x1F, 0x00, 0x0E, 0xF0, 0x1F, 0x00, 0x01, 0x78,
  0x0F, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1C, 0x3E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x7E, 0x07, 0x80, 0x00, 0x6E, 0x03, 0xE0, 0x00, 0x77, 0x00, 0xF0,
  0x00, 0x77, 0x80, 0x7C, 0x00, 0x73, 0xC0, 0x1F, 0x80, 0xF1, 0xE0, 0x07,
  0xFF, 0xF0, 0xF0, 0x01, 0xFF, 0xF0, 0x70, 0x00, 0x1F, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x10, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0xC0, 0x07, 0x83, 0xFF, 0xC0,
  0x3C, 0x3F, 0xFF, 0x01, 0xE3, 0xC0, 0xFC, 0x0F, 0x38, 0x03, 0xE0, 0x73,
  0x00, 0x0F, 0x87, 0xB0, 0x00, 0x3C, 0x3D, 0x00, 0x01, 0xE1, 0xF8, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x03, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x3C, 0x07, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x70, 0xF8, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x80, 0x01, 0xE0,
  0x07, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0xF8, 0x01, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xFE,
  0x00, 0x03, 0xC1, 0xFF, 0xE0, 0x00, 0xF0, 0xFF, 0xFC, 0x00, 0x38, 0x78,
  0x1F, 0x80, 0x1E, 0x38, 0x01, 0xF0, 0x07, 0x98, 0x00, 0x3C, 0x01, 0xEC,
  0x00, 0x0F, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0x70, 0x07,
  0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x1F, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x00, 0x78, 0x7C,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x06, 0x3C, 0x03, 0xC0, 0x03, 0xCF,
  0x00, 0xF0, 0x01, 0xE3, 0x80, 0x1E, 0x00, 0xF0, 0xE0, 0x07, 0x80, 0x78,
  0x78, 0x00, 0xF0, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x07, 0x80, 0x07, 0x8F,
  0x01, 0xE0, 0x01, 0xE7, 0x80, 0x70, 0x00, 0x3F, 0xC0, 0x1C, 0x00, 0x07,
  0xE0, 0x08, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x80, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x7C, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0x78,
  0x0F, 0x80, 0x1E, 0x07, 0x80, 0x07, 0x07, 0xC0, 0x03, 0xC3, 0xE0, 0x00,
  0xF1, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x87, 0xE0, 0x1F, 0x80, 0x78, 0xFF, 0x07,
  0xFC, 0x07, 0x9F, 0xF8, 0xFF, 0xE0, 0x73, 0x07, 0x8E, 0x1E, 0x07, 0x60,
  0x39, 0x80, 0xF0, 0xF4, 0x03, 0xB0, 0x0F, 0x0F, 0x80, 0x3A, 0x00, 0xF0,
  0xF8, 0x03, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC0,
  0x0F, 0x0E, 0x00, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0x80, 0x0E, 0x1E, 0x00,
  0x38, 0x00, 0xE1, 0xE0, 0x07, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x01, 0xE1,
  0xC0, 0x07, 0x80, 0x1E, 0x1C, 0x00, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x00,
  0x1C, 0x3C, 0x00, 0x70, 0x01, 0xC3, 0xC0, 0x0F, 0x00, 0x1C, 0x3C, 0x00,
  0xF0, 0x03, 0xC3, 0x80, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xE0, 0x03, 0xC7,
  0x80, 0x0E, 0x00, 0x38, 0x78, 0x00, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x00,
  0x38, 0x78, 0x01, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x00, 0x78, 0x70, 0x01,
  0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x00, 0x70, 0xF0, 0x01, 0xC0, 0x07, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0xF0, 0x03, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x07, 0x80, 0xFE, 0x00, 0x3C, 0x1F,
  0xFE, 0x01, 0xE1, 0xFF, 0xF8, 0x0F, 0x1E, 0x07, 0xE0, 0x79, 0xC0, 0x1F,
  0x03, 0x98, 0x00, 0x7C, 0x3D, 0x80, 0x01, 0xE1, 0xE8, 0x00, 0x0F, 0x0F,
  0xC0, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x07,
  0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x1F, 0xE0, 0x00, 0x3C, 0x1F, 0xFE,
  0x00, 0x0E, 0x1F, 0xFF, 0xC0, 0x07, 0x8F, 0x81, 0xF8, 0x01, 0xE7, 0x00,
  0x1F, 0x00, 0x79, 0x80, 0x03, 0xC0, 0x1E, 0xC0, 0x00, 0x78, 0x07, 0xE0,
  0x00, 0x1E, 0x01, 0xD0, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x1F, 0x01,
  0xEC, 0x00, 0x0F, 0x80, 0x7B, 0x80, 0x07, 0xC0, 0x1E, 0x78, 0x0F, 0xE0,
  0x0F, 0x0F, 0xFF, 0xF0, 0x03, 0xC1, 0xFF, 0xF0, 0x00, 0xF0, 0x0F, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0x00, 0x3F, 0xFE, 0x0F,
  0x00, 0xFF, 0xFF, 0x0F, 0x01, 0xFC, 0x07, 0x8E, 0x03, 0xF0, 0x01, 0xDE,
  0x07, 0xC0, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x06, 0xE0,
  0x78, 0x00, 0x0D, 0xE0, 0x3C, 0x00, 0x1D, 0xE0, 0x3E, 0x00, 0x39, 0xE0,
  0x1F, 0x80, 0xF1, 0xE0, 0x0F, 0xFF, 0xE1, 0xC0, 0x07, 0xFF, 0xC1, 0xC0,
  0x01, 0xFE, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE,
  0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x7A, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x08, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x20, 0x00, 0x00, 0x78, 0x60, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0,
  0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x40, 0x07, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x0F, 0xC0,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x01,
  0xE0, 0x3F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x07, 0xE0, 0xF0, 0x00, 0x17, 0x83, 0xC0, 0x00, 0xDE, 0x07, 0x80,
  0x06, 0x78, 0x1F, 0x00, 0x31, 0xC0, 0x3E, 0x07, 0x8F, 0x00, 0x7F, 0xFC,
  0x3C, 0x00, 0xFF, 0xE0, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x19, 0xFF, 0xE0, 0x00, 0x7B, 0xFF, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x78, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x03,
  0xE0, 0x01, 0xE0, 0x1F, 0x80, 0x03, 0x80, 0xFE, 0x00, 0x07, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x38, 0x03, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0xE0, 0x03,
  0x80, 0x78, 0x38, 0x01, 0xE0, 0x0E, 0x1E, 0x00, 0x78, 0x03, 0x87, 0x80,
  0x1E, 0x00, 0xF1, 0xC0, 0x07, 0x00, 0x3C, 0x70, 0x01, 0xC0, 0x0F, 0x1C,
  0x00, 0x70, 0x03, 0xC7, 0x00, 0x3C, 0x00, 0x73, 0xC0, 0x0F, 0x00, 0x1C,
  0xF0, 0x03, 0xC0, 0x07, 0x3C, 0x00, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0x00,
  0x73, 0x80, 0x0E, 0x00, 0x3C, 0xE0, 0x07, 0x80, 0x0F, 0x78, 0x01, 0xE0,
  0x03, 0xDE, 0x00, 0x78, 0x00, 0xF7, 0x80, 0x1C, 0x00, 0x39, 0xC0, 0x07,
  0x00, 0x0E, 0x70, 0x01, 0xC0, 0x03, 0x9C, 0x00, 0xF0, 0x01, 0xEF, 0x00,
  0x3C, 0x00, 0x7B, 0xC0, 0x0F, 0x00, 0x1C, 0xF0, 0x03, 0x80, 0x07, 0x38,
  0x00, 0xE0, 0x03, 0xCE, 0x00, 0x78, 0x00, 0xE3, 0x80, 0x1E, 0x00, 0x78,
  0xE0, 0x07, 0x80, 0x1E, 0x38, 0x03, 0xE0, 0x0F, 0x0E, 0x01, 0xB8, 0x07,
  0x83, 0xC0, 0xE7, 0x03, 0xE0, 0xF8, 0x71, 0xE1, 0xF0, 0x1F, 0xF8, 0x7F,
  0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0x78, 0x1E, 0x1F, 0x03, 0xF0, 0xF0, 0xE0, 0x3C, 0x3F, 0x03,
  0xC7, 0x00, 0xF3, 0xF0, 0x07, 0x18, 0x01, 0xCF, 0x00, 0x1C, 0xE0, 0x07,
  0x18, 0x00, 0x73, 0x00, 0x1C, 0x00, 0x01, 0xCC, 0x00, 0x70, 0x00, 0x07,
  0x60, 0x01, 0xC0, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x18,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1C,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0xB8, 0x00, 0x03, 0xC0, 0x06, 0xE0,
  0x00, 0x0F, 0x00, 0x1B, 0x80, 0x02, 0x38, 0x00, 0xCE, 0x00, 0x18, 0xE0,
  0x03, 0x3C, 0x01, 0xF3, 0xC0, 0x1C, 0xF0, 0x0F, 0x8F, 0x00, 0xE1, 0xC0,
  0xF8, 0x3C, 0x07, 0x87, 0x8F, 0xC0, 0x78, 0x3C, 0x1E, 0x7E, 0x01, 0xFF,
  0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x1E, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x05, 0xE0,
  0x0F, 0x80, 0x03, 0x78, 0x01, 0xE0, 0x01, 0x9E, 0x00, 0x7C, 0x00, 0xE7,
  0x00, 0x0F, 0xC0, 0xF1, 0xC0, 0x01, 0xFF, 0xF8, 0xF0, 0x00, 0x3F, 0xF8,
  0x3C, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x02,
  0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xC0, 0x3F,
  0xFF, 0x00, 0xF0, 0x1F, 0xFF, 0xF8, 0x3C, 0x0F, 0x80, 0xFF, 0xCF, 0x07,
  0x80, 0x07, 0xFF, 0x81, 0xE0, 0x00, 0x3F, 0xE0, 0x70, 0x00, 0x03, 0xF0,
  0x3C, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x3E,
  0x00, 0xE0, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x02, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xE0,
  0x01, 0xF0, 0x00, 0x38, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x01,
  0xC0, 0x3E, 0x00, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0xFC, 0x00,
  0x07, 0x87, 0xFF, 0xF0, 0x01, 0xE1, 0xE3, 0xFF, 0xC0, 0x38, 0x78, 0x0F,
  0xFF, 0x8E, 0x1C, 0x00, 0x3F, 0xFF, 0x87, 0x00, 0x00, 0xFF, 0xC2, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xC0,
  0x3F, 0xE0, 0x00, 0x3C, 0x0F, 0xFE, 0x00, 0x07, 0x03, 0xC3, 0xC0, 0x00,
  0xE0, 0xF0, 0x3C, 0x00, 0x3C, 0x3C, 0x03, 0xC0, 0x07, 0x07, 0x00, 0x3C,
  0x01, 0xE1, 0xE0, 0x07, 0x80, 0x78, 0x38, 0x00, 0x78, 0x0E, 0x0F, 0x00,
  0x07, 0x87, 0xC1, 0xC0, 0x00, 0x7F, 0xF0, 0x78, 0x00, 0x07, 0xF8, 0x02,
  0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 13, 47, 40, 14, -47 },
  { 78, 18, 18, 40, 15, -50 },
  { 119, 40, 47, 40, 1, -47 },
  { 354, 37, 63, 40, 2, -55 },
  { 646, 45, 49, 40, -1, -48 },
  { 922, 39, 49, 40, 0, -48 },
  { 1161, 6, 18, 40, 21, -50 },
  { 1175, 23, 60, 40, 15, -51 },
  { 1348, 23, 60, 40, 4, -51 },
  { 1521, 34, 33, 40, 4, -37 },
  { 1662, 33, 33, 40, 4, -37 },
  { 1799, 13, 18, 40, 10, -8 },
  { 1829, 19, 3, 40, 11, -22 },
  { 1837, 8, 7, 40, 14, -7 },
  { 1844, 37, 60, 40, 2, -51 },
  { 2122, 34, 49, 40, 4, -48 },
  { 2331, 32, 47, 40, 3, -47 },
  { 2519, 34, 48, 40, 2, -48 },
  { 2723, 34, 49, 40, 2, -48 },
  { 2932, 36, 47, 40, 1, -47 },
  { 3144, 35, 48, 40, 3, -47 },
  { 3354, 30, 48, 40, 5, -47 },
  { 3534, 33, 47, 40, 7, -47 },
  { 3728, 35, 49, 40, 3, -48 },
  { 3943, 31, 48, 40, 6, -48 },
  { 4129, 12, 35, 40, 14, -35 },
  { 4182, 16, 45, 40, 10, -35 },
  { 4272, 32, 37, 40, 6, -39 },
  { 4420, 35, 15, 40, 3, -28 },
  { 4486, 32, 37, 40, 3, -39 },
  { 4634, 28, 48, 40, 9, -48 },
  { 4802, 33, 55, 40, 4, -48 },
  { 5029, 35, 47, 40, 0, -47 },
  { 5235, 34, 47, 40, 3, -47 },
  { 5435, 32, 49, 40, 6, -48 },
  { 5631, 34, 47, 40, 4, -47 },
  { 5831, 36, 47, 40, 4, -47 },
  { 6043, 36, 47, 40, 4, -47 },
  { 6255, 33, 49, 40, 5, -48 },
  { 6458, 36, 47, 40, 3, -47 },
  { 6670, 36, 47, 40, 3, -47 },
  { 6882, 33, 48, 40, 4, -47 },
  { 7080, 39, 47, 40, 3, -47 },
  { 7310, 27, 47, 40, 6, -47 },
  { 7469, 38, 47, 40, 2, -47 },
  { 7693, 36, 47, 40, 3, -47 },
  { 7905, 34, 49, 40, 4, -48 },
  { 8114, 35, 47, 40, 4, -47 },
  { 8320, 34, 60, 40, 4, -48 },
  { 8575, 35, 47, 40, 4, -47 },
  { 8781, 37, 49, 40, 2, -48 },
  { 9008, 37, 47, 40, 6, -47 },
  { 9226, 34, 48, 40, 5, -47 },
  { 9430, 34, 47, 40, 8, -47 },
  { 9630, 38, 47, 40, 4, -47 },
  { 9854, 42, 47, 40, 0, -47 },
  { 10101, 38, 47, 40, 6, -47 },
  { 10325, 41, 47, 40, 0, -47 },
  { 10566, 27, 60, 40, 12, -51 },
  { 10769, 16, 60, 40, 13, -51 },
  { 10889, 28, 60, 40, 1, -51 },
  { 11099, 33, 26, 40, 5, -47 },
  { 11207, 33, 3, 40, 0, 7 },
  { 11220, 8, 12, 40, 16, -52 },
  { 11232, 32, 36, 40, 4, -35 },
  { 11376, 32, 51, 40, 4, -50 },
  { 11580, 29, 36, 40, 5, -35 },
  { 11711, 34, 51, 40, 4, -50 },
  { 11928, 30, 36, 40, 5, -35 },
  { 12063, 43, 64, 40, -1, -50 },
  { 12407, 33, 49, 40, 3, -35 },
  { 12610, 29, 50, 40, 5, -50 },
  { 12792, 29, 51, 40, 6, -50 },
  { 12977, 30, 64, 40, 5, -50 },
  { 13217, 34, 51, 40, 4, -50 },
  { 13434, 26, 51, 40, 8, -50 },
  { 13600, 36, 35, 40, 2, -35 },
  { 13758, 29, 35, 40, 5, -35 },
  { 13885, 30, 36, 40, 5, -35 },
  { 14020, 34, 48, 40, 2, -35 },
  { 14224, 32, 48, 40, 4, -35 },
  { 14416, 32, 35, 40, 8, -35 },
  { 14556, 32, 36, 40, 4, -35 },
  { 14700, 31, 48, 40, 5, -47 },
  { 14886, 30, 36, 40, 6, -35 },
  { 15021, 31, 35, 40, 5, -35 },
  { 15157, 34, 36, 40, 4, -35 },
  { 15310, 38, 36, 40, 1, -35 },
  { 15481, 34, 49, 40, 2, -35 },
  { 15690, 34, 36, 40, 3, -35 },
  { 15843, 30, 60, 40, 8, -51 },
  { 16068, 13, 60, 40, 14, -51 },
  { 16166, 31, 60, 40, 3, -51 },
  { 16399, 35, 13, 40, 3, -27 },
};

const GFXfont IBMPlexMono_LightItalic67pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic67pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic67pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _IBMPLEXMONO_LIGHTITALIC67PT7B_H_
