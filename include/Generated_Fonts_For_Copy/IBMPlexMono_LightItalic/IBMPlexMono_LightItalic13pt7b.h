#ifndef _IBMPLEXMONO_LIGHTITALIC13PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0xA0, 0x80, 0xB6, 0x80, 0x0A, 0x14, 0x73, 0x14, 0x28, 0xE6,
  0x28, 0x48, 0x50, 0x08, 0x1C, 0x2A, 0x49, 0x30, 0x1C, 0x12, 0x12, 0xD4,
  0x3C, 0x20, 0x31, 0x4A, 0x4A, 0x74, 0x00, 0x2E, 0x52, 0x52, 0x8C, 0x1C,
  0x24, 0x24, 0x24, 0x78, 0x90, 0x8A, 0x97, 0x76, 0xE0, 0x12, 0x48, 0x88,
  0x88, 0x88, 0x84, 0x22, 0x11, 0x11, 0x11, 0x22, 0x48, 0x10, 0x4A, 0x5E,
  0x53, 0x20, 0x10, 0x42, 0x3F, 0x20, 0x82, 0x00, 0x68, 0xF0, 0x80, 0x03,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x39,
  0x18, 0x61, 0xB6, 0x18, 0x62, 0x70, 0x18, 0xCD, 0x24, 0x10, 0x42, 0x08,
  0xFC, 0x1C, 0x45, 0x08, 0x10, 0x41, 0x04, 0x30, 0xFC, 0x1C, 0x44, 0x08,
  0x11, 0xC0, 0x81, 0x62, 0x38, 0x06, 0x14, 0x51, 0x24, 0x48, 0xBF, 0x82,
  0x08, 0x7D, 0x04, 0x2E, 0xC4, 0x10, 0x62, 0x70, 0x08, 0xC4, 0x2E, 0xC6,
  0x18, 0x62, 0x70, 0x7F, 0x0A, 0x10, 0x41, 0x02, 0x08, 0x10, 0x40, 0x3D,
  0x18, 0x51, 0x3B, 0x38, 0x63, 0xF8, 0x39, 0x18, 0x61, 0x85, 0xE0, 0x84,
  0x60, 0x40, 0x08, 0x20, 0x00, 0x14, 0x80, 0x04, 0x23, 0x30, 0x40, 0xC0,
  0x80, 0xFC, 0x00, 0x3F, 0x40, 0x81, 0x81, 0x19, 0x88, 0x00, 0x74, 0x62,
  0x11, 0x31, 0x00, 0xC0, 0x39, 0x18, 0x67, 0xA6, 0x9A, 0x6E, 0x81, 0xC0,
  0x08, 0x28, 0x50, 0xA2, 0x44, 0x9F, 0x21, 0x82, 0x7D, 0x14, 0x61, 0xFA,
  0x18, 0x61, 0xF8, 0x39, 0x14, 0x60, 0x82, 0x08, 0x62, 0x70, 0x79, 0x14,
  0x61, 0x86, 0x18, 0x62, 0xF0, 0x7E, 0x81, 0x04, 0x0F, 0xD0, 0x20, 0x40,
  0xF8, 0x7E, 0x81, 0x04, 0x0F, 0xD0, 0x20, 0x40, 0x80, 0x39, 0x18, 0x60,
  0x9E, 0x18, 0x66, 0x78, 0x42, 0x8A, 0x14, 0x2F, 0xD0, 0xA1, 0x44, 0x88,
  0x7E, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0xF8, 0x3C, 0x10, 0x42, 0x08,
  0x20, 0xA2, 0x70, 0x42, 0x89, 0x24, 0x8B, 0x1A, 0x22, 0x44, 0x84, 0x42,
  0x10, 0x84, 0x42, 0x10, 0xF8, 0x23, 0x63, 0x56, 0x5A, 0x5A, 0x52, 0x42,
  0x82, 0x84, 0x42, 0xCA, 0x95, 0x2A, 0x52, 0xA5, 0x4C, 0x88, 0x39, 0x18,
  0x61, 0x86, 0x18, 0x62, 0x70, 0x7C, 0x89, 0x0C, 0x2F, 0x90, 0x20, 0x40,
  0x80, 0x39, 0x18, 0x61, 0x86, 0x18, 0x62, 0x70, 0x91, 0x80, 0x7C, 0x89,
  0x0C, 0x2F, 0x92, 0x24, 0x44, 0x88, 0x1C, 0x45, 0x01, 0x01, 0xC0, 0x40,
  0xE2, 0x3C, 0xFE, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x42, 0x8A,
  0x14, 0x28, 0x50, 0xA2, 0x44, 0x70, 0x86, 0x28, 0xA4, 0x92, 0x4A, 0x28,
  0x40, 0x83, 0x06, 0x4C, 0xAB, 0x5A, 0xB5, 0x6C, 0x88, 0x21, 0x22, 0x14,
  0x18, 0x08, 0x18, 0x24, 0x44, 0x82, 0x82, 0x89, 0x12, 0x43, 0x06, 0x08,
  0x10, 0x20, 0x3F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0xFE, 0x3C,
  0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x3C, 0x88, 0x44, 0x44, 0x42,
  0x22, 0x21, 0x3C, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x3C, 0x18,
  0xA4, 0x91, 0x84, 0xFC, 0xB0, 0x75, 0x38, 0xA2, 0x8A, 0x27, 0xC0, 0x41,
  0x04, 0x1E, 0xC6, 0x18, 0x61, 0x8B, 0xC0, 0x39, 0x28, 0x60, 0x8A, 0x27,
  0x00, 0x04, 0x10, 0x5D, 0x4E, 0x18, 0xA2, 0x89, 0xE0, 0x39, 0x18, 0xFC,
  0x82, 0x37, 0x00, 0x07, 0x08, 0x08, 0x3F, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x90, 0x50, 0x20, 0x3A, 0x4D, 0x0A, 0x24, 0x48, 0x8F, 0x02, 0x88,
  0xF0, 0x41, 0x04, 0x16, 0x65, 0x18, 0xA2, 0x8A, 0x20, 0x10, 0x00, 0x38,
  0x20, 0x82, 0x09, 0x58, 0x80, 0x04, 0x07, 0x82, 0x08, 0x21, 0x04, 0x12,
  0x45, 0x0C, 0x41, 0x04, 0x16, 0x65, 0x19, 0xA9, 0x96, 0x60, 0x72, 0x42,
  0x08, 0x20, 0x82, 0x13, 0x51, 0x80, 0x56, 0xD5, 0x2A, 0x99, 0x32, 0x64,
  0x80, 0x59, 0x94, 0x62, 0x8A, 0x28, 0x80, 0x39, 0x18, 0x61, 0x86, 0x27,
  0x00, 0x3C, 0xC5, 0x0A, 0x14, 0x28, 0x9E, 0x40, 0x81, 0x00, 0x75, 0x38,
  0x62, 0x8A, 0x27, 0x82, 0x08, 0x40, 0x6F, 0x60, 0x81, 0x02, 0x08, 0x10,
  0x00, 0x79, 0x14, 0x1E, 0x0A, 0x27, 0x80, 0x20, 0x8F, 0xC8, 0x21, 0x04,
  0x56, 0x60, 0x46, 0x18, 0xA2, 0x8A, 0x27, 0x80, 0xC5, 0x14, 0x51, 0x4A,
  0x66, 0x00, 0x96, 0x5A, 0x69, 0xA7, 0x9D, 0x80, 0x36, 0x59, 0x09, 0x10,
  0x90, 0xB2, 0x6C, 0x22, 0x85, 0x12, 0x24, 0x48, 0x8F, 0x02, 0x88, 0xE0,
  0x7E, 0x30, 0x8C, 0x4B, 0x1B, 0xC0, 0x39, 0x08, 0x42, 0x60, 0x84, 0x44,
  0x21, 0xE0, 0x55, 0x6A, 0xAA, 0x78, 0x41, 0x08, 0x20, 0x72, 0x10, 0x20,
  0x82, 0x38, 0x66, 0xD9, 0x80,
};

const GFXglyph IBMPlexMono_LightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 3, 3, 8, 3, -10 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 8, 11, 8, 0, -10 },
  { 26, 8, 9, 8, 0, -9 },
  { 35, 8, 9, 8, 0, -9 },
  { 44, 1, 3, 8, 4, -10 },
  { 45, 4, 12, 8, 3, -10 },
  { 51, 4, 12, 8, 1, -10 },
  { 57, 6, 6, 8, 1, -7 },
  { 62, 6, 7, 8, 1, -7 },
  { 68, 2, 3, 8, 2, -1 },
  { 69, 4, 1, 8, 2, -4 },
  { 70, 1, 1, 8, 3, -1 },
  { 71, 8, 12, 8, 0, -10 },
  { 83, 6, 9, 8, 1, -9 },
  { 90, 6, 9, 8, 1, -9 },
  { 97, 7, 9, 8, 0, -9 },
  { 105, 7, 9, 8, 0, -9 },
  { 113, 7, 9, 8, 0, -9 },
  { 121, 6, 9, 8, 1, -9 },
  { 128, 6, 9, 8, 1, -9 },
  { 135, 7, 9, 8, 1, -9 },
  { 143, 6, 9, 8, 1, -9 },
  { 150, 6, 9, 8, 1, -9 },
  { 157, 2, 7, 8, 3, -7 },
  { 159, 3, 9, 8, 2, -7 },
  { 163, 6, 7, 8, 1, -7 },
  { 169, 6, 4, 8, 1, -6 },
  { 172, 6, 7, 8, 1, -7 },
  { 178, 5, 9, 8, 2, -9 },
  { 184, 6, 10, 8, 1, -9 },
  { 192, 7, 9, 8, 0, -9 },
  { 200, 6, 9, 8, 1, -9 },
  { 207, 6, 9, 8, 1, -9 },
  { 214, 6, 9, 8, 1, -9 },
  { 221, 7, 9, 8, 1, -9 },
  { 229, 7, 9, 8, 1, -9 },
  { 237, 6, 9, 8, 1, -9 },
  { 244, 7, 9, 8, 1, -9 },
  { 252, 7, 9, 8, 1, -9 },
  { 260, 6, 9, 8, 1, -9 },
  { 267, 7, 9, 8, 1, -9 },
  { 275, 5, 9, 8, 1, -9 },
  { 281, 8, 9, 8, 0, -9 },
  { 290, 7, 9, 8, 1, -9 },
  { 298, 6, 9, 8, 1, -9 },
  { 305, 7, 9, 8, 1, -9 },
  { 313, 6, 11, 8, 1, -9 },
  { 322, 7, 9, 8, 1, -9 },
  { 330, 7, 9, 8, 0, -9 },
  { 338, 7, 9, 8, 1, -9 },
  { 346, 7, 9, 8, 1, -9 },
  { 354, 6, 9, 8, 2, -9 },
  { 361, 7, 9, 8, 1, -9 },
  { 369, 8, 9, 8, 0, -9 },
  { 378, 7, 9, 8, 1, -9 },
  { 386, 8, 9, 8, 0, -9 },
  { 395, 6, 12, 8, 2, -10 },
  { 404, 4, 12, 8, 2, -10 },
  { 410, 6, 12, 8, 0, -10 },
  { 419, 6, 5, 8, 1, -9 },
  { 423, 6, 1, 8, 0, 1 },
  { 424, 2, 2, 8, 3, -11 },
  { 425, 6, 7, 8, 1, -7 },
  { 431, 6, 10, 8, 1, -10 },
  { 439, 6, 7, 8, 1, -7 },
  { 445, 6, 10, 8, 1, -10 },
  { 453, 6, 7, 8, 1, -7 },
  { 459, 8, 13, 8, 0, -10 },
  { 472, 7, 10, 8, 0, -7 },
  { 481, 6, 10, 8, 1, -10 },
  { 489, 6, 10, 8, 1, -10 },
  { 497, 6, 12, 8, 1, -9 },
  { 506, 6, 10, 8, 1, -10 },
  { 514, 6, 10, 8, 1, -10 },
  { 522, 7, 7, 8, 0, -7 },
  { 529, 6, 7, 8, 1, -7 },
  { 535, 6, 7, 8, 1, -7 },
  { 541, 7, 10, 8, 0, -7 },
  { 550, 6, 10, 8, 1, -7 },
  { 558, 7, 7, 8, 1, -7 },
  { 565, 6, 7, 8, 1, -7 },
  { 571, 6, 9, 8, 1, -9 },
  { 578, 6, 7, 8, 1, -7 },
  { 584, 6, 7, 8, 1, -7 },
  { 590, 6, 7, 8, 1, -7 },
  { 596, 8, 7, 8, 0, -7 },
  { 603, 7, 10, 8, 0, -7 },
  { 612, 6, 7, 8, 1, -7 },
  { 618, 5, 12, 8, 2, -10 },
  { 626, 2, 12, 8, 3, -10 },
  { 629, 6, 12, 8, 1, -10 },
  { 638, 6, 3, 8, 1, -5 },
};

const GFXfont IBMPlexMono_LightItalic13pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic13pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _IBMPLEXMONO_LIGHTITALIC13PT7B_H_
