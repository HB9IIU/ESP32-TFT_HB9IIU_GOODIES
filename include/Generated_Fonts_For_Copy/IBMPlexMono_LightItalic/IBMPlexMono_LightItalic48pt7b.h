#ifndef _IBMPLEXMONO_LIGHTITALIC48PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xF1,
  0xF0, 0xF8, 0x78, 0x00, 0x38, 0x33, 0x87, 0x30, 0x73, 0x07, 0x70, 0x77,
  0x06, 0x70, 0x67, 0x0E, 0x60, 0xE6, 0x0E, 0xE0, 0xEE, 0x0C, 0xE0, 0xC0,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38,
  0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x06, 0x07, 0x00, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x00,
  0x18, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x7F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFE, 0x00,
  0x70, 0x38, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x38, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0x8C, 0x7C, 0x03, 0xC1, 0x83, 0xC0, 0x70,
  0x30, 0x3C, 0x1C, 0x06, 0x03, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x18, 0x00,
  0x1C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x1E, 0x0C, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x1F, 0x60, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x06, 0x3C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x3C, 0x00,
  0x06, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x18, 0x07, 0x04, 0x03, 0x01, 0xC1, 0xC0,
  0x60, 0x38, 0x7C, 0x0C, 0x0E, 0x03, 0xC1, 0x83, 0xC0, 0x3E, 0x71, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x07, 0x00, 0xFF, 0x80, 0x06, 0x01, 0xC3, 0x80, 0x0E,
  0x03, 0x80, 0xC0, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x70, 0x06, 0x00, 0xC0, 0xE0, 0x0E, 0x00, 0xC0, 0xC0,
  0x0E, 0x00, 0xC1, 0x80, 0x0E, 0x00, 0xC3, 0x80, 0x0E, 0x01, 0xC7, 0x00,
  0x06, 0x01, 0x86, 0x00, 0x06, 0x03, 0x8E, 0x00, 0x07, 0x07, 0x10, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0xF0, 0xE0,
  0x00, 0x70, 0xC0, 0x60, 0x00, 0xE1, 0xC0, 0x70, 0x00, 0xC1, 0x80, 0x30,
  0x01, 0x83, 0x80, 0x30, 0x03, 0x83, 0x80, 0x30, 0x07, 0x03, 0x00, 0x70,
  0x06, 0x03, 0x00, 0x70, 0x0E, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0xE0, 0x30, 0x03, 0x80, 0xC0, 0x70, 0x01, 0xC3, 0x80,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0,
  0x0E, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x07, 0x00, 0x01, 0xF8, 0xE0, 0x00, 0xF1, 0xF8, 0x00, 0x1C,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x70, 0x07, 0x00, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x2E, 0x00, 0x1E, 0x03, 0xE0, 0x01,
  0x60, 0x66, 0x00, 0x37, 0x0E, 0x70, 0x02, 0x30, 0xC7, 0x80, 0x63, 0x9C,
  0x3C, 0x1C, 0x19, 0x81, 0xFF, 0x81, 0xF0, 0x07, 0xE0, 0x0E, 0x00, 0x39,
  0x8C, 0xE7, 0x39, 0xCC, 0x67, 0x39, 0xCC, 0x00, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x1C, 0x07, 0xFC, 0x18, 0x3F,
  0x3F, 0x99, 0xFE, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x87, 0x00,
  0x07, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x38, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x10, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x0F, 0x87, 0x83, 0xC3, 0xC1, 0xE0, 0xE0, 0xE0, 0x70,
  0x70, 0x38, 0x18, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7B, 0xFF, 0xBE,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x78,
  0x03, 0xC0, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06,
  0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x1C, 0x07, 0x70, 0x3E, 0x07, 0x70, 0x3C, 0x07, 0xF0, 0x3C, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38,
  0x60, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0x60, 0x70, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0x1E, 0x07, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x77, 0x00, 0x01, 0xCE, 0x00,
  0x0F, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0x70, 0x07, 0x81, 0xC0, 0x1E,
  0x03, 0x80, 0x18, 0x07, 0x00, 0x20, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xF0, 0x3C, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x04,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xF8, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x0E, 0x06,
  0x00, 0x07, 0x02, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x40, 0x00, 0x38, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x7C, 0x03, 0xC0, 0x1F,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87,
  0x00, 0x03, 0x83, 0x00, 0x03, 0x81, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x80,
  0xE0, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x18, 0x01, 0xC0,
  0x0C, 0x01, 0xC0, 0x0E, 0x01, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x7E, 0x00, 0x1C, 0xFF, 0xC0, 0x0D, 0xC0, 0xF8, 0x07, 0x80, 0x1C,
  0x07, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x82, 0x00, 0x01, 0xC3, 0x00,
  0x01, 0xC3, 0xC0, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC3, 0xF8, 0x0E,
  0x3F, 0xF8, 0x3B, 0x80, 0xF0, 0xF8, 0x01, 0xE7, 0xC0, 0x03, 0x9E, 0x00,
  0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x60,
  0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x0E, 0x00, 0x78, 0x1E, 0x07,
  0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0x60, 0x00,
  0x38, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3C, 0x07, 0x80, 0x38,
  0x01, 0xE0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x3E,
  0x01, 0xC0, 0x07, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x71, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x1E, 0x03, 0xE0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xF8, 0x1E, 0x07,
  0x80, 0x1C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0x98, 0x00,
  0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0E,
  0xC0, 0x00, 0x3B, 0x00, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x1E, 0xF0,
  0x00, 0xB1, 0xC0, 0x05, 0xC3, 0xC0, 0x77, 0x07, 0xFF, 0x38, 0x07, 0xF0,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x07, 0xC7, 0xE3, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x87, 0xE3, 0xE1, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x03, 0xF0, 0x3F,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x80, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x78, 0x1F,
  0x1C, 0x00, 0xE7, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3A, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0x80, 0xE0, 0x1E,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x01, 0x87, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x60, 0x1F, 0x18, 0xC0, 0xFF,
  0x33, 0x81, 0xC3, 0x67, 0x07, 0x02, 0xCC, 0x1C, 0x03, 0x98, 0x30, 0x07,
  0x70, 0x60, 0x0C, 0xE1, 0xC0, 0x19, 0xC3, 0x80, 0x33, 0x86, 0x00, 0xE6,
  0x0C, 0x01, 0xCC, 0x18, 0x03, 0x98, 0x30, 0x06, 0x70, 0x60, 0x0C, 0xE0,
  0xC0, 0x39, 0xC1, 0x80, 0x73, 0x83, 0x81, 0xE7, 0x07, 0x85, 0xCE, 0x07,
  0xF3, 0x1C, 0x07, 0xC6, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x06, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0xC0,
  0x01, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xC0, 0x38, 0x00, 0xE0, 0x0C,
  0x00, 0x70, 0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x38, 0x00,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0E, 0x00, 0x0C, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x03, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1C, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x78, 0x70, 0x00, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0x81, 0xF0, 0x1C, 0x00, 0xE0,
  0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0x8E, 0x00, 0x04, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x87, 0x00, 0x01, 0xC6, 0x00, 0x07, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x1E, 0x07, 0x80, 0x1F,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07,
  0x00, 0xF8, 0x07, 0x00, 0x3C, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C,
  0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x60, 0x00, 0xE0, 0xE0,
  0x01, 0xC0, 0xE0, 0x07, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x01,
  0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x04,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x7F, 0xF7, 0x00, 0xFF, 0xCE, 0x00,
  0x03, 0x9C, 0x00, 0x07, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0x63, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0F,
  0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x58, 0x3C, 0x01, 0xB0, 0x3C, 0x0E, 0xE0,
  0x3F, 0xF9, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x1E,
  0x03, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x07, 0x80, 0x07, 0x00, 0xF0,
  0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xC7, 0xC0,
  0x00, 0x1C, 0xFE, 0x00, 0x01, 0xDE, 0xE0, 0x00, 0x1F, 0xC7, 0x00, 0x01,
  0xF8, 0x70, 0x00, 0x1F, 0x03, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x01,
  0xC0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1D, 0x80,
  0x1F, 0x83, 0xB0, 0x07, 0x70, 0x66, 0x00, 0xEC, 0x0C, 0xE0, 0x39, 0x81,
  0x8C, 0x06, 0x30, 0x71, 0x81, 0xCE, 0x0E, 0x30, 0x71, 0xC1, 0xC7, 0x0E,
  0x38, 0x30, 0x63, 0x86, 0x06, 0x0C, 0x60, 0xC0, 0xC1, 0xDC, 0x18, 0x38,
  0x3B, 0x07, 0x07, 0x03, 0xE0, 0xE0, 0xE0, 0x78, 0x1C, 0x18, 0x0E, 0x03,
  0x03, 0x01, 0xC0, 0x60, 0x60, 0x10, 0x0C, 0x1C, 0x02, 0x03, 0x83, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x01, 0xC1, 0xF0, 0x00, 0x70, 0x7C, 0x00, 0x1C, 0x1F, 0x80,
  0x07, 0x07, 0xE0, 0x01, 0x81, 0x98, 0x00, 0x60, 0x67, 0x00, 0x38, 0x39,
  0xC0, 0x0E, 0x0E, 0x70, 0x03, 0x83, 0x8C, 0x00, 0xE0, 0xE3, 0x80, 0x30,
  0x30, 0xE0, 0x0C, 0x0C, 0x18, 0x07, 0x03, 0x06, 0x01, 0xC1, 0xC1, 0xC0,
  0x70, 0x70, 0x70, 0x1C, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x81, 0x80,
  0xE0, 0xE0, 0x60, 0x38, 0x38, 0x38, 0x06, 0x0E, 0x0E, 0x01, 0xC3, 0x83,
  0x80, 0x70, 0xC0, 0xE0, 0x0C, 0x30, 0x30, 0x03, 0x1C, 0x0C, 0x00, 0xE7,
  0x07, 0x00, 0x39, 0xC1, 0xC0, 0x06, 0x70, 0x70, 0x01, 0xD8, 0x1C, 0x00,
  0x76, 0x06, 0x00, 0x1F, 0x81, 0x80, 0x03, 0xE0, 0xE0, 0x00, 0xF8, 0x38,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x78,
  0x03, 0xC0, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06,
  0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38,
  0x60, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0x60, 0x70, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0x1E, 0x07, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0x80, 0x07, 0x80, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x30,
  0x00, 0x38, 0x38, 0x00, 0x3C, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0x1C, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x18, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x38, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x1E,
  0x07, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x70, 0x08, 0x00,
  0x38, 0x0C, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01,
  0x80, 0x07, 0x80, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x86, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x30, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0x80,
  0x70, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xC0, 0x3E, 0x00, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x82, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x3E, 0x00, 0x07,
  0x01, 0xE0, 0x01, 0xC0, 0x1F, 0x00, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x38, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xC0,
  0xE0, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x7C, 0x0F, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x30, 0x03, 0x80,
  0x30, 0x03, 0x80, 0x38, 0x03, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x78, 0x0E, 0x18, 0x0F,
  0x01, 0x83, 0x01, 0xE0, 0x30, 0xE0, 0x7C, 0x0E, 0x1C, 0x0D, 0x81, 0xC3,
  0x83, 0xB0, 0x30, 0x70, 0x66, 0x06, 0x0E, 0x1C, 0xE1, 0xC1, 0xC3, 0x1C,
  0x38, 0x30, 0x63, 0x86, 0x06, 0x1C, 0x70, 0xC0, 0xC3, 0x06, 0x38, 0x18,
  0xE0, 0xC7, 0x03, 0x18, 0x18, 0xC0, 0x63, 0x03, 0x18, 0x0C, 0xE0, 0x67,
  0x03, 0x98, 0x0C, 0xE0, 0x77, 0x01, 0x98, 0x0E, 0xC0, 0x33, 0x01, 0xD8,
  0x06, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x1E, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xE0,
  0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x3C, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0x70,
  0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00,
  0x18, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1D, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x60, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0x30, 0x03, 0x80, 0x38, 0x07, 0x00, 0x18,
  0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x06, 0x60, 0x00, 0x07, 0xA0, 0x00, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x23, 0x87, 0x1C, 0x30, 0xE1, 0x87, 0x08, 0x00, 0xFE,
  0x0C, 0x0F, 0xFE, 0x30, 0x78, 0x1D, 0xC3, 0x80, 0x17, 0x1C, 0x00, 0x3C,
  0x70, 0x00, 0xF3, 0x80, 0x03, 0x8C, 0x00, 0x06, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x33, 0x80, 0x00,
  0xCE, 0x00, 0x03, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE,
  0x00, 0x0F, 0x38, 0x00, 0x38, 0xE0, 0x01, 0x61, 0xC0, 0x0F, 0x87, 0x00,
  0x6E, 0x0F, 0x07, 0x3F, 0x1F, 0xF8, 0x7C, 0x1F, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x7E, 0x00, 0xE3, 0xFF, 0x01,
  0xCC, 0x0F, 0x03, 0x30, 0x0E, 0x0E, 0x80, 0x0E, 0x1F, 0x00, 0x1C, 0x3C,
  0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0x80, 0x00, 0xE7, 0x00,
  0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x38, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x68, 0x00, 0xE1, 0xD8, 0x03, 0xC3,
  0x98, 0x1F, 0x07, 0x1F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x07, 0x81, 0xE0, 0xE0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x03,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0x60,
  0x00, 0xE7, 0x00, 0x1C, 0x38, 0x03, 0x83, 0xC0, 0xF0, 0x0F, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x1F, 0xC1, 0xC0, 0x3F, 0xF8, 0xC0, 0x3C, 0x0E, 0x60, 0x3C, 0x01,
  0xF0, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x0C, 0x00,
  0x06, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x18, 0x38,
  0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x83,
  0x80, 0x03, 0xC1, 0xC0, 0x02, 0xC0, 0x70, 0x03, 0x60, 0x3C, 0x03, 0x70,
  0x0F, 0x07, 0x38, 0x03, 0xFF, 0x1C, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0x01, 0xF0, 0x3C, 0x1C, 0x00, 0xE1, 0xC0, 0x03, 0x9C,
  0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x00, 0x03,
  0xB8, 0x00, 0x3D, 0xC0, 0x07, 0x8E, 0x07, 0xF8, 0x7F, 0xFE, 0x03, 0xFE,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x09,
  0xC0, 0x00, 0xEE, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xE0, 0x0F, 0x07, 0x81,
  0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0x01, 0xFF, 0xC7,
  0x03, 0xC0, 0xE6, 0x07, 0x00, 0x3E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C,
  0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x18, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x78, 0x70, 0x00, 0xF8, 0x38, 0x01, 0xB0, 0x3C, 0x03, 0x30,
  0x1E, 0x06, 0x70, 0x0F, 0xFC, 0x70, 0x03, 0xF0, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x40, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xF8, 0x0F, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x83, 0xF0,
  0x0E, 0x3F, 0xE0, 0x39, 0x83, 0xC0, 0xEC, 0x03, 0x83, 0x60, 0x0E, 0x0D,
  0x00, 0x18, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x06, 0x1C, 0x00,
  0x18, 0x60, 0x00, 0xE1, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38,
  0xE0, 0x00, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x71, 0xC0,
  0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x61, 0x80, 0x03,
  0x86, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x04, 0x03, 0x80, 0x70, 0x18, 0x07, 0x01, 0xC0,
  0x70, 0x0E, 0x0F, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x18, 0xE0, 0x00,
  0xCE, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0xC0, 0x70, 0x06, 0x01,
  0xC0, 0x70, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC6,
  0x00, 0x07, 0x30, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x0F, 0xC0, 0x0E, 0x3F, 0xF0,
  0x0E, 0x70, 0x78, 0x0C, 0xC0, 0x38, 0x0D, 0x80, 0x1C, 0x1D, 0x00, 0x1C,
  0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x18, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x38, 0x0E, 0x00,
  0x38, 0xF0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x70, 0x70, 0x02,
  0x70, 0x38, 0x03, 0x70, 0x38, 0x06, 0x70, 0x1C, 0x0C, 0x70, 0x1C, 0x38,
  0x60, 0x0E, 0x70, 0xE0, 0x0E, 0xE0, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x80, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x40, 0x70, 0x07, 0x07, 0x01,
  0xC0, 0x60, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x38, 0x00, 0xE7,
  0x00, 0x0C, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x3C, 0x0F,
  0x03, 0xBF, 0x8F, 0xE0, 0xC8, 0x76, 0x1C, 0x34, 0x1D, 0x07, 0x0E, 0x07,
  0x80, 0xC7, 0x81, 0xE0, 0x31, 0xC0, 0x70, 0x1C, 0x70, 0x1C, 0x07, 0x18,
  0x07, 0x01, 0xC6, 0x01, 0x80, 0x71, 0x80, 0x60, 0x18, 0xE0, 0x18, 0x06,
  0x38, 0x0E, 0x01, 0x8E, 0x03, 0x80, 0xE3, 0x00, 0xE0, 0x38, 0xC0, 0x30,
  0x0E, 0x30, 0x0C, 0x03, 0x1C, 0x03, 0x00, 0xC7, 0x01, 0xC0, 0x31, 0xC0,
  0x70, 0x1C, 0x60, 0x1C, 0x07, 0x18, 0x06, 0x01, 0xC6, 0x01, 0x80, 0x63,
  0x80, 0x60, 0x18, 0xE0, 0x38, 0x0E, 0x00, 0x0E, 0x0F, 0xC0, 0x38, 0xFF,
  0x80, 0xE6, 0x0F, 0x03, 0xB0, 0x0E, 0x0D, 0x80, 0x38, 0x34, 0x00, 0x61,
  0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x61, 0x80,
  0x03, 0x86, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03,
  0x0E, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00, 0x0E, 0x18, 0x00,
  0x38, 0xE0, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0x3C, 0x0F,
  0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0x71, 0x80, 0x01, 0xCE,
  0x00, 0x03, 0x30, 0x00, 0x0D, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xDC, 0x00,
  0x07, 0x70, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1B, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x98, 0x00, 0x1C, 0x70,
  0x00, 0x70, 0xC0, 0x03, 0x83, 0x80, 0x1C, 0x07, 0x81, 0xE0, 0x0F, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0x83, 0xF0, 0x01, 0xC7, 0xFE, 0x00, 0xE6,
  0x07, 0x80, 0x66, 0x01, 0xC0, 0x74, 0x00, 0x70, 0x3E, 0x00, 0x38, 0x1E,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x87, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0xD0, 0x01,
  0xC0, 0xEC, 0x01, 0xE0, 0x73, 0x03, 0xE0, 0x38, 0xFF, 0xC0, 0x1C, 0x1F,
  0x80, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x0E, 0x07, 0xFF, 0x1C,
  0x1E, 0x07, 0x30, 0x78, 0x03, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x8E,
  0x00, 0x07, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x31, 0xC0,
  0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00,
  0x0C, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x03,
  0xC7, 0x00, 0x07, 0x8E, 0x00, 0x16, 0x0E, 0x00, 0x6C, 0x1E, 0x01, 0xB8,
  0x1E, 0x0E, 0x70, 0x1F, 0xF8, 0xE0, 0x0F, 0xC1, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x7F,
  0xE0, 0xFE, 0xFF, 0xC7, 0xFE, 0x03, 0x98, 0x00, 0x06, 0x40, 0x00, 0x0D,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x78, 0x0F, 0x83, 0x80, 0x07, 0x0C, 0x00,
  0x0C, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x40, 0x00, 0x3B, 0x80, 0x01, 0xC7,
  0x00, 0x0E, 0x0F, 0x80, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x40, 0x70,
  0x03, 0x81, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x60, 0xE0,
  0x01, 0x8F, 0x00, 0x0E, 0x70, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x71,
  0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x06, 0x38, 0x00,
  0x31, 0xC0, 0x03, 0x8C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38,
  0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x3C, 0x38, 0x02, 0xE1, 0xC0, 0x27,
  0x07, 0x07, 0x38, 0x3F, 0xF1, 0x80, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x0C,
  0xFF, 0x00, 0x3A, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x30, 0x00, 0xE0,
  0x60, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x30, 0x30, 0x00, 0xE0, 0x60, 0x01, 0xC1, 0xC0,
  0x03, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1C, 0x01,
  0xC0, 0x30, 0x07, 0x80, 0x60, 0x1E, 0x01, 0xC0, 0x78, 0x03, 0x81, 0xE0,
  0x07, 0x1F, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x18, 0x06, 0x06,
  0x18, 0x06, 0x06, 0x38, 0x0E, 0x07, 0x38, 0x0E, 0x07, 0x38, 0x0C, 0x03,
  0x30, 0x0C, 0x03, 0x30, 0x0C, 0x03, 0x30, 0x0C, 0x03, 0x70, 0x1C, 0x03,
  0x70, 0x1C, 0x03, 0x70, 0x1C, 0x03, 0x60, 0x18, 0x03, 0x60, 0x18, 0x07,
  0x60, 0x18, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x06, 0xE0, 0x38, 0x06,
  0xC0, 0x30, 0x0E, 0xC0, 0x30, 0x0E, 0xC0, 0x70, 0x0C, 0xC0, 0x70, 0x1C,
  0xC0, 0xB0, 0x18, 0xC0, 0xB0, 0x38, 0xE3, 0x18, 0x70, 0x7F, 0x1F, 0xE0,
  0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0x07, 0xF8, 0x1E, 0x61,
  0xC3, 0x8F, 0x0E, 0x30, 0x73, 0xC0, 0xCC, 0x06, 0xE0, 0x19, 0x00, 0xC0,
  0x03, 0x60, 0x18, 0x00, 0x68, 0x03, 0x00, 0x0D, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x1C, 0x03, 0xC0, 0x03, 0x00, 0x58, 0x00, 0x60, 0x1B, 0x00, 0x4C, 0x02,
  0x60, 0x39, 0x80, 0xCC, 0x0F, 0xB8, 0x31, 0xC7, 0x87, 0x0E, 0x39, 0xE0,
  0x7F, 0x83, 0xF0, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x03, 0x03, 0x80,
  0x07, 0x03, 0x00, 0x07, 0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x07, 0x00, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x06, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x0E, 0x00,
  0x0C, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x58, 0x0E, 0x00, 0xF8, 0x0E, 0x01,
  0xB8, 0x07, 0x07, 0x38, 0x07, 0xFE, 0x38, 0x01, 0xF8, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x20, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0xFC, 0x0F, 0x80, 0x3F, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0x83, 0xFF, 0xC1, 0x83, 0xC1,
  0xFD, 0xC1, 0xC0, 0x1F, 0xE0, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x60,
  0x00, 0xE0, 0x30, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x10, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x0C,
  0x01, 0xC0, 0x06, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC3, 0xFC, 0x00,
  0x61, 0xCF, 0xE0, 0x30, 0xC0, 0x7F, 0x18, 0x60, 0x03, 0xFC, 0x40, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x01, 0x87, 0xF8, 0x00,
  0xC7, 0x0E, 0x00, 0xC3, 0x03, 0x00, 0x63, 0x81, 0xC0, 0x61, 0x80, 0x70,
  0x71, 0x80, 0x1C, 0x70, 0xC0, 0x07, 0xF0, 0xE0, 0x01, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 9, 34, 29, 10, -34 },
  { 40, 12, 13, 29, 11, -36 },
  { 60, 29, 34, 29, 1, -34 },
  { 184, 27, 45, 29, 1, -39 },
  { 336, 32, 35, 29, -1, -34 },
  { 476, 28, 35, 29, 0, -34 },
  { 599, 5, 13, 29, 15, -36 },
  { 608, 17, 43, 29, 10, -36 },
  { 700, 16, 43, 29, 3, -36 },
  { 786, 24, 24, 29, 3, -26 },
  { 858, 23, 24, 29, 3, -27 },
  { 927, 9, 12, 29, 7, -5 },
  { 941, 14, 2, 29, 8, -16 },
  { 945, 6, 5, 29, 10, -5 },
  { 949, 27, 43, 29, 1, -36 },
  { 1095, 24, 35, 29, 3, -34 },
  { 1200, 23, 34, 29, 2, -34 },
  { 1298, 24, 34, 29, 2, -34 },
  { 1400, 24, 35, 29, 2, -34 },
  { 1505, 25, 34, 29, 1, -34 },
  { 1612, 25, 35, 29, 2, -34 },
  { 1722, 22, 35, 29, 3, -34 },
  { 1819, 24, 34, 29, 5, -34 },
  { 1921, 25, 35, 29, 2, -34 },
  { 2031, 22, 34, 29, 5, -34 },
  { 2125, 9, 25, 29, 10, -25 },
  { 2154, 12, 32, 29, 7, -25 },
  { 2202, 23, 27, 29, 4, -28 },
  { 2280, 25, 11, 29, 2, -20 },
  { 2315, 23, 27, 29, 2, -28 },
  { 2393, 19, 34, 29, 7, -34 },
  { 2474, 23, 39, 29, 3, -34 },
  { 2587, 25, 34, 29, 0, -34 },
  { 2694, 24, 34, 29, 2, -34 },
  { 2796, 23, 35, 29, 4, -34 },
  { 2897, 24, 34, 29, 3, -34 },
  { 2999, 25, 34, 29, 3, -34 },
  { 3106, 26, 34, 29, 3, -34 },
  { 3217, 23, 35, 29, 4, -34 },
  { 3318, 26, 34, 29, 2, -34 },
  { 3429, 26, 34, 29, 2, -34 },
  { 3540, 23, 35, 29, 3, -34 },
  { 3641, 28, 34, 29, 2, -34 },
  { 3760, 20, 34, 29, 4, -34 },
  { 3845, 27, 34, 29, 2, -34 },
  { 3960, 26, 34, 29, 2, -34 },
  { 4071, 24, 35, 29, 3, -34 },
  { 4176, 25, 34, 29, 3, -34 },
  { 4283, 24, 42, 29, 3, -34 },
  { 4409, 25, 34, 29, 3, -34 },
  { 4516, 27, 35, 29, 1, -34 },
  { 4635, 26, 34, 29, 5, -34 },
  { 4746, 24, 35, 29, 4, -34 },
  { 4851, 24, 34, 29, 6, -34 },
  { 4953, 27, 34, 29, 3, -34 },
  { 5068, 30, 34, 29, 0, -34 },
  { 5196, 26, 34, 29, 5, -34 },
  { 5307, 29, 34, 29, 0, -34 },
  { 5431, 20, 43, 29, 8, -36 },
  { 5539, 12, 43, 29, 9, -36 },
  { 5604, 20, 43, 29, 1, -36 },
  { 5712, 24, 19, 29, 3, -34 },
  { 5769, 23, 2, 29, 0, 5 },
  { 5775, 6, 9, 29, 11, -37 },
  { 5782, 22, 26, 29, 3, -25 },
  { 5854, 23, 37, 29, 3, -36 },
  { 5961, 20, 26, 29, 4, -25 },
  { 6026, 25, 37, 29, 3, -36 },
  { 6142, 21, 26, 29, 4, -25 },
  { 6211, 31, 46, 29, -1, -36 },
  { 6390, 24, 35, 29, 2, -25 },
  { 6495, 22, 36, 29, 3, -36 },
  { 6594, 21, 37, 29, 4, -36 },
  { 6692, 21, 46, 29, 4, -36 },
  { 6813, 24, 37, 29, 3, -36 },
  { 6924, 20, 37, 29, 5, -36 },
  { 7017, 26, 25, 29, 1, -25 },
  { 7099, 22, 25, 29, 3, -25 },
  { 7168, 22, 26, 29, 3, -25 },
  { 7240, 25, 35, 29, 1, -25 },
  { 7350, 23, 35, 29, 3, -25 },
  { 7451, 23, 25, 29, 5, -25 },
  { 7523, 22, 26, 29, 3, -25 },
  { 7595, 22, 35, 29, 4, -34 },
  { 7692, 21, 26, 29, 4, -25 },
  { 7761, 23, 25, 29, 3, -25 },
  { 7833, 24, 26, 29, 3, -25 },
  { 7911, 27, 26, 29, 1, -25 },
  { 7999, 24, 35, 29, 1, -25 },
  { 8104, 25, 26, 29, 2, -25 },
  { 8186, 22, 43, 29, 6, -36 },
  { 8305, 10, 43, 29, 10, -36 },
  { 8359, 22, 43, 29, 2, -36 },
  { 8478, 25, 9, 29, 2, -19 },
};

const GFXfont IBMPlexMono_LightItalic48pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic48pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic48pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _IBMPLEXMONO_LIGHTITALIC48PT7B_H_
