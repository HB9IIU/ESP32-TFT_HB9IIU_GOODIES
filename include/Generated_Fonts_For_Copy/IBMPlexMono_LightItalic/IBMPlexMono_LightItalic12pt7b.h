#ifndef _IBMPLEXMONO_LIGHTITALIC12PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x06, 0xB7, 0x00, 0x16, 0x29, 0xD9, 0x42, 0x99, 0xD4,
  0x28, 0x08, 0x79, 0x2A, 0x83, 0x03, 0x85, 0x6A, 0x38, 0x40, 0x33, 0x52,
  0x94, 0x78, 0x2C, 0x52, 0x92, 0x8C, 0x38, 0x48, 0x91, 0x4F, 0x12, 0x26,
  0xB2, 0xE0, 0x34, 0x88, 0x88, 0x88, 0x88, 0x40, 0x62, 0x11, 0x11, 0x12,
  0x24, 0x80, 0x30, 0x8E, 0xCC, 0x52, 0x40, 0x30, 0x82, 0x3F, 0x20, 0x82,
  0x00, 0x68, 0xE0, 0xC0, 0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40,
  0x82, 0x00, 0x39, 0x18, 0x61, 0xA6, 0x28, 0x9C, 0x33, 0xB4, 0x42, 0x10,
  0x9F, 0x1C, 0x49, 0x18, 0x20, 0x82, 0x18, 0x7E, 0x1C, 0x90, 0x46, 0x2C,
  0x18, 0x5E, 0x04, 0x18, 0x51, 0x24, 0x9F, 0xC2, 0x04, 0x7D, 0x08, 0x1E,
  0x88, 0x28, 0x9C, 0x19, 0x11, 0x7C, 0xC6, 0x2E, 0x7E, 0x28, 0x84, 0x10,
  0x84, 0x10, 0x79, 0x18, 0x9C, 0xCA, 0x28, 0xBC, 0x79, 0x18, 0x66, 0x78,
  0x43, 0x10, 0x60, 0x01, 0x80, 0x60, 0x00, 0xA4, 0x04, 0x66, 0x20, 0x40,
  0xC0, 0x80, 0xFC, 0x0F, 0x80, 0x83, 0x04, 0x11, 0x32, 0x00, 0x74, 0x62,
  0x26, 0x20, 0x18, 0x39, 0x1B, 0xEA, 0xCB, 0x2B, 0xA0, 0x70, 0x08, 0x62,
  0x89, 0x45, 0xF4, 0x61, 0x7A, 0x18, 0xBC, 0x8A, 0x28, 0xBC, 0x39, 0x18,
  0x20, 0x82, 0x28, 0x9C, 0x79, 0x18, 0x61, 0x86, 0x28, 0xBC, 0x7D, 0x08,
  0x3E, 0x82, 0x08, 0x3E, 0x7D, 0x08, 0x3E, 0x82, 0x08, 0x20, 0x39, 0x18,
  0x20, 0x9A, 0x28, 0x9E, 0x46, 0x18, 0x7E, 0x8A, 0x28, 0xA2, 0x7C, 0x42,
  0x08, 0x20, 0x82, 0x3E, 0x3C, 0x20, 0x82, 0x08, 0x29, 0x1C, 0x47, 0x12,
  0x45, 0x0D, 0x12, 0x24, 0x44, 0x42, 0x10, 0x88, 0x42, 0x1F, 0x22, 0x4D,
  0xAA, 0xD5, 0x52, 0xA1, 0x42, 0x47, 0x1A, 0x6A, 0xAA, 0x69, 0xA6, 0x39,
  0x18, 0x61, 0x86, 0x28, 0x9C, 0x79, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x39,
  0x18, 0x61, 0x86, 0x28, 0x9C, 0x28, 0x60, 0x79, 0x18, 0x61, 0xFA, 0x49,
  0x22, 0x3C, 0x85, 0x01, 0x80, 0xC0, 0xB1, 0x1C, 0xFE, 0x20, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x46, 0x18, 0x62, 0x8A, 0x28, 0xBC, 0x87, 0x0A, 0x22,
  0x45, 0x0A, 0x18, 0x10, 0x87, 0x0A, 0xD5, 0xAD, 0x9B, 0x26, 0x4C, 0x43,
  0x24, 0x28, 0x18, 0x18, 0x28, 0x44, 0x84, 0x86, 0x89, 0x22, 0x82, 0x04,
  0x08, 0x10, 0x3E, 0x04, 0x10, 0x41, 0x04, 0x30, 0x7E, 0x3A, 0x10, 0x84,
  0x22, 0x10, 0x84, 0x38, 0x92, 0x24, 0x92, 0x24, 0x80, 0x38, 0x42, 0x11,
  0x08, 0x42, 0x10, 0xB8, 0x10, 0xA4, 0xA2, 0x84, 0xFC, 0xC0, 0x7C, 0x63,
  0x19, 0xF4, 0x42, 0x11, 0x74, 0xC6, 0x31, 0xF0, 0x74, 0x61, 0x19, 0x30,
  0x04, 0x10, 0x9E, 0x8A, 0x28, 0xA6, 0xF0, 0x7C, 0x7D, 0x08, 0xB8, 0x0F,
  0x08, 0x08, 0x3E, 0x10, 0x10, 0x10, 0x10, 0x90, 0xE0, 0x20, 0x3D, 0x14,
  0x61, 0x4D, 0xE8, 0x9C, 0x42, 0x10, 0xFC, 0xC6, 0x31, 0x88, 0x10, 0x01,
  0xC2, 0x11, 0x2B, 0x60, 0x08, 0x1E, 0x21, 0x08, 0x52, 0xE1, 0x00, 0x41,
  0x04, 0x2E, 0x4A, 0x2B, 0x2B, 0x98, 0xE1, 0x08, 0x42, 0x21, 0x2A, 0x60,
  0x76, 0x95, 0x4C, 0xA9, 0x52, 0x80, 0xFE, 0x63, 0x18, 0xC4, 0x7C, 0x63,
  0x18, 0xB8, 0x5C, 0x94, 0x51, 0x46, 0xE8, 0x20, 0x7C, 0x63, 0x19, 0xF8,
  0x42, 0xEC, 0xC2, 0x10, 0x41, 0x00, 0x7C, 0x58, 0x38, 0xF8, 0x20, 0x8F,
  0xC8, 0x41, 0x25, 0x98, 0x8C, 0x63, 0x19, 0xF8, 0xCA, 0x53, 0x19, 0x30,
  0xB6, 0x9A, 0x69, 0xAB, 0x60, 0x36, 0xB4, 0x4C, 0x89, 0x6D, 0x00, 0x45,
  0x14, 0x51, 0x4D, 0xE8, 0x9C, 0x76, 0x21, 0x18, 0x8B, 0xE0, 0x1C, 0x82,
  0x04, 0x13, 0x83, 0x08, 0x41, 0x07, 0x00, 0x5A, 0xAA, 0xA8, 0x70, 0x84,
  0x42, 0x0D, 0x88, 0x21, 0x38, 0x66, 0xA9, 0x80,
};

const GFXglyph IBMPlexMono_LightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 3, 3, 7, 3, -9 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 7, 10, 7, 0, -9 },
  { 22, 8, 8, 7, 0, -8 },
  { 30, 7, 8, 7, 0, -8 },
  { 37, 1, 3, 7, 4, -9 },
  { 38, 4, 11, 7, 3, -9 },
  { 44, 4, 11, 7, 1, -9 },
  { 50, 6, 6, 7, 1, -7 },
  { 55, 6, 7, 7, 1, -7 },
  { 61, 2, 3, 7, 2, -1 },
  { 62, 3, 1, 7, 2, -4 },
  { 63, 2, 1, 7, 2, -1 },
  { 64, 7, 11, 7, 0, -9 },
  { 74, 6, 8, 7, 1, -8 },
  { 80, 5, 8, 7, 1, -8 },
  { 85, 7, 8, 7, 0, -8 },
  { 92, 6, 8, 7, 0, -8 },
  { 98, 7, 8, 7, 0, -8 },
  { 105, 6, 8, 7, 1, -8 },
  { 111, 5, 8, 7, 1, -8 },
  { 116, 6, 8, 7, 1, -8 },
  { 122, 6, 8, 7, 1, -8 },
  { 128, 6, 8, 7, 1, -8 },
  { 134, 3, 6, 7, 2, -6 },
  { 137, 3, 8, 7, 2, -6 },
  { 140, 6, 7, 7, 1, -7 },
  { 146, 6, 3, 7, 1, -5 },
  { 149, 5, 7, 7, 1, -7 },
  { 154, 5, 8, 7, 2, -8 },
  { 159, 6, 9, 7, 1, -8 },
  { 166, 6, 8, 7, 0, -8 },
  { 172, 6, 8, 7, 1, -8 },
  { 178, 6, 8, 7, 1, -8 },
  { 184, 6, 8, 7, 1, -8 },
  { 190, 6, 8, 7, 1, -8 },
  { 196, 6, 8, 7, 1, -8 },
  { 202, 6, 8, 7, 1, -8 },
  { 208, 6, 8, 7, 1, -8 },
  { 214, 6, 8, 7, 1, -8 },
  { 220, 6, 8, 7, 1, -8 },
  { 226, 7, 8, 7, 1, -8 },
  { 233, 5, 8, 7, 1, -8 },
  { 238, 7, 8, 7, 0, -8 },
  { 245, 6, 8, 7, 1, -8 },
  { 251, 6, 8, 7, 1, -8 },
  { 257, 6, 8, 7, 1, -8 },
  { 263, 6, 10, 7, 1, -8 },
  { 271, 6, 8, 7, 1, -8 },
  { 277, 7, 8, 7, 0, -8 },
  { 284, 7, 8, 7, 1, -8 },
  { 291, 6, 8, 7, 1, -8 },
  { 297, 7, 8, 7, 1, -8 },
  { 304, 7, 8, 7, 1, -8 },
  { 311, 8, 8, 7, 0, -8 },
  { 319, 7, 8, 7, 1, -8 },
  { 326, 7, 8, 7, 0, -8 },
  { 333, 5, 11, 7, 2, -9 },
  { 340, 3, 11, 7, 2, -9 },
  { 345, 5, 11, 7, 0, -9 },
  { 352, 6, 5, 7, 1, -8 },
  { 356, 6, 1, 7, 0, 1 },
  { 357, 1, 2, 7, 3, -10 },
  { 358, 5, 6, 7, 1, -6 },
  { 362, 5, 9, 7, 1, -9 },
  { 368, 5, 6, 7, 1, -6 },
  { 372, 6, 9, 7, 1, -9 },
  { 379, 5, 6, 7, 1, -6 },
  { 383, 8, 11, 7, 0, -9 },
  { 394, 6, 8, 7, 0, -6 },
  { 400, 5, 9, 7, 1, -9 },
  { 406, 5, 9, 7, 1, -9 },
  { 412, 5, 10, 7, 1, -8 },
  { 419, 6, 9, 7, 1, -9 },
  { 426, 5, 9, 7, 1, -9 },
  { 432, 7, 6, 7, 0, -6 },
  { 438, 5, 6, 7, 1, -6 },
  { 442, 5, 6, 7, 1, -6 },
  { 446, 6, 8, 7, 0, -6 },
  { 452, 5, 8, 7, 1, -6 },
  { 457, 6, 6, 7, 1, -6 },
  { 462, 5, 6, 7, 1, -6 },
  { 466, 6, 8, 7, 1, -8 },
  { 472, 5, 6, 7, 1, -6 },
  { 476, 5, 6, 7, 1, -6 },
  { 480, 6, 6, 7, 1, -6 },
  { 485, 7, 6, 7, 0, -6 },
  { 491, 6, 8, 7, 0, -6 },
  { 497, 6, 6, 7, 1, -6 },
  { 502, 6, 11, 7, 1, -9 },
  { 511, 2, 11, 7, 3, -9 },
  { 514, 5, 11, 7, 1, -9 },
  { 521, 6, 3, 7, 1, -5 },
};

const GFXfont IBMPlexMono_LightItalic12pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic12pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _IBMPLEXMONO_LIGHTITALIC12PT7B_H_
