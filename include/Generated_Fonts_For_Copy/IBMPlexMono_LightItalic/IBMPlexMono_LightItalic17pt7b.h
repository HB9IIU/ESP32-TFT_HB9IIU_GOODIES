#ifndef _IBMPLEXMONO_LIGHTITALIC17PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x24, 0x00, 0x4E, 0x59, 0x99, 0x90, 0x04, 0x81,
  0x20, 0x88, 0x24, 0x79, 0xC4, 0x41, 0x23, 0xCE, 0x24, 0x09, 0x02, 0x41,
  0x20, 0x02, 0x00, 0x80, 0xF0, 0xD2, 0x24, 0xC9, 0x02, 0x40, 0x70, 0x07,
  0x02, 0x20, 0x8A, 0x22, 0x49, 0x0F, 0x80, 0x80, 0x40, 0x18, 0x24, 0x89,
  0x12, 0x22, 0x44, 0x50, 0x74, 0x00, 0xE0, 0xA4, 0x24, 0x49, 0x11, 0x12,
  0x43, 0x80, 0x0E, 0x04, 0x41, 0x10, 0x44, 0x11, 0x0C, 0x84, 0xC2, 0x10,
  0x84, 0x21, 0x9C, 0xA9, 0xE6, 0x56, 0x80, 0x0C, 0x42, 0x10, 0x42, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x81, 0x02, 0x00, 0x30, 0x20, 0x82, 0x04, 0x10,
  0x41, 0x04, 0x20, 0x84, 0x10, 0x8C, 0x00, 0x08, 0x04, 0x02, 0x1D, 0x71,
  0xC0, 0xC0, 0x90, 0x8C, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x10, 0x10,
  0x10, 0x32, 0x64, 0xC0, 0xF8, 0x5C, 0x00, 0x40, 0x20, 0x08, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x0C,
  0x00, 0x1E, 0x10, 0x90, 0x48, 0x14, 0x0C, 0x4A, 0x65, 0x02, 0x81, 0x41,
  0x11, 0x87, 0x00, 0x0C, 0x14, 0x24, 0x44, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0xFF, 0x1E, 0x21, 0x41, 0x01, 0x01, 0x02, 0x06, 0x08, 0x10,
  0x20, 0xC0, 0xFE, 0x1E, 0x21, 0x41, 0x01, 0x02, 0x1C, 0x26, 0x02, 0x02,
  0x82, 0x86, 0x78, 0x01, 0x81, 0x41, 0x40, 0xA0, 0x90, 0x88, 0x84, 0x82,
  0xFF, 0x81, 0x00, 0x80, 0x40, 0x3F, 0x90, 0x08, 0x08, 0x05, 0xE3, 0x10,
  0x04, 0x02, 0x01, 0x41, 0x31, 0x8F, 0x80, 0x06, 0x08, 0x10, 0x20, 0x5E,
  0x63, 0xC1, 0x81, 0x81, 0x82, 0x46, 0x7C, 0xFF, 0x81, 0x82, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0xC0, 0x1E, 0x10, 0x90, 0x28, 0x22,
  0x10, 0xF1, 0x89, 0x02, 0x81, 0x40, 0xB0, 0x8F, 0x80, 0x3C, 0x86, 0x0C,
  0x18, 0x30, 0x61, 0xBE, 0x04, 0x10, 0x47, 0x00, 0x33, 0x00, 0x00, 0x04,
  0xE0, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x23, 0x11, 0x80, 0x01, 0x06, 0x18,
  0x60, 0x80, 0xC0, 0x30, 0x08, 0x04, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x40,
  0x30, 0x08, 0x06, 0x01, 0x06, 0x18, 0x60, 0x80, 0x3C, 0x87, 0x08, 0x10,
  0x20, 0x86, 0x10, 0x20, 0x01, 0x83, 0x00, 0x1E, 0x21, 0x21, 0x4F, 0x59,
  0x51, 0x91, 0x91, 0x93, 0x96, 0x88, 0x80, 0x40, 0x3C, 0x06, 0x03, 0x02,
  0x81, 0x21, 0x10, 0x88, 0x84, 0x7E, 0x21, 0x20, 0x90, 0x30, 0x10, 0x3E,
  0x21, 0x41, 0x41, 0x41, 0x7E, 0x43, 0x41, 0x81, 0x81, 0x82, 0xFC, 0x0E,
  0x18, 0x88, 0x28, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x21, 0x90, 0x87,
  0x80, 0x3E, 0x10, 0x88, 0x48, 0x14, 0x0A, 0x09, 0x04, 0x82, 0x41, 0x41,
  0x21, 0x9F, 0x00, 0x3F, 0x90, 0x10, 0x08, 0x04, 0x03, 0xF9, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x1F, 0xC0, 0x3F, 0x90, 0x10, 0x08, 0x04, 0x03, 0xF9,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x00, 0x1E, 0x18, 0x98, 0x28, 0x04,
  0x06, 0x02, 0x3D, 0x02, 0x81, 0x41, 0x11, 0x87, 0x40, 0x20, 0xA0, 0x50,
  0x68, 0x24, 0x13, 0xF9, 0x05, 0x02, 0x81, 0x41, 0x20, 0x90, 0x40, 0x3F,
  0x82, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x1F,
  0xC0, 0x1F, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x82, 0xC4,
  0x78, 0x20, 0xC8, 0x44, 0x21, 0x10, 0x48, 0x16, 0x06, 0x81, 0x10, 0x84,
  0x20, 0x88, 0x22, 0x04, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40,
  0x81, 0x07, 0xF0, 0x60, 0xB0, 0xD8, 0xEA, 0x55, 0x52, 0xAA, 0x25, 0x12,
  0x91, 0x40, 0xA0, 0x90, 0x40, 0x20, 0xA8, 0x54, 0x2A, 0x25, 0x12, 0x49,
  0x25, 0x12, 0x85, 0x43, 0x21, 0x90, 0xC0, 0x1E, 0x10, 0x90, 0x48, 0x14,
  0x0C, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x11, 0x87, 0x00, 0x3F, 0x10, 0xD0,
  0x28, 0x14, 0x0A, 0x09, 0xF8, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x00, 0x1E,
  0x10, 0x90, 0x48, 0x14, 0x0C, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x11, 0x8F,
  0x81, 0x90, 0x58, 0x10, 0x3F, 0x10, 0xD0, 0x28, 0x14, 0x0A, 0x09, 0xF8,
  0x90, 0xC4, 0x42, 0x20, 0x90, 0x40, 0x1E, 0x30, 0x90, 0x68, 0x04, 0x01,
  0xC0, 0x18, 0x02, 0x01, 0x40, 0xB0, 0x8F, 0x80, 0xFF, 0x84, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x00, 0x20, 0xA0,
  0x50, 0x28, 0x24, 0x12, 0x09, 0x05, 0x02, 0x82, 0x41, 0x11, 0x8F, 0x80,
  0x81, 0xC0, 0xA0, 0xD0, 0x44, 0x22, 0x21, 0x10, 0x90, 0x48, 0x28, 0x14,
  0x04, 0x00, 0x40, 0x50, 0x24, 0x09, 0x22, 0x88, 0xA5, 0x49, 0x52, 0x94,
  0xA5, 0x29, 0x8C, 0x63, 0x18, 0x20, 0x62, 0x18, 0x42, 0x04, 0x80, 0xA0,
  0x08, 0x03, 0x00, 0x50, 0x12, 0x04, 0x21, 0x04, 0x40, 0x40, 0x80, 0xC0,
  0x90, 0x88, 0x82, 0xC1, 0x40, 0xC0, 0x20, 0x20, 0x10, 0x08, 0x04, 0x00,
  0x3F, 0xC0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x08,
  0x04, 0x03, 0xFE, 0x3E, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x04, 0x08, 0x10, 0x3E, 0x00, 0x88, 0x44, 0x44, 0x42, 0x22, 0x21, 0x11,
  0x10, 0x1E, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40,
  0x81, 0x3E, 0x00, 0x0C, 0x05, 0x04, 0x84, 0x42, 0x12, 0x0A, 0x06, 0xFF,
  0xA4, 0x3D, 0x63, 0x41, 0x82, 0x82, 0x82, 0x82, 0xCE, 0x7B, 0x20, 0x20,
  0x20, 0x20, 0x4E, 0x71, 0x41, 0x41, 0x41, 0x41, 0x83, 0xC6, 0xBC, 0x1E,
  0x22, 0x43, 0x40, 0x80, 0x80, 0x82, 0x44, 0x38, 0x00, 0x80, 0x80, 0x40,
  0x23, 0xD3, 0x19, 0x05, 0x02, 0x82, 0x41, 0x20, 0x98, 0xC7, 0xA0, 0x1E,
  0x21, 0x41, 0x82, 0xFC, 0x80, 0x83, 0x46, 0x3C, 0x03, 0xE0, 0x40, 0x08,
  0x01, 0x03, 0xFC, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x08, 0x81, 0x90, 0x1A, 0x01, 0x80, 0x3D, 0x63, 0x41, 0x81, 0x82, 0x82,
  0x82, 0xC6, 0x7A, 0x04, 0x84, 0x78, 0x20, 0x20, 0x20, 0x20, 0x2E, 0x53,
  0x61, 0x41, 0x42, 0x42, 0x42, 0x82, 0x82, 0x0C, 0x0C, 0x00, 0x00, 0x78,
  0x88, 0x10, 0x10, 0x10, 0x11, 0x12, 0x2C, 0x30, 0x03, 0x03, 0x00, 0x00,
  0x3E, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x84, 0x48, 0x28, 0x18,
  0x20, 0x10, 0x08, 0x04, 0x02, 0xE2, 0x89, 0x84, 0x84, 0x4C, 0x28, 0x12,
  0x71, 0x68, 0x60, 0xF0, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x85,
  0x32, 0x86, 0x00, 0x3D, 0x89, 0x96, 0x45, 0x12, 0x44, 0x92, 0x24, 0x89,
  0x22, 0x88, 0x80, 0x2E, 0x53, 0x61, 0x41, 0x42, 0x42, 0x42, 0x82, 0x82,
  0x1E, 0x63, 0x41, 0x81, 0x81, 0x81, 0x82, 0x46, 0x3C, 0x6E, 0x71, 0x41,
  0x41, 0x41, 0x41, 0x83, 0xC6, 0xBC, 0x80, 0x80, 0x80, 0x3D, 0x63, 0x41,
  0x81, 0x82, 0x82, 0x82, 0xC6, 0x7A, 0x02, 0x04, 0x04, 0xF7, 0x18, 0x30,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x3E, 0x61, 0x40, 0x60, 0x3E, 0x02,
  0x02, 0xC2, 0x7C, 0x08, 0x08, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x22,
  0x23, 0x2C, 0x30, 0x83, 0x06, 0x0C, 0x28, 0x50, 0xA1, 0x4E, 0xE4, 0xE1,
  0x21, 0x21, 0x21, 0x21, 0x42, 0x46, 0x4C, 0x70, 0x49, 0x24, 0x62, 0x31,
  0x18, 0x8C, 0x4A, 0x45, 0x66, 0xEE, 0x00, 0x19, 0x9A, 0x98, 0xC4, 0x10,
  0x04, 0x03, 0x08, 0xCA, 0x56, 0x66, 0x00, 0x41, 0x41, 0x41, 0x42, 0x42,
  0x42, 0x42, 0x4E, 0x72, 0x04, 0x8C, 0xF8, 0x3D, 0x43, 0x42, 0x04, 0x18,
  0x22, 0x42, 0xF1, 0x9E, 0x0F, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0xF0,
  0x10, 0x10, 0x10, 0x20, 0x40, 0x40, 0x78, 0x24, 0xA4, 0x92, 0x52, 0x49,
  0x20, 0x3C, 0x04, 0x04, 0x04, 0x08, 0x10, 0x10, 0x0F, 0x18, 0x20, 0x10,
  0x10, 0x10, 0x10, 0xF0, 0x70, 0xA8, 0xA2, 0x50, 0xC0,
};

const GFXglyph IBMPlexMono_LightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 4, 5, 10, 4, -13 },
  { 10, 10, 12, 10, 0, -12 },
  { 25, 10, 16, 10, 0, -14 },
  { 45, 11, 12, 10, 0, -12 },
  { 62, 10, 12, 10, 0, -12 },
  { 77, 2, 5, 10, 5, -13 },
  { 79, 6, 15, 10, 4, -13 },
  { 91, 6, 15, 10, 1, -13 },
  { 103, 9, 8, 10, 1, -9 },
  { 112, 8, 9, 10, 1, -10 },
  { 121, 4, 5, 10, 2, -2 },
  { 124, 5, 1, 10, 3, -6 },
  { 125, 3, 2, 10, 3, -2 },
  { 126, 10, 15, 10, 0, -13 },
  { 145, 9, 12, 10, 1, -12 },
  { 159, 8, 12, 10, 1, -12 },
  { 171, 8, 12, 10, 1, -12 },
  { 183, 8, 12, 10, 1, -12 },
  { 195, 9, 12, 10, 0, -12 },
  { 209, 9, 12, 10, 1, -12 },
  { 223, 8, 12, 10, 1, -12 },
  { 235, 8, 12, 10, 2, -12 },
  { 247, 9, 12, 10, 1, -12 },
  { 261, 7, 12, 10, 2, -12 },
  { 272, 4, 9, 10, 3, -9 },
  { 277, 5, 12, 10, 2, -9 },
  { 285, 8, 9, 10, 2, -10 },
  { 294, 9, 4, 10, 1, -7 },
  { 299, 8, 9, 10, 1, -10 },
  { 308, 7, 12, 10, 2, -12 },
  { 319, 8, 14, 10, 1, -12 },
  { 333, 9, 12, 10, 0, -12 },
  { 347, 8, 12, 10, 1, -12 },
  { 359, 9, 12, 10, 1, -12 },
  { 373, 9, 12, 10, 1, -12 },
  { 387, 9, 12, 10, 1, -12 },
  { 401, 9, 12, 10, 1, -12 },
  { 415, 9, 12, 10, 1, -12 },
  { 429, 9, 12, 10, 1, -12 },
  { 443, 9, 12, 10, 1, -12 },
  { 457, 8, 12, 10, 1, -12 },
  { 469, 10, 12, 10, 1, -12 },
  { 484, 7, 12, 10, 1, -12 },
  { 495, 9, 12, 10, 1, -12 },
  { 509, 9, 12, 10, 1, -12 },
  { 523, 9, 12, 10, 1, -12 },
  { 537, 9, 12, 10, 1, -12 },
  { 551, 9, 15, 10, 1, -12 },
  { 568, 9, 12, 10, 1, -12 },
  { 582, 9, 12, 10, 1, -12 },
  { 596, 9, 12, 10, 2, -12 },
  { 610, 9, 12, 10, 1, -12 },
  { 624, 9, 12, 10, 2, -12 },
  { 638, 10, 12, 10, 1, -12 },
  { 653, 11, 12, 10, 0, -12 },
  { 670, 9, 12, 10, 2, -12 },
  { 684, 10, 12, 10, 0, -12 },
  { 699, 7, 15, 10, 3, -13 },
  { 713, 4, 15, 10, 3, -13 },
  { 721, 7, 15, 10, 0, -13 },
  { 735, 9, 7, 10, 1, -12 },
  { 743, 8, 1, 10, 0, 2 },
  { 744, 2, 3, 10, 4, -13 },
  { 745, 8, 9, 10, 1, -9 },
  { 754, 8, 13, 10, 1, -13 },
  { 767, 8, 9, 10, 1, -9 },
  { 776, 9, 13, 10, 1, -13 },
  { 791, 8, 9, 10, 1, -9 },
  { 800, 11, 16, 10, 0, -13 },
  { 822, 8, 12, 10, 1, -9 },
  { 834, 8, 13, 10, 1, -13 },
  { 847, 8, 13, 10, 1, -13 },
  { 860, 8, 16, 10, 1, -13 },
  { 876, 9, 13, 10, 1, -13 },
  { 891, 7, 13, 10, 2, -13 },
  { 903, 10, 9, 10, 0, -9 },
  { 915, 8, 9, 10, 1, -9 },
  { 924, 8, 9, 10, 1, -9 },
  { 933, 8, 12, 10, 1, -9 },
  { 945, 8, 12, 10, 1, -9 },
  { 957, 8, 9, 10, 2, -9 },
  { 966, 8, 9, 10, 1, -9 },
  { 975, 8, 12, 10, 1, -12 },
  { 987, 7, 9, 10, 2, -9 },
  { 995, 8, 9, 10, 1, -9 },
  { 1004, 9, 9, 10, 1, -9 },
  { 1015, 10, 9, 10, 0, -9 },
  { 1027, 8, 12, 10, 1, -9 },
  { 1039, 8, 9, 10, 1, -9 },
  { 1048, 8, 15, 10, 2, -13 },
  { 1063, 3, 15, 10, 4, -13 },
  { 1069, 8, 15, 10, 1, -13 },
  { 1084, 9, 4, 10, 1, -7 },
};

const GFXfont IBMPlexMono_LightItalic17pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic17pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _IBMPLEXMONO_LIGHTITALIC17PT7B_H_
