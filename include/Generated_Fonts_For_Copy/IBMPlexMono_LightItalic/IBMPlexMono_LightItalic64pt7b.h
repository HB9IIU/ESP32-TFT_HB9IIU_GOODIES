#ifndef _IBMPLEXMONO_LIGHTITALIC64PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC,
  0x07, 0xC0, 0x00, 0x1C, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xE0,
  0x38, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x03, 0xC0,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xE1, 0xCF, 0xE0, 0x03, 0xE0, 0x30, 0x3E, 0x00,
  0xF8, 0x0E, 0x03, 0xE0, 0x1E, 0x01, 0xC0, 0x3E, 0x07, 0x80, 0x38, 0x03,
  0x80, 0xF0, 0x07, 0x00, 0x40, 0x3C, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x18,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x0C, 0x00, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x70, 0x00,
  0x00, 0x3F, 0x8E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3B, 0xFC, 0x00, 0x00, 0x07, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x7C, 0x00,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x03, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0x80, 0x1E, 0x00, 0x00,
  0x70, 0x03, 0xC0, 0x80, 0x0E, 0x00, 0x78, 0x30, 0x01, 0xC0, 0x1F, 0x0F,
  0x00, 0x38, 0x03, 0xC1, 0xF0, 0x07, 0x00, 0xF0, 0x1F, 0x00, 0xC0, 0x3E,
  0x01, 0xF8, 0x38, 0x1F, 0x80, 0x1F, 0xE7, 0x0F, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x0F,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x00,
  0x70, 0x78, 0x00, 0x03, 0x80, 0x1C, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x83,
  0x80, 0x00, 0x07, 0x83, 0xE0, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x20, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1E, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0x83, 0xE0, 0xF8, 0x00, 0x00, 0xE0, 0x70, 0x07,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x0E, 0x00,
  0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x00, 0x1C,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80,
  0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x3C, 0x00, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xC0, 0x0E, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x01, 0xFE, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xF0,
  0xFF, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0x3C, 0x00, 0x03, 0xE0, 0x0F,
  0xF0, 0x00, 0x0B, 0x80, 0x39, 0xC0, 0x00, 0x2F, 0x01, 0xC7, 0x80, 0x01,
  0x9C, 0x0F, 0x1E, 0x00, 0x06, 0x78, 0x38, 0x3C, 0x00, 0x30, 0xF1, 0xE0,
  0xF8, 0x03, 0xC3, 0xC7, 0x01, 0xF0, 0x1E, 0x07, 0xBC, 0x03, 0xFF, 0xF0,
  0x1F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0xF3, 0xCF, 0x38, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x73, 0xCF, 0x3C,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x01, 0xC0, 0x01,
  0x78, 0x01, 0xC0, 0x0F, 0xFF, 0x01, 0xC0, 0x7F, 0x7F, 0xE3, 0xC7, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07, 0x80, 0x08, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x0F, 0x78, 0x03, 0xE0, 0x0F, 0x78, 0x07,
  0xE0, 0x0F, 0x78, 0x07, 0xE0, 0x1F, 0x78, 0x07, 0xE0, 0x1E, 0x78, 0x07,
  0xE0, 0x1E, 0x70, 0x03, 0xC0, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7E, 0x3C,
  0x00, 0x03, 0xF0, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00,
  0x0F, 0xC0, 0x78, 0x00, 0x7E, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x40, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x40, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x81, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0xFF,
  0x00, 0x00, 0xF1, 0xFF, 0xF0, 0x00, 0x71, 0xFF, 0xFC, 0x00, 0x3B, 0xC0,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x07, 0xC0,
  0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x3F, 0xC0, 0x03, 0xC7, 0xFF, 0xC0, 0x1E, 0x3F, 0xFF, 0xC0,
  0x7B, 0xE0, 0x3F, 0x83, 0xDC, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x3C, 0x3B,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xC0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0x3E, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x78, 0x7C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x1B, 0xC7, 0xC0, 0x03, 0xBC, 0x1F, 0x80, 0x79, 0xE0, 0x7F, 0xFF,
  0x9E, 0x01, 0xFF, 0xF0, 0xF0, 0x01, 0xFE, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xE7, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xF2, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xF8,
  0x0F, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00,
  0xE1, 0xC0, 0x07, 0xE1, 0xC3, 0x80, 0x3F, 0xE3, 0x8F, 0x00, 0xFF, 0xE7,
  0x1C, 0x03, 0xE0, 0xEE, 0x38, 0x0F, 0x00, 0x7C, 0x70, 0x1C, 0x00, 0xF1,
  0xE0, 0x78, 0x00, 0xE3, 0xC0, 0xE0, 0x01, 0xC7, 0x01, 0xC0, 0x03, 0x8E,
  0x07, 0x80, 0x07, 0x1C, 0x0E, 0x00, 0x1E, 0x78, 0x1C, 0x00, 0x38, 0xF0,
  0x38, 0x00, 0x71, 0xE0, 0xF0, 0x00, 0xE3, 0x81, 0xE0, 0x01, 0xC7, 0x03,
  0xC0, 0x03, 0x8E, 0x07, 0x00, 0x0F, 0x1C, 0x0E, 0x00, 0x1C, 0x38, 0x1C,
  0x00, 0x38, 0xF0, 0x38, 0x00, 0xF1, 0xE0, 0x78, 0x03, 0xE3, 0xC0, 0xF0,
  0x05, 0xC7, 0x80, 0xF0, 0x17, 0x8E, 0x01, 0xF0, 0xEE, 0x1C, 0x01, 0xFF,
  0x9C, 0x3C, 0x01, 0xFE, 0x38, 0x78, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xE0, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x3E, 0x01, 0xC0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x03, 0xF0, 0x0E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x70, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x07, 0xF0, 0x03, 0xC0,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1F, 0x1E, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x0F, 0x80, 0x70, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x01, 0xFF, 0xF9, 0xE0, 0x03, 0xFF, 0xF3, 0xC0, 0x07, 0xFF,
  0xE7, 0x80, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF8, 0x3C,
  0x00, 0x02, 0xE0, 0x3C, 0x00, 0x0D, 0xC0, 0x7C, 0x00, 0x73, 0x80, 0x7E,
  0x03, 0xCF, 0x00, 0x7F, 0xFF, 0x1E, 0x00, 0x7F, 0xFC, 0x3C, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x3E, 0x00,
  0x00, 0x01, 0xC1, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0x00, 0x3C,
  0x7F, 0x80, 0x00, 0x00, 0xF3, 0xEF, 0x00, 0x00, 0x03, 0xDF, 0x3C, 0x00,
  0x00, 0x0E, 0xF0, 0x78, 0x00, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x01, 0xFC,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x03,
  0xDC, 0x00, 0x0E, 0xE0, 0x3D, 0xC0, 0x01, 0xEE, 0x03, 0xDC, 0x00, 0x3D,
  0xE0, 0x39, 0xE0, 0x03, 0x9E, 0x03, 0x8E, 0x00, 0x79, 0xC0, 0x38, 0xE0,
  0x07, 0x1C, 0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x78, 0xF0, 0x1E, 0x1C, 0x07,
  0x87, 0x01, 0xC3, 0xC0, 0x70, 0x70, 0x3C, 0x3C, 0x07, 0x07, 0x03, 0x83,
  0xC0, 0x70, 0x78, 0x78, 0x38, 0x0F, 0x03, 0x87, 0x03, 0x80, 0xF0, 0x38,
  0xE0, 0x38, 0x0F, 0x03, 0x9E, 0x07, 0x80, 0xE0, 0x3D, 0xC0, 0x78, 0x0E,
  0x01, 0xFC, 0x07, 0x80, 0xE0, 0x1F, 0x80, 0x70, 0x1E, 0x01, 0xF0, 0x07,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x0F, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x1C, 0x00, 0xC0, 0x0F, 0x01, 0xC0, 0x08, 0x00, 0xE0, 0x3C,
  0x00, 0x80, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xC0,
  0x7E, 0x00, 0x00, 0x70, 0x1F, 0x80, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0x0F,
  0x01, 0xFC, 0x00, 0x03, 0xC0, 0xF7, 0x00, 0x00, 0xF0, 0x3D, 0xE0, 0x00,
  0x38, 0x0F, 0x78, 0x00, 0x0E, 0x03, 0x8E, 0x00, 0x03, 0x80, 0xE3, 0x80,
  0x01, 0xE0, 0x38, 0xF0, 0x00, 0x78, 0x1E, 0x3C, 0x00, 0x1E, 0x07, 0x87,
  0x00, 0x07, 0x01, 0xE1, 0xC0, 0x01, 0xC0, 0x70, 0x78, 0x00, 0x70, 0x1C,
  0x1E, 0x00, 0x3C, 0x07, 0x03, 0x80, 0x0F, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0xF0, 0x3C, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x0E,
  0x03, 0x80, 0x78, 0x07, 0x80, 0xE0, 0x1E, 0x01, 0xE0, 0x78, 0x03, 0x80,
  0x78, 0x1E, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x3C, 0x07, 0x01, 0xC0, 0x0F,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0xF0, 0x1C, 0x00, 0x78, 0x3C, 0x0F, 0x00,
  0x1E, 0x0F, 0x03, 0xC0, 0x03, 0x83, 0x80, 0xF0, 0x00, 0xE0, 0xE0, 0x38,
  0x00, 0x3C, 0x38, 0x0E, 0x00, 0x0F, 0x1E, 0x03, 0x80, 0x01, 0xC7, 0x81,
  0xE0, 0x00, 0x71, 0xE0, 0x78, 0x00, 0x1E, 0x70, 0x1E, 0x00, 0x03, 0x9C,
  0x07, 0x00, 0x00, 0xE7, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x70, 0x00, 0x0F,
  0xF0, 0x3C, 0x00, 0x01, 0xFC, 0x0F, 0x00, 0x00, 0x7E, 0x03, 0xC0, 0x00,
  0x1F, 0x80, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x7C,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x0F, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0x80, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x18, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0xFC,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x01, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x02, 0x00, 0x00, 0x01,
  0xE0, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x1F, 0x00, 0x78, 0x3C,
  0x01, 0xF0, 0x07, 0x83, 0xC0, 0x3F, 0x00, 0x70, 0x38, 0x03, 0xF0, 0x07,
  0x03, 0x80, 0x3F, 0x00, 0xF0, 0x38, 0x07, 0x70, 0x0F, 0x03, 0x80, 0x77,
  0x00, 0xE0, 0x38, 0x0F, 0x78, 0x0E, 0x03, 0x80, 0xE3, 0x81, 0xE0, 0x38,
  0x1E, 0x38, 0x1E, 0x03, 0x81, 0xC3, 0x81, 0xC0, 0x78, 0x1C, 0x38, 0x1C,
  0x07, 0x83, 0xC3, 0x83, 0xC0, 0x78, 0x38, 0x38, 0x3C, 0x07, 0x87, 0x83,
  0x83, 0x80, 0x70, 0x70, 0x38, 0x38, 0x07, 0x07, 0x03, 0x87, 0x80, 0x70,
  0xE0, 0x38, 0x78, 0x07, 0x0E, 0x03, 0x87, 0x00, 0x71, 0xE0, 0x38, 0x70,
  0x07, 0x1C, 0x03, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x01,
  0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x78, 0x01, 0xCE, 0x00, 0xF7,
  0x00, 0x1D, 0xE0, 0x0F, 0x70, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x1D, 0xC0,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x70,
  0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0F, 0x60, 0x00, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x20,
  0xF0, 0xF0, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x05, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0xF0, 0x0F, 0xFF, 0xE3, 0xC0, 0x7E,
  0x03, 0xCF, 0x03, 0xE0, 0x03, 0x38, 0x1E, 0x00, 0x06, 0xE0, 0xF0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x1B, 0x81,
  0xF0, 0x00, 0xCE, 0x03, 0xE0, 0x07, 0x38, 0x07, 0xC0, 0x79, 0xFF, 0x1F,
  0xFF, 0xC3, 0xFC, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x03, 0xF8, 0x00, 0x38, 0x3F, 0xFC, 0x01, 0xE3, 0xFF, 0xF8, 0x07,
  0x9F, 0x03, 0xF0, 0x1E, 0x60, 0x03, 0xC0, 0x73, 0x00, 0x07, 0x81, 0xD8,
  0x00, 0x1E, 0x07, 0x40, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F,
  0x07, 0x60, 0x00, 0x7C, 0x1C, 0xC0, 0x03, 0xE0, 0xF3, 0xE0, 0x7F, 0x03,
  0xC7, 0xFF, 0xF8, 0x0F, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0x80,
  0xFC, 0x03, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x83, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xCF, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0xE0,
  0x01, 0xFF, 0xF0, 0x70, 0x01, 0xFF, 0xFC, 0x78, 0x01, 0xF8, 0x0F, 0x3C,
  0x01, 0xF0, 0x01, 0xDE, 0x01, 0xE0, 0x00, 0x6F, 0x01, 0xE0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x70,
  0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x0D, 0xE0, 0x1F, 0x00, 0x0E, 0xF0, 0x07,
  0xC0, 0x0E, 0x70, 0x01, 0xF0, 0x1E, 0x38, 0x00, 0xFF, 0xFE, 0x3C, 0x00,
  0x1F, 0xFE, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC0, 0x7E, 0x03, 0xE0,
  0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3E, 0x70, 0x00, 0x0F,
  0xCF, 0x00, 0x07, 0xF8, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xCF,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x40, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x07, 0x00, 0x3F, 0xFF, 0x8F,
  0x00, 0x7E, 0x03, 0xCF, 0x00, 0xF8, 0x00, 0xEF, 0x01, 0xE0, 0x00, 0x6F,
  0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xF0,
  0x1E, 0x00, 0x06, 0xF0, 0x1F, 0x00, 0x0E, 0xF0, 0x0F, 0x80, 0x1C, 0xF0,
  0x07, 0xE0, 0x78, 0xE0, 0x07, 0xFF, 0xF0, 0xE0, 0x01, 0xFF, 0xE0, 0xE0,
  0x00, 0x7F, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x20, 0x00, 0x0F, 0x00,
  0x30, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x7F, 0x00, 0x0F, 0x0F, 0xFE, 0x00, 0x70, 0xFF, 0xF8, 0x03, 0x8F,
  0x03, 0xE0, 0x3C, 0xE0, 0x0F, 0x81, 0xEC, 0x00, 0x3C, 0x0F, 0x40, 0x01,
  0xE0, 0x7E, 0x00, 0x07, 0x83, 0xA0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x40, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xE0, 0x0F,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x70, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x00, 0xF0, 0x07, 0x80,
  0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xE0, 0x0E,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xF8, 0x00, 0x0E, 0x0F, 0xFF, 0x00,
  0x07, 0x0F, 0xFF, 0xC0, 0x07, 0x8F, 0x03, 0xF0, 0x03, 0xCE, 0x00, 0x78,
  0x01, 0xEC, 0x00, 0x1E, 0x00, 0xEC, 0x00, 0x0F, 0x00, 0x74, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x78, 0x03, 0x80, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x38, 0x07, 0xE0, 0x00, 0x1C, 0x1F,
  0x80, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x21, 0xC0, 0x3C, 0x00, 0x38, 0xE0,
  0x1E, 0x00, 0x3E, 0x70, 0x07, 0x80, 0x3C, 0x78, 0x03, 0xC0, 0x3C, 0x3C,
  0x00, 0xF0, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x0E, 0x00, 0x1E, 0x3C, 0x07,
  0x00, 0x0F, 0x3C, 0x03, 0x80, 0x03, 0xFC, 0x03, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x18, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x38, 0x03, 0xC0, 0x1E,
  0x03, 0xE0, 0x07, 0x81, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0xF8, 0x00,
  0x1C, 0x7C, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x01, 0xC7, 0xF8, 0x3F,
  0xE0, 0x73, 0xFF, 0x1F, 0xF8, 0x1D, 0xC3, 0xCE, 0x1F, 0x0F, 0xC0, 0x73,
  0x03, 0xC3, 0xE0, 0x1D, 0x80, 0x70, 0xF8, 0x07, 0x40, 0x1C, 0x3C, 0x01,
  0xF0, 0x07, 0x0F, 0x00, 0x78, 0x01, 0xC3, 0x80, 0x1E, 0x00, 0x71, 0xE0,
  0x07, 0x00, 0x3C, 0x78, 0x01, 0xC0, 0x0F, 0x1C, 0x00, 0x70, 0x03, 0xC7,
  0x00, 0x3C, 0x00, 0xE1, 0xC0, 0x0F, 0x00, 0x38, 0x70, 0x03, 0x80, 0x0E,
  0x3C, 0x00, 0xE0, 0x03, 0x8F, 0x00, 0x38, 0x01, 0xE3, 0x80, 0x0E, 0x00,
  0x78, 0xE0, 0x07, 0x80, 0x1C, 0x38, 0x01, 0xE0, 0x07, 0x0E, 0x00, 0x78,
  0x01, 0xC7, 0x80, 0x1C, 0x00, 0x71, 0xE0, 0x07, 0x00, 0x3C, 0x70, 0x01,
  0xC0, 0x0F, 0x1C, 0x00, 0xF0, 0x03, 0x87, 0x00, 0x3C, 0x00, 0xE1, 0xC0,
  0x0F, 0x00, 0x38, 0xF0, 0x03, 0x80, 0x0E, 0x3C, 0x00, 0xE0, 0x07, 0x8E,
  0x00, 0x38, 0x01, 0xE3, 0x80, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x80, 0x1C,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1E, 0x1F, 0xFC,
  0x00, 0xE1, 0xFF, 0xF0, 0x07, 0x1E, 0x07, 0xC0, 0x79, 0xC0, 0x1F, 0x03,
  0xD8, 0x00, 0x78, 0x1E, 0x80, 0x03, 0xC0, 0xFC, 0x00, 0x0F, 0x07, 0x40,
  0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x3C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xF0, 0x1F, 0x00,
  0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0xFF, 0xF0,
  0x01, 0xE3, 0xFF, 0xF8, 0x01, 0xE7, 0xC0, 0xFC, 0x01, 0xE6, 0x00, 0x3C,
  0x01, 0xCC, 0x00, 0x1E, 0x01, 0xD8, 0x00, 0x1E, 0x03, 0xD0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0,
  0x1D, 0x80, 0x01, 0xF0, 0x1C, 0xC0, 0x03, 0xE0, 0x3C, 0xF8, 0x1F, 0xC0,
  0x3C, 0x7F, 0xFF, 0x80, 0x3C, 0x1F, 0xFE, 0x00, 0x3C, 0x07, 0xF8, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x70, 0x0F, 0xFF, 0xE3, 0xC0,
  0x7E, 0x03, 0xCF, 0x03, 0xE0, 0x03, 0xBC, 0x1E, 0x00, 0x06, 0xF0, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x1B,
  0xC1, 0xF0, 0x00, 0xEF, 0x03, 0xE0, 0x07, 0x38, 0x07, 0xC0, 0x78, 0xE0,
  0x1F, 0xFF, 0xC3, 0x80, 0x1F, 0xFE, 0x1E, 0x00, 0x1F, 0xC0, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xF0, 0x01, 0xE7, 0x80,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x07, 0xB0, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x1D, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x02, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x80, 0x00,
  0x01, 0xE1, 0x80, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0F, 0x1F, 0x80, 0x00,
  0x3C, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x70, 0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x2F,
  0x0F, 0x00, 0x06, 0xE0, 0xF0, 0x00, 0xCE, 0x07, 0x80, 0x19, 0xE0, 0x7E,
  0x07, 0x1E, 0x03, 0xFF, 0xE1, 0xE0, 0x1F, 0xFC, 0x1E, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x37, 0xFF, 0x00, 0x07, 0xBF, 0xF8, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x78, 0x0E, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1E,
  0x01, 0xE0, 0x01, 0xF0, 0x0E, 0x00, 0x1F, 0x00, 0x70, 0x01, 0xF0, 0x03,
  0x80, 0x1F, 0x00, 0x1C, 0x03, 0xF0, 0x01, 0xE0, 0x3F, 0x00, 0x0F, 0x1F,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x06, 0x1E, 0x00, 0x70, 0x1E, 0x1E, 0x00, 0x70,
  0x0E, 0x1C, 0x00, 0xF0, 0x0F, 0x1C, 0x00, 0xF0, 0x0F, 0x1C, 0x00, 0xE0,
  0x07, 0x1C, 0x00, 0xE0, 0x07, 0x3C, 0x00, 0xE0, 0x07, 0x3C, 0x00, 0xE0,
  0x07, 0x38, 0x01, 0xE0, 0x07, 0x38, 0x01, 0xE0, 0x07, 0x38, 0x01, 0xC0,
  0x07, 0x38, 0x01, 0xC0, 0x07, 0x38, 0x01, 0xC0, 0x07, 0x78, 0x01, 0xC0,
  0x07, 0x70, 0x03, 0xC0, 0x07, 0x70, 0x03, 0xC0, 0x07, 0x70, 0x03, 0x80,
  0x0F, 0x70, 0x03, 0x80, 0x0F, 0x70, 0x03, 0x80, 0x0E, 0xF0, 0x03, 0x80,
  0x0E, 0xE0, 0x07, 0x80, 0x0E, 0xE0, 0x07, 0x80, 0x1E, 0xE0, 0x07, 0x00,
  0x1C, 0xE0, 0x07, 0x00, 0x1C, 0xE0, 0x0F, 0x00, 0x3C, 0xE0, 0x0F, 0x00,
  0x38, 0xE0, 0x1B, 0x00, 0x78, 0xE0, 0x1B, 0x00, 0xF0, 0xE0, 0x33, 0x81,
  0xE0, 0xF0, 0xE3, 0xC3, 0xE0, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xF3, 0x83, 0xC3, 0xE0,
  0x7E, 0x1E, 0x1C, 0x0F, 0x07, 0xC0, 0xF1, 0xC0, 0x38, 0xF8, 0x03, 0x8C,
  0x01, 0xE7, 0x80, 0x1C, 0xC0, 0x0F, 0x10, 0x00, 0xE6, 0x00, 0x78, 0x00,
  0x07, 0x20, 0x03, 0xC0, 0x00, 0x1B, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x01, 0x70, 0x00,
  0x07, 0x00, 0x1B, 0x80, 0x00, 0x38, 0x00, 0xDC, 0x00, 0x21, 0xC0, 0x0C,
  0xF0, 0x07, 0x8E, 0x00, 0x67, 0x80, 0xF8, 0x78, 0x06, 0x1C, 0x0F, 0x83,
  0xC0, 0x70, 0xE1, 0xF8, 0x0F, 0x0F, 0x07, 0x9F, 0x00, 0x7F, 0xF0, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xF0, 0x0F,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x02, 0xF0, 0x0F, 0x00, 0x06, 0xF0, 0x0F,
  0x00, 0x0C, 0xE0, 0x07, 0x80, 0x18, 0xE0, 0x07, 0xE0, 0x79, 0xE0, 0x03,
  0xFF, 0xF1, 0xE0, 0x01, 0xFF, 0xC1, 0xE0, 0x00, 0x7F, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x20, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x07, 0x03, 0xFF, 0xFE, 0x07, 0x03, 0xC0, 0x7F, 0x8F, 0x07,
  0x80, 0x0F, 0xEF, 0x07, 0x00, 0x01, 0xFF, 0x0F, 0x00, 0x00, 0x7E, 0x0E,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x70, 0x03, 0xE0, 0x00, 0x70, 0x07,
  0xC0, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x3F,
  0xC0, 0x00, 0x38, 0x7F, 0xFE, 0x00, 0x38, 0x71, 0xFF, 0xE0, 0x3C, 0x70,
  0x1F, 0xFF, 0x3C, 0xF0, 0x01, 0xFF, 0xF8, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0x01, 0xFF, 0x00, 0x01, 0xC1, 0xFF, 0xC0, 0x00, 0xE1,
  0xF1, 0xF0, 0x00, 0xE0, 0xE0, 0x78, 0x00, 0x70, 0xE0, 0x1E, 0x00, 0x70,
  0xF0, 0x07, 0x80, 0x38, 0x70, 0x03, 0xC0, 0x38, 0x78, 0x00, 0xF0, 0x3C,
  0x38, 0x00, 0x3C, 0x3C, 0x1C, 0x00, 0x0F, 0xFC, 0x1C, 0x00, 0x03, 0xFC,
  0x06, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 13, 45, 38, 13, -45 },
  { 75, 16, 17, 38, 15, -47 },
  { 109, 38, 45, 38, 1, -45 },
  { 323, 35, 58, 38, 2, -51 },
  { 577, 43, 46, 38, -1, -45 },
  { 825, 38, 46, 38, 0, -45 },
  { 1044, 6, 17, 38, 20, -47 },
  { 1057, 22, 58, 38, 14, -49 },
  { 1217, 23, 58, 38, 3, -49 },
  { 1384, 32, 32, 38, 4, -35 },
  { 1512, 31, 31, 38, 4, -35 },
  { 1633, 13, 17, 38, 9, -7 },
  { 1661, 19, 3, 38, 10, -21 },
  { 1669, 8, 7, 38, 13, -7 },
  { 1676, 35, 58, 38, 2, -49 },
  { 1930, 32, 46, 38, 4, -45 },
  { 2114, 30, 45, 38, 3, -45 },
  { 2283, 33, 45, 38, 2, -45 },
  { 2469, 33, 46, 38, 2, -45 },
  { 2659, 34, 45, 38, 1, -45 },
  { 2851, 33, 46, 38, 3, -45 },
  { 3041, 30, 46, 38, 4, -45 },
  { 3214, 31, 45, 38, 7, -45 },
  { 3389, 33, 46, 38, 3, -45 },
  { 3579, 29, 45, 38, 6, -45 },
  { 3743, 12, 34, 38, 13, -34 },
  { 3794, 16, 44, 38, 9, -34 },
  { 3882, 30, 36, 38, 6, -38 },
  { 4017, 33, 15, 38, 3, -27 },
  { 4079, 31, 36, 38, 3, -38 },
  { 4219, 26, 45, 38, 9, -45 },
  { 4366, 31, 52, 38, 4, -45 },
  { 4568, 33, 45, 38, 0, -45 },
  { 4754, 32, 45, 38, 3, -45 },
  { 4934, 32, 46, 38, 5, -45 },
  { 5118, 32, 45, 38, 4, -45 },
  { 5298, 35, 45, 38, 3, -45 },
  { 5495, 35, 45, 38, 3, -45 },
  { 5692, 31, 46, 38, 5, -45 },
  { 5871, 34, 45, 38, 3, -45 },
  { 6063, 35, 45, 38, 3, -45 },
  { 6260, 31, 46, 38, 4, -45 },
  { 6439, 38, 45, 38, 3, -45 },
  { 6653, 26, 45, 38, 6, -45 },
  { 6800, 36, 45, 38, 2, -45 },
  { 7003, 34, 45, 38, 3, -45 },
  { 7195, 32, 46, 38, 4, -45 },
  { 7379, 34, 45, 38, 3, -45 },
  { 7571, 32, 56, 38, 4, -45 },
  { 7795, 34, 45, 38, 3, -45 },
  { 7987, 35, 46, 38, 2, -45 },
  { 8189, 35, 45, 38, 6, -45 },
  { 8386, 32, 46, 38, 5, -45 },
  { 8570, 33, 45, 38, 7, -45 },
  { 8756, 36, 45, 38, 4, -45 },
  { 8959, 41, 45, 38, 0, -45 },
  { 9190, 36, 45, 38, 6, -45 },
  { 9393, 39, 45, 38, 0, -45 },
  { 9613, 27, 58, 38, 11, -49 },
  { 9809, 16, 58, 38, 12, -49 },
  { 9925, 26, 58, 38, 1, -49 },
  { 10114, 31, 25, 38, 5, -45 },
  { 10211, 31, 3, 38, 0, 7 },
  { 10223, 8, 12, 38, 15, -50 },
  { 10235, 30, 35, 38, 4, -34 },
  { 10367, 30, 48, 38, 4, -47 },
  { 10547, 28, 35, 38, 5, -34 },
  { 10670, 33, 48, 38, 4, -47 },
  { 10868, 28, 35, 38, 5, -34 },
  { 10991, 41, 61, 38, -1, -47 },
  { 11304, 32, 48, 38, 2, -34 },
  { 11496, 29, 47, 38, 4, -47 },
  { 11667, 29, 49, 38, 5, -48 },
  { 11845, 29, 62, 38, 5, -48 },
  { 12070, 33, 48, 38, 4, -47 },
  { 12268, 26, 48, 38, 7, -47 },
  { 12424, 34, 34, 38, 2, -34 },
  { 12569, 29, 34, 38, 4, -34 },
  { 12693, 29, 35, 38, 5, -34 },
  { 12820, 32, 47, 38, 2, -34 },
  { 13008, 30, 47, 38, 4, -34 },
  { 13185, 31, 33, 38, 7, -33 },
  { 13313, 31, 35, 38, 3, -34 },
  { 13449, 30, 46, 38, 5, -45 },
  { 13622, 28, 34, 38, 6, -33 },
  { 13741, 29, 33, 38, 5, -33 },
  { 13861, 32, 34, 38, 4, -33 },
  { 13997, 37, 35, 38, 1, -34 },
  { 14159, 32, 47, 38, 2, -33 },
  { 14347, 32, 35, 38, 3, -34 },
  { 14487, 30, 58, 38, 7, -49 },
  { 14705, 13, 58, 38, 13, -49 },
  { 14800, 29, 58, 38, 3, -49 },
  { 15011, 33, 13, 38, 3, -26 },
};

const GFXfont IBMPlexMono_LightItalic64pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic64pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic64pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _IBMPLEXMONO_LIGHTITALIC64PT7B_H_
