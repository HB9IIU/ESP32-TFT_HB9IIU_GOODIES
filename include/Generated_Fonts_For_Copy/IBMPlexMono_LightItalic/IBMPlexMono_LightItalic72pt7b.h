#ifndef _IBMPLEXMONO_LIGHTITALIC72PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xC7, 0x80, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0,
  0x1E, 0x78, 0x07, 0x9E, 0x01, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F,
  0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xC3, 0xCF, 0xF8, 0x00, 0x7F, 0x03, 0x81, 0xFC,
  0x00, 0xFC, 0x03, 0x80, 0x7C, 0x00, 0xF8, 0x03, 0x80, 0x3E, 0x01, 0xF0,
  0x03, 0x80, 0x1F, 0x01, 0xE0, 0x03, 0x80, 0x0C, 0x03, 0xE0, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x00,
  0x03, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x01, 0xF8,
  0x0E, 0x00, 0x00, 0x00, 0xFE, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x9E, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3C, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x1F, 0xC0,
  0x00, 0x00, 0x38, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x03, 0xE0, 0x00, 0x00,
  0x38, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01,
  0xF0, 0x00, 0x00, 0x70, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x01, 0xF0, 0x00,
  0x00, 0x70, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x01, 0xF0, 0x00, 0x00, 0x70,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x30, 0x00, 0xE0, 0x03, 0xE0,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0xFC, 0x00, 0xE0, 0x07, 0xC0, 0x7E, 0x00,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x1F, 0xC1, 0xE0, 0x7F,
  0x00, 0x0F, 0xF9, 0xC3, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x81, 0xE0,
  0x00, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x3E, 0x07, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x08, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x00, 0x00, 0x03, 0x81, 0xF0, 0x07,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x03,
  0x80, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0x80, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0x00, 0x78, 0x07, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x00, 0x7F, 0xE3, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x13, 0xE0, 0x00, 0x07, 0xC0, 0x06, 0xF8, 0x00, 0x01, 0xF0, 0x03,
  0xDE, 0x00, 0x00, 0xFE, 0x01, 0xF7, 0x80, 0x00, 0x37, 0x80, 0x79, 0xE0,
  0x00, 0x19, 0xF0, 0x3C, 0x7C, 0x00, 0x06, 0x3E, 0x0F, 0x0F, 0x80, 0x03,
  0x87, 0x87, 0x83, 0xF0, 0x03, 0xC1, 0xF3, 0xE0, 0x7F, 0x03, 0xF0, 0x3C,
  0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x1E, 0x3C,
  0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xE3, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x07, 0x3F, 0x00, 0x3C, 0x01, 0xFB, 0xFF, 0x01, 0xE0, 0x7F,
  0xE7, 0xFF, 0x0E, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x03, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x1F, 0x3C, 0x00,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0xF0, 0x01, 0xE7, 0x80, 0x1F, 0x80,
  0x1E, 0x78, 0x03, 0xF8, 0x01, 0xEF, 0x80, 0x3F, 0x80, 0x3E, 0xF8, 0x03,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x80, 0x3E, 0xF8, 0x01, 0xF0, 0x03, 0xEF,
  0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFD, 0xE0, 0x00, 0x00, 0xFE, 0x78, 0x00, 0x00, 0x7E, 0x1E,
  0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x83, 0xC0, 0x00, 0x1F, 0x80,
  0xF0, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x03, 0xF0,
  0x03, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x03, 0x80, 0x00, 0x07, 0xC0, 0x08, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x80, 0x00, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x01, 0xFE, 0x00, 0x00, 0x38, 0x7F, 0xFE, 0x00,
  0x03, 0xC7, 0xFF, 0xFC, 0x00, 0x1E, 0xFF, 0xFF, 0xF0, 0x00, 0xEF, 0x80,
  0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x02, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x20, 0x00, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x1F, 0xE0, 0x00, 0xF8, 0x7F, 0xFC, 0x00, 0x78, 0xFF,
  0xFF, 0x80, 0x7C, 0xFF, 0xFF, 0xE0, 0x3C, 0xF8, 0x07, 0xF8, 0x3E, 0xE0,
  0x00, 0x7E, 0x1E, 0xE0, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x07, 0xCF, 0xE0,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F,
  0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xEF, 0x0F,
  0xC0, 0x01, 0xEF, 0x03, 0xFC, 0x03, 0xE7, 0x81, 0xFF, 0xFF, 0xE7, 0xC0,
  0x3F, 0xFF, 0xE3, 0xC0, 0x0F, 0xFF, 0xC3, 0xE0, 0x00, 0xFF, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7F,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x7E, 0x0F, 0x0E, 0x00, 0x3F, 0xE1, 0xC3, 0xC0,
  0x1F, 0xFE, 0x38, 0x78, 0x07, 0xFF, 0xE7, 0x0F, 0x00, 0xFC, 0x0C, 0xE1,
  0xC0, 0x3E, 0x00, 0xFC, 0x78, 0x07, 0x80, 0x0F, 0x8F, 0x01, 0xE0, 0x01,
  0xF1, 0xE0, 0x3C, 0x00, 0x1C, 0x3C, 0x0F, 0x00, 0x03, 0x87, 0x01, 0xE0,
  0x00, 0xF1, 0xE0, 0x3C, 0x00, 0x1E, 0x3C, 0x07, 0x80, 0x03, 0xC7, 0x81,
  0xE0, 0x00, 0x78, 0xF0, 0x3C, 0x00, 0x0E, 0x1E, 0x07, 0x80, 0x01, 0xC3,
  0x80, 0xF0, 0x00, 0x78, 0xF0, 0x1E, 0x00, 0x0F, 0x1E, 0x03, 0xC0, 0x01,
  0xE3, 0xC0, 0x78, 0x00, 0x3C, 0x78, 0x0F, 0x00, 0x0F, 0x0F, 0x01, 0xE0,
  0x01, 0xE1, 0xE0, 0x3C, 0x00, 0x7C, 0x3C, 0x07, 0x80, 0x1F, 0x87, 0x80,
  0xF8, 0x06, 0xF0, 0xE0, 0x0F, 0x83, 0xDE, 0x1C, 0x01, 0xFF, 0xF3, 0x83,
  0x80, 0x1F, 0xFC, 0x70, 0x70, 0x01, 0xFF, 0x1E, 0x0F, 0x00, 0x1F, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x00, 0x01, 0xFC, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3C, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00,
  0x00, 0x7C, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x07, 0xF0, 0x07, 0x80, 0x01, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x03, 0xFF, 0xF8, 0x78, 0x00, 0x3F, 0xFF, 0x87, 0x80, 0x03, 0xFF, 0xF8,
  0xF8, 0x00, 0x7F, 0xFF, 0x8F, 0x80, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3B, 0xC0,
  0x1F, 0x80, 0x07, 0x3C, 0x00, 0xFE, 0x01, 0xF3, 0xC0, 0x0F, 0xFF, 0xFE,
  0x3C, 0x00, 0x3F, 0xFF, 0xC3, 0xC0, 0x01, 0xFF, 0xF0, 0x78, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x78,
  0x07, 0xE0, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x00,
  0x00, 0x3C, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x1F, 0x78, 0x00, 0x00, 0x03,
  0xCF, 0x9F, 0x00, 0x00, 0x00, 0xF7, 0xC3, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x03, 0xBC, 0x00, 0x03, 0xBC, 0x03, 0xDE, 0x00, 0x03, 0xDE,
  0x01, 0xEF, 0x00, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x01, 0xE7, 0x00, 0x79,
  0xE0, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x00, 0xE3, 0xC0, 0x1C, 0x38, 0x00,
  0xF1, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x07, 0x87, 0x80, 0x78, 0x38, 0x03, 0xC1, 0xC0, 0x38, 0x3C, 0x01, 0xE0,
  0xF0, 0x3C, 0x1E, 0x00, 0xE0, 0x78, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x1E,
  0x07, 0x80, 0x78, 0x0E, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x8E, 0x01, 0xC0,
  0x1E, 0x03, 0xCF, 0x01, 0xE0, 0x0F, 0x01, 0xEF, 0x00, 0xF0, 0x07, 0x00,
  0x77, 0x80, 0x78, 0x07, 0x80, 0x3F, 0x80, 0x3C, 0x03, 0xC0, 0x1F, 0x80,
  0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x0E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x3C, 0x00,
  0x20, 0x01, 0xE0, 0x1E, 0x00, 0x10, 0x00, 0xF0, 0x0F, 0x00, 0x10, 0x00,
  0x70, 0x07, 0x80, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x03, 0xF8,
  0x00, 0x00, 0x78, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x1F, 0xE0, 0x00, 0x07, 0x80, 0x79, 0xE0, 0x00, 0x0F, 0x00, 0xF3,
  0xC0, 0x00, 0x1E, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x03, 0xCF, 0x00, 0x00,
  0x78, 0x07, 0x8F, 0x00, 0x01, 0xE0, 0x0F, 0x1E, 0x00, 0x03, 0xC0, 0x3C,
  0x3C, 0x00, 0x07, 0x80, 0x78, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x07,
  0x81, 0xE0, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x78,
  0x07, 0x80, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x1E, 0x00,
  0x01, 0xE3, 0xC0, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x78, 0x00, 0x07, 0x9E,
  0x01, 0xE0, 0x00, 0x07, 0xBC, 0x03, 0xC0, 0x00, 0x0F, 0x78, 0x07, 0x80,
  0x00, 0x1E, 0xF0, 0x0F, 0x00, 0x00, 0x3F, 0xE0, 0x1E, 0x00, 0x00, 0x3F,
  0x80, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0x7C, 0x00,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7E, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x1E, 0x7C,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x20, 0x00,
  0x03, 0xE0, 0x03, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x60, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x3C,
  0x00, 0xFC, 0x00, 0x70, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x0F, 0x00, 0x7F,
  0x00, 0x3C, 0x07, 0x80, 0x3F, 0x80, 0x1E, 0x03, 0xC0, 0x1D, 0xC0, 0x0E,
  0x01, 0xC0, 0x1E, 0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0x70, 0x07, 0x80, 0x70,
  0x0F, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x9E, 0x01, 0xC0, 0x3C, 0x03, 0x8F,
  0x01, 0xE0, 0x1E, 0x03, 0xC7, 0x80, 0xF0, 0x0F, 0x01, 0xC3, 0xC0, 0x78,
  0x07, 0x81, 0xE0, 0xE0, 0x38, 0x03, 0xC0, 0xF0, 0x70, 0x3C, 0x01, 0xE0,
  0xF0, 0x38, 0x1E, 0x00, 0xF0, 0x78, 0x1C, 0x0F, 0x00, 0x78, 0x38, 0x0E,
  0x07, 0x00, 0x38, 0x3C, 0x07, 0x07, 0x80, 0x1C, 0x1C, 0x03, 0x83, 0xC0,
  0x0E, 0x1E, 0x01, 0xE1, 0xC0, 0x0F, 0x0F, 0x00, 0xF0, 0xE0, 0x07, 0x87,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x1E,
  0x38, 0x00, 0xF3, 0xC0, 0x0F, 0x1C, 0x00, 0x79, 0xE0, 0x03, 0x9E, 0x00,
  0x3C, 0xE0, 0x01, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0xE7, 0x00, 0x0E, 0x70,
  0x00, 0x73, 0x80, 0x07, 0x78, 0x00, 0x3B, 0xC0, 0x03, 0xBC, 0x00, 0x1D,
  0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0x98, 0x00, 0x00, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x30, 0xF0, 0xF8, 0x78, 0x78, 0x3C,
  0x3C, 0x1E, 0x1E, 0x0E, 0x0F, 0x07, 0x06, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0xF0, 0x03, 0xFF, 0xFC, 0x3C, 0x03, 0xFF, 0xFF, 0x8F,
  0x01, 0xFE, 0x01, 0xE3, 0xC0, 0xFE, 0x00, 0x1D, 0xE0, 0x3E, 0x00, 0x03,
  0x78, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xFC, 0x1E, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0D, 0xE0, 0x3E,
  0x00, 0x06, 0x78, 0x0F, 0xC0, 0x07, 0x9E, 0x01, 0xFC, 0x07, 0xC7, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xFF,
  0x00, 0x03, 0xC0, 0xFF, 0xF0, 0x00, 0xF0, 0xFF, 0xFE, 0x00, 0x78, 0x7F,
  0xFF, 0xC0, 0x1E, 0x3E, 0x03, 0xF8, 0x07, 0x9E, 0x00, 0x3F, 0x01, 0xEE,
  0x00, 0x07, 0xC0, 0x7B, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1E, 0x0F,
  0x40, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F,
  0x81, 0xFC, 0x00, 0x07, 0xE0, 0xF3, 0x80, 0x07, 0xF0, 0x3C, 0xF8, 0x07,
  0xF8, 0x0F, 0x1F, 0xFF, 0xFC, 0x03, 0xC3, 0xFF, 0xFE, 0x00, 0xF0, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x38, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0x1F, 0xFF, 0x03, 0xE0, 0x01, 0xFF,
  0xFE, 0x1E, 0x00, 0x3F, 0xFF, 0xF8, 0xF0, 0x03, 0xFC, 0x03, 0xE7, 0x80,
  0x3F, 0x80, 0x07, 0x3C, 0x01, 0xF0, 0x00, 0x0D, 0xE0, 0x1F, 0x00, 0x00,
  0x6F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x01, 0xF8, 0x07, 0x80, 0x00, 0x0B, 0xC0, 0x3E, 0x00, 0x00, 0xDE, 0x01,
  0xF0, 0x00, 0x0D, 0xF0, 0x07, 0xC0, 0x00, 0xEF, 0x00, 0x3F, 0x00, 0x1E,
  0x78, 0x00, 0xFE, 0x03, 0xE3, 0xC0, 0x03, 0xFF, 0xFE, 0x1E, 0x00, 0x0F,
  0xFF, 0xE0, 0xF0, 0x00, 0x3F, 0xFE, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x1F, 0xF0, 0xF0, 0x07, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x10, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xCF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x1F, 0x00, 0x1F, 0xFF, 0xE1, 0xE0, 0x07, 0xFF,
  0xFF, 0x1E, 0x00, 0xFF, 0x00, 0xF9, 0xE0, 0x1F, 0xC0, 0x03, 0x9E, 0x01,
  0xF0, 0x00, 0x0D, 0xE0, 0x3E, 0x00, 0x00, 0xDE, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0D, 0xE0, 0x3E,
  0x00, 0x01, 0xDE, 0x01, 0xF0, 0x00, 0x3B, 0xC0, 0x1F, 0x80, 0x07, 0x3C,
  0x00, 0xFE, 0x03, 0xE3, 0xC0, 0x07, 0xFF, 0xFC, 0x3C, 0x00, 0x3F, 0xFF,
  0x83, 0xC0, 0x01, 0xFF, 0xF0, 0x3C, 0x00, 0x07, 0xFC, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0x80, 0x03,
  0xC0, 0xFF, 0xF0, 0x03, 0xC3, 0xFF, 0xF8, 0x03, 0xC7, 0xFF, 0xFC, 0x03,
  0xCF, 0x80, 0xFC, 0x07, 0xCE, 0x00, 0x7E, 0x07, 0x9C, 0x00, 0x3E, 0x07,
  0xB8, 0x00, 0x1E, 0x07, 0xB0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x3C, 0x01, 0xF8, 0x00,
  0x38, 0x03, 0xF0, 0x00, 0x78, 0x07, 0xE0, 0x00, 0x78, 0x1F, 0x80, 0x00,
  0x78, 0x3F, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x00, 0x79, 0xF8, 0x00, 0x00,
  0xF3, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0xFF, 0xF0, 0x00,
  0x3C, 0x3F, 0xFF, 0xC0, 0x03, 0xC7, 0xFF, 0xFC, 0x00, 0x7C, 0xFC, 0x0F,
  0xE0, 0x07, 0x9E, 0x00, 0x3E, 0x00, 0x79, 0xC0, 0x01, 0xF0, 0x07, 0xB8,
  0x00, 0x0F, 0x00, 0x7B, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0x00,
  0xFC, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xF0, 0x01,
  0xE0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x1F, 0xE0,
  0x00, 0x1E, 0x1F, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x43,
  0xC0, 0x3C, 0x00, 0x06, 0x3C, 0x03, 0xC0, 0x01, 0xF7, 0x80, 0x1E, 0x00,
  0x3F, 0x78, 0x01, 0xF0, 0x07, 0xE7, 0x80, 0x0F, 0x00, 0xFC, 0x78, 0x00,
  0xF8, 0x1F, 0x87, 0x80, 0x07, 0x83, 0xE0, 0x78, 0x00, 0x7C, 0x7C, 0x0F,
  0x00, 0x03, 0xCF, 0x80, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0x00, 0x01, 0xFE,
  0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x10, 0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x01,
  0xE0, 0x01, 0xF8, 0x0F, 0x00, 0x3F, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0x80,
  0x3F, 0x00, 0x3C, 0x03, 0xF0, 0x01, 0xE0, 0x7E, 0x00, 0x0F, 0x07, 0xE0,
  0x00, 0xF0, 0x7E, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0x3C, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0x8F, 0xF8, 0x3F, 0xF0,
  0x0E, 0x3F, 0xF0, 0xFF, 0xF0, 0x3C, 0xFF, 0xF3, 0xFF, 0xE0, 0x7B, 0xC3,
  0xE7, 0x87, 0xC0, 0xF6, 0x03, 0xDC, 0x07, 0xC1, 0xF8, 0x07, 0xB0, 0x07,
  0x83, 0xE0, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x00,
  0xE0, 0xF0, 0x01, 0xE0, 0x01, 0xC1, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0x80,
  0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0x03, 0xC1, 0xC0, 0x03, 0xC0, 0x07, 0x87, 0x80, 0x07, 0x80,
  0x0F, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0xE0, 0x01, 0xE0,
  0x03, 0xC3, 0xC0, 0x03, 0xC0, 0x07, 0x87, 0x80, 0x07, 0x00, 0x0F, 0x0F,
  0x00, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x70, 0x00, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0x03, 0xC3,
  0xC0, 0x03, 0x80, 0x07, 0x87, 0x80, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xC0, 0xFF, 0xF0, 0x03, 0xC3, 0xFF, 0xF8, 0x03, 0xC7, 0xFF, 0xFC,
  0x03, 0xCF, 0x80, 0xFC, 0x07, 0xCE, 0x00, 0x7E, 0x07, 0x9C, 0x00, 0x3E,
  0x07, 0xB8, 0x00, 0x1E, 0x07, 0xB0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x3D, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xF0,
  0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xC0, 0xFF, 0xF0, 0x00, 0x1E, 0x1F, 0xFF, 0xC0, 0x01,
  0xE1, 0xFF, 0xFF, 0x00, 0x0F, 0x1F, 0x01, 0xFC, 0x00, 0x79, 0xE0, 0x03,
  0xF0, 0x03, 0xDC, 0x00, 0x0F, 0x80, 0x1E, 0xC0, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x0F, 0x40, 0x00, 0x07, 0x80, 0x7E, 0x00, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0xF3, 0x80, 0x07, 0xF0, 0x07, 0x9F,
  0x00, 0xFF, 0x00, 0x3C, 0x7F, 0xFF, 0xF0, 0x01, 0xE1, 0xFF, 0xFF, 0x00,
  0x0F, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7C, 0x00, 0xFF, 0xFF, 0x0F, 0x00,
  0x7F, 0xFF, 0xF1, 0xE0, 0x1F, 0xE0, 0x1F, 0x3C, 0x07, 0xF0, 0x00, 0xE7,
  0x80, 0xF8, 0x00, 0x06, 0xF0, 0x3E, 0x00, 0x00, 0xDE, 0x0F, 0x80, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0x6F, 0x03, 0xE0, 0x00, 0x1B, 0xC0, 0x3E, 0x00, 0x07, 0x78, 0x07, 0xE0,
  0x03, 0xCF, 0x00, 0x7F, 0x01, 0xF1, 0xE0, 0x07, 0xFF, 0xFC, 0x3C, 0x00,
  0x7F, 0xFF, 0x07, 0x80, 0x07, 0xFF, 0xC1, 0xE0, 0x00, 0x3F, 0xC0, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFB, 0xFF, 0xFC, 0x3F, 0xFF, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE0, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0x7C, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x0C, 0x07, 0xC0, 0x00, 0x02, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x08, 0x00, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x7C,
  0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x07,
  0x80, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xF8, 0x01, 0xE0, 0x01, 0xFA, 0x00,
  0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x78, 0x07, 0xF0, 0x00,
  0x3C, 0x0F, 0xE0, 0x00, 0x1E, 0x0F, 0xE0, 0x00, 0x0F, 0x1F, 0xC0, 0x00,
  0x07, 0x9F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x0D, 0xE0, 0x78, 0x00, 0x0D,
  0xE0, 0x7C, 0x00, 0x39, 0xE0, 0x7E, 0x00, 0x79, 0xE0, 0x3F, 0x81, 0xF3,
  0xE0, 0x3F, 0xFF, 0xE3, 0xC0, 0x1F, 0xFF, 0xC3, 0xC0, 0x07, 0xFF, 0x03,
  0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x1F, 0xFE, 0x00,
  0x03, 0xC7, 0xFF, 0x80, 0x00, 0xFB, 0xFF, 0xE0, 0x00, 0x1E, 0xFF, 0xF8,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x1C, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xF0,
  0x00, 0x78, 0x01, 0xF8, 0x00, 0x1C, 0x01, 0xFC, 0x00, 0x0F, 0x01, 0xFE,
  0x00, 0x03, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x60, 0x78, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x07, 0x80,
  0x3C, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x0F, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x01, 0xC3, 0xC0, 0x07, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x00, 0x1E, 0x38, 0x00, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0x80, 0x07, 0x9E,
  0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x00,
  0x0F, 0x3C, 0x00, 0x78, 0x00, 0x79, 0xC0, 0x03, 0x80, 0x03, 0xCE, 0x00,
  0x3C, 0x00, 0x1C, 0xF0, 0x01, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x00, 0x0F,
  0x3C, 0x00, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xC0, 0x03, 0xCE, 0x00, 0x1C,
  0x00, 0x1C, 0x70, 0x01, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x00, 0x0F, 0x3C,
  0x00, 0x78, 0x00, 0xF9, 0xE0, 0x03, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x00,
  0x3C, 0x78, 0x01, 0xF0, 0x03, 0xC3, 0xC0, 0x1B, 0x80, 0x3E, 0x1E, 0x01,
  0xDC, 0x01, 0xE0, 0xF0, 0x1C, 0xF0, 0x1F, 0x07, 0xE1, 0xE7, 0xC3, 0xF0,
  0x1F, 0xFE, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xE7, 0x83, 0xE1, 0xF8, 0x1F, 0xC3, 0xC3,
  0xC0, 0x3C, 0x1F, 0x80, 0xE1, 0xC0, 0x1E, 0x3F, 0x00, 0x79, 0xC0, 0x0F,
  0x3F, 0x00, 0x3C, 0xE0, 0x03, 0x8E, 0x00, 0x1E, 0x60, 0x01, 0xC4, 0x00,
  0x07, 0x60, 0x00, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0xF0, 0x00, 0x01, 0xD8,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x00, 0x1E, 0x00, 0x1B, 0xC0, 0x00, 0x0F, 0x00, 0x0D, 0xE0, 0x00, 0xC7,
  0x80, 0x0E, 0x70, 0x00, 0xE3, 0xC0, 0x07, 0x38, 0x01, 0xF9, 0xE0, 0x07,
  0x1E, 0x03, 0xF0, 0xF0, 0x07, 0x8F, 0x03, 0xF0, 0x3C, 0x07, 0x87, 0x87,
  0xE0, 0x1F, 0x07, 0x83, 0xE7, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x07, 0x80, 0x00,
  0x7E, 0x00, 0x78, 0x00, 0x0D, 0xE0, 0x07, 0xC0, 0x01, 0x9E, 0x00, 0x7E,
  0x00, 0x79, 0xE0, 0x03, 0xF8, 0x1F, 0x1E, 0x00, 0x1F, 0xFF, 0xE3, 0xE0,
  0x01, 0xFF, 0xFC, 0x3C, 0x00, 0x07, 0xFF, 0x83, 0xC0, 0x00, 0x1F, 0xC0,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x03,
  0xE0, 0x07, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0x01, 0xFF, 0xFF, 0x00, 0xF0, 0x3F,
  0xFF, 0xFC, 0x1E, 0x07, 0xE0, 0x3F, 0xF1, 0xE0, 0x78, 0x00, 0x3F, 0xDE,
  0x0F, 0x00, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0xE0, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0xE0,
  0x00, 0x0F, 0x80, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x40, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x00, 0xE0, 0x07, 0xC0, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x00, 0x0F, 0x07, 0xFF, 0x00, 0x00, 0xF0, 0x7F, 0xFF, 0x80,
  0x07, 0x0F, 0xFF, 0xFF, 0x80, 0x78, 0xF0, 0x7F, 0xFF, 0xC7, 0x8F, 0x00,
  0x7F, 0xFF, 0xF8, 0xF0, 0x00, 0x7F, 0xFF, 0x0F, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x60, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0xFF, 0xE0, 0x00, 0x1C, 0x0F,
  0xFF, 0x80, 0x01, 0xE0, 0xF8, 0x7C, 0x00, 0x0F, 0x0F, 0x81, 0xF0, 0x00,
  0xF0, 0x78, 0x07, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x00, 0x78, 0x38, 0x00,
  0xF8, 0x03, 0xC3, 0xC0, 0x03, 0xE0, 0x3C, 0x1C, 0x00, 0x0F, 0x87, 0xC1,
  0xE0, 0x00, 0x3F, 0xFE, 0x0F, 0x00, 0x01, 0xFF, 0xE0, 0x70, 0x00, 0x03,
  0xFE, 0x01, 0x80, 0x00, 0x0F, 0xC0, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 14, 51, 43, 15, -50 },
  { 91, 18, 19, 43, 17, -53 },
  { 134, 43, 50, 43, 1, -50 },
  { 403, 40, 66, 43, 2, -58 },
  { 733, 48, 52, 43, -1, -51 },
  { 1045, 42, 52, 43, 0, -51 },
  { 1318, 7, 19, 43, 22, -53 },
  { 1335, 25, 65, 43, 16, -55 },
  { 1539, 25, 65, 43, 4, -55 },
  { 1743, 37, 36, 43, 4, -39 },
  { 1910, 34, 36, 43, 5, -40 },
  { 2063, 13, 19, 43, 11, -8 },
  { 2094, 20, 4, 43, 12, -24 },
  { 2104, 8, 8, 43, 15, -7 },
  { 2112, 40, 65, 43, 2, -55 },
  { 2437, 36, 52, 43, 5, -51 },
  { 2671, 34, 50, 43, 3, -50 },
  { 2884, 36, 51, 43, 3, -51 },
  { 3114, 37, 52, 43, 2, -51 },
  { 3355, 37, 50, 43, 2, -50 },
  { 3587, 37, 51, 43, 4, -50 },
  { 3823, 33, 51, 43, 5, -50 },
  { 4034, 35, 50, 43, 8, -50 },
  { 4253, 38, 52, 43, 3, -51 },
  { 4500, 33, 51, 43, 7, -51 },
  { 4711, 13, 39, 43, 15, -38 },
  { 4775, 17, 49, 43, 11, -38 },
  { 4880, 35, 40, 43, 6, -42 },
  { 5055, 37, 18, 43, 4, -31 },
  { 5139, 34, 40, 43, 4, -42 },
  { 5309, 30, 52, 43, 10, -51 },
  { 5504, 35, 59, 43, 5, -51 },
  { 5763, 37, 50, 43, 0, -50 },
  { 5995, 35, 50, 43, 4, -50 },
  { 6214, 35, 52, 43, 6, -51 },
  { 6442, 36, 50, 43, 4, -50 },
  { 6667, 38, 50, 43, 4, -50 },
  { 6905, 39, 50, 43, 4, -50 },
  { 7149, 36, 52, 43, 5, -51 },
  { 7383, 39, 50, 43, 3, -50 },
  { 7627, 39, 50, 43, 3, -50 },
  { 7871, 34, 51, 43, 5, -50 },
  { 8088, 42, 50, 43, 4, -50 },
  { 8351, 30, 50, 43, 6, -50 },
  { 8539, 41, 50, 43, 2, -50 },
  { 8796, 39, 50, 43, 3, -50 },
  { 9040, 36, 52, 43, 5, -51 },
  { 9274, 38, 50, 43, 4, -50 },
  { 9512, 36, 64, 43, 5, -51 },
  { 9800, 38, 50, 43, 4, -50 },
  { 10038, 39, 52, 43, 2, -51 },
  { 10292, 39, 50, 43, 7, -50 },
  { 10536, 36, 51, 43, 6, -50 },
  { 10766, 37, 50, 43, 8, -50 },
  { 10998, 41, 50, 43, 4, -50 },
  { 11255, 47, 50, 43, -1, -50 },
  { 11549, 40, 50, 43, 7, -50 },
  { 11799, 44, 50, 43, 0, -50 },
  { 12074, 29, 65, 43, 13, -55 },
  { 12310, 17, 65, 43, 14, -55 },
  { 12449, 30, 65, 43, 1, -55 },
  { 12693, 35, 28, 43, 5, -50 },
  { 12816, 35, 4, 43, 0, 7 },
  { 12834, 8, 13, 43, 17, -55 },
  { 12847, 34, 39, 43, 4, -38 },
  { 13013, 34, 54, 43, 5, -53 },
  { 13243, 31, 39, 43, 6, -38 },
  { 13395, 37, 54, 43, 4, -53 },
  { 13645, 32, 39, 43, 6, -38 },
  { 13801, 46, 68, 43, -1, -53 },
  { 14192, 36, 53, 43, 3, -38 },
  { 14431, 32, 53, 43, 5, -53 },
  { 14643, 32, 55, 43, 6, -54 },
  { 14863, 32, 69, 43, 6, -54 },
  { 15139, 36, 54, 43, 5, -53 },
  { 15382, 29, 54, 43, 8, -53 },
  { 15578, 39, 38, 43, 2, -38 },
  { 15764, 32, 38, 43, 5, -38 },
  { 15916, 33, 39, 43, 5, -38 },
  { 16077, 37, 52, 43, 2, -38 },
  { 16318, 35, 52, 43, 4, -38 },
  { 16546, 35, 37, 43, 8, -37 },
  { 16708, 34, 39, 43, 4, -38 },
  { 16874, 33, 51, 43, 6, -50 },
  { 17085, 32, 38, 43, 6, -37 },
  { 17237, 34, 38, 43, 5, -38 },
  { 17399, 37, 38, 43, 4, -37 },
  { 17575, 41, 39, 43, 1, -38 },
  { 17775, 36, 52, 43, 2, -37 },
  { 18009, 36, 39, 43, 4, -38 },
  { 18185, 33, 65, 43, 8, -55 },
  { 18454, 14, 65, 43, 15, -55 },
  { 18568, 33, 65, 43, 3, -55 },
  { 18837, 37, 15, 43, 4, -29 },
};

const GFXfont IBMPlexMono_LightItalic72pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic72pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic72pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _IBMPLEXMONO_LIGHTITALIC72PT7B_H_
