#ifndef _IBMPLEXMONO_LIGHTITALIC47PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x87, 0xC3, 0xE1,
  0xF0, 0xF0, 0x00, 0x38, 0x73, 0x07, 0x70, 0x67, 0x06, 0x70, 0x67, 0x0E,
  0x60, 0xE6, 0x0E, 0xE0, 0xCE, 0x0C, 0xE0, 0xCE, 0x1C, 0xC1, 0xC0, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x70, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x0E, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x38,
  0x18, 0x01, 0xFF, 0x83, 0xFF, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0x03, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0xFF, 0xC1, 0xFF,
  0x8F, 0xF8, 0x1F, 0xF0, 0x03, 0x81, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x70, 0x30, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xC6, 0x7C, 0x03, 0xC1, 0x87,
  0x81, 0xE0, 0x60, 0x70, 0x70, 0x38, 0x08, 0x18, 0x0C, 0x00, 0x0E, 0x03,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x0E,
  0x03, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x78, 0x60, 0x00, 0x0F, 0x18, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x31,
  0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00,
  0x30, 0x18, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x01, 0x80, 0x60,
  0x00, 0x60, 0x38, 0x20, 0x18, 0x0E, 0x18, 0x06, 0x03, 0x8F, 0x01, 0x81,
  0xC0, 0xF0, 0xE0, 0xE0, 0x1F, 0x31, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x00, 0xFF,
  0x00, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x03, 0x81, 0xC0, 0x18, 0x07, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x70, 0x06, 0x00, 0xC0, 0xE0, 0x0E, 0x00,
  0xC0, 0xC0, 0x0E, 0x00, 0xC1, 0xC0, 0x0E, 0x01, 0xC3, 0x80, 0x0E, 0x01,
  0x83, 0x00, 0x0E, 0x01, 0x86, 0x00, 0x06, 0x03, 0x0E, 0x00, 0x07, 0x07,
  0x1C, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x38,
  0xE1, 0xC0, 0x00, 0x71, 0xC0, 0x60, 0x00, 0xE1, 0x80, 0x60, 0x00, 0xC3,
  0x80, 0x60, 0x01, 0x83, 0x00, 0x60, 0x03, 0x83, 0x00, 0x60, 0x07, 0x03,
  0x00, 0x60, 0x06, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x03, 0x01, 0xC0, 0x70, 0x01,
  0xC3, 0x80, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1C,
  0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0C,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x70, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x07, 0xFB, 0xC0, 0x00, 0xE1, 0xE0,
  0x00, 0x18, 0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x60, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x7E, 0x00, 0x3E, 0x06,
  0x60, 0x02, 0x60, 0xC7, 0x00, 0x67, 0x1C, 0x70, 0x04, 0x31, 0x83, 0xC1,
  0xC3, 0xB8, 0x1F, 0xF8, 0x1F, 0x00, 0x7E, 0x00, 0xE0, 0x77, 0x77, 0x66,
  0xEE, 0xEE, 0xCC, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0xF0, 0x18, 0x0E, 0xFC, 0x18, 0x7F, 0x3F, 0xBB,
  0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xCC, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x1C, 0x03, 0x80, 0x3C, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x70, 0x00,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x87, 0x87, 0x83, 0xC1, 0xC1, 0xE0,
  0xE0, 0x70, 0x70, 0x38, 0x38, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x00,
  0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x37,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0xDC, 0x00, 0x03, 0xB8, 0x1E, 0x07, 0x70,
  0x3C, 0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x87, 0x00, 0x0E,
  0x0E, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x0F, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xDC, 0x00,
  0x1E, 0x70, 0x00, 0xF1, 0x80, 0x07, 0x0E, 0x00, 0x78, 0x38, 0x03, 0xC0,
  0xE0, 0x1E, 0x03, 0x80, 0x20, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x7C, 0x03, 0x80, 0x1C, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x04, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0x81, 0xF0, 0x1C, 0x00,
  0xE0, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xCC, 0x00, 0x07,
  0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x3E, 0x03, 0xE0, 0x1F, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x30, 0x00, 0x07, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x03,
  0x80, 0x60, 0x03, 0x80, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x03,
  0xC0, 0x0E, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x81,
  0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x71, 0xFC, 0x00, 0x33, 0xFF, 0x80, 0x1B, 0x01,
  0xE0, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x03, 0x87, 0x80, 0x03, 0x81, 0xE0, 0x03, 0x80,
  0x7C, 0x07, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0xFC,
  0x01, 0x9F, 0xFC, 0x0E, 0xE0, 0x7C, 0x36, 0x00, 0x71, 0xF0, 0x00, 0xE7,
  0x80, 0x03, 0x9C, 0x00, 0x07, 0x70, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0x98, 0x00, 0x1C, 0x60, 0x00, 0x71, 0xC0, 0x03, 0x83, 0x80, 0x1C, 0x07,
  0x81, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x8C, 0x00,
  0x07, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x78, 0xE0, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xFC, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x07, 0x07, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x07, 0x00,
  0x1C, 0x03, 0xC0, 0x70, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0x80,
  0xF0, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x70, 0x00,
  0x38, 0x38, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x78, 0x0F, 0x03, 0x80, 0x1C,
  0x1C, 0x00, 0x38, 0xE0, 0x00, 0x63, 0x80, 0x01, 0xDC, 0x00, 0x07, 0x70,
  0x00, 0x1D, 0xC0, 0x00, 0x76, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3D, 0x80, 0x00, 0xF7, 0x00, 0x07, 0x9C, 0x00, 0x1E, 0x38, 0x01, 0xB8,
  0xF8, 0x1D, 0xC0, 0xFF, 0xE7, 0x00, 0xFC, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x0F, 0xC7, 0xC3,
  0xE1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0,
  0x00, 0x01, 0xE0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x1F,
  0x03, 0xC3, 0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x7A,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07,
  0x81, 0xE0, 0x1C, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x86, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60, 0x1F,
  0x39, 0xC0, 0xFF, 0x73, 0x83, 0xC3, 0xE6, 0x0E, 0x03, 0x8C, 0x1C, 0x07,
  0x38, 0x30, 0x06, 0x70, 0xE0, 0x1C, 0xE1, 0x80, 0x39, 0x83, 0x00, 0x73,
  0x06, 0x00, 0xC6, 0x1C, 0x01, 0x8C, 0x38, 0x03, 0x38, 0x70, 0x0E, 0x70,
  0xE0, 0x1C, 0xE1, 0xC0, 0x79, 0xC1, 0x80, 0xE3, 0x83, 0x86, 0xC7, 0x03,
  0xF9, 0x8E, 0x03, 0xE7, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x30, 0x00, 0x07,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x18, 0x38, 0x00, 0x38, 0x18, 0x00, 0x30, 0x18, 0x00, 0x70,
  0x18, 0x00, 0x60, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x0C, 0x03, 0x80, 0x0C, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x07, 0x38, 0x00, 0x07, 0x30, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x1C, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x38, 0x00,
  0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x70, 0x70, 0x01, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x01,
  0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x83, 0x80, 0x00, 0xC7, 0x00, 0x03, 0x87, 0x00, 0x0E,
  0x0E, 0x00, 0x3C, 0x0E, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x0F, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1C, 0x03, 0xC0,
  0x30, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x87,
  0x00, 0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xE0,
  0x00, 0x31, 0xC0, 0x00, 0x63, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8C, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0x80, 0x01, 0xC6, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x78, 0x38, 0x03, 0xE0, 0x7F, 0xFF, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0,
  0x0F, 0x83, 0xE0, 0x3C, 0x01, 0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x87,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x7F,
  0xE6, 0x00, 0xFF, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x38, 0xC0, 0x00, 0x71, 0x80, 0x00, 0xE3, 0x80, 0x01, 0xC7,
  0x00, 0x07, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x2C, 0x1E, 0x00, 0xB8, 0x1E,
  0x06, 0x70, 0x1F, 0xF8, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x81, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x1C,
  0x00, 0x06, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x06, 0x00, 0x03, 0x83, 0x80, 0x00, 0xC0, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x03,
  0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x1C, 0x01,
  0xC0, 0x1E, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70,
  0x07, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x60,
  0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x1C,
  0x7C, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x1D, 0xEE, 0x00, 0x01, 0xFC, 0xE0,
  0x00, 0x1F, 0x87, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x3E, 0x03, 0x80, 0x03,
  0xC0, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x06, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x83,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x6C, 0x0F, 0xC0, 0x1D, 0x81, 0x98, 0x03,
  0x70, 0x33, 0x00, 0xEE, 0x06, 0x70, 0x39, 0xC1, 0xCE, 0x06, 0x38, 0x38,
  0xC1, 0xC6, 0x07, 0x18, 0x30, 0xC0, 0xC3, 0x8E, 0x38, 0x18, 0x33, 0x87,
  0x03, 0x06, 0x60, 0xE0, 0xE0, 0xDC, 0x1C, 0x1C, 0x1F, 0x03, 0x03, 0x81,
  0xE0, 0x60, 0x60, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x81, 0x80, 0xC0, 0x70,
  0x70, 0x10, 0x0E, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x0E, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x01, 0xC1, 0xF0, 0x00, 0x60,
  0x7C, 0x00, 0x38, 0x1F, 0x80, 0x0E, 0x06, 0xE0, 0x03, 0x81, 0xB8, 0x00,
  0xE0, 0xE6, 0x00, 0x30, 0x39, 0xC0, 0x0C, 0x0E, 0x70, 0x07, 0x03, 0x8C,
  0x01, 0xC0, 0xC3, 0x00, 0x70, 0x30, 0xE0, 0x1C, 0x1C, 0x38, 0x06, 0x07,
  0x06, 0x01, 0x81, 0xC1, 0xC0, 0x60, 0x70, 0x70, 0x38, 0x18, 0x0C, 0x0E,
  0x06, 0x03, 0x03, 0x83, 0x80, 0xE0, 0xC0, 0xE0, 0x38, 0x30, 0x38, 0x06,
  0x0C, 0x0E, 0x01, 0x87, 0x03, 0x00, 0x71, 0xC0, 0xC0, 0x1C, 0x70, 0x70,
  0x03, 0x18, 0x1C, 0x00, 0xE6, 0x07, 0x00, 0x39, 0x81, 0xC0, 0x06, 0xE0,
  0x60, 0x01, 0xB8, 0x18, 0x00, 0x7E, 0x06, 0x00, 0x1F, 0x03, 0x80, 0x03,
  0xC0, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07,
  0x81, 0xE0, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xE0, 0x00,
  0x19, 0xC0, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xDC, 0x00, 0x03,
  0xB8, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC3, 0x00,
  0x03, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x0F, 0x07,
  0x80, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x06, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x00, 0xE0, 0x70, 0x01,
  0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x06,
  0x70, 0x00, 0x0C, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x37, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xDC, 0x00,
  0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x38,
  0x0E, 0x00, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x8E, 0x00,
  0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x06, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x38, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x70,
  0x03, 0x80, 0x60, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x1E,
  0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x80, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x3C, 0x00, 0x07,
  0x03, 0xC0, 0x03, 0x80, 0x7C, 0x07, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00,
  0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x60, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0xE0, 0x01,
  0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x78, 0x0F, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x07, 0xB0, 0x00, 0x03, 0x98, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x70, 0x30, 0x00, 0x38, 0x18, 0x00, 0x38, 0x0E,
  0x00, 0x1C, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x07, 0x00, 0x18, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x07, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x60,
  0x00, 0x30, 0x70, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x06, 0x03, 0xC0, 0x60, 0xC0, 0x78,
  0x1C, 0x18, 0x1F, 0x03, 0x87, 0x03, 0xE0, 0x60, 0xE0, 0x6C, 0x0C, 0x1C,
  0x1D, 0x83, 0x83, 0x83, 0x30, 0x70, 0x70, 0xE6, 0x0C, 0x0C, 0x18, 0xC1,
  0x81, 0x83, 0x18, 0x70, 0x30, 0xE3, 0x0E, 0x06, 0x18, 0x61, 0x80, 0xC7,
  0x0E, 0x30, 0x18, 0xC1, 0xCE, 0x03, 0x38, 0x39, 0xC0, 0xE6, 0x07, 0x30,
  0x1C, 0xC0, 0x66, 0x03, 0xB8, 0x0D, 0xC0, 0x76, 0x01, 0xB8, 0x0F, 0xC0,
  0x36, 0x01, 0xB0, 0x06, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0,
  0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x00, 0x60, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xC0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x38,
  0x00, 0x60, 0x30, 0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xC0,
  0x38, 0x01, 0xC0, 0xE0, 0x01, 0x83, 0x80, 0x03, 0x8E, 0x00, 0x03, 0x1C,
  0x00, 0x07, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x23, 0x86, 0x1C, 0x30, 0xC1, 0x86, 0x0C,
  0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x70, 0x78, 0x19, 0xC3, 0x80, 0x37, 0x1C,
  0x00, 0x58, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8C, 0x00, 0x0E, 0x70, 0x00,
  0x39, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xE0, 0x00, 0x73,
  0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x63, 0x80,
  0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xE1, 0xC0, 0x0B,
  0x87, 0x00, 0x4C, 0x0F, 0x07, 0x3F, 0x1F, 0xF0, 0xFC, 0x3F, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE1, 0xF8, 0x03, 0x8F, 0xF8, 0x0C, 0xE0, 0xF0,
  0x36, 0x00, 0xE1, 0xD0, 0x01, 0x87, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x70,
  0x00, 0x31, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x77,
  0x00, 0x01, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00,
  0x07, 0x1A, 0x00, 0x38, 0xEC, 0x01, 0xC3, 0x98, 0x1E, 0x0E, 0x3F, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0x81, 0xC0, 0xE0,
  0x0E, 0x1C, 0x00, 0x73, 0x80, 0x07, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x07,
  0x83, 0xC0, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0xFE, 0x0C, 0x03, 0xFF, 0x9C, 0x07, 0x81, 0xDC, 0x0E,
  0x00, 0x5C, 0x1C, 0x00, 0x3C, 0x18, 0x00, 0x38, 0x38, 0x00, 0x38, 0x30,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x60, 0x00, 0x38, 0xE0,
  0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0,
  0x01, 0xE0, 0xE0, 0x01, 0xE0, 0x70, 0x02, 0xE0, 0x70, 0x06, 0xE0, 0x3C,
  0x1C, 0xC0, 0x1F, 0xF8, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xFC, 0x07, 0x81, 0xE0, 0xE0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x03, 0x30,
  0x00, 0x37, 0x00, 0x03, 0x70, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xEE,
  0x00, 0x7C, 0xE0, 0x7F, 0x0F, 0xFF, 0xC0, 0xFF, 0x80, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00,
  0xE7, 0x00, 0x1C, 0x78, 0x03, 0x83, 0xC0, 0xF0, 0x1F, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0x1C, 0x0F, 0x03, 0xB8, 0x38, 0x01, 0x70, 0xE0, 0x01, 0xE3, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE1,
  0xC0, 0x01, 0xC3, 0x80, 0x07, 0x83, 0x80, 0x1F, 0x07, 0x00, 0x6E, 0x07,
  0x83, 0x9C, 0x07, 0xFE, 0x30, 0x03, 0xF0, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x10, 0x00,
  0xE0, 0x70, 0x03, 0xC0, 0xF8, 0x1F, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x87, 0xE0, 0x1C, 0x7F, 0xC0, 0xE6, 0x0F, 0x06,
  0x40, 0x38, 0x34, 0x00, 0xE1, 0xE0, 0x07, 0x1E, 0x00, 0x38, 0xE0, 0x01,
  0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x18, 0xE0,
  0x00, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x1C,
  0x60, 0x00, 0xE7, 0x00, 0x06, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8C, 0x00,
  0x1C, 0x60, 0x00, 0xE3, 0x00, 0x07, 0x38, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0xE0, 0x1E, 0x07, 0x01, 0xC0, 0x38,
  0x38, 0x01, 0xC3, 0x80, 0x0C, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x70, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x08, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x80, 0x18, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x03,
  0x83, 0x00, 0x0E, 0x18, 0x00, 0x38, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x0F,
  0xC0, 0x0E, 0x3F, 0xE0, 0x0C, 0x60, 0xF0, 0x0C, 0x80, 0x38, 0x0D, 0x00,
  0x38, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x18, 0x00, 0x70, 0x18, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x1E, 0x00, 0x30, 0xF0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0x60,
  0x00, 0x70, 0x70, 0x02, 0x70, 0x30, 0x07, 0x70, 0x38, 0x0E, 0x70, 0x18,
  0x1C, 0x60, 0x1C, 0x38, 0x60, 0x0C, 0x70, 0xE0, 0x0E, 0xE0, 0xE0, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x08, 0x1C, 0x03, 0x83, 0x00, 0xE0, 0xE0,
  0x38, 0x1C, 0x0E, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x0C, 0x70, 0x01, 0x9C,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x1F, 0x03, 0xBF, 0x8F,
  0xE0, 0xD8, 0xE6, 0x38, 0x34, 0x1B, 0x07, 0x0E, 0x06, 0x81, 0xC7, 0x01,
  0xC0, 0x71, 0xC0, 0x70, 0x1C, 0x70, 0x18, 0x06, 0x18, 0x06, 0x01, 0x86,
  0x01, 0x80, 0x61, 0x80, 0xE0, 0x38, 0xE0, 0x38, 0x0E, 0x38, 0x0E, 0x03,
  0x8C, 0x03, 0x00, 0xC3, 0x00, 0xC0, 0x30, 0xC0, 0x30, 0x0C, 0x30, 0x1C,
  0x07, 0x1C, 0x07, 0x01, 0xC7, 0x01, 0xC0, 0x71, 0x80, 0x60, 0x18, 0x60,
  0x18, 0x06, 0x18, 0x06, 0x01, 0x86, 0x03, 0x80, 0xE3, 0x80, 0xE0, 0x38,
  0xE0, 0x38, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x71, 0xFF, 0x03, 0x98, 0x3C,
  0x1D, 0x00, 0xE0, 0xD0, 0x03, 0x87, 0x80, 0x1C, 0x78, 0x00, 0xE3, 0x80,
  0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x63,
  0x80, 0x03, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC6, 0x00, 0x0E, 0x30, 0x00,
  0x71, 0x80, 0x03, 0x9C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x30,
  0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x1C, 0xE0, 0x00, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x00, 0x3C, 0x1E, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x38,
  0x70, 0x00, 0x63, 0x80, 0x01, 0x8E, 0x00, 0x07, 0x30, 0x00, 0x1D, 0xC0,
  0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x60, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xE6,
  0x00, 0x03, 0x18, 0x00, 0x1C, 0x70, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x80,
  0x1C, 0x07, 0x81, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x03, 0x8F, 0xF8, 0x03, 0x38, 0x3C, 0x03, 0x60, 0x0E, 0x07, 0x40,
  0x06, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07, 0x07, 0x00, 0x03, 0x07, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00,
  0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1A, 0x00, 0x38, 0x3B, 0x00, 0x70, 0x39, 0x81, 0xE0, 0x38, 0xFF,
  0xC0, 0x38, 0x3F, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x70, 0x78, 0x1D,
  0xC3, 0x80, 0x17, 0x1C, 0x00, 0x3C, 0x60, 0x00, 0xE3, 0x80, 0x03, 0x8C,
  0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0xB8, 0x00,
  0x0C, 0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0xE0, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0,
  0x01, 0xE1, 0xC0, 0x0B, 0x87, 0x00, 0x6E, 0x0F, 0x07, 0x30, 0x1F, 0xF8,
  0xC0, 0x1F, 0x87, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x7F, 0xE1, 0xFF, 0xFF, 0x8F, 0xFC, 0x03, 0x38, 0x00, 0x0E,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x78, 0x0F, 0x83, 0x80, 0x0F, 0x1C, 0x00,
  0x18, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x73, 0x80, 0x01, 0xCF,
  0x00, 0x0E, 0x0F, 0x00, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x20, 0x1C, 0x00, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0xF0, 0x06, 0x07, 0x00, 0x38, 0x78, 0x00, 0xE3, 0x80,
  0x03, 0xBC, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x38,
  0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x70, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00,
  0x38, 0xE0, 0x01, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x63, 0x80, 0x03, 0x1C,
  0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x30, 0x00, 0x71, 0x80, 0x03,
  0x1C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xF1, 0xC0,
  0x07, 0x8E, 0x00, 0x58, 0x38, 0x04, 0xC1, 0xE0, 0xE6, 0x07, 0xFE, 0x70,
  0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x19, 0xFE, 0x00, 0xF8, 0x30, 0x01, 0xC0,
  0xC0, 0x07, 0x03, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x70, 0x00, 0xC1, 0xC0,
  0x07, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x60, 0x01, 0xC1, 0x80, 0x06,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0C,
  0x00, 0xE0, 0x30, 0x07, 0x01, 0xC0, 0x3C, 0x07, 0x01, 0xE0, 0x1C, 0x1F,
  0x00, 0x71, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x0E, 0x04,
  0x38, 0x0E, 0x0E, 0x38, 0x0C, 0x06, 0x38, 0x0C, 0x06, 0x30, 0x0C, 0x06,
  0x30, 0x0C, 0x07, 0x30, 0x1C, 0x07, 0x70, 0x1C, 0x07, 0x70, 0x18, 0x07,
  0x70, 0x18, 0x07, 0x60, 0x18, 0x07, 0x60, 0x18, 0x06, 0x60, 0x38, 0x06,
  0xE0, 0x38, 0x06, 0xE0, 0x30, 0x06, 0xE0, 0x30, 0x0E, 0xC0, 0x30, 0x0C,
  0xC0, 0x70, 0x0C, 0xC0, 0x70, 0x1C, 0xC0, 0x70, 0x18, 0xC0, 0xB0, 0x38,
  0xC0, 0xB0, 0x70, 0xE3, 0x38, 0xE0, 0xFE, 0x1F, 0xC0, 0x3C, 0x0F, 0x80,
  0x00, 0xF0, 0x0F, 0x00, 0x7F, 0x07, 0xF8, 0x3E, 0x61, 0xC7, 0x0F, 0x0C,
  0x60, 0x67, 0x81, 0xC8, 0x0E, 0x60, 0x1B, 0x01, 0xC0, 0x03, 0x40, 0x38,
  0x00, 0x68, 0x07, 0x00, 0x0F, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x03, 0x80,
  0x03, 0x00, 0xF0, 0x00, 0x60, 0x17, 0x00, 0x8C, 0x06, 0xE0, 0x39, 0x80,
  0xCC, 0x1E, 0x38, 0x31, 0x87, 0x87, 0x0C, 0x3B, 0xC0, 0x7F, 0x03, 0xF0,
  0x07, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x03, 0x00,
  0x07, 0x07, 0x00, 0x06, 0x07, 0x00, 0x06, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0x0E, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x0E, 0x00,
  0x0C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x1C, 0x00,
  0x78, 0x0C, 0x00, 0xB8, 0x0E, 0x01, 0xB8, 0x0F, 0x07, 0x30, 0x07, 0xFE,
  0x30, 0x01, 0xF8, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x40, 0x01, 0xC0, 0x60, 0x03,
  0x80, 0xF8, 0x0F, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFF, 0x07, 0x0F, 0x07, 0xC7, 0x0C, 0x00, 0xF6, 0x1C, 0x00,
  0x3E, 0x1C, 0x00, 0x3C, 0x18, 0x00, 0x78, 0x18, 0x00, 0xF0, 0x18, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x10, 0x01, 0xC0,
  0x30, 0x03, 0x80, 0x38, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x3C, 0x00,
  0x1C, 0x7F, 0x00, 0x1C, 0x63, 0xF8, 0x1C, 0x60, 0x3F, 0x8C, 0xE0, 0x07,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x08, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x03, 0x07,
  0xF0, 0x01, 0xC7, 0x1C, 0x00, 0xC3, 0x07, 0x00, 0xC3, 0x01, 0xC0, 0x63,
  0x80, 0x70, 0x61, 0x80, 0x1C, 0x70, 0xC0, 0x0F, 0xF0, 0xE0, 0x01, 0xE0,
  0x00,
};

const GFXglyph IBMPlexMono_LightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 9, 33, 28, 10, -33 },
  { 39, 12, 13, 28, 11, -35 },
  { 59, 28, 33, 28, 1, -33 },
  { 175, 26, 44, 28, 1, -38 },
  { 318, 32, 34, 28, -1, -33 },
  { 454, 28, 34, 28, 0, -33 },
  { 573, 4, 13, 28, 15, -35 },
  { 580, 17, 42, 28, 10, -36 },
  { 670, 17, 42, 28, 2, -36 },
  { 760, 24, 23, 28, 3, -26 },
  { 829, 23, 22, 28, 3, -25 },
  { 893, 9, 12, 28, 7, -5 },
  { 907, 13, 2, 28, 8, -15 },
  { 911, 5, 5, 28, 10, -5 },
  { 915, 27, 42, 28, 1, -36 },
  { 1057, 23, 34, 28, 3, -33 },
  { 1155, 22, 33, 28, 2, -33 },
  { 1246, 24, 33, 28, 2, -33 },
  { 1345, 23, 34, 28, 2, -33 },
  { 1443, 25, 33, 28, 1, -33 },
  { 1547, 25, 34, 28, 2, -33 },
  { 1654, 22, 34, 28, 3, -33 },
  { 1748, 23, 33, 28, 5, -33 },
  { 1843, 24, 34, 28, 2, -33 },
  { 1945, 22, 33, 28, 4, -33 },
  { 2036, 9, 25, 28, 10, -25 },
  { 2065, 12, 32, 28, 7, -25 },
  { 2113, 23, 26, 28, 4, -27 },
  { 2188, 25, 11, 28, 2, -20 },
  { 2223, 23, 26, 28, 2, -27 },
  { 2298, 20, 33, 28, 6, -33 },
  { 2381, 23, 38, 28, 3, -33 },
  { 2491, 24, 33, 28, 0, -33 },
  { 2590, 24, 33, 28, 2, -33 },
  { 2689, 23, 34, 28, 4, -33 },
  { 2787, 23, 33, 28, 3, -33 },
  { 2882, 25, 33, 28, 3, -33 },
  { 2986, 25, 33, 28, 3, -33 },
  { 3090, 23, 34, 28, 4, -33 },
  { 3188, 26, 33, 28, 2, -33 },
  { 3296, 26, 33, 28, 2, -33 },
  { 3404, 23, 34, 28, 3, -33 },
  { 3502, 28, 33, 28, 2, -33 },
  { 3618, 19, 33, 28, 4, -33 },
  { 3697, 27, 33, 28, 1, -33 },
  { 3809, 26, 33, 28, 2, -33 },
  { 3917, 23, 34, 28, 3, -33 },
  { 4015, 24, 33, 28, 3, -33 },
  { 4114, 23, 41, 28, 3, -33 },
  { 4232, 24, 33, 28, 3, -33 },
  { 4331, 26, 34, 28, 1, -33 },
  { 4442, 25, 33, 28, 5, -33 },
  { 4546, 24, 34, 28, 4, -33 },
  { 4648, 25, 33, 28, 5, -33 },
  { 4752, 27, 33, 28, 3, -33 },
  { 4864, 30, 33, 28, 0, -33 },
  { 4988, 27, 33, 28, 4, -33 },
  { 5100, 29, 33, 28, 0, -33 },
  { 5220, 20, 42, 28, 8, -36 },
  { 5325, 12, 42, 28, 9, -36 },
  { 5388, 19, 42, 28, 1, -36 },
  { 5488, 23, 19, 28, 3, -33 },
  { 5543, 23, 2, 28, 0, 5 },
  { 5549, 6, 9, 28, 11, -37 },
  { 5556, 22, 26, 28, 3, -25 },
  { 5628, 22, 36, 28, 3, -35 },
  { 5727, 20, 26, 28, 4, -25 },
  { 5792, 24, 36, 28, 3, -35 },
  { 5900, 20, 26, 28, 4, -25 },
  { 5965, 31, 45, 28, -1, -35 },
  { 6140, 23, 35, 28, 2, -25 },
  { 6241, 21, 35, 28, 3, -35 },
  { 6333, 21, 35, 28, 4, -34 },
  { 6425, 21, 45, 28, 4, -35 },
  { 6544, 24, 36, 28, 3, -35 },
  { 6652, 19, 36, 28, 5, -35 },
  { 6738, 26, 25, 28, 1, -25 },
  { 6820, 21, 25, 28, 3, -25 },
  { 6886, 22, 26, 28, 3, -25 },
  { 6958, 24, 34, 28, 1, -25 },
  { 7060, 22, 34, 28, 3, -25 },
  { 7154, 23, 24, 28, 5, -24 },
  { 7223, 22, 26, 28, 3, -25 },
  { 7295, 22, 34, 28, 4, -33 },
  { 7389, 21, 25, 28, 4, -24 },
  { 7455, 22, 24, 28, 3, -24 },
  { 7521, 24, 25, 28, 3, -24 },
  { 7596, 27, 26, 28, 1, -25 },
  { 7684, 24, 34, 28, 1, -24 },
  { 7786, 24, 26, 28, 2, -25 },
  { 7864, 22, 42, 28, 5, -36 },
  { 7980, 9, 42, 28, 10, -36 },
  { 8028, 22, 42, 28, 2, -36 },
  { 8144, 25, 9, 28, 2, -19 },
};

const GFXfont IBMPlexMono_LightItalic47pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic47pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic47pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _IBMPLEXMONO_LIGHTITALIC47PT7B_H_
