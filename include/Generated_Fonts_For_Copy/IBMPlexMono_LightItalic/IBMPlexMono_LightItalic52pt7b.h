#ifndef _IBMPLEXMONO_LIGHTITALIC52PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xC0, 0x38, 0x39,
  0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x03, 0xB8, 0x19, 0xC1, 0xCE, 0x0E, 0x70,
  0x73, 0x83, 0x98, 0x1D, 0xC0, 0xCE, 0x0E, 0x70, 0x70, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE3,
  0xFF, 0x81, 0xFF, 0xC0, 0x06, 0x03, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x3F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0x81,
  0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xF8,
  0x67, 0xE0, 0x0F, 0x07, 0x07, 0x80, 0xF0, 0x38, 0x1E, 0x0F, 0x01, 0x80,
  0x60, 0x70, 0x0C, 0x02, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xE0,
  0x60, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x3E, 0x18, 0x00, 0x00, 0xFD, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1B, 0xF8, 0x00, 0x00, 0xC3, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x18, 0x07, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70,
  0x40, 0x18, 0x07, 0x8F, 0x00, 0xC0, 0x38, 0x3C, 0x06, 0x03, 0xC0, 0xF8,
  0x30, 0x7C, 0x03, 0xF3, 0x8F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1C, 0x03, 0xFF, 0x80, 0x07,
  0x00, 0xF0, 0x70, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x30, 0x06, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x00,
  0x70, 0x18, 0x00, 0xC0, 0x0E, 0x07, 0x00, 0x18, 0x01, 0xC1, 0xC0, 0x03,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x0E, 0x0E, 0x00, 0x0E, 0x03, 0x83, 0x80,
  0x01, 0xE0, 0xF0, 0xE0, 0x00, 0x1F, 0xFC, 0x18, 0x00, 0x01, 0xFF, 0x07,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x3F, 0xE0, 0x00,
  0x0E, 0x0F, 0xFE, 0x00, 0x01, 0x83, 0xC1, 0xE0, 0x00, 0x70, 0xF0, 0x1C,
  0x00, 0x1C, 0x1C, 0x01, 0x80, 0x03, 0x03, 0x00, 0x30, 0x00, 0xE0, 0xE0,
  0x06, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x01, 0x80,
  0x60, 0x07, 0x00, 0x70, 0x0C, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x38, 0x07, 0x00, 0xC0, 0x03, 0x83, 0xC0, 0x38, 0x00, 0x7F, 0xF0,
  0x0E, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x07,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7C, 0x7E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x9C, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x2E, 0x07, 0x38, 0x00,
  0xDC, 0x1C, 0x70, 0x01, 0x9C, 0x38, 0xF0, 0x06, 0x3C, 0xE0, 0xF0, 0x3C,
  0x3B, 0xC0, 0xFF, 0xF0, 0x7F, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x7E, 0x00,
  0x70, 0x00, 0x39, 0xCE, 0x73, 0x39, 0xCE, 0x73, 0x99, 0xCE, 0x70, 0x00,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x80, 0x0E, 0x00,
  0x5C, 0x03, 0x80, 0xFF, 0xE0, 0xE1, 0xFC, 0xFF, 0x3B, 0xFC, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x01,
  0xC0, 0x38, 0x00, 0x70, 0x04, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE8, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFB, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x3C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x78, 0x0E, 0x01, 0xDE, 0x07, 0xC0, 0x77, 0x01, 0xF0, 0x1D, 0xC0, 0x7C,
  0x0F, 0x70, 0x1E, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x0E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x3E, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xEE,
  0x00, 0x03, 0xE7, 0x00, 0x03, 0xE7, 0x00, 0x07, 0xC3, 0x80, 0x07, 0xC1,
  0xC0, 0x07, 0xC0, 0xE0, 0x07, 0xC0, 0x70, 0x03, 0xC0, 0x30, 0x00, 0x80,
  0x38, 0x00, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x03, 0xE0, 0x7E, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC0, 0x80,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x07, 0x80, 0xE0,
  0x00, 0xF0, 0x70, 0x00, 0x1C, 0x04, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x84, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x78, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x1F, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE1, 0xFC,
  0x00, 0x31, 0xFF, 0xC0, 0x0D, 0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0x01, 0xF0,
  0x03, 0xE0, 0x70, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x10, 0x00,
  0x07, 0x8E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x0F,
  0x80, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x0F, 0xE0, 0x1E, 0x7F, 0xF0, 0x39,
  0xFF, 0xF8, 0xF7, 0x01, 0xF9, 0xD8, 0x00, 0xF3, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0x78, 0x00, 0xF0,
  0x7C, 0x07, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEE, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x78, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x7C, 0x07, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x80,
  0x03, 0xC0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x01,
  0xF0, 0x1E, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x1C, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC0,
  0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F,
  0xC0, 0x7C, 0x1F, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x78,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x3E, 0x70, 0x00, 0x2E, 0x78, 0x00, 0xDC, 0x3E,
  0x03, 0xDC, 0x1F, 0xFF, 0xB8, 0x0F, 0xFE, 0x38, 0x03, 0xF8, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x87, 0xC3, 0xE3, 0xF1, 0xF8, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1E,
  0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0x7C, 0x3C,
  0x00, 0x78, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0xE0, 0x00,
  0x3C, 0x80, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0xF0,
  0x00, 0xE0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x70, 0x0F, 0xC7, 0x1C, 0x07, 0xF9,
  0x87, 0x03, 0xFF, 0x61, 0x81, 0xE0, 0xD8, 0xE0, 0x70, 0x1E, 0x38, 0x38,
  0x03, 0x8E, 0x0E, 0x00, 0xE3, 0x87, 0x00, 0x30, 0xC1, 0xC0, 0x0C, 0x70,
  0x70, 0x03, 0x1C, 0x1C, 0x01, 0xC7, 0x06, 0x00, 0x71, 0xC3, 0x80, 0x1C,
  0x70, 0xE0, 0x06, 0x18, 0x38, 0x03, 0x86, 0x0E, 0x00, 0xE1, 0x81, 0x80,
  0x78, 0xE0, 0x70, 0x3E, 0x38, 0x1F, 0x3B, 0x8E, 0x03, 0xFC, 0xE1, 0x80,
  0xFE, 0x30, 0x60, 0x06, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x07, 0x00,
  0x0E, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00,
  0x38, 0x03, 0x80, 0x07, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x78, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x07, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x78, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x38, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x79, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0xF8, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x7C, 0x03, 0xE0,
  0x07, 0x00, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x0E,
  0x00, 0x01, 0x87, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x87, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x3E, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1E,
  0x00, 0xF8, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x38,
  0x1C, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x1C,
  0x00, 0x0F, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x03, 0xE0, 0x70, 0x03, 0xF0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x3C,
  0x00, 0xF0, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1E,
  0x00, 0x01, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xFF,
  0xEE, 0x00, 0xFF, 0xE7, 0x00, 0x7F, 0xF3, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0xF0, 0xE0,
  0x00, 0xF8, 0x78, 0x00, 0xD8, 0x3E, 0x00, 0xDC, 0x0F, 0x81, 0xEE, 0x03,
  0xFF, 0xE7, 0x00, 0xFF, 0xE3, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F,
  0x00, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x02, 0x00, 0x07, 0x87, 0x00, 0x03, 0x81,
  0xC0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x78, 0x01, 0xE0, 0x1F, 0x03, 0xE0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0xF0, 0x07, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0xE0, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x7E,
  0x00, 0x00, 0x73, 0xF8, 0x00, 0x01, 0xDE, 0xF0, 0x00, 0x0F, 0xF1, 0xC0,
  0x00, 0x3F, 0x87, 0x80, 0x00, 0xFC, 0x0E, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0xC0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xB8, 0x19, 0x80,
  0x1D, 0xC1, 0xCE, 0x01, 0xCE, 0x0E, 0x70, 0x0E, 0x70, 0x73, 0x80, 0xE3,
  0x03, 0x8C, 0x06, 0x38, 0x1C, 0x70, 0x71, 0xC0, 0xC3, 0x87, 0x0E, 0x0E,
  0x1C, 0x38, 0x70, 0x70, 0x63, 0x83, 0x83, 0x83, 0x98, 0x18, 0x1C, 0x1D,
  0xC1, 0xC0, 0xE0, 0x7C, 0x0E, 0x06, 0x03, 0xE0, 0x70, 0x70, 0x1E, 0x03,
  0x83, 0x80, 0xE0, 0x1C, 0x1C, 0x03, 0x00, 0xC0, 0xE0, 0x10, 0x0E, 0x07,
  0x00, 0x80, 0x70, 0x30, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xE0, 0x00, 0x70, 0x3E, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x70, 0x3F, 0x00,
  0x07, 0x03, 0x70, 0x00, 0x70, 0x77, 0x00, 0x07, 0x07, 0x38, 0x00, 0xE0,
  0x73, 0x80, 0x0E, 0x07, 0x38, 0x00, 0xE0, 0x71, 0x80, 0x0E, 0x06, 0x1C,
  0x00, 0xE0, 0xE1, 0xC0, 0x0E, 0x0E, 0x1C, 0x01, 0xC0, 0xE0, 0xE0, 0x1C,
  0x0E, 0x0E, 0x01, 0xC0, 0xE0, 0xE0, 0x1C, 0x0C, 0x06, 0x01, 0xC1, 0xC0,
  0x70, 0x1C, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x03, 0x83,
  0x81, 0xC0, 0x38, 0x38, 0x18, 0x03, 0x83, 0x83, 0x80, 0x38, 0x38, 0x38,
  0x01, 0xC7, 0x03, 0x80, 0x1C, 0x70, 0x38, 0x01, 0xC7, 0x03, 0x80, 0x0C,
  0x70, 0x30, 0x00, 0xE7, 0x07, 0x00, 0x0E, 0x70, 0x70, 0x00, 0xEE, 0x07,
  0x00, 0x07, 0xE0, 0x70, 0x00, 0x7E, 0x07, 0x00, 0x07, 0xE0, 0x60, 0x00,
  0x3E, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00,
  0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x70, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0xF0,
  0x00, 0x07, 0xBC, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x3C,
  0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0xF0, 0x38, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x3E, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0xE0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x03, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70,
  0x00, 0x07, 0x3C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x87, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0x80, 0x20, 0x00, 0x70, 0x1C, 0x00, 0x1E, 0x0F,
  0x80, 0x03, 0xC7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x1E, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1C,
  0x00, 0x07, 0x83, 0x80, 0x03, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x04, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x40, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xF1, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x87, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0x78, 0x01,
  0xF0, 0x1F, 0x01, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x70,
  0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x0C, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x38,
  0x60, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x83, 0x80, 0x70, 0x0E, 0x0E, 0x03,
  0xE0, 0x38, 0x38, 0x0F, 0x80, 0xC0, 0xE0, 0x7E, 0x07, 0x03, 0x81, 0xF8,
  0x1C, 0x0C, 0x06, 0xE0, 0x70, 0x30, 0x3B, 0x81, 0x80, 0xC0, 0xC6, 0x0E,
  0x03, 0x07, 0x18, 0x38, 0x1C, 0x18, 0x60, 0xE0, 0x70, 0xE1, 0x83, 0x01,
  0xC3, 0x86, 0x1C, 0x07, 0x0C, 0x18, 0x70, 0x1C, 0x70, 0x71, 0xC0, 0x71,
  0x81, 0xC6, 0x01, 0xCE, 0x07, 0x38, 0x07, 0x38, 0x1C, 0xE0, 0x18, 0xC0,
  0x73, 0x80, 0x67, 0x01, 0xCC, 0x01, 0x98, 0x07, 0x70, 0x06, 0xE0, 0x0D,
  0xC0, 0x3B, 0x80, 0x37, 0x00, 0xEC, 0x00, 0xD8, 0x03, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07,
  0x80, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC1, 0xC0, 0x01,
  0xE0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0xF0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38,
  0x78, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x38, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x63, 0xC7, 0x0C, 0x38, 0x61, 0xC3, 0x0C, 0x00, 0x7F, 0x03,
  0x80, 0xFF, 0xE3, 0x80, 0xFF, 0xF9, 0xC0, 0xF8, 0x0E, 0xE0, 0xF0, 0x01,
  0x70, 0xF0, 0x00, 0xF8, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x63, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x02, 0xE0, 0xF0, 0x07, 0x70,
  0x3E, 0x0F, 0x3F, 0x8F, 0xFF, 0x1F, 0x83, 0xFF, 0x07, 0xC0, 0xFE, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0xFE, 0x00, 0x71, 0xFF, 0xC0, 0x71, 0xFF, 0xF0, 0x39, 0xE0, 0xF8,
  0x1D, 0xC0, 0x1E, 0x0E, 0x80, 0x07, 0x07, 0xC0, 0x03, 0xC3, 0xC0, 0x00,
  0xE3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xCE, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x1D,
  0x00, 0x1E, 0x0E, 0xE0, 0x3E, 0x07, 0x3F, 0xFE, 0x07, 0x0F, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3E, 0x07, 0xC0, 0xF0, 0x03, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x1C,
  0x00, 0x09, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x47, 0x00, 0x00,
  0xEE, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0xF0,
  0x3E, 0x07, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x1F, 0x81, 0xC0, 0x1F, 0xFC, 0x38, 0x07, 0xFF, 0xC7, 0x01,
  0xF0, 0x1C, 0xC0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x03, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x60, 0xE0,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x1E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xE0,
  0x70, 0x00, 0x78, 0x0E, 0x00, 0x1F, 0x01, 0xE0, 0x06, 0xE0, 0x1F, 0x03,
  0x9C, 0x01, 0xFF, 0xE3, 0x80, 0x1F, 0xF8, 0x70, 0x00, 0xFC, 0x10, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x03, 0xE0,
  0xF0, 0x01, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xF3, 0x80, 0x07, 0xCE, 0x03,
  0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x4E, 0x00, 0x01,
  0xCE, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x3E, 0x03, 0xE0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x08, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x7C,
  0x07, 0x00, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x00,
  0x3E, 0x38, 0x00, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x00, 0xFB, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x81, 0xC0, 0x3F, 0xF8, 0x70, 0x1F, 0xFF, 0x18,
  0x0F, 0x80, 0xEE, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x0F, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x2C, 0x0E, 0x00,
  0x1F, 0x03, 0xC0, 0x0D, 0xC0, 0x7C, 0x0E, 0x70, 0x0F, 0xFF, 0x1C, 0x01,
  0xFF, 0x87, 0x00, 0x1F, 0x81, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x40, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x0F, 0xC0, 0x7C, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x7E, 0x00, 0xE1, 0xFF, 0x01, 0xC7, 0xFF, 0x03, 0x9C,
  0x1F, 0x0F, 0x60, 0x1E, 0x1D, 0x80, 0x1C, 0x3A, 0x00, 0x3C, 0x78, 0x00,
  0x38, 0xE0, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x63,
  0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x31, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00,
  0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x40, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x40, 0x1C, 0x01, 0xC0, 0x30,
  0x0F, 0x80, 0xE0, 0x3E, 0x01, 0xC0, 0xF0, 0x03, 0x87, 0xC0, 0x07, 0x1F,
  0x00, 0x0C, 0x78, 0x00, 0x39, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x10, 0x01, 0xC0, 0x30, 0x03, 0x80, 0xF8, 0x07,
  0x00, 0xF8, 0x0E, 0x00, 0xF8, 0x1C, 0x00, 0xF8, 0x70, 0x00, 0xF8, 0xE0,
  0x00, 0xF9, 0xC0, 0x00, 0xFB, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x83, 0xF8, 0x00, 0x71, 0xFF, 0xC0, 0x0E,
  0x7F, 0xFC, 0x03, 0x9E, 0x0F, 0x80, 0x73, 0x00, 0x70, 0x0E, 0xC0, 0x0F,
  0x01, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x01, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x03, 0x81, 0xF8, 0x00, 0xE1, 0xF8, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x8E, 0x07, 0x00, 0x71,
  0xC0, 0xE0, 0x1F, 0x70, 0x0E, 0x07, 0x8E, 0x01, 0xC1, 0xE1, 0xC0, 0x1C,
  0x78, 0x38, 0x03, 0xDE, 0x07, 0x00, 0x3F, 0x80, 0xC0, 0x07, 0xE0, 0x20,
  0x00, 0x78, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x40, 0x70, 0x07, 0x03, 0x80, 0x7C, 0x38, 0x0F,
  0x81, 0xC0, 0xF8, 0x0E, 0x0F, 0x00, 0x71, 0xF0, 0x03, 0x9F, 0x00, 0x19,
  0xE0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x1E,
  0x07, 0xC0, 0xE7, 0xF0, 0xFE, 0x0E, 0xFF, 0x9F, 0xF0, 0xEC, 0x3B, 0x87,
  0x0F, 0x83, 0xB0, 0x70, 0xF0, 0x1E, 0x03, 0x0E, 0x01, 0xC0, 0x31, 0xE0,
  0x1C, 0x03, 0x1C, 0x03, 0x80, 0x71, 0xC0, 0x38, 0x07, 0x1C, 0x03, 0x80,
  0x71, 0xC0, 0x38, 0x07, 0x18, 0x03, 0x00, 0x63, 0x80, 0x30, 0x06, 0x38,
  0x07, 0x00, 0xE3, 0x80, 0x70, 0x0E, 0x38, 0x07, 0x00, 0xE3, 0x80, 0x70,
  0x0E, 0x30, 0x06, 0x00, 0xC7, 0x00, 0x60, 0x0C, 0x70, 0x0E, 0x01, 0xC7,
  0x00, 0xE0, 0x1C, 0x70, 0x0E, 0x01, 0xC7, 0x00, 0xE0, 0x1C, 0x60, 0x0C,
  0x01, 0x8E, 0x00, 0xC0, 0x18, 0xE0, 0x1C, 0x03, 0x80, 0x0E, 0x0F, 0xC0,
  0x1C, 0x3F, 0xE0, 0x38, 0xFF, 0xE0, 0x73, 0x83, 0xE1, 0xCC, 0x03, 0xC3,
  0xB0, 0x03, 0x87, 0x40, 0x07, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x38, 0xF0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00,
  0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3,
  0x80, 0x01, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x07, 0xC0, 0xF8, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x70, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x70,
  0x78, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0x83, 0xF8, 0x00, 0xE3, 0xFF, 0x80, 0x71, 0xFF,
  0xF0, 0x1C, 0xF0, 0x7C, 0x07, 0x70, 0x07, 0x81, 0xD0, 0x00, 0xE0, 0x7C,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x0F,
  0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xE8, 0x00, 0xF0, 0x3B, 0x80, 0xF8,
  0x1C, 0x7F, 0xFC, 0x07, 0x0F, 0xFE, 0x01, 0xC0, 0xFE, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x03, 0x80, 0xFF, 0xE1, 0xC0, 0xFF,
  0xF8, 0xC0, 0xFC, 0x0E, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x70,
  0x00, 0x3C, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x3C, 0x00, 0x03, 0x1C,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x73,
  0xC0, 0x00, 0x31, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x07, 0x83, 0x80, 0x03,
  0xC1, 0xC0, 0x03, 0xE0, 0xF0, 0x03, 0x70, 0x3E, 0x07, 0x38, 0x0F, 0xFF,
  0x1C, 0x03, 0xFF, 0x0C, 0x00, 0x7E, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF9, 0xFF, 0xC0, 0x1C, 0xE0,
  0x00, 0x0E, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x40, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xF8,
  0x07, 0xE0, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x10, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE2, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x71, 0xF0, 0x00, 0x78, 0x7E, 0x01, 0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x0C, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x7C, 0x03, 0x80, 0xF8, 0x03,
  0x83, 0xE0, 0x07, 0x07, 0xC0, 0x07, 0x1F, 0x00, 0x07, 0x3E, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x70,
  0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00,
  0x03, 0x8E, 0x00, 0x07, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3,
  0x80, 0x03, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x5C, 0x38,
  0x01, 0xB8, 0x78, 0x06, 0x70, 0xF8, 0x3C, 0xE0, 0xFF, 0xF3, 0x80, 0xFF,
  0xC7, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x06, 0xFF, 0x80, 0x0E, 0xFF,
  0x80, 0x0E, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x0C, 0x00, 0x38, 0x0C,
  0x00, 0x70, 0x1C, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x1C, 0x07, 0xC0, 0x1C,
  0x0F, 0x80, 0x1C, 0x7F, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x1C, 0x03, 0x81, 0x87, 0x00, 0xC0, 0xF1, 0xC0, 0x30, 0x1C,
  0x60, 0x0C, 0x07, 0x18, 0x07, 0x00, 0xCE, 0x01, 0xC0, 0x33, 0x80, 0x70,
  0x0C, 0xE0, 0x18, 0x03, 0x38, 0x06, 0x00, 0xCC, 0x03, 0x80, 0x33, 0x00,
  0xE0, 0x0D, 0xC0, 0x38, 0x03, 0x70, 0x0E, 0x00, 0xDC, 0x03, 0x80, 0x77,
  0x00, 0xC0, 0x1D, 0x80, 0x70, 0x07, 0x60, 0x1C, 0x01, 0xF8, 0x07, 0x00,
  0x6E, 0x01, 0xC0, 0x3B, 0x80, 0x70, 0x0E, 0xE0, 0x3C, 0x07, 0xB8, 0x0E,
  0x01, 0xCE, 0x07, 0xC0, 0xF3, 0x81, 0x70, 0x78, 0xF1, 0xDE, 0x3C, 0x3F,
  0xE3, 0xFF, 0x07, 0xF0, 0xFF, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x78, 0x03,
  0xE0, 0x03, 0xF0, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x81, 0xF3, 0x8F, 0x1E,
  0x0F, 0x0E, 0x30, 0x38, 0xF0, 0x19, 0x80, 0x77, 0x80, 0x66, 0x01, 0xC8,
  0x01, 0xF0, 0x07, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0x60, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x02, 0xC0, 0x00,
  0xC0, 0x1B, 0x00, 0x63, 0x80, 0x4C, 0x03, 0xCE, 0x03, 0x38, 0x3E, 0x38,
  0x1C, 0xE1, 0xE0, 0xF0, 0xE3, 0xDF, 0x01, 0xFF, 0x07, 0xF0, 0x07, 0xF8,
  0x1F, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x1C,
  0x00, 0x5C, 0x07, 0x00, 0x17, 0x01, 0xE0, 0x19, 0xC0, 0x3C, 0x0E, 0x70,
  0x0F, 0xFF, 0x3C, 0x01, 0xFF, 0x8E, 0x00, 0x1F, 0x83, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x40, 0x01, 0xE0, 0x38, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0xC1, 0xFF, 0xF0, 0x70, 0xFF, 0xFF, 0x38, 0x3C, 0x0F, 0xFE, 0x1C,
  0x00, 0x7F, 0x87, 0x00, 0x07, 0xE1, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0xF0,
  0x38, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x78, 0x00, 0xC0,
  0x3C, 0x00, 0x30, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x87, 0xF8, 0x00,
  0xE3, 0xFF, 0xE0, 0x18, 0xE1, 0xFF, 0xC6, 0x38, 0x0F, 0xFF, 0x8E, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0xC3, 0xFC, 0x00, 0x31, 0xFF, 0x80, 0x1C, 0x71, 0xE0, 0x06, 0x38,
  0x3C, 0x03, 0x9C, 0x07, 0x80, 0xE7, 0x00, 0xF0, 0x71, 0x80, 0x1E, 0x38,
  0xE0, 0x07, 0xFE, 0x30, 0x00, 0xFF, 0x0C, 0x00, 0x0F, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 10, 36, 31, 11, -36 },
  { 46, 13, 14, 31, 12, -38 },
  { 69, 31, 36, 31, 1, -36 },
  { 209, 29, 48, 31, 1, -42 },
  { 383, 35, 38, 31, -1, -37 },
  { 550, 31, 38, 31, 0, -37 },
  { 698, 5, 14, 31, 16, -38 },
  { 707, 18, 47, 31, 11, -40 },
  { 813, 18, 47, 31, 3, -40 },
  { 919, 26, 26, 31, 3, -29 },
  { 1004, 26, 25, 31, 3, -28 },
  { 1086, 10, 14, 31, 8, -6 },
  { 1104, 14, 3, 31, 9, -17 },
  { 1110, 6, 6, 31, 11, -6 },
  { 1115, 28, 47, 31, 2, -40 },
  { 1280, 26, 38, 31, 3, -37 },
  { 1404, 25, 36, 31, 2, -36 },
  { 1517, 26, 37, 31, 2, -37 },
  { 1638, 26, 38, 31, 2, -37 },
  { 1762, 27, 36, 31, 1, -36 },
  { 1884, 26, 37, 31, 3, -36 },
  { 2005, 23, 37, 31, 4, -36 },
  { 2112, 25, 36, 31, 6, -36 },
  { 2225, 27, 38, 31, 2, -37 },
  { 2354, 24, 37, 31, 5, -37 },
  { 2465, 9, 28, 31, 11, -28 },
  { 2497, 12, 36, 31, 8, -28 },
  { 2551, 25, 29, 31, 5, -30 },
  { 2642, 26, 13, 31, 3, -22 },
  { 2685, 24, 29, 31, 3, -30 },
  { 2772, 22, 37, 31, 7, -37 },
  { 2874, 26, 43, 31, 3, -37 },
  { 3014, 27, 36, 31, 0, -36 },
  { 3136, 25, 36, 31, 3, -36 },
  { 3249, 26, 38, 31, 4, -37 },
  { 3373, 26, 36, 31, 3, -36 },
  { 3490, 28, 36, 31, 3, -36 },
  { 3616, 28, 36, 31, 3, -36 },
  { 3742, 25, 38, 31, 4, -37 },
  { 3861, 28, 36, 31, 2, -36 },
  { 3987, 29, 36, 31, 2, -36 },
  { 4118, 25, 37, 31, 3, -36 },
  { 4234, 30, 36, 31, 3, -36 },
  { 4369, 21, 36, 31, 5, -36 },
  { 4464, 29, 36, 31, 2, -36 },
  { 4595, 28, 36, 31, 2, -36 },
  { 4721, 26, 38, 31, 3, -37 },
  { 4845, 27, 36, 31, 3, -36 },
  { 4967, 26, 46, 31, 3, -37 },
  { 5117, 27, 36, 31, 3, -36 },
  { 5239, 28, 38, 31, 2, -37 },
  { 5372, 28, 36, 31, 5, -36 },
  { 5498, 26, 37, 31, 4, -36 },
  { 5619, 27, 36, 31, 6, -36 },
  { 5741, 30, 36, 31, 3, -36 },
  { 5876, 33, 36, 31, 0, -36 },
  { 6025, 29, 36, 31, 5, -36 },
  { 6156, 32, 36, 31, 0, -36 },
  { 6300, 21, 47, 31, 9, -40 },
  { 6424, 13, 47, 31, 10, -40 },
  { 6501, 21, 47, 31, 1, -40 },
  { 6625, 25, 20, 31, 4, -36 },
  { 6688, 25, 3, 31, 0, 5 },
  { 6698, 6, 9, 31, 12, -40 },
  { 6705, 25, 28, 31, 3, -27 },
  { 6793, 25, 39, 31, 3, -38 },
  { 6915, 23, 28, 31, 4, -27 },
  { 6996, 27, 39, 31, 3, -38 },
  { 7128, 23, 28, 31, 4, -27 },
  { 7209, 34, 49, 31, -1, -38 },
  { 7418, 26, 38, 31, 2, -27 },
  { 7542, 23, 38, 31, 4, -38 },
  { 7652, 23, 40, 31, 4, -39 },
  { 7767, 23, 50, 31, 4, -39 },
  { 7911, 27, 39, 31, 3, -38 },
  { 8043, 21, 39, 31, 6, -38 },
  { 8146, 28, 27, 31, 1, -27 },
  { 8241, 23, 27, 31, 4, -27 },
  { 8319, 24, 28, 31, 4, -27 },
  { 8403, 26, 37, 31, 2, -27 },
  { 8524, 25, 37, 31, 3, -27 },
  { 8640, 25, 27, 31, 6, -27 },
  { 8725, 25, 28, 31, 3, -27 },
  { 8813, 24, 37, 31, 4, -36 },
  { 8924, 23, 28, 31, 5, -27 },
  { 9005, 24, 27, 31, 4, -27 },
  { 9086, 26, 28, 31, 3, -27 },
  { 9177, 30, 28, 31, 1, -27 },
  { 9282, 26, 38, 31, 2, -27 },
  { 9406, 26, 28, 31, 3, -27 },
  { 9497, 24, 47, 31, 6, -40 },
  { 9638, 10, 47, 31, 11, -40 },
  { 9697, 24, 47, 31, 2, -40 },
  { 9838, 26, 11, 31, 3, -21 },
};

const GFXfont IBMPlexMono_LightItalic52pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic52pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic52pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _IBMPLEXMONO_LIGHTITALIC52PT7B_H_
