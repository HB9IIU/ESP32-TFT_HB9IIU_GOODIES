#ifndef _IBMPLEXMONO_LIGHTITALIC44PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x0F, 0x87, 0xC1, 0xC0,
  0x38, 0x66, 0x0C, 0xC1, 0xB8, 0x77, 0x0E, 0xE1, 0xD8, 0x33, 0x06, 0x60,
  0xCC, 0x3B, 0x87, 0x70, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x0C, 0x01, 0xFF, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0x00, 0x60, 0x60, 0x00,
  0x38, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x03, 0xFE, 0x0F, 0xF8, 0xFF, 0x03,
  0xFE, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x83, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x1C, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xE3, 0x3E, 0x03, 0x83, 0x0F, 0x07, 0x03,
  0x07, 0x0E, 0x06, 0x02, 0x0E, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x0E, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x04, 0x00, 0x07, 0x0C,
  0x00, 0x07, 0x8C, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x18, 0xF0, 0x00, 0x18, 0x38, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x1C, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x30,
  0x1C, 0x40, 0x30, 0x1C, 0x60, 0x30, 0x38, 0xF0, 0x30, 0x38, 0x78, 0x30,
  0xF0, 0x3E, 0x33, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x1C, 0x07, 0xFC, 0x00, 0xE0, 0x38, 0x70, 0x03, 0x01, 0xC0, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x07, 0x00, 0xE0, 0x18, 0x18,
  0x03, 0x00, 0x60, 0xC0, 0x0C, 0x03, 0x87, 0x00, 0x30, 0x0C, 0x38, 0x00,
  0xC0, 0x30, 0xC0, 0x03, 0x81, 0xC6, 0x00, 0x07, 0x0E, 0x38, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x1C, 0x38, 0x00, 0x38, 0xE0,
  0x60, 0x00, 0xC3, 0x00, 0xC0, 0x06, 0x1C, 0x03, 0x00, 0x38, 0x60, 0x0C,
  0x00, 0xC1, 0x80, 0x70, 0x06, 0x06, 0x01, 0xC0, 0x30, 0x18, 0x06, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x06, 0x03, 0x01, 0x80,
  0x0C, 0x38, 0x0E, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x00, 0xE0, 0x01,
  0xC0, 0x38, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x60,
  0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00,
  0xC0, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x1F,
  0xDE, 0x00, 0x1C, 0x3E, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x01,
  0xC0, 0x30, 0x00, 0x60, 0x0E, 0x00, 0x38, 0x01, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x80, 0xF8, 0x00, 0xE0, 0x6E, 0x00,
  0x5C, 0x19, 0x80, 0x13, 0x8C, 0x70, 0x0C, 0xE7, 0x0E, 0x0E, 0x1D, 0x81,
  0xFF, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x77, 0x76, 0x66, 0xEE, 0xEC, 0xCC,
  0x00, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x30, 0x0C, 0x03, 0xF8, 0x30, 0x7D, 0xFC, 0xCF, 0xE0,
  0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x39,
  0x80, 0x01, 0xC7, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x70,
  0x0E, 0x00, 0xC0, 0x70, 0x03, 0x80, 0x80, 0x08, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x87, 0x83, 0xC3, 0xC1,
  0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF,
  0x00, 0x3C, 0x0F, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x61,
  0xC0, 0x01, 0x86, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x76, 0x07, 0x81,
  0xF8, 0x1E, 0x06, 0xE0, 0x78, 0x3B, 0x81, 0xC0, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0xE0,
  0x70, 0x07, 0x00, 0xF0, 0x78, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1E, 0xC0, 0x01, 0xE6, 0x00, 0x1E, 0x70,
  0x01, 0xC3, 0x80, 0x3C, 0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x06, 0x00, 0x40,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x80, 0x3C, 0x0F, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0x71, 0xC0, 0x01, 0xC1, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x00, 0xE0, 0x70,
  0x00, 0xC0, 0x40, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x61, 0x80, 0x01, 0xC7, 0x80, 0x07, 0x07, 0x80, 0x1E, 0x07, 0xC0,
  0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x73,
  0x00, 0x01, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x60,
  0x00, 0xE0, 0xC0, 0x03, 0x81, 0x80, 0x0E, 0x07, 0x00, 0x18, 0x0E, 0x00,
  0x70, 0x1C, 0x01, 0xC0, 0x30, 0x07, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x8F, 0xE0, 0x03, 0x3F, 0xF0, 0x0F, 0xC0, 0xF0, 0x1E,
  0x00, 0xF0, 0x30, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE1, 0x80, 0x01, 0x87, 0x80, 0x07, 0x07, 0x80, 0x1C,
  0x07, 0x80, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x7E, 0x03, 0x9F, 0xF8, 0x37, 0x03, 0xC7, 0xC0,
  0x0E, 0x68, 0x00, 0x67, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E,
  0x00, 0x0E, 0xE0, 0x00, 0xC6, 0x00, 0x1C, 0x70, 0x03, 0x83, 0xC0, 0xF0,
  0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xD8, 0x00,
  0x0E, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x73, 0x00, 0x07, 0x18,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0x81, 0xE0,
  0x1C, 0x00, 0xE0, 0x70, 0x00, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x86,
  0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x30, 0x00, 0x70, 0x70,
  0x00, 0xC0, 0x70, 0x03, 0x00, 0x70, 0x1C, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x0F, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0xE0, 0x00, 0xC3, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x38, 0x00, 0x06, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC3, 0x80, 0x07, 0x87,
  0x80, 0x1E, 0x07, 0x80, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0x03, 0xC1, 0xC0, 0x0E, 0x38, 0x00, 0x73,
  0x00, 0x07, 0x70, 0x00, 0x36, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x70, 0x01,
  0x67, 0x00, 0x3E, 0x3C, 0x0E, 0xE1, 0xFF, 0xDC, 0x07, 0xE1, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0xF8, 0xF8, 0xF8, 0x70, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x1E, 0x07,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE0, 0x08, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF,
  0xC1, 0xE0, 0x78, 0xE0, 0x0E, 0x70, 0x01, 0xD8, 0x00, 0x7E, 0x00, 0x0D,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00,
  0xF0, 0x3C, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x87, 0x00, 0x0C, 0x30, 0x00,
  0x63, 0x80, 0x03, 0x18, 0x00, 0x19, 0xC0, 0x78, 0xCC, 0x0F, 0xE6, 0x60,
  0xE0, 0xB3, 0x06, 0x03, 0xB8, 0x70, 0x1D, 0xC3, 0x00, 0xCC, 0x38, 0x06,
  0x61, 0xC0, 0x33, 0x0C, 0x01, 0x98, 0x60, 0x1D, 0xC3, 0x00, 0xEE, 0x18,
  0x06, 0x60, 0xC0, 0x33, 0x06, 0x03, 0x98, 0x30, 0x2C, 0xC1, 0xC1, 0xE6,
  0x07, 0xF7, 0x30, 0x3F, 0x31, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xCC, 0x00, 0x03,
  0x18, 0x00, 0x0E, 0x30, 0x00, 0x18, 0x60, 0x00, 0x70, 0xE0, 0x00, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x06, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x30, 0x0C,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0C, 0x00, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xC0, 0x03, 0x03, 0x80, 0x07, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x38, 0xE0, 0x00, 0x31, 0x80,
  0x00, 0x67, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x60, 0x07, 0x81, 0x80, 0x06, 0x06, 0x00,
  0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x30, 0x00, 0x70, 0xC0, 0x01, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x70,
  0x03, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x18, 0x00, 0xE0, 0xE0, 0x01,
  0xC3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xC0, 0x00, 0xE3,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x31, 0xC0, 0x01, 0xC7, 0x00,
  0x07, 0x18, 0x00, 0x38, 0x60, 0x03, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xF0, 0x38, 0x0E, 0x00, 0xE0,
  0xE0, 0x03, 0x86, 0x00, 0x1C, 0x70, 0x00, 0x67, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x70,
  0xE0, 0x07, 0x07, 0x00, 0x78, 0x1E, 0x07, 0x80, 0x7F, 0xF0, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xE0, 0x1E, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x30, 0x30, 0x00, 0xE0, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x18, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00, 0x06, 0x38, 0x00, 0x38,
  0xC0, 0x00, 0xE3, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x31, 0xC0,
  0x01, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE3, 0x80, 0x07,
  0x0E, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x1E, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x18, 0x38,
  0x00, 0x71, 0xC0, 0x01, 0x87, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x7F, 0xCE, 0x01,
  0xFF, 0x38, 0x00, 0x0C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x06,
  0x38, 0x00, 0x18, 0x60, 0x00, 0xE1, 0x80, 0x03, 0x87, 0x00, 0x1E, 0x1C,
  0x00, 0x78, 0x38, 0x02, 0xC0, 0xF0, 0x33, 0x01, 0xFF, 0x8C, 0x01, 0xF8,
  0x00, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x06, 0x0E, 0x00,
  0x06, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0C, 0x00,
  0x0E, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x30, 0x00,
  0x38, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x80, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x82, 0x00, 0x1C, 0x38, 0x00, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0xE0, 0x3C,
  0x1E, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x03, 0xC1, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x06, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x03, 0x80,
  0x03, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x1E, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x67, 0x70, 0x00, 0x1B,
  0x9C, 0x00, 0x0F, 0xC3, 0x80, 0x03, 0xE0, 0xE0, 0x00, 0xF0, 0x18, 0x00,
  0x38, 0x07, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x06,
  0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x01, 0x80,
  0x03, 0x80, 0x60, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80,
  0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x6C,
  0x01, 0xF8, 0x36, 0x00, 0xD8, 0x3B, 0x00, 0xEC, 0x1D, 0xC0, 0xE6, 0x0C,
  0x60, 0x67, 0x06, 0x30, 0x73, 0x83, 0x18, 0x31, 0xC1, 0x8E, 0x38, 0xC1,
  0xC3, 0x18, 0x60, 0xE1, 0x98, 0x30, 0x60, 0xFC, 0x38, 0x30, 0x3C, 0x1C,
  0x18, 0x1E, 0x0E, 0x0C, 0x0E, 0x06, 0x0E, 0x06, 0x03, 0x07, 0x01, 0x01,
  0x83, 0x81, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x60, 0x00,
  0x30, 0x70, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0C, 0x00,
  0x07, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC0, 0x07,
  0x80, 0x07, 0x07, 0x80, 0x07, 0x07, 0xC0, 0x06, 0x0F, 0xC0, 0x06, 0x0E,
  0xC0, 0x06, 0x0E, 0xC0, 0x0E, 0x0C, 0xE0, 0x0E, 0x0C, 0xE0, 0x0E, 0x0C,
  0x60, 0x0C, 0x1C, 0x60, 0x0C, 0x1C, 0x70, 0x0C, 0x1C, 0x30, 0x1C, 0x18,
  0x30, 0x1C, 0x18, 0x38, 0x1C, 0x18, 0x38, 0x18, 0x18, 0x18, 0x18, 0x38,
  0x18, 0x18, 0x38, 0x1C, 0x38, 0x30, 0x1C, 0x38, 0x30, 0x0C, 0x38, 0x30,
  0x0C, 0x30, 0x30, 0x0E, 0x30, 0x70, 0x06, 0x30, 0x70, 0x06, 0x70, 0x60,
  0x07, 0x70, 0x60, 0x07, 0x70, 0x60, 0x03, 0x60, 0x60, 0x03, 0x60, 0xE0,
  0x03, 0xE0, 0xE0, 0x03, 0xE0, 0xE0, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0x00, 0x3C, 0x0F, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x38, 0x30, 0x00,
  0x61, 0xC0, 0x01, 0x86, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73,
  0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x76, 0x00,
  0x01, 0xF8, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38,
  0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x06, 0x00, 0x1C, 0x1C, 0x00,
  0xE0, 0x70, 0x07, 0x00, 0xF0, 0x78, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1C, 0x00, 0xF0, 0x30, 0x00, 0x70,
  0x60, 0x00, 0xE0, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0E,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x71, 0xC0,
  0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x1E, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80,
  0x3C, 0x0F, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x61, 0xC0,
  0x01, 0x86, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xC0, 0x00, 0x77, 0x00, 0x01,
  0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8,
  0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x38,
  0xE0, 0x00, 0xE1, 0x80, 0x07, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x3C,
  0x0F, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0xC0, 0x03, 0x07, 0x00, 0x0E, 0x38, 0x00, 0x1D, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1C, 0x00, 0xF0, 0x30, 0x00, 0x70, 0x60, 0x00, 0xE0, 0xC0, 0x00, 0xC3,
  0x80, 0x01, 0x87, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x38, 0x60, 0x00, 0x71, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00,
  0x1E, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x30, 0x38, 0x00, 0xE0, 0x30,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x01, 0xC0, 0x07, 0x03,
  0x80, 0x0E, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xE0, 0x3E, 0x03, 0x80, 0x0F,
  0x07, 0x00, 0x07, 0x0E, 0x00, 0x02, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x40, 0x00, 0x1C, 0x60, 0x00, 0x38, 0xF0, 0x00, 0x38,
  0x78, 0x00, 0x70, 0x3E, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x0E,
  0x18, 0x00, 0x1C, 0x30, 0x00, 0x30, 0xE0, 0x00, 0x61, 0xC0, 0x01, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x30, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xC1, 0xC0, 0x01, 0x81,
  0x80, 0x07, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x38, 0x07, 0x81, 0xE0, 0x07,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x63, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0x80, 0xC0, 0x07,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x18, 0x00, 0x60, 0x70, 0x00,
  0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x0C, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x38, 0x1C, 0x06, 0x1C, 0x0F, 0x03, 0x0C, 0x0F, 0x83,
  0x86, 0x06, 0xC1, 0xC3, 0x07, 0x60, 0xC1, 0x83, 0x30, 0x60, 0xC1, 0x98,
  0x70, 0x61, 0x8C, 0x38, 0x30, 0xC6, 0x18, 0x18, 0xE3, 0x0C, 0x0C, 0x61,
  0x8E, 0x0E, 0x30, 0xC7, 0x07, 0x30, 0x63, 0x03, 0x98, 0x39, 0x81, 0x9C,
  0x1D, 0xC0, 0xCC, 0x06, 0xE0, 0x66, 0x03, 0x60, 0x36, 0x01, 0xB0, 0x1B,
  0x00, 0xD8, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x01, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x06, 0x00,
  0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xC0,
  0x01, 0x80, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x9C, 0x00, 0x03, 0x86, 0x00,
  0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0x38,
  0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x01, 0x80, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x3F, 0xFC, 0x0F, 0xFE,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0C, 0xC0,
  0x00, 0x73, 0x80, 0x03, 0x86, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x30, 0x03,
  0x80, 0xC0, 0x1C, 0x03, 0x80, 0xE0, 0x06, 0x03, 0x00, 0x1C, 0x1C, 0x00,
  0x30, 0xE0, 0x00, 0xC7, 0x00, 0x03, 0x98, 0x00, 0x06, 0xE0, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x67, 0x1C, 0x63, 0x0C, 0x61, 0x01,
  0xF8, 0x30, 0x7F, 0xE3, 0x0F, 0x03, 0x71, 0xC0, 0x1F, 0x38, 0x00, 0xF3,
  0x80, 0x06, 0x70, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x3C, 0xE0, 0x03, 0x8E, 0x00,
  0x58, 0x70, 0x0D, 0x87, 0x83, 0x9F, 0x3F, 0xF1, 0xF0, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x0F, 0xC0, 0x38, 0xFF, 0x81, 0xDC, 0x1E, 0x0E, 0x80, 0x38,
  0x68, 0x01, 0xC3, 0x80, 0x06, 0x1C, 0x00, 0x31, 0xC0, 0x01, 0xCE, 0x00,
  0x0E, 0x70, 0x00, 0x73, 0x00, 0x03, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0xCE,
  0x00, 0x06, 0x70, 0x00, 0x73, 0x80, 0x03, 0x98, 0x00, 0x18, 0xC0, 0x01,
  0xC7, 0x00, 0x0C, 0x78, 0x00, 0xE3, 0xE0, 0x0E, 0x1D, 0x81, 0xE0, 0xC7,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x1E, 0x0F,
  0x07, 0x00, 0x71, 0xC0, 0x06, 0x30, 0x00, 0x8E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x4C, 0x00, 0x1D,
  0x80, 0x07, 0x38, 0x01, 0xC3, 0x80, 0x70, 0x38, 0x1C, 0x03, 0xFF, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x1F, 0xC3, 0x81, 0xFF, 0x8C, 0x0F,
  0x03, 0x30, 0x70, 0x02, 0xC1, 0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x70, 0x00,
  0x71, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3,
  0x80, 0x03, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x16,
  0x07, 0x00, 0xD8, 0x1E, 0x0E, 0x60, 0x3F, 0xF3, 0x80, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0x81, 0xE0, 0xE0, 0x06, 0x1C, 0x00,
  0x71, 0x80, 0x07, 0x38, 0x00, 0x73, 0x00, 0x07, 0x70, 0x00, 0x67, 0x00,
  0x0E, 0x60, 0x03, 0xC6, 0x07, 0xF0, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x06, 0x60, 0x00, 0xE7,
  0x00, 0x1C, 0x38, 0x03, 0x81, 0xC0, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x40, 0x1C, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x1C,
  0x0F, 0xFC, 0x60, 0x78, 0x19, 0x83, 0x80, 0x16, 0x1C, 0x00, 0x78, 0x70,
  0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0C, 0x30, 0x00, 0x31, 0xC0, 0x00,
  0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x71, 0x80, 0x01, 0x86,
  0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00,
  0x3E, 0x0E, 0x01, 0xB0, 0x3C, 0x0C, 0xC0, 0x7F, 0xE3, 0x00, 0x7E, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x20,
  0x00, 0xC0, 0xC0, 0x07, 0x03, 0xC0, 0x78, 0x07, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x7C, 0x06, 0x3F, 0xE1, 0xCC, 0x1C, 0x3B, 0x01, 0xC7, 0x80,
  0x18, 0xF0, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0xE0, 0x01, 0x9C, 0x00,
  0x33, 0x80, 0x0E, 0x60, 0x01, 0xCC, 0x00, 0x39, 0x80, 0x07, 0x70, 0x00,
  0xCE, 0x00, 0x19, 0xC0, 0x07, 0x30, 0x00, 0xE6, 0x00, 0x1C, 0xC0, 0x03,
  0x38, 0x00, 0x67, 0x00, 0x0C, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x40, 0x60, 0x1C, 0x0C, 0x07,
  0x03, 0x83, 0x80, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0x8E, 0x00, 0x37, 0x00,
  0x07, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x40, 0x0C, 0x06, 0x01, 0xC0, 0xF0, 0x1C, 0x03, 0x81, 0xC0, 0x1C,
  0x18, 0x00, 0xE1, 0x80, 0x07, 0x18, 0x00, 0x3B, 0x80, 0x01, 0xF0, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC1, 0xF0, 0x07, 0x1F, 0xF0, 0x1C,
  0xC1, 0xE0, 0x76, 0x03, 0x81, 0xE0, 0x07, 0x06, 0x80, 0x1C, 0x1C, 0x00,
  0x70, 0xE0, 0x01, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x30, 0x03, 0x80,
  0xC0, 0x3C, 0x03, 0x03, 0xC0, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xC3,
  0x80, 0x07, 0x0E, 0x00, 0xD8, 0x1C, 0x07, 0x60, 0x70, 0x39, 0x80, 0xE1,
  0xCE, 0x01, 0x8E, 0x38, 0x07, 0x70, 0xE0, 0x0F, 0x80, 0x00, 0x38, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x83, 0x80, 0xF0, 0xC0,
  0x70, 0x30, 0x38, 0x1C, 0x1C, 0x07, 0x1C, 0x01, 0xCE, 0x00, 0x67, 0x00,
  0x1F, 0x80, 0x03, 0x80, 0x00, 0x0C, 0x78, 0x3C, 0x0D, 0xFC, 0x7E, 0x1D,
  0x1C, 0x87, 0x1E, 0x0D, 0x07, 0x1C, 0x0D, 0x03, 0x1C, 0x0E, 0x03, 0x18,
  0x0E, 0x07, 0x18, 0x0C, 0x07, 0x38, 0x0C, 0x06, 0x38, 0x0C, 0x06, 0x30,
  0x1C, 0x06, 0x30, 0x1C, 0x06, 0x30, 0x18, 0x0E, 0x30, 0x18, 0x0E, 0x70,
  0x18, 0x0C, 0x70, 0x18, 0x0C, 0x60, 0x38, 0x0C, 0x60, 0x38, 0x0C, 0x60,
  0x30, 0x1C, 0x60, 0x30, 0x1C, 0xE0, 0x30, 0x18, 0xE0, 0x30, 0x18, 0xC0,
  0x70, 0x18, 0x0C, 0x1F, 0x01, 0x8F, 0xF8, 0x73, 0x07, 0x0E, 0xC0, 0x71,
  0xE0, 0x06, 0x3C, 0x00, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0x38, 0x00, 0x67,
  0x00, 0x0C, 0xE0, 0x03, 0x98, 0x00, 0x73, 0x00, 0x0E, 0x60, 0x01, 0xDC,
  0x00, 0x33, 0x80, 0x06, 0x70, 0x01, 0xCC, 0x00, 0x39, 0x80, 0x07, 0x30,
  0x00, 0xCE, 0x00, 0x19, 0xC0, 0x03, 0x38, 0x00, 0xE0, 0x00, 0xFE, 0x00,
  0x3F, 0xF8, 0x07, 0x83, 0xC0, 0xE0, 0x0E, 0x1C, 0x00, 0x63, 0x80, 0x07,
  0x30, 0x00, 0x37, 0x00, 0x03, 0x70, 0x00, 0x36, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0x60, 0x01, 0xC7, 0x00, 0x18, 0x30,
  0x03, 0x83, 0xC0, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0x0F, 0xC0,
  0x0E, 0x3F, 0xE0, 0x1D, 0xC1, 0xE0, 0x3A, 0x00, 0xE0, 0x68, 0x01, 0xC0,
  0xE0, 0x01, 0x81, 0xC0, 0x03, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xC3, 0x80,
  0x01, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x70, 0x70, 0x00, 0xC1, 0xE0, 0x03, 0x83, 0xE0, 0x0E, 0x07, 0x60, 0x78,
  0x0C, 0x7F, 0xE0, 0x18, 0x3F, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x38, 0x3F, 0xF1, 0x83, 0xC0,
  0xCC, 0x3C, 0x01, 0x61, 0x80, 0x0F, 0x1C, 0x00, 0x39, 0xC0, 0x01, 0xCE,
  0x00, 0x0C, 0x60, 0x00, 0x67, 0x00, 0x03, 0x38, 0x00, 0x39, 0xC0, 0x01,
  0xCE, 0x00, 0x0E, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x01, 0xC6, 0x00, 0x0E, 0x38, 0x00, 0xF1, 0xC0, 0x0B, 0x07, 0x00, 0xD8,
  0x3C, 0x1C, 0xC0, 0xFF, 0xCE, 0x01, 0xF8, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xC0, 0x66,
  0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01,
  0xE0, 0x3C, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x90, 0x00, 0x1C, 0xC0, 0x00, 0xCF, 0x80,
  0x0E, 0x1F, 0x01, 0xE0, 0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x04,
  0x07, 0x00, 0xF0, 0x38, 0x0E, 0x01, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0x63,
  0xC0, 0x03, 0x38, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x67,
  0x00, 0x0C, 0xE0, 0x03, 0x98, 0x00, 0x73, 0x00, 0x0E, 0x60, 0x01, 0x9C,
  0x00, 0x33, 0x80, 0x06, 0x70, 0x01, 0xCC, 0x00, 0x39, 0x80, 0x07, 0x30,
  0x00, 0xCE, 0x00, 0x19, 0xC0, 0x03, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xC0,
  0x03, 0x98, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x05, 0x8E, 0x01, 0x30, 0xF0,
  0xEE, 0x0F, 0xF9, 0xC0, 0xFC, 0x00, 0xFF, 0x00, 0x37, 0xF8, 0x03, 0x81,
  0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x83, 0x00, 0x1C, 0x18, 0x00,
  0xE0, 0xC0, 0x07, 0x0E, 0x00, 0x30, 0x70, 0x01, 0x83, 0x80, 0x1C, 0x18,
  0x00, 0xE0, 0xC0, 0x06, 0x06, 0x00, 0x70, 0x30, 0x03, 0x03, 0x80, 0x38,
  0x1C, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x03, 0xC0, 0x30, 0x3C, 0x01, 0x8F,
  0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x0E, 0x0C, 0x30, 0x18,
  0x18, 0x60, 0x30, 0x30, 0xC0, 0x60, 0x71, 0x80, 0xC0, 0x67, 0x01, 0x80,
  0xCE, 0x07, 0x01, 0x98, 0x0E, 0x03, 0x30, 0x18, 0x06, 0x60, 0x30, 0x0C,
  0xC0, 0x60, 0x1B, 0x80, 0xC0, 0x77, 0x03, 0x80, 0xEC, 0x07, 0x01, 0x98,
  0x0C, 0x03, 0x30, 0x18, 0x06, 0x60, 0x30, 0x1C, 0xC0, 0xE0, 0x33, 0x81,
  0xC0, 0xE7, 0x03, 0x81, 0x8E, 0x0B, 0x07, 0x0E, 0x37, 0x1C, 0x1F, 0xC7,
  0xF0, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x3E, 0x01, 0xF8, 0x3F, 0x83, 0xCC,
  0x30, 0xC3, 0x87, 0x30, 0x77, 0x81, 0x90, 0x39, 0x00, 0xD8, 0x0C, 0x00,
  0x68, 0x06, 0x00, 0x34, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x3E, 0x00,
  0x30, 0x13, 0x01, 0x98, 0x19, 0x83, 0xCC, 0x08, 0xC3, 0x87, 0x1C, 0x77,
  0x81, 0xFC, 0x1F, 0x80, 0x78, 0x07, 0x00, 0x07, 0x00, 0x0C, 0x1C, 0x00,
  0x30, 0x70, 0x01, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x60,
  0xE0, 0x01, 0x83, 0x80, 0x06, 0x0E, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0,
  0x03, 0x83, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x70, 0x00, 0xC1, 0xC0, 0x07,
  0x07, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xC0, 0x16, 0x07,
  0x00, 0x98, 0x0F, 0x0E, 0xE0, 0x1F, 0xF3, 0x80, 0x3F, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x10, 0x00, 0xE0,
  0x60, 0x07, 0x03, 0xE0, 0x78, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x0C, 0x1F, 0xFC, 0x30, 0xE0, 0xFF, 0xC7, 0x00, 0x7F, 0x18, 0x00,
  0x78, 0x60, 0x01, 0xC1, 0x80, 0x0E, 0x06, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x02, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x60, 0x38, 0x01,
  0xC1, 0xC0, 0x03, 0x1F, 0x80, 0x0C, 0x67, 0xE0, 0x31, 0x81, 0xFC, 0xCE,
  0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38,
  0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x06, 0x1F, 0xC0, 0x1C, 0x71,
  0x80, 0x31, 0xC1, 0x80, 0x63, 0x03, 0x81, 0x8C, 0x03, 0x87, 0x18, 0x03,
  0x1C, 0x70, 0x07, 0xF0, 0xC0, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_LightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 9, 31, 26, 9, -31 },
  { 36, 11, 12, 26, 10, -33 },
  { 53, 26, 31, 26, 1, -31 },
  { 154, 24, 40, 26, 1, -35 },
  { 274, 30, 32, 26, -1, -31 },
  { 394, 26, 32, 26, 0, -31 },
  { 498, 4, 12, 26, 14, -33 },
  { 504, 15, 39, 26, 10, -33 },
  { 578, 16, 39, 26, 2, -33 },
  { 656, 22, 22, 26, 3, -24 },
  { 717, 21, 22, 26, 3, -24 },
  { 775, 9, 12, 26, 6, -5 },
  { 789, 13, 2, 26, 7, -14 },
  { 793, 5, 5, 26, 9, -5 },
  { 797, 25, 39, 26, 1, -33 },
  { 919, 22, 32, 26, 3, -31 },
  { 1007, 21, 31, 26, 2, -31 },
  { 1089, 22, 31, 26, 2, -31 },
  { 1175, 23, 32, 26, 1, -31 },
  { 1267, 23, 31, 26, 1, -31 },
  { 1357, 23, 32, 26, 2, -31 },
  { 1449, 20, 32, 26, 3, -31 },
  { 1529, 21, 31, 26, 5, -31 },
  { 1611, 23, 32, 26, 2, -31 },
  { 1703, 20, 31, 26, 4, -31 },
  { 1781, 8, 24, 26, 9, -24 },
  { 1805, 11, 31, 26, 6, -24 },
  { 1848, 21, 25, 26, 4, -26 },
  { 1914, 23, 11, 26, 2, -19 },
  { 1946, 21, 25, 26, 2, -26 },
  { 2012, 18, 31, 26, 6, -31 },
  { 2082, 21, 36, 26, 3, -31 },
  { 2177, 23, 31, 26, 0, -31 },
  { 2267, 22, 31, 26, 2, -31 },
  { 2353, 21, 32, 26, 4, -31 },
  { 2437, 22, 31, 26, 3, -31 },
  { 2523, 24, 31, 26, 2, -31 },
  { 2616, 24, 31, 26, 2, -31 },
  { 2709, 22, 32, 26, 3, -31 },
  { 2797, 24, 31, 26, 2, -31 },
  { 2890, 24, 31, 26, 2, -31 },
  { 2983, 21, 32, 26, 3, -31 },
  { 3067, 26, 31, 26, 2, -31 },
  { 3168, 18, 31, 26, 4, -31 },
  { 3238, 25, 31, 26, 1, -31 },
  { 3335, 24, 31, 26, 2, -31 },
  { 3428, 22, 32, 26, 3, -31 },
  { 3516, 23, 31, 26, 2, -31 },
  { 3606, 22, 39, 26, 3, -31 },
  { 3714, 23, 31, 26, 2, -31 },
  { 3804, 24, 32, 26, 1, -31 },
  { 3900, 24, 31, 26, 4, -31 },
  { 3993, 23, 32, 26, 3, -31 },
  { 4085, 23, 31, 26, 5, -31 },
  { 4175, 25, 31, 26, 3, -31 },
  { 4272, 28, 31, 26, 0, -31 },
  { 4381, 25, 31, 26, 4, -31 },
  { 4478, 27, 31, 26, 0, -31 },
  { 4583, 18, 39, 26, 8, -33 },
  { 4671, 11, 39, 26, 8, -33 },
  { 4725, 18, 39, 26, 1, -33 },
  { 4813, 22, 17, 26, 3, -31 },
  { 4860, 21, 2, 26, 0, 5 },
  { 4866, 5, 8, 26, 10, -34 },
  { 4871, 20, 24, 26, 3, -23 },
  { 4931, 21, 34, 26, 3, -33 },
  { 5021, 19, 24, 26, 3, -23 },
  { 5078, 22, 34, 26, 3, -33 },
  { 5172, 20, 24, 26, 3, -23 },
  { 5232, 29, 42, 26, -1, -33 },
  { 5385, 22, 32, 26, 2, -23 },
  { 5473, 19, 33, 26, 3, -33 },
  { 5552, 19, 34, 26, 4, -33 },
  { 5633, 20, 42, 26, 3, -33 },
  { 5738, 22, 34, 26, 3, -33 },
  { 5832, 18, 34, 26, 5, -33 },
  { 5909, 24, 23, 26, 1, -23 },
  { 5978, 19, 23, 26, 3, -23 },
  { 6033, 20, 24, 26, 3, -23 },
  { 6093, 23, 32, 26, 1, -23 },
  { 6185, 21, 32, 26, 3, -23 },
  { 6269, 21, 23, 26, 5, -23 },
  { 6330, 21, 24, 26, 2, -23 },
  { 6393, 21, 32, 26, 3, -31 },
  { 6477, 19, 24, 26, 4, -23 },
  { 6534, 21, 23, 26, 3, -23 },
  { 6595, 23, 24, 26, 2, -23 },
  { 6664, 25, 24, 26, 1, -23 },
  { 6739, 22, 32, 26, 1, -23 },
  { 6827, 22, 24, 26, 2, -23 },
  { 6893, 20, 39, 26, 5, -33 },
  { 6991, 9, 39, 26, 9, -33 },
  { 7035, 20, 39, 26, 2, -33 },
  { 7133, 23, 9, 26, 2, -18 },
};

const GFXfont IBMPlexMono_LightItalic44pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic44pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic44pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _IBMPLEXMONO_LIGHTITALIC44PT7B_H_
