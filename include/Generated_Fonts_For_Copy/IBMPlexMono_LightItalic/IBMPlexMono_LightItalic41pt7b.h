#ifndef _IBMPLEXMONO_LIGHTITALIC41PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x1F, 0x07, 0x00, 0x38, 0x66,
  0x1C, 0xC3, 0x98, 0x63, 0x0C, 0xE1, 0x98, 0x33, 0x0E, 0x61, 0xCC, 0x33,
  0x86, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x60, 0x00,
  0x70, 0x60, 0x00, 0x60, 0x60, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x20,
  0xC0, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0xC1, 0x80, 0x01, 0x81, 0x80, 0x01,
  0x83, 0x00, 0x01, 0x83, 0x00, 0x03, 0x03, 0x00, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x1C, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x38, 0x00, 0x18,
  0x30, 0x00, 0x38, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xF1,
  0x9E, 0x03, 0x83, 0x0E, 0x0E, 0x04, 0x0E, 0x18, 0x18, 0x10, 0x30, 0x30,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x82, 0x00,
  0x07, 0x8C, 0x00, 0x07, 0xD8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xBE, 0x00, 0x01, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x40, 0x60, 0x01, 0x80, 0xC3, 0x03,
  0x03, 0x8E, 0x06, 0x06, 0x0F, 0x0C, 0x1C, 0x0F, 0x98, 0xF0, 0x07, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x1F, 0xE0, 0x0E, 0x03,
  0x86, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x03, 0x00, 0xC0, 0x30,
  0x30, 0x0C, 0x03, 0x06, 0x00, 0xC0, 0x30, 0xC0, 0x0C, 0x07, 0x1C, 0x00,
  0xC0, 0x61, 0x80, 0x0C, 0x0E, 0x30, 0x00, 0xE1, 0xC6, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x0E, 0x38, 0x60, 0x00, 0xC6, 0x03, 0x00, 0x18,
  0x60, 0x30, 0x03, 0x0C, 0x03, 0x00, 0x30, 0xC0, 0x30, 0x06, 0x0C, 0x03,
  0x00, 0xC0, 0xC0, 0x30, 0x1C, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x06, 0x1C, 0x06, 0x00, 0x7F, 0x80, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xE1, 0xE0, 0x01, 0x80, 0x60, 0x03, 0x80,
  0x70, 0x03, 0x80, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x03, 0x80,
  0x70, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0xC0, 0xE0, 0x00, 0xC1,
  0xC0, 0x03, 0xE7, 0x80, 0x0F, 0x7E, 0x00, 0x38, 0x70, 0x00, 0x30, 0x38,
  0x00, 0x60, 0x18, 0x00, 0x60, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0xE0, 0x07, 0x03, 0xE0, 0x07, 0x86, 0x60, 0x09,
  0x86, 0x70, 0x19, 0xCC, 0x38, 0x30, 0xDC, 0x3F, 0xE0, 0xF8, 0x0F, 0xC0,
  0x70, 0x77, 0x66, 0x66, 0xEC, 0xCC, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0E,
  0x06, 0x07, 0xFE, 0x31, 0xF8, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0xCC, 0x00, 0x0E, 0x70, 0x00, 0xE1, 0x80, 0x0E,
  0x06, 0x00, 0xE0, 0x30, 0x0E, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x1E,
  0x1C, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x60, 0x60, 0xC0, 0xFF, 0xFF, 0xFC,
  0x7B, 0xFE, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0x81, 0xC0, 0xE0, 0x0E,
  0x0C, 0x00, 0x61, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x03, 0x30, 0x00,
  0x37, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0xE0, 0x70, 0x7E, 0x0F,
  0x07, 0xE0, 0xF0, 0x7E, 0x0E, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8E,
  0x00, 0x38, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0x38, 0x1C, 0x01, 0xFF, 0x80,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xD8, 0x00, 0xF3,
  0x00, 0x3C, 0xE0, 0x0E, 0x1C, 0x03, 0x83, 0x81, 0xE0, 0x60, 0x18, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x70, 0x3C, 0x07, 0x00, 0xE0, 0x70,
  0x03, 0x87, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xF0,
  0x3C, 0x0E, 0x00, 0x70, 0x60, 0x03, 0x81, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x84, 0x00, 0x1C, 0xE0, 0x01, 0xC3, 0x80,
  0x1E, 0x0F, 0x01, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0x60, 0x00, 0x37, 0x00,
  0x03, 0x38, 0x00, 0x31, 0x80, 0x03, 0x8C, 0x00, 0x38, 0x60, 0x03, 0x83,
  0x00, 0x18, 0x38, 0x01, 0x81, 0xC0, 0x18, 0x0C, 0x01, 0xC0, 0x60, 0x1C,
  0x03, 0x01, 0xC0, 0x18, 0x0C, 0x01, 0xC0, 0xC0, 0x0E, 0x0E, 0x00, 0x60,
  0xE0, 0x03, 0x0E, 0x00, 0x18, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0xFC, 0x01, 0x9F,
  0xF8, 0x0D, 0x81, 0xE0, 0x70, 0x07, 0x01, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x88, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80, 0x1C, 0x0F,
  0x03, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x7E,
  0x03, 0x3F, 0xF0, 0xEC, 0x0F, 0x1A, 0x00, 0x73, 0x80, 0x0E, 0xF0, 0x00,
  0xDC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0D, 0x80, 0x01,
  0xB0, 0x00, 0x76, 0x00, 0x0C, 0xE0, 0x03, 0x8E, 0x00, 0xE0, 0xE0, 0x78,
  0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x70, 0x00,
  0x76, 0x00, 0x06, 0x60, 0x00, 0xE6, 0x00, 0x1C, 0x60, 0x01, 0xC6, 0x00,
  0x38, 0x80, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00,
  0xF0, 0x3C, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x86, 0x00, 0x0C, 0x70, 0x00,
  0x63, 0x80, 0x03, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0x83, 0x00, 0x1C, 0x1C,
  0x01, 0xC0, 0x70, 0x1C, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xC0, 0x78,
  0x38, 0x00, 0xE3, 0x80, 0x03, 0x18, 0x00, 0x19, 0xC0, 0x00, 0xEE, 0x00,
  0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xC3,
  0x80, 0x1E, 0x1F, 0x03, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0xE0, 0x38, 0x1E, 0x1E, 0x00, 0xE3, 0x00, 0x0C, 0xE0,
  0x01, 0x98, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0x9C, 0x01, 0xF3, 0xC0,
  0xEC, 0x3F, 0xFB, 0x81, 0xFC, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x1F, 0x1F, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x78, 0xF8, 0x70, 0x03, 0xC1, 0xF0, 0x7C, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xD0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xFE,
  0x0F, 0x07, 0x8E, 0x00, 0xEE, 0x00, 0x37, 0x00, 0x1B, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x03, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x61, 0xC0,
  0x06, 0x18, 0x00, 0x71, 0x80, 0x03, 0x30, 0x1E, 0x73, 0x07, 0xF6, 0x30,
  0xE1, 0xE7, 0x0C, 0x0E, 0x61, 0xC0, 0x66, 0x18, 0x06, 0x61, 0x80, 0x66,
  0x38, 0x0E, 0xE3, 0x80, 0xCC, 0x30, 0x0C, 0xC3, 0x00, 0xCC, 0x30, 0x0C,
  0xC3, 0x01, 0xCC, 0x30, 0x1C, 0xC3, 0x83, 0x8C, 0x1C, 0xD8, 0xC1, 0xF9,
  0x8C, 0x02, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0xDC,
  0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03,
  0x86, 0x00, 0x18, 0x38, 0x01, 0xC1, 0xC0, 0x0C, 0x06, 0x00, 0xE0, 0x30,
  0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0x60, 0x38, 0x03, 0x81, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x70, 0x00, 0xC3,
  0x00, 0x06, 0x38, 0x00, 0x39, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x0E, 0x00, 0xE0,
  0xE0, 0x07, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x1C, 0x00, 0x31, 0xC0, 0x07, 0x1C, 0x00, 0x61, 0x80, 0x0E, 0x18, 0x01,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0x80, 0x1C, 0x38, 0x00, 0xE3, 0x00,
  0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x70, 0x00, 0x67, 0x00, 0x06, 0x70,
  0x00, 0x66, 0x00, 0x0E, 0x60, 0x00, 0xC6, 0x00, 0x1C, 0xE0, 0x07, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xC1,
  0xE0, 0x70, 0x06, 0x0E, 0x00, 0x70, 0xC0, 0x03, 0x1C, 0x00, 0x21, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x08,
  0x60, 0x00, 0xC6, 0x00, 0x1C, 0x70, 0x03, 0x83, 0x80, 0x70, 0x3C, 0x0E,
  0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01,
  0x80, 0x78, 0x0C, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x18, 0x38, 0x00,
  0xE1, 0x80, 0x07, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x38,
  0x00, 0x71, 0xC0, 0x03, 0x8C, 0x00, 0x1C, 0x60, 0x00, 0xE3, 0x00, 0x07,
  0x38, 0x00, 0x31, 0xC0, 0x01, 0x8E, 0x00, 0x1C, 0x60, 0x00, 0xE3, 0x00,
  0x06, 0x18, 0x00, 0x71, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x83,
  0x00, 0x38, 0x18, 0x07, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x03, 0xC1, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0x71, 0xC0, 0x03, 0x18, 0x00,
  0x23, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0xFE, 0xE0,
  0x3F, 0xEE, 0x00, 0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xCE,
  0x00, 0x1C, 0xE0, 0x01, 0xC6, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x58,
  0x3C, 0x19, 0x81, 0xFF, 0x38, 0x07, 0xE3, 0x80, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x60, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x60, 0x00, 0xC1,
  0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x70, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x60, 0xC0, 0x01, 0x80, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x10, 0x01, 0xC6, 0x00, 0x30, 0xC0, 0x0E, 0x1C,
  0x03, 0x81, 0xC0, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x06, 0x00, 0x0F,
  0x06, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x70, 0x00, 0x18, 0xF0, 0x00,
  0x19, 0xF0, 0x00, 0x3B, 0xB8, 0x00, 0x3F, 0x38, 0x00, 0x3E, 0x18, 0x00,
  0x3C, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x60, 0x03, 0x80, 0x60, 0x01, 0x80,
  0x60, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0x61, 0xB0, 0x0F, 0xC3, 0x30, 0x1B, 0x06, 0x60, 0x66, 0x0C, 0xC1, 0xCC,
  0x39, 0xC3, 0x18, 0x71, 0x8E, 0x30, 0xC3, 0x18, 0xE1, 0x86, 0x61, 0x83,
  0x0E, 0xC3, 0x06, 0x0F, 0x06, 0x0C, 0x1E, 0x0C, 0x38, 0x38, 0x18, 0x60,
  0x60, 0x70, 0xC0, 0x40, 0xC1, 0x81, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x1C, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0C, 0x3E, 0x00, 0x70, 0xF8, 0x01, 0xC3, 0x60, 0x06, 0x0D, 0x80, 0x18,
  0x37, 0x00, 0x60, 0xCC, 0x01, 0x87, 0x30, 0x0E, 0x18, 0xC0, 0x38, 0x63,
  0x80, 0xC1, 0x86, 0x03, 0x06, 0x18, 0x0C, 0x18, 0x70, 0x30, 0xE0, 0xC0,
  0xC3, 0x03, 0x07, 0x0C, 0x0C, 0x18, 0x30, 0x38, 0x60, 0xC0, 0x61, 0x83,
  0x01, 0x86, 0x1C, 0x06, 0x18, 0x60, 0x1C, 0xE1, 0x80, 0x33, 0x06, 0x00,
  0xCC, 0x18, 0x03, 0x30, 0x60, 0x06, 0xC3, 0x80, 0x1B, 0x0E, 0x00, 0x7C,
  0x30, 0x01, 0xE0, 0xC0, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07,
  0x81, 0xC0, 0xE0, 0x0E, 0x0C, 0x00, 0x61, 0xC0, 0x07, 0x38, 0x00, 0x73,
  0x80, 0x03, 0x30, 0x00, 0x37, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00,
  0x1C, 0xC0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0x38,
  0x1C, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x60, 0x07, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x70,
  0xC0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x70, 0x00, 0x61, 0xC0,
  0x01, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x70, 0x60, 0x03, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0x81, 0xC0, 0xE0,
  0x0E, 0x0C, 0x00, 0x61, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x03, 0x30,
  0x00, 0x37, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01,
  0x8E, 0x00, 0x38, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0x38, 0x1C, 0x01, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x40, 0x06, 0x0E, 0x00,
  0x71, 0xC0, 0x03, 0x30, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x60, 0x07, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x18, 0x30,
  0x00, 0x70, 0xC0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x70, 0x00,
  0x61, 0xC0, 0x01, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x70, 0x60, 0x03, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x38, 0x38, 0x00, 0xC0, 0x60, 0x03, 0x01,
  0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60,
  0x1C, 0x01, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0E, 0x06, 0x00, 0x38, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F,
  0x01, 0xE0, 0x38, 0x00, 0xE0, 0xE0, 0x00, 0xE1, 0x80, 0x01, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x38, 0xE0, 0x00, 0x60, 0xF0, 0x01, 0xC0, 0xF8, 0x0F, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00,
  0x71, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x0E, 0x38,
  0x00, 0x71, 0xC0, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06,
  0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x80,
  0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x03, 0x80, 0x38, 0x1E, 0x07, 0x80,
  0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xB0,
  0x00, 0x1D, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x30, 0x00, 0x61, 0x80, 0x07,
  0x0C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x00, 0x18, 0x1C, 0x01, 0xC0, 0xE0,
  0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x80,
  0x30, 0x18, 0x01, 0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0x86,
  0x00, 0x0C, 0x70, 0x00, 0x63, 0x00, 0x03, 0x38, 0x00, 0x19, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x07, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x06, 0x38,
  0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x38, 0x1C, 0x30, 0x38, 0x18, 0x30, 0x38, 0x18, 0x30, 0x6C, 0x18, 0x30,
  0x6C, 0x38, 0x30, 0xCC, 0x30, 0x30, 0xCC, 0x30, 0x30, 0xCC, 0x30, 0x71,
  0x8C, 0x30, 0x61, 0x8C, 0x60, 0x63, 0x0C, 0x60, 0x63, 0x0C, 0x60, 0x67,
  0x0C, 0x60, 0x66, 0x0C, 0xC0, 0x66, 0x0C, 0xC0, 0x6C, 0x06, 0xC0, 0x6C,
  0x06, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0,
  0x07, 0x80, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0x81, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x0E, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x81, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x06,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x39, 0x80, 0x00, 0xE3, 0x80, 0x03,
  0x83, 0x00, 0x06, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x30, 0xE0, 0x00,
  0x71, 0x80, 0x00, 0x67, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x08, 0x03,
  0x00, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x06, 0x60, 0x00, 0xC7, 0x00, 0x1C, 0x30,
  0x03, 0x83, 0x00, 0x30, 0x38, 0x06, 0x01, 0x80, 0xE0, 0x1C, 0x1C, 0x00,
  0xC1, 0x80, 0x0C, 0x30, 0x00, 0x67, 0x00, 0x06, 0xE0, 0x00, 0x74, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x66, 0x33, 0x10, 0x03, 0xF0,
  0xE1, 0xFF, 0x9C, 0x78, 0x1B, 0x1E, 0x01, 0xE3, 0x00, 0x1C, 0xE0, 0x03,
  0x98, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x07, 0x30, 0x00, 0xC6, 0x00, 0x38,
  0xC0, 0x0B, 0x1C, 0x03, 0x61, 0xC0, 0xDC, 0x1F, 0xF3, 0xF1, 0xF8, 0x3C,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x0F, 0xC0,
  0x63, 0xFE, 0x0C, 0xC1, 0xE1, 0xA0, 0x1C, 0x78, 0x01, 0xCE, 0x00, 0x39,
  0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0xB8, 0x00, 0x77,
  0x00, 0x0E, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x0E, 0x60, 0x01, 0x9C,
  0x00, 0x73, 0x40, 0x1C, 0x6E, 0x0F, 0x0C, 0xFF, 0xC1, 0x87, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xF0, 0x78, 0x70, 0x06, 0x38, 0x01, 0xCC,
  0x00, 0x47, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x19, 0x80, 0x0E,
  0x60, 0x07, 0x1C, 0x03, 0x83, 0xC1, 0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x1F, 0xC3, 0x01, 0xFF, 0x38, 0x3C, 0x0D, 0xC3, 0xC0, 0x1C, 0x1C, 0x00,
  0xE1, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0E,
  0x18, 0x00, 0x70, 0xC0, 0x07, 0x07, 0x00, 0x78, 0x38, 0x06, 0xC0, 0xE0,
  0x66, 0x03, 0xFE, 0x70, 0x0F, 0xC3, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0xF0, 0x3C, 0x70, 0x07, 0x18, 0x00, 0xCC, 0x00, 0x37, 0x00, 0x0D, 0x80,
  0x07, 0x60, 0x07, 0xB8, 0x1F, 0xCF, 0xFF, 0x83, 0xFE, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x13, 0x80, 0x07, 0x60, 0x03, 0x9C, 0x01, 0xC3,
  0xC1, 0xE0, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00,
  0x38, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x30, 0x3F, 0xE7, 0x0F, 0x03, 0x70,
  0xC0, 0x1E, 0x1C, 0x00, 0xE3, 0x80, 0x06, 0x30, 0x00, 0x67, 0x00, 0x0E,
  0x70, 0x00, 0xE6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00,
  0xC6, 0x00, 0x1C, 0x60, 0x01, 0xC6, 0x00, 0x38, 0x70, 0x07, 0x87, 0x00,
  0xD8, 0x3C, 0x19, 0x81, 0xFF, 0x38, 0x0F, 0xC3, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x0C, 0x00, 0xE0, 0xF0, 0x3C, 0x07,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x0F, 0x81, 0xCF, 0xF0, 0x66, 0x0E, 0x1B, 0x01, 0xC6, 0x80,
  0x73, 0xC0, 0x0C, 0xE0, 0x03, 0x38, 0x01, 0xCC, 0x00, 0x73, 0x00, 0x1C,
  0xC0, 0x06, 0x70, 0x01, 0x9C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0E, 0x60,
  0x03, 0x18, 0x00, 0xCE, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x07, 0x30, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x04,
  0x18, 0x0E, 0x0C, 0x0E, 0x06, 0x0E, 0x03, 0x1E, 0x03, 0x9C, 0x01, 0x9C,
  0x00, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x40, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x10, 0x06,
  0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x30, 0x07, 0x0C, 0x00, 0xE3, 0x00,
  0x1C, 0xC0, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC3, 0xE0, 0x18, 0xFF, 0x81, 0x98,
  0x3C, 0x1B, 0x01, 0xC1, 0xC0, 0x0C, 0x3C, 0x00, 0xC3, 0x80, 0x1C, 0x38,
  0x01, 0x83, 0x00, 0x38, 0x30, 0x0E, 0x07, 0x03, 0xC0, 0x71, 0xE0, 0x07,
  0x38, 0x00, 0x61, 0xC0, 0x06, 0x0C, 0x03, 0x60, 0xE0, 0x7E, 0x06, 0x0E,
  0xE0, 0x71, 0xCC, 0x03, 0x38, 0xC0, 0x3E, 0x0C, 0x01, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x02, 0x1C, 0x07, 0x1C, 0x1E, 0x18, 0x38,
  0x18, 0x70, 0x19, 0xE0, 0x3B, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x1C, 0xF0,
  0xF8, 0x67, 0xE7, 0xF1, 0xA1, 0xB1, 0xC7, 0x06, 0x83, 0x1C, 0x1C, 0x0C,
  0x60, 0x70, 0x33, 0x81, 0x80, 0xCC, 0x06, 0x03, 0x30, 0x18, 0x1C, 0xC0,
  0x60, 0x63, 0x03, 0x81, 0x8C, 0x0C, 0x06, 0x70, 0x30, 0x19, 0x80, 0xC0,
  0x66, 0x03, 0x03, 0x98, 0x0C, 0x0C, 0x60, 0x70, 0x31, 0x81, 0x80, 0xCE,
  0x06, 0x03, 0x30, 0x18, 0x0C, 0xC0, 0x60, 0x70, 0x1C, 0x3E, 0x07, 0x3F,
  0xC1, 0x98, 0x38, 0x6C, 0x07, 0x1A, 0x01, 0xCF, 0x00, 0x33, 0x80, 0x0C,
  0xE0, 0x07, 0x30, 0x01, 0xCC, 0x00, 0x73, 0x00, 0x19, 0xC0, 0x06, 0x70,
  0x01, 0x98, 0x00, 0x66, 0x00, 0x39, 0x80, 0x0C, 0x60, 0x03, 0x38, 0x00,
  0xCE, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x07, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x3C, 0x1E, 0x0E, 0x00, 0xE3, 0x80, 0x0C, 0x60, 0x01, 0x9C, 0x00,
  0x3B, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x6C, 0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00, 0x66, 0x00, 0x1C, 0x60, 0x03,
  0x0E, 0x00, 0xE0, 0xE0, 0x78, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x06, 0x1F,
  0x80, 0x31, 0xFF, 0x01, 0x98, 0x3C, 0x0D, 0x00, 0xE0, 0xF0, 0x03, 0x87,
  0x00, 0x1C, 0x38, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60,
  0x01, 0xC3, 0x00, 0x0C, 0x38, 0x00, 0xE1, 0xA0, 0x0E, 0x0D, 0xC1, 0xE0,
  0x67, 0xFE, 0x03, 0x0F, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x60, 0xFF, 0x9C, 0x78, 0x1B, 0x9E, 0x00,
  0xE3, 0x80, 0x1C, 0xE0, 0x01, 0x98, 0x00, 0x37, 0x00, 0x0E, 0xE0, 0x01,
  0xD8, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x07,
  0x30, 0x00, 0xE6, 0x00, 0x38, 0xE0, 0x0B, 0x1C, 0x03, 0x61, 0xC0, 0xCC,
  0x1F, 0xF3, 0x81, 0xF8, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0xFF, 0x8F, 0xFF, 0xE3, 0xFC, 0x0C, 0xC0, 0x01, 0xA0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0x01, 0xE0, 0xC0, 0x07,
  0x1C, 0x00, 0x41, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0xCF, 0x00, 0x1C, 0x7C,
  0x07, 0x81, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x01, 0x81,
  0x80, 0xF0, 0x30, 0x38, 0x06, 0x1E, 0x01, 0xC7, 0x00, 0x3B, 0xC0, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x01, 0xCC, 0x00, 0x73, 0x00, 0x19, 0xC0,
  0x06, 0x70, 0x01, 0x98, 0x00, 0xE6, 0x00, 0x39, 0x80, 0x0C, 0x60, 0x03,
  0x38, 0x00, 0xCE, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x07, 0x30, 0x01, 0x8C,
  0x00, 0xE3, 0x00, 0x58, 0xC0, 0x16, 0x38, 0x0B, 0x8F, 0x0E, 0xE1, 0xFF,
  0x30, 0x1F, 0x0C, 0x00, 0xFE, 0x00, 0xDF, 0xC0, 0x18, 0x18, 0x03, 0x83,
  0x00, 0x30, 0xE0, 0x06, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x07, 0x0C,
  0x00, 0xE1, 0x80, 0x18, 0x30, 0x03, 0x0E, 0x00, 0xE1, 0x80, 0x18, 0x30,
  0x07, 0x06, 0x01, 0xC0, 0xC0, 0x38, 0x18, 0x1E, 0x07, 0x07, 0x80, 0xE3,
  0xC0, 0x1F, 0xF0, 0x01, 0xF0, 0x00, 0x18, 0x1C, 0x30, 0xC0, 0xC1, 0xC6,
  0x06, 0x06, 0x60, 0x30, 0x33, 0x01, 0x81, 0x98, 0x0C, 0x0C, 0xC0, 0xC0,
  0x66, 0x06, 0x03, 0x30, 0x30, 0x1B, 0x01, 0x80, 0xD8, 0x0C, 0x06, 0xC0,
  0xE0, 0x36, 0x06, 0x03, 0xB0, 0x30, 0x1B, 0x81, 0x80, 0xD8, 0x0C, 0x0E,
  0xC0, 0xE0, 0x66, 0x0B, 0x07, 0x38, 0xDC, 0x70, 0xFC, 0x7F, 0x03, 0xC1,
  0xE0, 0x00, 0x01, 0xC0, 0x78, 0x0F, 0xC3, 0xF8, 0x3D, 0xCE, 0x39, 0xE1,
  0x90, 0x37, 0x03, 0x60, 0x68, 0x06, 0x80, 0xC0, 0x0D, 0x01, 0x80, 0x1C,
  0x03, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x14, 0x00, 0x60, 0x2C, 0x04,
  0xC0, 0x98, 0x3D, 0x83, 0x30, 0xE3, 0x8C, 0x77, 0x83, 0xF8, 0x7C, 0x03,
  0xC0, 0xF0, 0x00, 0x06, 0x00, 0x38, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x1C,
  0x00, 0x60, 0xE0, 0x03, 0x06, 0x00, 0x38, 0x30, 0x01, 0xC1, 0x80, 0x0C,
  0x0C, 0x00, 0x60, 0xE0, 0x03, 0x07, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80,
  0x0E, 0x0C, 0x00, 0x60, 0x60, 0x07, 0x03, 0x00, 0x58, 0x18, 0x02, 0xC0,
  0xE0, 0x2E, 0x03, 0x83, 0x70, 0x1F, 0xF3, 0x00, 0x3E, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x03, 0x00, 0x70, 0x3C,
  0x07, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x38, 0x7F,
  0xF1, 0x87, 0x03, 0xEC, 0x30, 0x03, 0xE3, 0x80, 0x0E, 0x18, 0x00, 0xE0,
  0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x08, 0x03, 0x80, 0x60, 0x38, 0x03, 0x03,
  0x80, 0x18, 0x30, 0x00, 0xC3, 0xFC, 0x03, 0x3B, 0xFF, 0x19, 0xC3, 0xFF,
  0xCC, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0x07, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60,
  0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x70, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x00, 0x07, 0x80, 0x18, 0xFE, 0x00, 0xCE, 0x38, 0x0E, 0x60, 0xE0, 0x66,
  0x03, 0x06, 0x30, 0x1C, 0x73, 0x00, 0x7F, 0x18, 0x01, 0xF0,
};

const GFXglyph IBMPlexMono_LightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 9, 29, 25, 8, -29 },
  { 34, 11, 11, 25, 9, -30 },
  { 50, 24, 29, 25, 1, -29 },
  { 137, 23, 37, 25, 1, -33 },
  { 244, 28, 29, 25, -1, -29 },
  { 346, 24, 29, 25, 0, -29 },
  { 433, 4, 11, 25, 13, -30 },
  { 439, 14, 37, 25, 9, -31 },
  { 504, 14, 37, 25, 2, -31 },
  { 569, 21, 20, 25, 2, -22 },
  { 622, 19, 20, 25, 3, -23 },
  { 670, 8, 11, 25, 6, -5 },
  { 681, 11, 2, 25, 7, -13 },
  { 684, 5, 4, 25, 8, -4 },
  { 687, 23, 37, 25, 1, -31 },
  { 794, 20, 29, 25, 3, -29 },
  { 867, 19, 29, 25, 2, -29 },
  { 936, 21, 29, 25, 1, -29 },
  { 1013, 21, 29, 25, 1, -29 },
  { 1090, 21, 29, 25, 1, -29 },
  { 1167, 21, 29, 25, 2, -29 },
  { 1244, 19, 29, 25, 3, -29 },
  { 1313, 20, 29, 25, 4, -29 },
  { 1386, 21, 29, 25, 2, -29 },
  { 1463, 19, 29, 25, 4, -29 },
  { 1532, 8, 21, 25, 8, -21 },
  { 1553, 10, 27, 25, 6, -21 },
  { 1587, 19, 23, 25, 4, -24 },
  { 1642, 21, 9, 25, 2, -17 },
  { 1666, 20, 23, 25, 2, -24 },
  { 1724, 17, 29, 25, 6, -29 },
  { 1786, 20, 34, 25, 3, -29 },
  { 1871, 21, 29, 25, 0, -29 },
  { 1948, 20, 29, 25, 2, -29 },
  { 2021, 20, 29, 25, 3, -29 },
  { 2094, 21, 29, 25, 2, -29 },
  { 2171, 22, 29, 25, 2, -29 },
  { 2251, 23, 29, 25, 2, -29 },
  { 2335, 20, 29, 25, 3, -29 },
  { 2408, 22, 29, 25, 2, -29 },
  { 2488, 22, 29, 25, 2, -29 },
  { 2568, 19, 29, 25, 3, -29 },
  { 2637, 24, 29, 25, 2, -29 },
  { 2724, 16, 29, 25, 4, -29 },
  { 2782, 23, 29, 25, 1, -29 },
  { 2866, 22, 29, 25, 2, -29 },
  { 2946, 20, 29, 25, 3, -29 },
  { 3019, 22, 29, 25, 2, -29 },
  { 3099, 20, 36, 25, 3, -29 },
  { 3189, 22, 29, 25, 2, -29 },
  { 3269, 23, 29, 25, 1, -29 },
  { 3353, 22, 29, 25, 4, -29 },
  { 3433, 21, 29, 25, 3, -29 },
  { 3510, 21, 29, 25, 5, -29 },
  { 3587, 24, 29, 25, 2, -29 },
  { 3674, 26, 29, 25, 0, -29 },
  { 3769, 23, 29, 25, 4, -29 },
  { 3853, 25, 29, 25, 0, -29 },
  { 3944, 17, 37, 25, 7, -31 },
  { 4023, 10, 37, 25, 8, -31 },
  { 4070, 17, 37, 25, 1, -31 },
  { 4149, 20, 16, 25, 3, -29 },
  { 4189, 20, 2, 25, 0, 4 },
  { 4194, 4, 7, 25, 10, -31 },
  { 4198, 19, 21, 25, 3, -21 },
  { 4248, 19, 30, 25, 3, -30 },
  { 4320, 18, 21, 25, 3, -21 },
  { 4368, 21, 30, 25, 3, -30 },
  { 4447, 18, 21, 25, 3, -21 },
  { 4495, 27, 38, 25, -1, -30 },
  { 4624, 20, 29, 25, 2, -21 },
  { 4697, 18, 30, 25, 3, -30 },
  { 4765, 17, 30, 25, 4, -30 },
  { 4829, 18, 38, 25, 3, -30 },
  { 4915, 20, 30, 25, 3, -30 },
  { 4990, 16, 30, 25, 5, -30 },
  { 5050, 22, 21, 25, 1, -21 },
  { 5108, 18, 21, 25, 3, -21 },
  { 5156, 19, 21, 25, 3, -21 },
  { 5206, 21, 29, 25, 1, -21 },
  { 5283, 19, 29, 25, 3, -21 },
  { 5352, 19, 21, 25, 5, -21 },
  { 5402, 20, 21, 25, 2, -21 },
  { 5455, 19, 29, 25, 3, -29 },
  { 5524, 18, 21, 25, 4, -21 },
  { 5572, 19, 21, 25, 3, -21 },
  { 5622, 21, 21, 25, 2, -21 },
  { 5678, 23, 21, 25, 1, -21 },
  { 5739, 21, 29, 25, 1, -21 },
  { 5816, 21, 21, 25, 2, -21 },
  { 5872, 19, 37, 25, 5, -31 },
  { 5960, 8, 37, 25, 9, -31 },
  { 5997, 19, 37, 25, 2, -31 },
  { 6085, 21, 8, 25, 2, -17 },
};

const GFXfont IBMPlexMono_LightItalic41pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic41pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic41pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _IBMPLEXMONO_LIGHTITALIC41PT7B_H_
