#ifndef _IBMPLEXMONO_LIGHTITALIC31PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0x81,
  0x02, 0x04, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x0E, 0x00, 0x63, 0x63, 0x63,
  0x63, 0x42, 0x46, 0xC6, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x01, 0x84,
  0x00, 0x21, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00, 0x21, 0x80, 0xFC, 0x3F,
  0x1F, 0x87, 0xE0, 0x21, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00, 0x21, 0x80,
  0xFC, 0x3F, 0x1F, 0x87, 0xE4, 0x21, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00,
  0x21, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00, 0x61, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x73, 0x38, 0x61,
  0x8E, 0x30, 0xC2, 0x30, 0x40, 0x18, 0x20, 0x06, 0x10, 0x03, 0x18, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0x38, 0x00, 0x86, 0x00, 0xC3,
  0x00, 0x61, 0x80, 0x20, 0xCC, 0x10, 0x67, 0x08, 0x61, 0xCC, 0xF0, 0x7F,
  0xF0, 0x0F, 0xE0, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x03, 0xC0,
  0x18, 0x3F, 0x81, 0x83, 0x0C, 0x08, 0x10, 0x20, 0xC1, 0x81, 0x0C, 0x0C,
  0x08, 0x40, 0x60, 0xC6, 0x03, 0x06, 0x60, 0x18, 0x66, 0x00, 0x7E, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x01, 0xDC, 0x60, 0x08,
  0xC1, 0x00, 0xC4, 0x08, 0x0C, 0x60, 0x40, 0x43, 0x02, 0x06, 0x18, 0x30,
  0x60, 0x63, 0x06, 0x03, 0xF8, 0x60, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x70, 0xE0, 0x18, 0x18, 0x04, 0x06, 0x01, 0x01, 0x80, 0x40, 0x60,
  0x18, 0x18, 0x02, 0x0C, 0x00, 0xC7, 0x01, 0xFF, 0x80, 0xE7, 0x80, 0x60,
  0x80, 0x18, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x70, 0x14,
  0x3C, 0x05, 0x99, 0x83, 0x36, 0x3F, 0x8F, 0x07, 0xC1, 0x80, 0x69, 0x6D,
  0xB4, 0x00, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x80, 0x30, 0x06, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x06,
  0x02, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xC1, 0x82, 0xF9, 0xBF, 0x1F, 0xF0, 0x03, 0x80, 0x07, 0x80, 0x0C,
  0xC0, 0x18, 0xC0, 0x38, 0x60, 0x30, 0x20, 0x60, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF,
  0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x39, 0xCC, 0xE6, 0x33, 0x18, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0x70, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x38, 0x30, 0xC0, 0x33, 0x00, 0x66,
  0x00, 0x58, 0x00, 0xB0, 0x01, 0x60, 0x02, 0xC0, 0x0F, 0x06, 0x1E, 0x1C,
  0x3C, 0x38, 0x78, 0x00, 0xF0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x31,
  0x80, 0xE3, 0x83, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x01, 0xE0,
  0x0E, 0xC0, 0x39, 0x80, 0xE3, 0x03, 0x84, 0x0E, 0x18, 0x08, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x0C, 0x07, 0x18, 0x03,
  0x18, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x01, 0xF8,
  0x07, 0xFE, 0x0E, 0x0E, 0x0C, 0x07, 0x18, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x1C, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x40, 0x0C, 0xE0, 0x1C,
  0x70, 0x38, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x36, 0x00, 0x64, 0x00, 0xC4, 0x01, 0x8C, 0x03, 0x0C, 0x02, 0x0C,
  0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x18, 0x60, 0x18, 0x40, 0x18,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x0F, 0xFE, 0x1F, 0xFC, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x33, 0xE0, 0x7F, 0xE0, 0xE0, 0xE1, 0x80,
  0xE4, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0D, 0x00, 0x33,
  0x00, 0xE3, 0x83, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x33, 0xE0,
  0xBF, 0xE7, 0x83, 0xDC, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x66, 0x01, 0x9C, 0x1C, 0x3F, 0xE0, 0x7E, 0x00, 0x7F,
  0xFE, 0xFF, 0xFD, 0x80, 0x1B, 0x00, 0x64, 0x00, 0xD8, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0E, 0x07, 0x0C,
  0x03, 0x18, 0x01, 0x18, 0x01, 0x18, 0x03, 0x18, 0x03, 0x0C, 0x0E, 0x07,
  0xF8, 0x07, 0xF8, 0x1C, 0x1C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x02, 0x60,
  0x06, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x70, 0x3C, 0x3F, 0xF0, 0x0F,
  0xC0, 0x07, 0xE0, 0x7F, 0xC3, 0x83, 0x9C, 0x03, 0x60, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7E, 0x02, 0x9C, 0x1E, 0x3F, 0xD8,
  0x7C, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xCF, 0x1C, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x87, 0x0C, 0x38, 0x60, 0xC3, 0x06, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x10, 0x7F, 0xFE, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xBF, 0xFF, 0x00, 0x20, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30,
  0x00, 0x80, 0x00, 0x07, 0xC0, 0xFF, 0x8E, 0x1C, 0xC0, 0x36, 0x01, 0xE0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x80, 0x70, 0x1F, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x38, 0x30, 0xC0, 0x31, 0x80,
  0x66, 0x00, 0x4C, 0x3C, 0x90, 0xFF, 0x63, 0x8E, 0xC6, 0x0D, 0x98, 0x12,
  0x30, 0x24, 0x60, 0x58, 0xC1, 0xB1, 0x03, 0x62, 0x06, 0xC6, 0x19, 0x8F,
  0xD3, 0x0F, 0x26, 0x00, 0x8C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1F, 0xF0,
  0x0F, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x48, 0x00, 0xCC,
  0x00, 0xCC, 0x01, 0x8C, 0x01, 0x8C, 0x03, 0x0C, 0x03, 0x0C, 0x06, 0x04,
  0x06, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x1F, 0xFE, 0x1F, 0xFE, 0x18, 0x06,
  0x30, 0x06, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0x1F, 0xF0,
  0x3F, 0xF8, 0x60, 0x30, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x30, 0x0C, 0x40, 0x31, 0xFF, 0xC3, 0xFF, 0x86, 0x01, 0x8C, 0x01,
  0x98, 0x03, 0x20, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x66, 0x01, 0xCF,
  0xFF, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x63,
  0x00, 0x6C, 0x01, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x19,
  0x80, 0x63, 0x00, 0xC3, 0x87, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0xE0,
  0x3F, 0xF0, 0x60, 0x70, 0xC0, 0x71, 0x80, 0x62, 0x00, 0xCC, 0x00, 0x98,
  0x01, 0x30, 0x02, 0x60, 0x0C, 0xC0, 0x19, 0x00, 0x36, 0x00, 0x6C, 0x00,
  0xD8, 0x03, 0x30, 0x06, 0x60, 0x0C, 0x80, 0x33, 0x00, 0xE6, 0x03, 0x8F,
  0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x3F, 0xFC, 0x7F, 0xFC, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8,
  0x1F, 0xFF, 0x8F, 0xFF, 0x86, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x0F,
  0xFF, 0x86, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xFC, 0x0E, 0x0C, 0x1C, 0x06, 0x18, 0x02, 0x30, 0x05, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0xFC, 0xC0,
  0xFC, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0x60, 0x18, 0x60,
  0x28, 0x70, 0x78, 0x3F, 0xD8, 0x1F, 0x18, 0x0C, 0x01, 0x86, 0x00, 0xC2,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x10, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06,
  0x10, 0x03, 0x18, 0x01, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0x00, 0x61, 0x80,
  0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x04, 0x30, 0x06, 0x18, 0x03, 0x0C,
  0x01, 0x84, 0x00, 0xC6, 0x00, 0x60, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x31, 0x80, 0x63, 0x01, 0xC3, 0x07, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x18,
  0x01, 0xC6, 0x00, 0xC1, 0x80, 0x60, 0x40, 0x30, 0x30, 0x18, 0x0C, 0x0C,
  0x03, 0x06, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x08, 0xC0, 0x06, 0x78, 0x01,
  0xB6, 0x00, 0x78, 0xC0, 0x1C, 0x30, 0x06, 0x06, 0x01, 0x81, 0x80, 0xC0,
  0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x1C, 0x01,
  0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x78, 0x1E, 0x1E, 0x05, 0x84, 0x83, 0x61,
  0x31, 0x90, 0xCC, 0x64, 0x33, 0x33, 0x0C, 0x48, 0xC3, 0x1E, 0x30, 0x87,
  0x0C, 0x21, 0xC2, 0x18, 0x20, 0x86, 0x10, 0x61, 0x80, 0x18, 0x60, 0x06,
  0x10, 0x01, 0x84, 0x00, 0x43, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x03, 0x00,
  0x0E, 0x01, 0x87, 0x00, 0xC2, 0x80, 0x63, 0x60, 0x31, 0xB0, 0x10, 0xD8,
  0x08, 0x64, 0x0C, 0x23, 0x06, 0x11, 0x83, 0x18, 0x41, 0x8C, 0x20, 0x86,
  0x18, 0x43, 0x0C, 0x61, 0x02, 0x30, 0x81, 0x98, 0xC0, 0xCC, 0x60, 0x64,
  0x30, 0x12, 0x18, 0x0F, 0x0C, 0x07, 0x84, 0x03, 0xC6, 0x00, 0xE0, 0x01,
  0xF0, 0x0F, 0xF8, 0x38, 0x30, 0xC0, 0x33, 0x00, 0x66, 0x00, 0x58, 0x00,
  0xB0, 0x01, 0x60, 0x02, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x31, 0x80, 0xE3, 0x83,
  0x83, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xFE, 0x18, 0x06, 0x18,
  0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30,
  0x06, 0x20, 0x0E, 0x7F, 0xFC, 0x7F, 0xF0, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x38, 0x30, 0xC0, 0x33, 0x00, 0x66, 0x00,
  0x58, 0x00, 0xB0, 0x01, 0x60, 0x02, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x31, 0x80,
  0xE3, 0x83, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0xC0, 0x01, 0x82, 0x01, 0x8C,
  0x03, 0xB0, 0x03, 0xC0, 0x03, 0x00, 0x1F, 0xF8, 0x1F, 0xFE, 0x18, 0x06,
  0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x06, 0x20, 0x0E, 0x7F, 0xFC, 0x7F, 0xF0, 0x61, 0x80, 0x60, 0xC0,
  0x60, 0xC0, 0x40, 0x60, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18,
  0xC0, 0x18, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0x81, 0xC3, 0x00, 0x71, 0x80,
  0x11, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x07, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x60, 0x03, 0x38, 0x03, 0x0E, 0x07, 0x83, 0xFF, 0x80, 0x7F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x02, 0x30, 0x06,
  0x30, 0x06, 0x30, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x04, 0x60, 0x0C,
  0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18,
  0x60, 0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0xC0, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x36, 0x00, 0x6C, 0x01, 0x98, 0x03, 0x10, 0x04, 0x20, 0x18, 0x60,
  0x30, 0xC0, 0xC1, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x04, 0x30, 0x08, 0x60,
  0x19, 0x80, 0x33, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xA0, 0x01, 0xC0, 0x03,
  0x00, 0x00, 0x20, 0x00, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00,
  0x13, 0x00, 0x19, 0x87, 0x0C, 0xC3, 0x86, 0x61, 0xC2, 0x21, 0xE3, 0x10,
  0xB1, 0x88, 0xC8, 0xC4, 0x64, 0x42, 0x22, 0x23, 0x31, 0x31, 0x90, 0x98,
  0xD8, 0x48, 0x68, 0x24, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E, 0x07, 0x07, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0xC0, 0x0C, 0x06, 0x01, 0xC0, 0x60, 0x18, 0x03,
  0x03, 0x00, 0x30, 0x60, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x00, 0xD8, 0x00,
  0x0F, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xB0, 0x00, 0x1B, 0x00,
  0x03, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x0C, 0x01, 0xC0, 0xC0, 0x18, 0x06,
  0x03, 0x00, 0x60, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0xB0, 0x01,
  0x98, 0x01, 0x8C, 0x01, 0xC3, 0x00, 0xC1, 0x80, 0xC0, 0x60, 0xC0, 0x30,
  0xC0, 0x08, 0x60, 0x06, 0x60, 0x03, 0x60, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0xC1, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x80, 0xC0,
  0xC0, 0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x20, 0x30, 0x30, 0x10, 0x10,
  0x18, 0x18, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x04, 0x04, 0x06, 0x06, 0x02,
  0x02, 0x03, 0x0F, 0xF0, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x30, 0xFF, 0x0F, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x06, 0xC0, 0x19, 0x80, 0x61, 0x00, 0x83, 0x03, 0x02, 0x0C, 0x06, 0x30,
  0x0C, 0x60, 0x0D, 0x80, 0x1E, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFC, 0x4C,
  0x66, 0x21, 0x07, 0xC4, 0x7F, 0x93, 0x83, 0xCC, 0x07, 0x60, 0x0D, 0x80,
  0x3C, 0x00, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x0E, 0xC0,
  0x51, 0x83, 0xC7, 0xFB, 0xCF, 0x87, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0xF8, 0x33, 0xF8, 0x6C,
  0x38, 0xE0, 0x31, 0x80, 0x33, 0x00, 0x64, 0x00, 0xD8, 0x01, 0xB0, 0x02,
  0x60, 0x0C, 0xC0, 0x19, 0x80, 0x73, 0x00, 0xCD, 0x07, 0x1B, 0xFC, 0x31,
  0xF0, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xC1, 0x8C, 0x03, 0x60, 0x09, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x90, 0x06, 0x60,
  0x31, 0xC1, 0x83, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x07, 0xC6, 0x1F, 0xE4,
  0x38, 0x34, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xC0, 0x0C, 0xC0, 0x08,
  0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x58, 0x60, 0xD0,
  0x7F, 0xB0, 0x1E, 0x30, 0x03, 0xF0, 0x3F, 0xE1, 0xC1, 0xCC, 0x03, 0x20,
  0x0D, 0x80, 0x74, 0x0F, 0x9F, 0xF8, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x03, 0x60, 0x19, 0xC1, 0xC3, 0xFE, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x01, 0x03, 0x00, 0x1C, 0x18, 0x00, 0x30,
  0xC0, 0x00, 0xE6, 0x00, 0x03, 0xA0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xE3, 0x0F, 0xF2, 0x1C, 0x1A, 0x18, 0x06, 0x30, 0x06, 0x30,
  0x06, 0x60, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x1C, 0x60, 0x2C, 0x30, 0x68, 0x3F, 0xD8, 0x0F, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x40, 0x30, 0xE0, 0xE0, 0x7F, 0xC0, 0x1F, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x7C, 0x13,
  0xF8, 0xD8, 0x73, 0x40, 0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x32, 0x00, 0x98,
  0x02, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x40, 0x13, 0x00, 0x4C,
  0x03, 0x00, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x08, 0x61, 0xC2, 0x1C, 0x13, 0xC1, 0xB8,
  0x0F, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x04, 0x0C, 0x38, 0x30, 0x30, 0xC0,
  0x63, 0x00, 0xC8, 0x01, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x11, 0xF0, 0x33,
  0xF8, 0x36, 0x1C, 0x3C, 0x0C, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x60,
  0x70, 0x67, 0xC0, 0x66, 0x00, 0x63, 0x02, 0x63, 0x07, 0x41, 0x8E, 0xC1,
  0xDC, 0xC0, 0xF0, 0xC0, 0x60, 0xFF, 0x0F, 0xE0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x23, 0x07, 0x31, 0xC3, 0x38, 0x27,
  0x03, 0xC0, 0x38, 0x00, 0x33, 0x8F, 0x1B, 0xEF, 0x8E, 0x3C, 0xE6, 0x1C,
  0x33, 0x0C, 0x13, 0x06, 0x09, 0x83, 0x04, 0xC1, 0x06, 0x60, 0x83, 0x30,
  0xC1, 0x90, 0x60, 0x98, 0x30, 0x4C, 0x18, 0x66, 0x08, 0x33, 0x04, 0x19,
  0x06, 0x0C, 0x19, 0xF0, 0x4F, 0xE3, 0x61, 0xCD, 0x03, 0x38, 0x0C, 0xC0,
  0x33, 0x00, 0xC8, 0x02, 0x60, 0x09, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60,
  0x19, 0x00, 0x4C, 0x01, 0x30, 0x0C, 0x03, 0xE0, 0x3F, 0xE1, 0xC1, 0x8C,
  0x03, 0x60, 0x0D, 0x80, 0x16, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x06, 0x60, 0x39, 0xC1, 0xC3, 0xFE, 0x07, 0xE0, 0x08, 0xF8,
  0x19, 0xFC, 0x1B, 0x0E, 0x1C, 0x06, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03,
  0x30, 0x03, 0x30, 0x02, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x30, 0x0C,
  0x68, 0x38, 0x6F, 0xF0, 0x63, 0xE0, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0xC6, 0x3F, 0xC8, 0xE0, 0xD1,
  0x80, 0x66, 0x00, 0xCC, 0x01, 0xB0, 0x03, 0x60, 0x04, 0xC0, 0x19, 0x80,
  0x33, 0x00, 0x66, 0x01, 0xCC, 0x05, 0x8C, 0x1A, 0x1F, 0xEC, 0x0F, 0x98,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x7E, 0x3E, 0xFC, 0xFE, 0x1B, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x07, 0xF0, 0x7F, 0xE3, 0x81, 0xCC,
  0x02, 0x30, 0x00, 0xC0, 0x03, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x60,
  0x00, 0x80, 0x02, 0xC0, 0x1B, 0x80, 0xE7, 0xFF, 0x07, 0xF0, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x1F, 0xFF, 0xFF,
  0xFF, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x04, 0x0C, 0x1C, 0x18, 0x70, 0x23, 0xC0, 0x5E, 0x01,
  0xF8, 0x01, 0xC0, 0x00, 0x60, 0x0B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01,
  0xA0, 0x0F, 0x00, 0x58, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x81, 0xEC,
  0x0E, 0x70, 0xB1, 0xF9, 0x87, 0x8C, 0xFC, 0x0D, 0xF8, 0x08, 0x20, 0x18,
  0x40, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x0C, 0x06, 0x18, 0x0C, 0x20,
  0x30, 0x40, 0x61, 0x81, 0x83, 0x0E, 0x06, 0x78, 0x0F, 0xE0, 0x1F, 0x00,
  0x20, 0xC6, 0x60, 0x82, 0x60, 0x82, 0x60, 0x83, 0x61, 0x83, 0x41, 0x83,
  0x41, 0x83, 0xC1, 0x02, 0xC1, 0x02, 0xC3, 0x06, 0x83, 0x06, 0x83, 0x06,
  0x85, 0x0C, 0xCD, 0x1C, 0xF9, 0xF8, 0x70, 0xE0, 0x03, 0x87, 0x81, 0xE3,
  0xF1, 0xCD, 0x8C, 0xC3, 0x41, 0x60, 0xE0, 0x40, 0x18, 0x10, 0x06, 0x08,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x0C, 0x03, 0x05, 0x06, 0xC1,
  0x63, 0x18, 0x9B, 0x87, 0xE7, 0xC0, 0xF0, 0xE0, 0x18, 0x02, 0x30, 0x0C,
  0x60, 0x18, 0xC0, 0x31, 0x80, 0x62, 0x00, 0xCC, 0x01, 0x18, 0x06, 0x30,
  0x0C, 0x60, 0x18, 0xC0, 0x31, 0x81, 0xC3, 0x03, 0x87, 0x0B, 0x07, 0xF6,
  0x07, 0x8C, 0x00, 0x18, 0x00, 0x62, 0x00, 0xC7, 0x07, 0x07, 0xFC, 0x03,
  0xE0, 0x00, 0x1F, 0x86, 0x7F, 0xEC, 0xC1, 0xFB, 0x00, 0x66, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x10, 0x60, 0x61, 0x80,
  0x4F, 0x00, 0x9F, 0xF1, 0xB3, 0xFF, 0x40, 0xFC, 0x01, 0xFC, 0x0F, 0xF0,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x03, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x06, 0x08, 0x10,
  0x20, 0xC1, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x08, 0x30,
  0x60, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x1F,
  0xC0, 0x7F, 0x01, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x1C, 0x03, 0x3E, 0x02, 0x63, 0x06, 0x43, 0x84, 0xC1,
  0x8C, 0x80, 0xF8, 0x80, 0x70,
};

const GFXglyph IBMPlexMono_LightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 22, 19, 6, -22 },
  { 21, 8, 8, 19, 7, -23 },
  { 29, 19, 22, 19, 0, -22 },
  { 82, 17, 28, 19, 1, -25 },
  { 142, 21, 22, 19, -1, -22 },
  { 200, 18, 22, 19, 0, -22 },
  { 250, 3, 8, 19, 10, -23 },
  { 253, 11, 28, 19, 7, -24 },
  { 292, 10, 28, 19, 2, -24 },
  { 327, 16, 15, 19, 2, -17 },
  { 357, 15, 16, 19, 2, -17 },
  { 387, 5, 9, 19, 5, -4 },
  { 393, 9, 2, 19, 5, -10 },
  { 396, 4, 3, 19, 6, -3 },
  { 398, 17, 28, 19, 1, -24 },
  { 458, 15, 22, 19, 2, -22 },
  { 500, 15, 22, 19, 1, -22 },
  { 542, 16, 22, 19, 1, -22 },
  { 586, 16, 22, 19, 1, -22 },
  { 630, 16, 22, 19, 1, -22 },
  { 674, 15, 22, 19, 2, -22 },
  { 716, 14, 22, 19, 2, -22 },
  { 755, 15, 22, 19, 3, -22 },
  { 797, 16, 22, 19, 1, -22 },
  { 841, 14, 22, 19, 3, -22 },
  { 880, 6, 16, 19, 6, -16 },
  { 892, 7, 21, 19, 5, -16 },
  { 911, 15, 17, 19, 3, -18 },
  { 943, 15, 7, 19, 2, -13 },
  { 957, 14, 17, 19, 2, -18 },
  { 987, 13, 22, 19, 4, -22 },
  { 1023, 15, 25, 19, 2, -22 },
  { 1070, 16, 22, 19, 0, -22 },
  { 1114, 15, 22, 19, 2, -22 },
  { 1156, 15, 22, 19, 3, -22 },
  { 1198, 15, 22, 19, 2, -22 },
  { 1240, 16, 22, 19, 2, -22 },
  { 1284, 17, 22, 19, 2, -22 },
  { 1331, 16, 22, 19, 2, -22 },
  { 1375, 17, 22, 19, 1, -22 },
  { 1422, 17, 22, 19, 1, -22 },
  { 1469, 15, 22, 19, 2, -22 },
  { 1511, 18, 22, 19, 2, -22 },
  { 1561, 12, 22, 19, 3, -22 },
  { 1594, 18, 22, 19, 1, -22 },
  { 1644, 17, 22, 19, 1, -22 },
  { 1691, 15, 22, 19, 2, -22 },
  { 1733, 16, 22, 19, 2, -22 },
  { 1777, 15, 28, 19, 2, -22 },
  { 1830, 16, 22, 19, 2, -22 },
  { 1874, 17, 22, 19, 1, -22 },
  { 1921, 17, 22, 19, 3, -22 },
  { 1968, 16, 22, 19, 2, -22 },
  { 2012, 15, 22, 19, 4, -22 },
  { 2054, 17, 22, 19, 2, -22 },
  { 2101, 20, 22, 19, 0, -22 },
  { 2156, 17, 22, 19, 3, -22 },
  { 2203, 19, 22, 19, 0, -22 },
  { 2256, 13, 28, 19, 5, -24 },
  { 2302, 8, 28, 19, 6, -24 },
  { 2330, 12, 28, 19, 1, -24 },
  { 2372, 15, 12, 19, 2, -22 },
  { 2395, 15, 2, 19, 0, 3 },
  { 2399, 4, 6, 19, 7, -24 },
  { 2402, 14, 16, 19, 2, -16 },
  { 2430, 15, 23, 19, 2, -23 },
  { 2474, 14, 16, 19, 2, -16 },
  { 2502, 16, 23, 19, 2, -23 },
  { 2548, 14, 16, 19, 2, -16 },
  { 2576, 21, 29, 19, -1, -23 },
  { 2653, 16, 22, 19, 1, -16 },
  { 2697, 14, 23, 19, 2, -23 },
  { 2738, 13, 23, 19, 3, -23 },
  { 2776, 14, 29, 19, 2, -23 },
  { 2827, 16, 23, 19, 2, -23 },
  { 2873, 12, 23, 19, 4, -23 },
  { 2908, 17, 16, 19, 1, -16 },
  { 2942, 14, 16, 19, 2, -16 },
  { 2970, 14, 16, 19, 2, -16 },
  { 2998, 16, 22, 19, 1, -16 },
  { 3042, 15, 22, 19, 2, -16 },
  { 3084, 15, 16, 19, 3, -16 },
  { 3114, 14, 16, 19, 2, -16 },
  { 3142, 15, 22, 19, 2, -22 },
  { 3184, 13, 16, 19, 3, -16 },
  { 3210, 15, 16, 19, 2, -16 },
  { 3240, 16, 16, 19, 2, -16 },
  { 3272, 18, 16, 19, 0, -16 },
  { 3308, 15, 22, 19, 1, -16 },
  { 3350, 15, 16, 19, 2, -16 },
  { 3380, 14, 28, 19, 4, -24 },
  { 3429, 7, 28, 19, 6, -24 },
  { 3454, 15, 28, 19, 1, -24 },
  { 3507, 16, 7, 19, 2, -13 },
};

const GFXfont IBMPlexMono_LightItalic31pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic31pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic31pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _IBMPLEXMONO_LIGHTITALIC31PT7B_H_
