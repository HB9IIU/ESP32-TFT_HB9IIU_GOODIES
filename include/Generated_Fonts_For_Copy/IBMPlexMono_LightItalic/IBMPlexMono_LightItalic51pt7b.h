#ifndef _IBMPLEXMONO_LIGHTITALIC51PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x7E, 0x0F, 0x83,
  0xF0, 0x3C, 0x00, 0x38, 0x39, 0xC1, 0xCC, 0x0C, 0xE0, 0xE7, 0x07, 0x38,
  0x39, 0xC1, 0xCE, 0x0E, 0x60, 0x67, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E,
  0x70, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x03, 0xFF, 0x01, 0xFF, 0x1F,
  0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0x81, 0xC0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0,
  0x0F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0xFF, 0xE0,
  0x06, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xF8, 0xE7,
  0xE0, 0x3E, 0x0C, 0x1E, 0x03, 0x80, 0xC0, 0x70, 0x78, 0x0C, 0x07, 0x07,
  0x00, 0xC0, 0x40, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x18,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x07, 0x81, 0x80, 0x00,
  0x7C, 0x38, 0x00, 0x03, 0xF3, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x73, 0xF0,
  0x00, 0x07, 0x0F, 0x80, 0x00, 0x60, 0x78, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x60, 0x3C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x03,
  0xC0, 0x00, 0xC0, 0x38, 0x20, 0x0C, 0x03, 0x8F, 0x00, 0xC0, 0x78, 0x78,
  0x0C, 0x0F, 0x03, 0xC1, 0xC1, 0xF0, 0x1F, 0x98, 0x7E, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x3F, 0xF0, 0x00, 0xE0, 0x1F,
  0xFC, 0x00, 0x30, 0x07, 0x87, 0x80, 0x1C, 0x03, 0x80, 0x60, 0x0E, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xE0,
  0x06, 0x00, 0x60, 0x70, 0x01, 0x80, 0x18, 0x18, 0x00, 0x60, 0x0E, 0x0E,
  0x00, 0x18, 0x03, 0x87, 0x00, 0x07, 0x01, 0xC3, 0x80, 0x01, 0xE0, 0xF0,
  0xE0, 0x00, 0x3F, 0xF8, 0x70, 0x00, 0x07, 0xFC, 0x20, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x0F, 0xFC, 0x00,
  0x03, 0x07, 0x87, 0x80, 0x01, 0xC3, 0x80, 0x60, 0x00, 0xE0, 0xC0, 0x1C,
  0x00, 0x30, 0x70, 0x07, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x0E, 0x06, 0x00,
  0x70, 0x07, 0x01, 0x80, 0x18, 0x01, 0x80, 0x60, 0x06, 0x00, 0xE0, 0x18,
  0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x0C, 0x00,
  0x78, 0x3C, 0x07, 0x00, 0x0F, 0xFE, 0x03, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0,
  0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0xF7, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38,
  0x02, 0xE0, 0x00, 0xF0, 0x1F, 0x80, 0x03, 0xC0, 0xE7, 0x00, 0x1B, 0x83,
  0x9C, 0x00, 0x4F, 0x1C, 0x78, 0x03, 0x1C, 0x70, 0xF0, 0x3C, 0x7B, 0x81,
  0xFF, 0xE0, 0xFE, 0x03, 0xFF, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0x80, 0x39,
  0xCC, 0xE7, 0x39, 0xCE, 0x67, 0x39, 0xCE, 0x70, 0x00, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x40, 0x0E, 0x00, 0x7E,
  0x03, 0x81, 0xFF, 0xF0, 0xC3, 0xFC, 0x7F, 0xB7, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x0F,
  0x01, 0xC0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x01, 0xC0,
  0x10, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03,
  0x81, 0xC0, 0x70, 0x38, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C,
  0xF9, 0xFB, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x01, 0xE0,
  0x70, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0x70, 0x0E, 0x03, 0xDC,
  0x07, 0xC0, 0xE7, 0x01, 0xF0, 0x39, 0xC0, 0x78, 0x0E, 0x70, 0x1E, 0x03,
  0x9C, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x07, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0xF8, 0xE0, 0x01,
  0xF0, 0xE0, 0x03, 0xE0, 0xE0, 0x07, 0xC0, 0xC0, 0x0F, 0x81, 0xC0, 0x1E,
  0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x07, 0x80, 0xE0, 0x00,
  0xE0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC0, 0x80,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x70, 0x00,
  0x38, 0x08, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x02, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x10, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x0F, 0x80, 0x7C, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00,
  0x70, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x0E, 0x00, 0xE0,
  0x01, 0xC0, 0x18, 0x00, 0x38, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE1, 0xFC, 0x00, 0x33, 0xFF, 0xC0, 0x1D, 0xFF, 0xF8,
  0x07, 0xF0, 0x3F, 0x01, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x10, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0xF0, 0x0F, 0x80, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x1F, 0xC0, 0x1C, 0x7F, 0xF0, 0x1D, 0xFF, 0xF8, 0x3B, 0xC0, 0x7C,
  0x3B, 0x00, 0x1E, 0x3E, 0x00, 0x0E, 0x7C, 0x00, 0x0E, 0x78, 0x00, 0x0F,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x78, 0x00, 0x38, 0x3C, 0x00, 0xF8, 0x3E, 0x03, 0xF0,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78,
  0xC0, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xC0, 0x3E,
  0x00, 0x3C, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x0F, 0x01, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x3C,
  0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7E,
  0x07, 0xC1, 0xE0, 0x03, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF9, 0xE0, 0x03, 0x73, 0xF0, 0x1D, 0xC3,
  0xFF, 0xF3, 0x81, 0xFF, 0xCE, 0x00, 0xFE, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x81,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC1, 0xF0, 0x7E, 0x1F, 0x0F, 0xC1, 0xE0, 0x00, 0xF0, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE,
  0x03, 0xFF, 0xF8, 0x3E, 0x03, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0x3D, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x03, 0xE0, 0x3C, 0x00, 0x70, 0x1C, 0x00,
  0x3C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xC3, 0x00, 0xF8, 0x63, 0x80, 0xFE, 0x71, 0xC0, 0xFF, 0xB8, 0xC0,
  0xF0, 0x5C, 0xE0, 0xF0, 0x1E, 0x70, 0x70, 0x0E, 0x38, 0x30, 0x07, 0x1C,
  0x38, 0x03, 0x8C, 0x1C, 0x01, 0xCE, 0x0E, 0x00, 0xE7, 0x06, 0x00, 0x73,
  0x87, 0x00, 0x31, 0xC3, 0x80, 0x18, 0xE1, 0xC0, 0x1C, 0x60, 0xE0, 0x0E,
  0x30, 0x70, 0x0F, 0x18, 0x38, 0x07, 0x9C, 0x1E, 0x05, 0x8E, 0x07, 0x8E,
  0xC7, 0x03, 0xFE, 0xE3, 0x80, 0xFE, 0x71, 0xC0, 0x1C, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x0C, 0x00,
  0x01, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x70,
  0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00,
  0x0E, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xE0, 0x03, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x70,
  0x00, 0x78, 0x38, 0x00, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x07, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x9C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0xF3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0xF8, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x3C, 0x00, 0xF0,
  0x3C, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x07,
  0x00, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0xE0,
  0x3C, 0x00, 0xF0, 0x1F, 0x81, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x1C, 0x01, 0xF8, 0x07, 0x00, 0x1F, 0x01, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x78, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x03, 0xC0,
  0x70, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7E, 0x07, 0xC0, 0x3C, 0x00,
  0xE0, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x02, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x01, 0xFF, 0xCE,
  0x00, 0xFF, 0xE7, 0x00, 0x7F, 0xF3, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x18,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x8E, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x01,
  0xF0, 0x78, 0x01, 0xB8, 0x1F, 0x03, 0x9C, 0x07, 0xFF, 0xCE, 0x01, 0xFF,
  0x86, 0x00, 0x3F, 0x04, 0x00, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x38, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E,
  0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x02, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x83, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0x78, 0x03, 0xC0,
  0x1F, 0x03, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x78,
  0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x78, 0x03, 0x80, 0x07, 0x80, 0x3C,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x00, 0x70, 0x07,
  0x80, 0x03, 0x80, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x70, 0x78, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C,
  0x7C, 0x00, 0x00, 0xE7, 0xF0, 0x00, 0x07, 0x73, 0x80, 0x00, 0x77, 0x0E,
  0x00, 0x03, 0xF0, 0x70, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x6E, 0x00, 0x77, 0x0E, 0xE0, 0x07, 0x60,
  0xE6, 0x00, 0xEE, 0x0E, 0x60, 0x0E, 0xE0, 0xE7, 0x01, 0xCE, 0x0E, 0x70,
  0x38, 0xE0, 0xC3, 0x03, 0x8E, 0x1C, 0x30, 0x70, 0xC1, 0xC3, 0x87, 0x1C,
  0x1C, 0x38, 0xE1, 0xC1, 0xC1, 0x8C, 0x1C, 0x1C, 0x19, 0xC1, 0xC1, 0x81,
  0xF8, 0x1C, 0x38, 0x1F, 0x81, 0x83, 0x80, 0xF0, 0x38, 0x38, 0x0E, 0x03,
  0x83, 0x80, 0xE0, 0x38, 0x38, 0x0C, 0x03, 0x83, 0x00, 0x40, 0x38, 0x70,
  0x08, 0x03, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0xE0, 0x03, 0xE0, 0x00, 0x70, 0x3E, 0x00, 0x07,
  0x03, 0xE0, 0x00, 0x60, 0x3F, 0x00, 0x0E, 0x07, 0x70, 0x00, 0xE0, 0x77,
  0x00, 0x0E, 0x07, 0x30, 0x00, 0xE0, 0x73, 0x80, 0x0E, 0x07, 0x38, 0x00,
  0xC0, 0x63, 0x80, 0x1C, 0x0E, 0x18, 0x01, 0xC0, 0xE1, 0xC0, 0x1C, 0x0E,
  0x1C, 0x01, 0xC0, 0xE1, 0xC0, 0x1C, 0x0E, 0x0E, 0x01, 0x80, 0xC0, 0xE0,
  0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0x01, 0x80, 0x30, 0x70, 0x38, 0x03,
  0x87, 0x03, 0x80, 0x38, 0x70, 0x38, 0x03, 0x87, 0x03, 0x80, 0x1C, 0x70,
  0x38, 0x01, 0xC6, 0x03, 0x80, 0x1C, 0x60, 0x30, 0x00, 0xCE, 0x07, 0x00,
  0x0E, 0xE0, 0x70, 0x00, 0xEE, 0x07, 0x00, 0x0E, 0xE0, 0x70, 0x00, 0x7E,
  0x07, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x7C, 0x0E, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0x7C,
  0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xF0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1D,
  0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0x80,
  0x03, 0xC0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x03,
  0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x70, 0x00,
  0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x1C, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x3C, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x80, 0x03, 0xC0, 0x60, 0x00, 0x78, 0x3C,
  0x00, 0x0E, 0x1E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x0E, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x3C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x03, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0x3C,
  0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x04, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x80, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x1E, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0xC0,
  0x03, 0xC0, 0x70, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38,
  0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x03, 0xC0, 0x30, 0x70, 0x1E, 0x03, 0x83,
  0x80, 0xF0, 0x1C, 0x1C, 0x0F, 0x80, 0xE0, 0xC0, 0x6C, 0x06, 0x06, 0x07,
  0x60, 0x30, 0x30, 0x3B, 0x83, 0x81, 0x81, 0x9C, 0x1C, 0x1C, 0x1C, 0xE0,
  0xC0, 0xE0, 0xC7, 0x06, 0x07, 0x0E, 0x38, 0x70, 0x38, 0x70, 0xC3, 0x81,
  0xC3, 0x06, 0x18, 0x0E, 0x38, 0x30, 0xC0, 0x71, 0x81, 0x8E, 0x03, 0x1C,
  0x0C, 0x70, 0x18, 0xC0, 0x63, 0x00, 0xCE, 0x03, 0x18, 0x06, 0x70, 0x19,
  0xC0, 0x33, 0x00, 0xEE, 0x03, 0xB8, 0x07, 0x60, 0x1D, 0x80, 0x3B, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0,
  0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x38, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80,
  0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01,
  0xC1, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x63, 0x87, 0x1C, 0x30, 0xE1, 0x87, 0x08,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC7, 0x03, 0xFF, 0xE7, 0x07, 0xC0, 0xE7,
  0x0F, 0x00, 0x37, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x78, 0x70, 0x00, 0xB8, 0x70, 0x01, 0xB0, 0x78, 0x03, 0x70,
  0x3E, 0x0E, 0x7F, 0x3F, 0xFE, 0x7F, 0x1F, 0xFC, 0x3F, 0x07, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x07, 0xE0,
  0x0E, 0x1F, 0xF8, 0x0E, 0x3F, 0xFC, 0x0E, 0x70, 0x3E, 0x0E, 0xC0, 0x0E,
  0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x07, 0x1F, 0x00, 0x07, 0x1E, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x7C, 0x00, 0xF8, 0x77, 0x03, 0xF0,
  0xE3, 0xFF, 0xE0, 0xE1, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x3E, 0x0F, 0x00, 0x38, 0x78,
  0x00, 0x73, 0xC0, 0x01, 0xCE, 0x00, 0x04, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x01, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00, 0x0E,
  0x1E, 0x00, 0x70, 0x3E, 0x07, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x01, 0xFC, 0x0C, 0x01, 0xFF, 0xC7, 0x00, 0xFF, 0xF9, 0xC0,
  0x7C, 0x0F, 0x70, 0x3C, 0x00, 0xDC, 0x1E, 0x00, 0x1F, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x30, 0xF0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE0, 0x70, 0x00,
  0xF8, 0x1C, 0x00, 0x6E, 0x07, 0x80, 0x3B, 0x80, 0xF8, 0x3D, 0xC0, 0x3F,
  0xFE, 0x70, 0x03, 0xFF, 0x1C, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x03, 0xE0, 0xF0, 0x01, 0xC3,
  0xC0, 0x03, 0x87, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x70, 0x00, 0x1C, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0xF7, 0x00, 0x0F, 0xCE, 0x03, 0xFF, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0xCE, 0x00, 0x03, 0xCE, 0x00, 0x07,
  0x1C, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0x3E, 0x07, 0xE0, 0x3F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x02, 0x00, 0x38, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00,
  0x1F, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF1, 0xC0,
  0x7F, 0xFC, 0xE0, 0x7C, 0x0F, 0x70, 0x78, 0x01, 0xB8, 0x78, 0x00, 0x7C,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x63, 0xC0, 0x00,
  0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x0F, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x07, 0xC1, 0xC0,
  0x02, 0xE0, 0xF0, 0x07, 0x70, 0x3E, 0x0F, 0x38, 0x1F, 0xFF, 0x38, 0x03,
  0xFF, 0x1C, 0x00, 0xFE, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x40, 0x00, 0xE0,
  0x70, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x83,
  0xF0, 0x0E, 0x3F, 0xF0, 0x39, 0xFF, 0xE1, 0xEE, 0x07, 0x87, 0x30, 0x0F,
  0x1D, 0x00, 0x1C, 0x74, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x3C,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x06, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39,
  0xC0, 0x00, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80,
  0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x38, 0x07, 0xC0, 0x70, 0x1F, 0x00, 0xE0, 0x78, 0x01, 0xC3, 0xE0,
  0x03, 0x0F, 0x80, 0x0E, 0x3C, 0x00, 0x1D, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x08, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x78, 0x03,
  0x80, 0x78, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x38, 0x00, 0x78, 0x70,
  0x00, 0x78, 0xE0, 0x00, 0x79, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x1F, 0x80, 0x07, 0x1F, 0xF8, 0x03, 0x8F, 0xFF,
  0x00, 0xE7, 0x83, 0xE0, 0x3B, 0x80, 0x78, 0x0E, 0x80, 0x0E, 0x03, 0xC0,
  0x03, 0x80, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x1C, 0x03, 0xE0,
  0x0E, 0x07, 0xE0, 0x03, 0x8F, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x30,
  0x00, 0x0E, 0x0E, 0x00, 0x23, 0x81, 0xC0, 0x1D, 0xC0, 0x70, 0x0F, 0x70,
  0x0E, 0x07, 0x9C, 0x03, 0x83, 0xC7, 0x00, 0x71, 0xE1, 0xC0, 0x1D, 0xF0,
  0x70, 0x07, 0xF8, 0x38, 0x00, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x02, 0x06, 0x00, 0x70, 0xE0,
  0x1F, 0x0E, 0x03, 0xC0, 0xE0, 0x78, 0x0E, 0x1F, 0x00, 0xE3, 0xE0, 0x0C,
  0x78, 0x01, 0xCF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x67, 0xF1, 0xFE, 0x0E, 0xFF, 0xBF, 0xE0, 0xFC,
  0x7B, 0x0F, 0x0F, 0x03, 0xE0, 0x70, 0xF0, 0x3C, 0x07, 0x0E, 0x03, 0xC0,
  0x71, 0xE0, 0x38, 0x07, 0x1C, 0x03, 0x80, 0x71, 0xC0, 0x38, 0x06, 0x1C,
  0x03, 0x00, 0x61, 0xC0, 0x30, 0x0E, 0x18, 0x07, 0x00, 0xE3, 0x80, 0x70,
  0x0E, 0x38, 0x07, 0x00, 0xE3, 0x80, 0x70, 0x0C, 0x38, 0x06, 0x00, 0xC3,
  0x00, 0x60, 0x1C, 0x30, 0x0E, 0x01, 0xC7, 0x00, 0xE0, 0x1C, 0x70, 0x0E,
  0x01, 0xC7, 0x00, 0xE0, 0x18, 0x70, 0x0C, 0x01, 0x86, 0x00, 0xC0, 0x38,
  0x60, 0x1C, 0x03, 0x8E, 0x01, 0xC0, 0x38, 0xE0, 0x1C, 0x03, 0x80, 0x00,
  0x0F, 0xC0, 0x38, 0xFF, 0xC0, 0xE7, 0xFF, 0x83, 0x38, 0x1E, 0x1C, 0xC0,
  0x3C, 0x74, 0x00, 0x71, 0xD0, 0x01, 0xC7, 0x80, 0x07, 0x1C, 0x00, 0x1C,
  0xF0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x18, 0xE0,
  0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00,
  0xE7, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x01, 0xCE,
  0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7E,
  0x07, 0xC0, 0xF0, 0x03, 0x83, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x77, 0x00, 0x01, 0xCE,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x3E,
  0x07, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x01, 0xC7, 0xFE, 0x01, 0xC7, 0xFF, 0x80, 0xE7, 0x03, 0xE0,
  0x76, 0x00, 0x70, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x07,
  0x0F, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x7C,
  0x00, 0xF8, 0x3B, 0x81, 0xF8, 0x38, 0xFF, 0xF8, 0x1C, 0x3F, 0xF0, 0x0E,
  0x07, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xC7, 0x03, 0xFF, 0xE7, 0x07, 0xC0, 0xF7, 0x0F, 0x00, 0x37, 0x1E, 0x00,
  0x1F, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x78, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0xF0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0xF8, 0x70, 0x01, 0xB8, 0x78, 0x03, 0x38, 0x3E, 0x0F, 0x70, 0x3F, 0xFE,
  0x70, 0x0F, 0xFC, 0x70, 0x07, 0xF0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xFF, 0x00, 0xEE, 0x00, 0x00, 0xC8,
  0x00, 0x01, 0xD0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xF8, 0x00, 0x78, 0x7E, 0x01, 0xF8, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x08, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x7E, 0x03, 0x80, 0xF8, 0x03, 0x03,
  0xE0, 0x07, 0x07, 0xC0, 0x07, 0x1F, 0x00, 0x07, 0x7E, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xCE, 0x00, 0x06, 0x38, 0x00, 0x38, 0xC0, 0x00, 0xE7,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xC7, 0x00,
  0x07, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x38,
  0x00, 0xB8, 0xE0, 0x02, 0xE3, 0x80, 0x17, 0x0F, 0x00, 0xDC, 0x3E, 0x0E,
  0x70, 0x7F, 0xF1, 0xC0, 0xFF, 0x87, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0D, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x70, 0x30, 0x00,
  0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x70, 0xE0, 0x00, 0xE1,
  0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x0C, 0x00, 0x38, 0x18,
  0x00, 0xF0, 0x70, 0x03, 0xC0, 0xE0, 0x0F, 0x01, 0xC0, 0x3E, 0x03, 0x80,
  0xF8, 0x07, 0x07, 0xE0, 0x0C, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0x87, 0x00, 0xC0, 0xE1, 0xC0,
  0x30, 0x18, 0x60, 0x1C, 0x06, 0x18, 0x07, 0x01, 0xCE, 0x01, 0xC0, 0x73,
  0x80, 0x60, 0x1C, 0xE0, 0x18, 0x07, 0x38, 0x0E, 0x01, 0xCC, 0x03, 0x80,
  0x73, 0x00, 0xE0, 0x1D, 0xC0, 0x38, 0x07, 0x70, 0x0C, 0x01, 0xDC, 0x03,
  0x00, 0x77, 0x01, 0xC0, 0x19, 0x80, 0x70, 0x06, 0x60, 0x1C, 0x03, 0xB8,
  0x07, 0x00, 0xEE, 0x01, 0x80, 0x3B, 0x80, 0xE0, 0x1C, 0xE0, 0x38, 0x07,
  0x30, 0x0E, 0x03, 0xCC, 0x07, 0x80, 0xE3, 0x83, 0x60, 0x78, 0xF1, 0xDC,
  0x3C, 0x3F, 0xE7, 0xFE, 0x07, 0xF0, 0xFF, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0xFF, 0x07, 0xFC, 0x0F, 0x9C,
  0x70, 0xF1, 0xF0, 0xE7, 0x03, 0x9E, 0x07, 0x30, 0x1D, 0xE0, 0x1B, 0x00,
  0xE4, 0x00, 0xD8, 0x07, 0x00, 0x06, 0x80, 0x38, 0x00, 0x3C, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x38, 0x03, 0xC0, 0x01, 0x80, 0x3E, 0x00, 0x0C,
  0x01, 0xF0, 0x04, 0x60, 0x19, 0x80, 0x73, 0x80, 0xCC, 0x0F, 0x1C, 0x0C,
  0x71, 0xF0, 0xF1, 0xE3, 0x9E, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x7E,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x70, 0x30, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x03, 0x80, 0x03, 0x81, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00,
  0x1E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x0F, 0x81, 0xC0, 0x0D, 0xC0, 0xF0,
  0x0D, 0xC0, 0x7C, 0x1E, 0xE0, 0x1F, 0xFE, 0x70, 0x07, 0xFE, 0x38, 0x00,
  0xFC, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x80, 0x03, 0xC0, 0xE0, 0x03, 0xC0,
  0x7C, 0x07, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x81, 0xC3, 0xFF, 0xF0, 0xE3, 0xC0,
  0xFE, 0x71, 0xC0, 0x0F, 0xF8, 0xC0, 0x00, 0xF8, 0x60, 0x00, 0x78, 0x70,
  0x00, 0x78, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x0C, 0x01, 0xE0, 0x07,
  0x01, 0xE0, 0x03, 0x81, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0x61, 0xFC, 0x00,
  0x39, 0xFF, 0xF0, 0x1C, 0xE3, 0xFF, 0xCE, 0x70, 0x1F, 0xFF, 0x38, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0xC0, 0xFE, 0x00, 0x1C, 0x3F, 0xE0, 0x03, 0x0F, 0x1E, 0x00, 0xE1,
  0xC1, 0xE0, 0x1C, 0x70, 0x1C, 0x07, 0x0E, 0x01, 0xC0, 0xE3, 0x80, 0x3C,
  0x78, 0x70, 0x03, 0xFE, 0x0C, 0x00, 0x3F, 0x83, 0x80, 0x03, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 11, 36, 31, 10, -36 },
  { 51, 13, 14, 31, 12, -38 },
  { 74, 30, 36, 31, 1, -36 },
  { 209, 28, 47, 31, 1, -41 },
  { 374, 34, 37, 31, -1, -36 },
  { 532, 30, 37, 31, 0, -36 },
  { 671, 5, 14, 31, 16, -38 },
  { 680, 18, 46, 31, 11, -39 },
  { 784, 17, 46, 31, 3, -39 },
  { 882, 26, 25, 31, 3, -28 },
  { 964, 25, 25, 31, 3, -28 },
  { 1043, 10, 14, 31, 7, -6 },
  { 1061, 15, 3, 31, 8, -17 },
  { 1067, 7, 6, 31, 10, -6 },
  { 1073, 29, 46, 31, 1, -39 },
  { 1240, 26, 37, 31, 3, -36 },
  { 1361, 24, 36, 31, 2, -36 },
  { 1469, 26, 36, 31, 2, -36 },
  { 1586, 26, 37, 31, 2, -36 },
  { 1707, 27, 36, 31, 1, -36 },
  { 1829, 26, 37, 31, 3, -36 },
  { 1950, 24, 37, 31, 3, -36 },
  { 2061, 24, 36, 31, 6, -36 },
  { 2169, 27, 37, 31, 2, -36 },
  { 2294, 23, 36, 31, 5, -36 },
  { 2398, 10, 28, 31, 10, -28 },
  { 2433, 13, 36, 31, 7, -28 },
  { 2492, 24, 28, 31, 5, -30 },
  { 2576, 26, 13, 31, 3, -22 },
  { 2619, 25, 28, 31, 2, -30 },
  { 2707, 21, 36, 31, 7, -36 },
  { 2802, 25, 42, 31, 3, -36 },
  { 2934, 26, 36, 31, 0, -36 },
  { 3051, 25, 36, 31, 3, -36 },
  { 3164, 25, 37, 31, 4, -36 },
  { 3280, 26, 36, 31, 3, -36 },
  { 3397, 27, 36, 31, 3, -36 },
  { 3519, 28, 36, 31, 3, -36 },
  { 3645, 25, 37, 31, 4, -36 },
  { 3761, 28, 36, 31, 2, -36 },
  { 3887, 28, 36, 31, 2, -36 },
  { 4013, 25, 37, 31, 3, -36 },
  { 4129, 29, 36, 31, 3, -36 },
  { 4260, 21, 36, 31, 4, -36 },
  { 4355, 28, 36, 31, 2, -36 },
  { 4481, 28, 36, 31, 2, -36 },
  { 4607, 26, 37, 31, 3, -36 },
  { 4728, 27, 36, 31, 3, -36 },
  { 4850, 26, 45, 31, 3, -36 },
  { 4997, 27, 36, 31, 3, -36 },
  { 5119, 27, 37, 31, 2, -36 },
  { 5244, 28, 36, 31, 5, -36 },
  { 5370, 26, 37, 31, 4, -36 },
  { 5491, 26, 36, 31, 6, -36 },
  { 5608, 29, 36, 31, 3, -36 },
  { 5739, 32, 36, 31, 0, -36 },
  { 5883, 28, 36, 31, 5, -36 },
  { 6009, 31, 36, 31, 0, -36 },
  { 6149, 21, 46, 31, 9, -39 },
  { 6270, 12, 46, 31, 10, -39 },
  { 6339, 21, 46, 31, 1, -39 },
  { 6460, 25, 20, 31, 4, -36 },
  { 6523, 25, 3, 31, 0, 5 },
  { 6533, 6, 9, 31, 12, -39 },
  { 6540, 24, 28, 31, 3, -27 },
  { 6624, 24, 39, 31, 3, -38 },
  { 6741, 22, 28, 31, 4, -27 },
  { 6818, 26, 39, 31, 3, -38 },
  { 6945, 23, 28, 31, 4, -27 },
  { 7026, 33, 49, 31, -1, -38 },
  { 7229, 25, 38, 31, 2, -27 },
  { 7348, 22, 38, 31, 4, -38 },
  { 7453, 23, 39, 31, 4, -38 },
  { 7566, 23, 49, 31, 4, -38 },
  { 7707, 26, 39, 31, 3, -38 },
  { 7834, 20, 39, 31, 6, -38 },
  { 7932, 28, 27, 31, 1, -27 },
  { 8027, 22, 27, 31, 4, -27 },
  { 8102, 23, 28, 31, 4, -27 },
  { 8183, 25, 37, 31, 2, -27 },
  { 8299, 24, 37, 31, 3, -27 },
  { 8410, 24, 26, 31, 6, -26 },
  { 8488, 24, 28, 31, 3, -27 },
  { 8572, 24, 37, 31, 4, -36 },
  { 8683, 22, 27, 31, 5, -26 },
  { 8758, 23, 27, 31, 4, -27 },
  { 8836, 26, 28, 31, 3, -27 },
  { 8927, 29, 28, 31, 1, -27 },
  { 9029, 25, 37, 31, 2, -26 },
  { 9145, 25, 28, 31, 3, -27 },
  { 9233, 23, 46, 31, 6, -39 },
  { 9366, 10, 46, 31, 11, -39 },
  { 9424, 24, 46, 31, 2, -39 },
  { 9562, 27, 11, 31, 2, -21 },
};

const GFXfont IBMPlexMono_LightItalic51pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic51pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic51pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _IBMPLEXMONO_LIGHTITALIC51PT7B_H_
