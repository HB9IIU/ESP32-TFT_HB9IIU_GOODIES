#ifndef _IBMPLEXMONO_LIGHTITALIC10PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x88, 0xB7, 0x00, 0x1C, 0xA6, 0xCC, 0xD9, 0x4A, 0x00, 0x10,
  0xE5, 0x58, 0x38, 0xAA, 0x9C, 0x20, 0x67, 0x31, 0xA0, 0x05, 0x94, 0xA6,
  0x00, 0x31, 0x24, 0x9C, 0xA2, 0x5E, 0x80, 0xE0, 0x34, 0x88, 0x88, 0x88,
  0x40, 0x44, 0x92, 0x52, 0x80, 0x22, 0x3E, 0xCA, 0x00, 0x24, 0xF4, 0x40,
  0x58, 0xE0, 0x80, 0x04, 0x21, 0x04, 0x20, 0x84, 0x10, 0x80, 0x74, 0x63,
  0x59, 0x4B, 0x80, 0x11, 0x94, 0x22, 0x13, 0xE0, 0x3A, 0x42, 0x11, 0x33,
  0xE0, 0x3A, 0x42, 0x60, 0xC5, 0xC0, 0x08, 0xCA, 0x99, 0x7C, 0x40, 0x7C,
  0x3D, 0x21, 0x4B, 0x80, 0x34, 0xF9, 0x99, 0xE0, 0xFC, 0x84, 0x42, 0x22,
  0x00, 0x39, 0x14, 0x8C, 0xCA, 0x27, 0x00, 0x74, 0xA3, 0x2F, 0x13, 0x00,
  0x40, 0x80, 0x20, 0x04, 0xA0, 0x09, 0xB1, 0x06, 0x08, 0xF8, 0x3C, 0x41,
  0x82, 0x13, 0x60, 0x74, 0x44, 0x44, 0x01, 0x00, 0x74, 0x6D, 0xAD, 0x7A,
  0x1C, 0x11, 0x8A, 0x97, 0xC6, 0x20, 0x79, 0x9E, 0x99, 0xF0, 0x74, 0x61,
  0x08, 0x4B, 0x80, 0x74, 0x63, 0x19, 0x4B, 0x80, 0x7C, 0x21, 0xE8, 0x43,
  0xC0, 0x7C, 0x21, 0xE8, 0x42, 0x00, 0x74, 0xA3, 0x69, 0x4B, 0xC0, 0x45,
  0x14, 0x9E, 0x4A, 0x28, 0x80, 0x3C, 0x41, 0x08, 0x20, 0x8F, 0x80, 0x71,
  0x11, 0x19, 0xE0, 0x8C, 0xA9, 0xCA, 0x52, 0x40, 0x48, 0x88, 0x88, 0xF0,
  0x45, 0xB7, 0x66, 0xAA, 0x28, 0x80, 0x25, 0x96, 0x9A, 0x9A, 0x68, 0x80,
  0x74, 0x63, 0x19, 0x4B, 0x80, 0x74, 0x63, 0xE8, 0x42, 0x00, 0x74, 0x63,
  0x19, 0x4B, 0x8A, 0x30, 0x74, 0x63, 0xEA, 0x52, 0x40, 0x39, 0x14, 0x0E,
  0x0A, 0x27, 0x00, 0xF9, 0x08, 0x84, 0x21, 0x00, 0x8C, 0x65, 0x29, 0x4B,
  0x80, 0x8C, 0x65, 0x2A, 0x51, 0x00, 0x8C, 0x6B, 0xEF, 0x4A, 0x40, 0x44,
  0xA3, 0x04, 0x31, 0x28, 0x80, 0x8E, 0x45, 0x18, 0x41, 0x04, 0x00, 0x7C,
  0x21, 0x08, 0x42, 0x0F, 0x80, 0x74, 0x88, 0x88, 0x88, 0xC0, 0xAA, 0x95,
  0x40, 0x31, 0x11, 0x12, 0x22, 0xE0, 0x22, 0xA5, 0x10, 0xF8, 0xB0, 0x79,
  0x99, 0xF0, 0x88, 0xBD, 0x99, 0xE0, 0x69, 0x89, 0xE0, 0x08, 0x9D, 0x29,
  0x4B, 0xC0, 0x79, 0xE9, 0xE0, 0x0C, 0x47, 0xC4, 0x20, 0x8A, 0x28, 0x60,
  0x3A, 0x63, 0x17, 0xC9, 0xC0, 0xC8, 0xBD, 0x99, 0x90, 0x20, 0xC4, 0x47,
  0x60, 0x10, 0x72, 0x22, 0xAA, 0x60, 0x84, 0x2D, 0xAE, 0x66, 0xC0, 0xE4,
  0x44, 0x5B, 0x40, 0x6D, 0x5A, 0xAA, 0xA8, 0xBD, 0x99, 0x90, 0x79, 0x99,
  0xE0, 0x5B, 0x52, 0x9B, 0x42, 0x00, 0x79, 0x99, 0xF2, 0x20, 0xDB, 0x10,
  0x84, 0x00, 0x78, 0x71, 0xE0, 0x44, 0xF4, 0x4B, 0x40, 0x99, 0x99, 0xF0,
  0xD9, 0x9B, 0xE0, 0xAE, 0x73, 0xAB, 0x00, 0x2F, 0x52, 0x2B, 0xD0, 0x4A,
  0x52, 0x97, 0xC9, 0xC0, 0xFC, 0x99, 0x2F, 0x00, 0x39, 0x08, 0x4C, 0x11,
  0x10, 0x60, 0x55, 0xAA, 0x80, 0x30, 0x88, 0x41, 0x90, 0x84, 0xE0, 0x66,
  0xA9, 0x80,
};

const GFXglyph IBMPlexMono_LightItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 7, 7, 6, 0, -7 },
  { 25, 6, 7, 6, 0, -7 },
  { 31, 1, 3, 6, 3, -7 },
  { 32, 4, 9, 6, 2, -8 },
  { 37, 3, 9, 6, 1, -8 },
  { 41, 5, 5, 6, 1, -5 },
  { 45, 4, 5, 6, 1, -6 },
  { 48, 2, 3, 6, 1, -1 },
  { 49, 3, 1, 6, 2, -4 },
  { 50, 1, 1, 6, 2, -1 },
  { 51, 6, 9, 6, 0, -8 },
  { 58, 5, 7, 6, 1, -7 },
  { 63, 5, 7, 6, 0, -7 },
  { 68, 5, 7, 6, 0, -7 },
  { 73, 5, 7, 6, 0, -7 },
  { 78, 5, 7, 6, 0, -7 },
  { 83, 5, 7, 6, 1, -7 },
  { 88, 4, 7, 6, 1, -7 },
  { 92, 5, 7, 6, 1, -7 },
  { 97, 6, 7, 6, 0, -7 },
  { 103, 5, 7, 6, 1, -7 },
  { 108, 2, 5, 6, 2, -5 },
  { 110, 3, 7, 6, 1, -5 },
  { 113, 5, 6, 6, 1, -6 },
  { 117, 5, 3, 6, 1, -5 },
  { 119, 5, 6, 6, 0, -6 },
  { 123, 5, 7, 6, 1, -7 },
  { 128, 5, 8, 6, 1, -7 },
  { 133, 5, 7, 6, 0, -7 },
  { 138, 4, 7, 6, 1, -7 },
  { 142, 5, 7, 6, 1, -7 },
  { 147, 5, 7, 6, 1, -7 },
  { 152, 5, 7, 6, 1, -7 },
  { 157, 5, 7, 6, 1, -7 },
  { 162, 5, 7, 6, 1, -7 },
  { 167, 6, 7, 6, 0, -7 },
  { 173, 6, 7, 6, 0, -7 },
  { 179, 4, 7, 6, 1, -7 },
  { 183, 5, 7, 6, 1, -7 },
  { 188, 4, 7, 6, 1, -7 },
  { 192, 6, 7, 6, 0, -7 },
  { 198, 6, 7, 6, 0, -7 },
  { 204, 5, 7, 6, 1, -7 },
  { 209, 5, 7, 6, 1, -7 },
  { 214, 5, 9, 6, 1, -7 },
  { 220, 5, 7, 6, 1, -7 },
  { 225, 6, 7, 6, 0, -7 },
  { 231, 5, 7, 6, 1, -7 },
  { 236, 5, 7, 6, 1, -7 },
  { 241, 5, 7, 6, 1, -7 },
  { 246, 5, 7, 6, 1, -7 },
  { 251, 6, 7, 6, 0, -7 },
  { 257, 6, 7, 6, 1, -7 },
  { 263, 6, 7, 6, 0, -7 },
  { 269, 4, 9, 6, 2, -8 },
  { 274, 2, 9, 6, 2, -8 },
  { 277, 4, 9, 6, 0, -8 },
  { 282, 5, 4, 6, 1, -7 },
  { 285, 5, 1, 6, 0, 1 },
  { 286, 2, 2, 6, 2, -8 },
  { 287, 4, 5, 6, 1, -5 },
  { 290, 4, 7, 6, 1, -7 },
  { 294, 4, 5, 6, 1, -5 },
  { 297, 5, 7, 6, 1, -7 },
  { 302, 4, 5, 6, 1, -5 },
  { 305, 6, 9, 6, 0, -7 },
  { 312, 5, 7, 6, 0, -5 },
  { 317, 4, 7, 6, 1, -7 },
  { 321, 4, 7, 6, 1, -7 },
  { 325, 4, 9, 6, 1, -7 },
  { 330, 5, 7, 6, 1, -7 },
  { 335, 4, 7, 6, 1, -7 },
  { 339, 6, 5, 6, 0, -5 },
  { 343, 4, 5, 6, 1, -5 },
  { 346, 4, 5, 6, 1, -5 },
  { 349, 5, 7, 6, 0, -5 },
  { 354, 4, 7, 6, 1, -5 },
  { 358, 5, 5, 6, 1, -5 },
  { 362, 4, 5, 6, 1, -5 },
  { 365, 4, 7, 6, 1, -7 },
  { 369, 4, 5, 6, 1, -5 },
  { 372, 4, 5, 6, 1, -5 },
  { 375, 5, 5, 6, 1, -5 },
  { 379, 6, 5, 6, 0, -5 },
  { 383, 5, 7, 6, 0, -5 },
  { 388, 5, 5, 6, 1, -5 },
  { 392, 5, 9, 6, 1, -8 },
  { 398, 2, 9, 6, 2, -8 },
  { 401, 5, 9, 6, 0, -8 },
  { 407, 6, 3, 6, 0, -4 },
};

const GFXfont IBMPlexMono_LightItalic10pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic10pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _IBMPLEXMONO_LIGHTITALIC10PT7B_H_
