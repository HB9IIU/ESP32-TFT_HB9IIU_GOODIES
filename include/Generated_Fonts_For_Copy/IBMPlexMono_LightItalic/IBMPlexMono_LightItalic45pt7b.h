#ifndef _IBMPLEXMONO_LIGHTITALIC45PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x8F, 0x87, 0xC1, 0xC0,
  0x38, 0x73, 0x87, 0x30, 0x73, 0x06, 0x30, 0x67, 0x06, 0x70, 0xE7, 0x0E,
  0x60, 0xE6, 0x0C, 0x60, 0xCE, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x38, 0x18, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x06, 0x07, 0x00, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE0, 0x06,
  0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x06, 0x06, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x06, 0x06, 0x00, 0x7F, 0xC0,
  0xFF, 0x8F, 0xF8, 0x3F, 0xE0, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x06, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x03, 0xC6, 0x7C, 0x03, 0x83, 0x07, 0x03, 0x81, 0x81, 0xC1, 0x80,
  0xC0, 0x41, 0xC0, 0x60, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x38,
  0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01,
  0xE1, 0x80, 0x00, 0x7D, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x18, 0xF0, 0x00, 0x0C, 0x3C, 0x00, 0x0C, 0x0E,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0,
  0x60, 0x00, 0x60, 0x30, 0x80, 0x60, 0x38, 0x60, 0x30, 0x1C, 0x78, 0x18,
  0x1C, 0x1E, 0x0C, 0x1C, 0x03, 0xC6, 0x3C, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x30, 0x3C, 0x38, 0x01, 0x80, 0xC0, 0x60, 0x0E, 0x06, 0x01, 0x80,
  0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x18, 0x0C, 0x03, 0x80, 0x60, 0x70,
  0x0C, 0x01, 0x81, 0x80, 0x30, 0x06, 0x0C, 0x00, 0xC0, 0x38, 0x60, 0x03,
  0x00, 0xC3, 0x80, 0x06, 0x07, 0x0C, 0x00, 0x1C, 0x38, 0x60, 0x00, 0x3F,
  0xC3, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0x0F, 0xF8, 0x00, 0x18, 0x70, 0x60, 0x00, 0xE1, 0x80,
  0xC0, 0x03, 0x0C, 0x03, 0x00, 0x18, 0x30, 0x0C, 0x00, 0xE1, 0xC0, 0x30,
  0x07, 0x07, 0x00, 0xC0, 0x18, 0x18, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x07,
  0x01, 0x80, 0x70, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x1C, 0x0E, 0x07, 0x00,
  0x38, 0x70, 0x38, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0x18, 0x00, 0x70, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x06, 0x00, 0x70,
  0x01, 0x80, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x00,
  0x60, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x0F,
  0xC7, 0x00, 0x0F, 0x3F, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x01,
  0xC0, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x3E, 0x00,
  0x3C, 0x0D, 0x80, 0x0B, 0x06, 0x70, 0x04, 0xE3, 0x9C, 0x03, 0x1C, 0xC3,
  0xC3, 0x87, 0x70, 0x7F, 0xC0, 0xF8, 0x07, 0xE0, 0x1C, 0x00, 0x33, 0x77,
  0x76, 0x66, 0xEE, 0xEC, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x20, 0x0E,
  0x01, 0xF0, 0x30, 0x3F, 0xF8, 0xC7, 0xF1, 0xFF, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x00, 0x07,
  0x0E, 0x00, 0x38, 0x18, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0xC0, 0x70, 0x03,
  0x80, 0xC0, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x38,
  0x70, 0x70, 0xE0, 0xE0, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x79, 0xFF, 0xBE,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80,
  0x1E, 0x0F, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x00, 0x71, 0xC0,
  0x01, 0xC7, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xE0, 0x00, 0x33, 0x00, 0x00,
  0xDC, 0x00, 0x03, 0x70, 0x00, 0x0D, 0xC0, 0x00, 0x37, 0x03, 0x81, 0xD8,
  0x1E, 0x07, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0C,
  0xE0, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x70,
  0x01, 0xC0, 0xE0, 0x0E, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0E, 0xE0, 0x01, 0xE7, 0x00,
  0x1E, 0x38, 0x01, 0xE1, 0x80, 0x1C, 0x0C, 0x03, 0xC0, 0xE0, 0x1C, 0x07,
  0x00, 0x40, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3E, 0x0F, 0x81, 0xE0, 0x0E, 0x07, 0x00,
  0x1C, 0x38, 0x00, 0x70, 0xC0, 0x00, 0xC5, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0x81, 0xF0,
  0x1E, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x03, 0x8F,
  0x00, 0x07, 0x0F, 0x00, 0x1C, 0x0F, 0x80, 0xF0, 0x07, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xDC, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x18, 0x00,
  0x07, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x38, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x30, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x1C,
  0x00, 0x60, 0x38, 0x00, 0x60, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x87, 0xE0, 0x03, 0x3F, 0xF0, 0x0E, 0xC0, 0xF0, 0x1E, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x61, 0x80, 0x01, 0xC7, 0x80, 0x07, 0x07, 0x80, 0x1E, 0x07, 0xC0,
  0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC7, 0xF0, 0x1C, 0xFF, 0xE0, 0xCC, 0x07, 0x8E, 0x80,
  0x1C, 0x78, 0x00, 0x73, 0xC0, 0x03, 0x9C, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0x18, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x1E,
  0x07, 0x80, 0x7F, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF6, 0x00, 0x03, 0x98, 0x00, 0x0E, 0x60, 0x00, 0x73, 0x80, 0x03, 0xCE,
  0x00, 0x0E, 0x30, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xF0, 0x07, 0x81, 0xF0, 0x1C, 0x00, 0xE0, 0x70, 0x00, 0xE0,
  0xC0, 0x01, 0xC3, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x1C, 0x30, 0x00, 0x38, 0x70, 0x00, 0x60, 0xE0, 0x01, 0xC0, 0xE0,
  0x07, 0x00, 0xF0, 0x38, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0E, 0x03,
  0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0xC7, 0x00, 0x01, 0x8E, 0x00, 0x03,
  0x98, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x33,
  0x80, 0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00, 0x07, 0x0F, 0x00, 0x1C, 0x0F,
  0x80, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xFE, 0x01, 0xE0, 0x78, 0x3C, 0x01, 0xC1, 0xC0, 0x07, 0x1C, 0x00, 0x19,
  0xC0, 0x00, 0xEE, 0x00, 0x07, 0x60, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x39, 0x80, 0x03, 0xCE,
  0x00, 0x1E, 0x78, 0x03, 0x61, 0xE0, 0x37, 0x07, 0xFF, 0x38, 0x0F, 0xE3,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x07, 0x07, 0xC7, 0xE3,
  0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xC7, 0xC3, 0xE0, 0xE0, 0x01,
  0xC0, 0x7C, 0x1F, 0x83, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x08,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0xE0, 0x78, 0x1E, 0x1C, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x01, 0xF8, 0x00,
  0x39, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x0E, 0x07,
  0x00, 0x18, 0x38, 0x00, 0x60, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x60, 0x3E, 0x73, 0x83, 0xFD, 0xCC, 0x0E, 0x1F, 0x30, 0x70, 0x38,
  0xC3, 0x80, 0xE7, 0x0C, 0x01, 0x9C, 0x30, 0x06, 0x60, 0xC0, 0x39, 0x87,
  0x00, 0xE6, 0x1C, 0x03, 0x18, 0x60, 0x0C, 0xE1, 0x80, 0x33, 0x86, 0x01,
  0xCE, 0x18, 0x07, 0x30, 0x60, 0x3C, 0xC1, 0xC0, 0xE3, 0x07, 0x05, 0x8C,
  0x0F, 0xE6, 0x30, 0x1F, 0x18, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x66, 0x00, 0x01, 0xCC, 0x00,
  0x03, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x70, 0x00, 0x70, 0x60, 0x00,
  0xC0, 0xC0, 0x03, 0x81, 0x80, 0x07, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0E, 0x00,
  0x60, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x06, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x60, 0x00, 0xC0, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E,
  0x00, 0x0C, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x70, 0x60, 0x00, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x1E, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x18, 0x00,
  0xF0, 0x30, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0xC3, 0x80, 0x01,
  0x87, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x86, 0x00, 0x1E, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80,
  0x3C, 0x0F, 0x01, 0xC0, 0x1E, 0x06, 0x00, 0x38, 0x38, 0x00, 0x61, 0xC0,
  0x01, 0xC6, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x18, 0x00, 0x70, 0x70,
  0x01, 0xC1, 0xE0, 0x0E, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xE0, 0x1E, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0, 0x01, 0xC3, 0x00, 0x07, 0x1C,
  0x00, 0x0C, 0x70, 0x00, 0x31, 0xC0, 0x00, 0xC7, 0x00, 0x03, 0x18, 0x00,
  0x1C, 0x60, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0xE0, 0x00, 0x73, 0x00, 0x01, 0x8C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0xE7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0xE1, 0x80, 0x03,
  0x8E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x0F, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1E,
  0x07, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xC0, 0x00,
  0xC7, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x7F, 0xEE, 0x01, 0xFF, 0xB8, 0x00, 0x0E,
  0xE0, 0x00, 0x33, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x38, 0x00, 0x1C, 0xE0,
  0x00, 0x71, 0x80, 0x01, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01,
  0x60, 0xE0, 0x0B, 0x81, 0xE0, 0xEE, 0x03, 0xFF, 0x38, 0x07, 0xF0, 0x00,
  0x07, 0x00, 0x03, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0C,
  0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x30, 0x00, 0x38, 0x30, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x30,
  0x70, 0x00, 0x30, 0x70, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x83, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x70,
  0x0F, 0x01, 0xE0, 0x78, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00,
  0x60, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x0F,
  0x00, 0x0E, 0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x30, 0x3C, 0x00, 0x06,
  0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x3E, 0x00,
  0x00, 0xEE, 0xE0, 0x00, 0x1B, 0x8C, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0xF8,
  0x18, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x07, 0x00,
  0x0C, 0x00, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x7C, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x06, 0xC0, 0x0D, 0x81, 0xB0, 0x07,
  0x60, 0x6E, 0x01, 0xB8, 0x39, 0x80, 0xEE, 0x0E, 0x60, 0x73, 0x03, 0x98,
  0x18, 0xC0, 0xC7, 0x0E, 0x30, 0x30, 0xC3, 0x0C, 0x0C, 0x31, 0xC7, 0x07,
  0x0C, 0xE1, 0xC1, 0xC3, 0xB0, 0x60, 0x60, 0x7C, 0x18, 0x18, 0x1E, 0x06,
  0x06, 0x07, 0x83, 0x81, 0x80, 0xC0, 0xE0, 0xE0, 0x20, 0x38, 0x38, 0x08,
  0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x03, 0x07, 0x80, 0x03, 0x07, 0xC0, 0x07, 0x06, 0xC0, 0x07, 0x0E, 0xC0,
  0x07, 0x0E, 0xE0, 0x06, 0x0E, 0xE0, 0x06, 0x0C, 0x60, 0x06, 0x0C, 0x60,
  0x0E, 0x0C, 0x70, 0x0E, 0x1C, 0x30, 0x0E, 0x1C, 0x30, 0x0C, 0x1C, 0x38,
  0x0C, 0x18, 0x38, 0x0C, 0x18, 0x18, 0x1C, 0x18, 0x18, 0x1C, 0x38, 0x1C,
  0x1C, 0x38, 0x1C, 0x18, 0x38, 0x0C, 0x18, 0x30, 0x0E, 0x18, 0x30, 0x0E,
  0x38, 0x30, 0x06, 0x38, 0x70, 0x06, 0x38, 0x70, 0x07, 0x30, 0x70, 0x07,
  0x30, 0x60, 0x03, 0x30, 0x60, 0x03, 0xF0, 0x60, 0x03, 0xF0, 0xE0, 0x01,
  0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x00, 0x71,
  0xC0, 0x01, 0xC7, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xE0, 0x00, 0x33, 0x00,
  0x00, 0xDC, 0x00, 0x03, 0x70, 0x00, 0x0D, 0xC0, 0x00, 0x37, 0x00, 0x01,
  0xD8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x0C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x18, 0x00, 0x30,
  0x70, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0x00, 0x1E, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C,
  0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x0E, 0x07, 0x00,
  0x38, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x38, 0x00, 0x0C,
  0xE0, 0x00, 0x33, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x70, 0x00, 0x0D, 0xC0,
  0x00, 0x37, 0x00, 0x01, 0xD8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE,
  0x00, 0x03, 0xB8, 0x00, 0x0C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00,
  0x0E, 0x18, 0x00, 0x30, 0x70, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0xC0, 0xF0,
  0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x01, 0x00,
  0x0E, 0x1E, 0x00, 0x38, 0xE0, 0x00, 0x77, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0x00, 0x1E, 0x07, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00,
  0x0E, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x18, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x0E,
  0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x80, 0x30, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x78, 0x0F, 0x80, 0x70, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x30, 0x00, 0x08, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x10, 0x00, 0x07, 0x0C, 0x00,
  0x03, 0x8F, 0x00, 0x03, 0x83, 0xC0, 0x03, 0x80, 0x7C, 0x07, 0x80, 0x1F,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x0C, 0x70, 0x00,
  0x71, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x63,
  0x80, 0x01, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xC0, 0x00, 0xE7, 0x00,
  0x03, 0x9C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0xC0, 0x01, 0xC7, 0x00, 0x07,
  0x18, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00, 0x06, 0x38,
  0x00, 0x38, 0xE0, 0x00, 0xE3, 0x00, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0xC0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x38, 0x00, 0xE0,
  0xE0, 0x07, 0x01, 0xE0, 0x78, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x73, 0x00, 0x00, 0xE6, 0x00,
  0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00,
  0xE0, 0x60, 0x01, 0xC0, 0xC0, 0x07, 0x01, 0x80, 0x0E, 0x03, 0x80, 0x18,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x18, 0x06, 0x00,
  0x30, 0x1C, 0x00, 0x60, 0x30, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0x80, 0x03,
  0x87, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x19,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x01, 0x98, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x38,
  0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x30, 0x1C, 0x06, 0x38, 0x1E, 0x07,
  0x1C, 0x0F, 0x03, 0x8E, 0x0F, 0x81, 0x87, 0x06, 0xC0, 0xC3, 0x03, 0x60,
  0xE1, 0x83, 0x30, 0x70, 0xC1, 0x98, 0x30, 0x61, 0xCC, 0x18, 0x30, 0xC7,
  0x1C, 0x18, 0x63, 0x8E, 0x0C, 0x60, 0xC6, 0x06, 0x30, 0x63, 0x07, 0x38,
  0x33, 0x83, 0x98, 0x19, 0xC1, 0xDC, 0x0C, 0xC0, 0xEC, 0x06, 0x60, 0x66,
  0x03, 0x70, 0x37, 0x01, 0xB8, 0x1B, 0x00, 0xD8, 0x0F, 0x80, 0x7C, 0x07,
  0x80, 0x3E, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x3C, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x30,
  0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x70, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x18, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0xB8, 0x00,
  0x03, 0x9C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC0, 0xC0,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x06, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xE0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xB0, 0x00, 0x0E, 0xE0, 0x00, 0x71, 0x80, 0x03, 0x87, 0x00, 0x0C, 0x1C,
  0x00, 0x70, 0x30, 0x03, 0x80, 0xE0, 0x1C, 0x01, 0x80, 0x60, 0x07, 0x03,
  0x80, 0x0C, 0x1C, 0x00, 0x30, 0xE0, 0x00, 0xE3, 0x00, 0x01, 0x9C, 0x00,
  0x07, 0xE0, 0x00, 0x0D, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC7, 0x38, 0xC7, 0x18, 0xE2, 0x00, 0xFC, 0x00, 0x1F, 0xF9, 0xC3,
  0xE0, 0xEE, 0x3C, 0x01, 0x61, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xC0, 0x01,
  0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x00, 0x03, 0xB8, 0x00, 0x19, 0xC0,
  0x00, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x00, 0x03, 0x98, 0x00, 0x1C,
  0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x8E, 0x00,
  0x7C, 0x38, 0x06, 0xE0, 0xE0, 0xE7, 0xE7, 0xFE, 0x1F, 0x0F, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0xFC, 0x03, 0x1F, 0xF0, 0x39, 0x81, 0xC1, 0xD8, 0x07, 0x0F, 0x80,
  0x18, 0x68, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x19, 0xC0, 0x00, 0xCE,
  0x00, 0x06, 0x70, 0x00, 0x33, 0x00, 0x03, 0x98, 0x00, 0x1C, 0xC0, 0x00,
  0xEE, 0x00, 0x07, 0x70, 0x00, 0x33, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0,
  0x00, 0xC7, 0x00, 0x0E, 0x78, 0x00, 0xE3, 0xA0, 0x0E, 0x1D, 0xC1, 0xE0,
  0xE7, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3C,
  0x0F, 0x0E, 0x00, 0xE1, 0x80, 0x0E, 0x60, 0x00, 0x9C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x13, 0x00, 0x07, 0x70, 0x00, 0xC6, 0x00, 0x38, 0xE0, 0x0E, 0x0F, 0x07,
  0x80, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x01, 0xF8, 0x30, 0x0F,
  0xFC, 0xE0, 0x7C, 0x1D, 0xC0, 0xE0, 0x0B, 0x83, 0x80, 0x0F, 0x0E, 0x00,
  0x1C, 0x18, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18,
  0x60, 0x00, 0x70, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC3, 0x00, 0x07, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x2C, 0x0C, 0x00, 0xF8, 0x1C, 0x03, 0x70, 0x1C,
  0x0C, 0xE0, 0x1F, 0xF1, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xFC, 0x03, 0xC0, 0xE0, 0x70, 0x07, 0x0C, 0x00, 0x31, 0xC0, 0x03, 0x38,
  0x00, 0x33, 0x00, 0x03, 0x70, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x03, 0xC6,
  0x07, 0xF8, 0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x06, 0x60, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x01,
  0xC3, 0x80, 0x38, 0x1E, 0x0F, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xFE, 0x70, 0x7C, 0x1D, 0xC3, 0xC0, 0x17, 0x0E, 0x00,
  0x3C, 0x70, 0x00, 0xE1, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x39,
  0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0xC0,
  0x01, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x71, 0xC0, 0x03,
  0x87, 0x00, 0x16, 0x1C, 0x00, 0xF8, 0x38, 0x06, 0xE0, 0x70, 0x33, 0x80,
  0xFF, 0x8E, 0x01, 0xF8, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x81, 0x00, 0x0E, 0x0E, 0x00, 0x70,
  0x3C, 0x07, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE1, 0xF8, 0x0C, 0x7F,
  0xC0, 0xCE, 0x1E, 0x0D, 0x80, 0xE1, 0xD0, 0x07, 0x1E, 0x00, 0x71, 0xC0,
  0x07, 0x1C, 0x00, 0x71, 0x80, 0x07, 0x18, 0x00, 0x73, 0x80, 0x07, 0x38,
  0x00, 0x63, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xE7,
  0x00, 0x0E, 0x70, 0x00, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x1C,
  0x60, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x20, 0x38,
  0x0F, 0x03, 0x01, 0xC0, 0x30, 0x38, 0x07, 0x07, 0x00, 0x71, 0xC0, 0x07,
  0x38, 0x00, 0x67, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x04, 0x01, 0x80, 0xE0, 0x18,
  0x07, 0x01, 0x80, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x73,
  0x00, 0x03, 0xB0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x3F, 0x00, 0x31, 0xFF, 0x00, 0x67, 0x07, 0x01, 0xD8, 0x07, 0x03, 0xE0,
  0x0E, 0x07, 0x80, 0x0C, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x30, 0x00,
  0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x06, 0x01, 0xC0,
  0x0C, 0x1E, 0x00, 0x18, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01,
  0xC1, 0xC0, 0x33, 0x03, 0x80, 0xF6, 0x03, 0x83, 0x8C, 0x07, 0x0E, 0x38,
  0x06, 0x38, 0x70, 0x0E, 0xE0, 0xE0, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0xFF,
  0xF0, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x83, 0x80, 0x70, 0xE0, 0x78,
  0x30, 0x38, 0x0C, 0x1C, 0x07, 0x0E, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x1F,
  0x80, 0x03, 0x80, 0x00, 0x00, 0x78, 0x3E, 0x06, 0x7E, 0x3F, 0x83, 0x43,
  0xB1, 0xC1, 0xC1, 0xD0, 0x61, 0xC0, 0x70, 0x38, 0xE0, 0x30, 0x18, 0x60,
  0x38, 0x0C, 0x30, 0x1C, 0x06, 0x18, 0x0E, 0x03, 0x1C, 0x06, 0x03, 0x8E,
  0x03, 0x01, 0xC6, 0x01, 0x80, 0xE3, 0x01, 0xC0, 0x61, 0x80, 0xE0, 0x30,
  0xC0, 0x70, 0x18, 0xE0, 0x30, 0x1C, 0x70, 0x18, 0x0E, 0x38, 0x0C, 0x07,
  0x18, 0x06, 0x03, 0x0C, 0x07, 0x01, 0x86, 0x03, 0x80, 0xC7, 0x01, 0x80,
  0x63, 0x80, 0xC0, 0x71, 0xC0, 0x60, 0x38, 0x00, 0x1F, 0x80, 0xE7, 0xFC,
  0x0C, 0xE1, 0xE0, 0xD8, 0x0E, 0x1D, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00,
  0x71, 0xC0, 0x07, 0x18, 0x00, 0x71, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80,
  0x06, 0x38, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xE3, 0x00, 0x0E, 0x70,
  0x00, 0xE7, 0x00, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0xC6,
  0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x18, 0x00, 0x7E, 0x00, 0x0F, 0xFC,
  0x01, 0xE0, 0x70, 0x1C, 0x01, 0xC1, 0xC0, 0x07, 0x0C, 0x00, 0x18, 0xE0,
  0x00, 0xC6, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xD8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x87,
  0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x70, 0x3C, 0x01, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x06, 0x3F, 0xE0, 0x1C, 0xC0, 0xE0, 0x3B, 0x00,
  0xE0, 0x7C, 0x00, 0xC0, 0xD0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x03,
  0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x70,
  0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x60, 0xE0, 0x01, 0xC3, 0xC0,
  0x07, 0x07, 0x40, 0x1C, 0x0E, 0xE0, 0xF0, 0x1C, 0xFF, 0xC0, 0x30, 0x7E,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xF9, 0xC3, 0xE0, 0xEE, 0x1C, 0x01, 0x71, 0xC0,
  0x07, 0x9C, 0x00, 0x38, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73,
  0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xCE, 0x00, 0x06, 0x70, 0x00,
  0x33, 0x00, 0x03, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0xE6, 0x00, 0x0E, 0x38,
  0x00, 0x71, 0xC0, 0x05, 0x86, 0x00, 0x7C, 0x38, 0x06, 0xE0, 0xE0, 0x67,
  0x03, 0xFE, 0x30, 0x0F, 0xC1, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xE0, 0x1D, 0xC0, 0x00,
  0x6C, 0x00, 0x01, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x80, 0x7C, 0x0F, 0x81, 0xC0, 0x0F, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x08,
  0x00, 0x0C, 0xF0, 0x00, 0x71, 0xE0, 0x03, 0x83, 0xE0, 0x3C, 0x03, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x06, 0x06, 0x00, 0xE0, 0xE0, 0x38, 0x0E, 0x0F, 0x00,
  0xE1, 0xC0, 0x0E, 0x78, 0x00, 0xCE, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x63, 0x80, 0x06, 0x30, 0x00,
  0x63, 0x00, 0x0E, 0x30, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xC7, 0x00,
  0x0C, 0x60, 0x00, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0xCE, 0x00, 0x1C, 0xE0,
  0x01, 0x8E, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x8E,
  0x00, 0xB8, 0x70, 0x1B, 0x07, 0x83, 0x30, 0x3F, 0xE3, 0x01, 0xF8, 0x40,
  0x7F, 0x00, 0x37, 0xF8, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70,
  0x01, 0x83, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x06, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0xC0, 0x07, 0x06, 0x00,
  0x30, 0x30, 0x03, 0x81, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x1C, 0x07,
  0x01, 0xC0, 0x30, 0x3C, 0x01, 0x87, 0xC0, 0x0F, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x1C, 0x06, 0x0C, 0x1C, 0x06, 0x0E, 0x18, 0x0E, 0x06, 0x18, 0x0E,
  0x06, 0x18, 0x0C, 0x06, 0x18, 0x0C, 0x06, 0x38, 0x0C, 0x06, 0x38, 0x0C,
  0x07, 0x30, 0x1C, 0x07, 0x30, 0x1C, 0x06, 0x30, 0x18, 0x06, 0x30, 0x18,
  0x06, 0x70, 0x18, 0x06, 0x70, 0x18, 0x06, 0x60, 0x38, 0x0E, 0x60, 0x38,
  0x0E, 0x60, 0x30, 0x0C, 0x60, 0x30, 0x1C, 0xE0, 0x70, 0x18, 0xE0, 0x70,
  0x38, 0x60, 0xB0, 0x30, 0x71, 0x98, 0xF0, 0x7F, 0x1F, 0xC0, 0x3E, 0x0F,
  0x80, 0x00, 0xE0, 0x1E, 0x00, 0xFC, 0x1F, 0xC0, 0xF3, 0x8E, 0x38, 0x78,
  0xE6, 0x06, 0x78, 0x19, 0x81, 0x88, 0x06, 0x40, 0x70, 0x01, 0xA0, 0x18,
  0x00, 0x68, 0x06, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x30, 0x0B, 0x00, 0x0C,
  0x02, 0xC0, 0x03, 0x01, 0xB0, 0x18, 0xC0, 0x4C, 0x0F, 0x30, 0x33, 0x8F,
  0x0E, 0x18, 0x67, 0x81, 0xFC, 0x1F, 0x80, 0x3E, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x38, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0xC0, 0x03, 0x81, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x18, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x03,
  0x83, 0x80, 0x07, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x38, 0x01, 0xE0, 0x70, 0x05, 0xC0, 0x70, 0x1B, 0x80, 0xF0, 0x66, 0x00,
  0xFF, 0x8C, 0x00, 0x7C, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x04, 0x00, 0x38, 0x0C, 0x00,
  0xF0, 0x3E, 0x07, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xFC, 0x1C, 0x38, 0x3E, 0x38, 0x60, 0x0F, 0x61, 0xC0, 0x03,
  0xC3, 0x00, 0x0F, 0x06, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x18, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x30, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0x60, 0x78, 0x00, 0xC1, 0xE0, 0x01, 0x87, 0xF0, 0x03, 0x8C, 0xFE,
  0x07, 0x18, 0x1F, 0xC6, 0x70, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C,
  0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x80, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x07, 0xC0, 0x06, 0x0F, 0xE0, 0x07, 0x1C, 0x70, 0x06, 0x38, 0x30,
  0x0C, 0x30, 0x18, 0x0C, 0x70, 0x1C, 0x18, 0x60, 0x0E, 0x38, 0xE0, 0x07,
  0xF0, 0x40, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_LightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 9, 31, 27, 9, -31 },
  { 36, 12, 12, 27, 10, -33 },
  { 54, 27, 31, 27, 1, -31 },
  { 159, 25, 43, 27, 1, -37 },
  { 294, 30, 33, 27, -1, -32 },
  { 418, 26, 33, 27, 0, -32 },
  { 526, 4, 12, 27, 14, -33 },
  { 532, 15, 40, 27, 10, -34 },
  { 607, 16, 40, 27, 2, -34 },
  { 687, 22, 22, 27, 3, -25 },
  { 748, 22, 22, 27, 3, -25 },
  { 809, 8, 12, 27, 7, -5 },
  { 821, 13, 2, 27, 7, -15 },
  { 825, 6, 5, 27, 9, -5 },
  { 829, 25, 40, 27, 1, -34 },
  { 954, 22, 33, 27, 3, -32 },
  { 1045, 21, 31, 27, 2, -31 },
  { 1127, 22, 32, 27, 2, -32 },
  { 1215, 23, 33, 27, 1, -32 },
  { 1310, 24, 31, 27, 1, -31 },
  { 1403, 23, 32, 27, 2, -31 },
  { 1495, 21, 32, 27, 3, -31 },
  { 1579, 22, 31, 27, 5, -31 },
  { 1665, 23, 33, 27, 2, -32 },
  { 1760, 21, 32, 27, 4, -32 },
  { 1844, 9, 24, 27, 9, -24 },
  { 1871, 11, 31, 27, 7, -24 },
  { 1914, 22, 25, 27, 4, -26 },
  { 1983, 23, 11, 27, 2, -19 },
  { 2015, 22, 25, 27, 2, -26 },
  { 2084, 19, 32, 27, 6, -32 },
  { 2160, 22, 37, 27, 3, -32 },
  { 2262, 23, 31, 27, 0, -31 },
  { 2352, 23, 31, 27, 2, -31 },
  { 2442, 22, 33, 27, 4, -32 },
  { 2533, 22, 31, 27, 3, -31 },
  { 2619, 25, 31, 27, 2, -31 },
  { 2716, 25, 31, 27, 2, -31 },
  { 2813, 22, 33, 27, 3, -32 },
  { 2904, 24, 31, 27, 2, -31 },
  { 2997, 24, 31, 27, 2, -31 },
  { 3090, 22, 32, 27, 3, -31 },
  { 3178, 27, 31, 27, 2, -31 },
  { 3283, 18, 31, 27, 4, -31 },
  { 3353, 26, 31, 27, 1, -31 },
  { 3454, 24, 31, 27, 2, -31 },
  { 3547, 22, 33, 27, 3, -32 },
  { 3638, 24, 31, 27, 2, -31 },
  { 3731, 22, 40, 27, 3, -32 },
  { 3841, 24, 31, 27, 2, -31 },
  { 3934, 25, 33, 27, 1, -32 },
  { 4038, 25, 31, 27, 4, -31 },
  { 4135, 22, 32, 27, 4, -31 },
  { 4223, 23, 31, 27, 5, -31 },
  { 4313, 25, 31, 27, 3, -31 },
  { 4410, 28, 31, 27, 0, -31 },
  { 4519, 25, 31, 27, 4, -31 },
  { 4616, 27, 31, 27, 0, -31 },
  { 4721, 18, 40, 27, 8, -34 },
  { 4811, 12, 40, 27, 8, -34 },
  { 4871, 18, 40, 27, 1, -34 },
  { 4961, 22, 18, 27, 3, -31 },
  { 5011, 22, 2, 27, 0, 5 },
  { 5017, 5, 8, 27, 11, -35 },
  { 5022, 21, 25, 27, 3, -24 },
  { 5088, 21, 34, 27, 3, -33 },
  { 5178, 19, 25, 27, 4, -24 },
  { 5238, 23, 34, 27, 3, -33 },
  { 5336, 20, 25, 27, 3, -24 },
  { 5399, 29, 43, 27, -1, -33 },
  { 5555, 22, 34, 27, 2, -24 },
  { 5649, 20, 33, 27, 3, -33 },
  { 5732, 20, 34, 27, 4, -33 },
  { 5817, 20, 43, 27, 4, -33 },
  { 5925, 23, 34, 27, 3, -33 },
  { 6023, 18, 34, 27, 5, -33 },
  { 6100, 25, 24, 27, 1, -24 },
  { 6175, 20, 24, 27, 3, -24 },
  { 6235, 21, 25, 27, 3, -24 },
  { 6301, 23, 33, 27, 1, -24 },
  { 6396, 21, 33, 27, 3, -24 },
  { 6483, 22, 23, 27, 5, -23 },
  { 6547, 22, 25, 27, 2, -24 },
  { 6616, 20, 32, 27, 4, -31 },
  { 6696, 20, 24, 27, 4, -23 },
  { 6756, 21, 23, 27, 3, -23 },
  { 6817, 24, 24, 27, 2, -23 },
  { 6889, 26, 25, 27, 1, -24 },
  { 6971, 23, 33, 27, 1, -23 },
  { 7066, 23, 25, 27, 2, -24 },
  { 7138, 21, 40, 27, 5, -34 },
  { 7243, 9, 40, 27, 9, -34 },
  { 7288, 21, 40, 27, 2, -34 },
  { 7393, 24, 9, 27, 2, -18 },
};

const GFXfont IBMPlexMono_LightItalic45pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic45pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _IBMPLEXMONO_LIGHTITALIC45PT7B_H_
