#ifndef _IBMPLEXMONO_LIGHTITALIC70PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0x3E, 0x00, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F,
  0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F,
  0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x38, 0x70, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0xE7,
  0xFC, 0x00, 0x7E, 0x03, 0x83, 0xF8, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x1F,
  0x00, 0x70, 0x07, 0xC0, 0x78, 0x01, 0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x00,
  0x10, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x03, 0xE0,
  0x0E, 0x00, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x00, 0x1F, 0x01, 0xC0, 0x00,
  0x00, 0x7E, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x1C, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xBF, 0xF0, 0x00, 0x00, 0x0E, 0x1F, 0xC0, 0x00, 0x00, 0x38, 0x1F, 0x80,
  0x00, 0x01, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x0F, 0x80,
  0x00, 0x07, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0xE0,
  0x03, 0xE0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x0C,
  0x00, 0x38, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0x80,
  0x3E, 0x07, 0xC0, 0x1C, 0x01, 0xF8, 0x0F, 0x80, 0x70, 0x0F, 0xC0, 0x3F,
  0x81, 0xC0, 0x7E, 0x00, 0x3F, 0xC7, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0x80, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1F,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0x81, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xE0,
  0x3E, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x07, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x70, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0xC3, 0xF0, 0x00, 0x01, 0xFF, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF,
  0xE0, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x23, 0xC0, 0x00, 0x0F, 0x80, 0x0D, 0xF0, 0x00, 0x07,
  0xC0, 0x0F, 0x78, 0x00, 0x03, 0xF0, 0x07, 0xBC, 0x00, 0x03, 0x78, 0x07,
  0x9E, 0x00, 0x01, 0x9E, 0x07, 0x8F, 0x80, 0x01, 0xCF, 0x83, 0xC3, 0xC0,
  0x01, 0xC3, 0xC3, 0xC1, 0xF0, 0x01, 0xE1, 0xF3, 0xE0, 0x7E, 0x03, 0xE0,
  0x79, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x78, 0xF1, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x04, 0x00, 0x07, 0x00, 0x02,
  0x78, 0x00, 0xF0, 0x01, 0xE7, 0xF0, 0x0F, 0x00, 0xFE, 0xFF, 0xE0, 0xF0,
  0xFF, 0xF1, 0xFF, 0xCF, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE0, 0x1F, 0x3F, 0x9F, 0xEF, 0xFF, 0xF7, 0xF9, 0xFC, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x1F, 0x00, 0x3D, 0xE0, 0x0F, 0xC0,
  0x0F, 0xF8, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x1E, 0xF0, 0x03, 0xE0, 0x07, 0xBC, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00, 0x1F, 0x9E, 0x00, 0x00, 0x3F, 0x8F,
  0x00, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x3F, 0x03,
  0xC0, 0x00, 0x7F, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x7E, 0x00,
  0x78, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x04, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x06, 0x00, 0x00,
  0x1F, 0x00, 0x20, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x10, 0x00, 0x00, 0x1F, 0x03, 0x00, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0x80, 0x00, 0x78, 0x7F, 0xFC,
  0x00, 0x0F, 0x3F, 0xFF, 0xE0, 0x01, 0xCF, 0xFF, 0xFE, 0x00, 0x3B, 0xE0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x81, 0x00, 0x00, 0x01, 0xF0,
  0x70, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x81, 0xFE, 0x00, 0x0F, 0x0F, 0xFF, 0xC0, 0x1F, 0x3F, 0xFF, 0xE0,
  0x1E, 0x7F, 0xFF, 0xF0, 0x3E, 0xFC, 0x07, 0xF8, 0x3D, 0xE0, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x7E, 0x7B, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1E,
  0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x78, 0x00, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x01, 0xFC, 0x7C,
  0x00, 0x03, 0xBC, 0x7F, 0x00, 0x07, 0x7C, 0x3F, 0xC0, 0x3E, 0x78, 0x1F,
  0xFF, 0xFC, 0xF8, 0x0F, 0xFF, 0xF8, 0xF0, 0x03, 0xFF, 0xE1, 0xF0, 0x00,
  0xFF, 0x81, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xFE, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xF2,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF0,
  0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0xE0, 0x7C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x01, 0xF8, 0x38, 0x38, 0x01,
  0xFF, 0x8E, 0x1E, 0x00, 0xFF, 0xE3, 0x87, 0x80, 0x7F, 0xFC, 0xE1, 0xE0,
  0x3F, 0x03, 0xB8, 0x70, 0x0F, 0x00, 0x7E, 0x3C, 0x07, 0x80, 0x0F, 0x8F,
  0x01, 0xE0, 0x03, 0xE3, 0xC0, 0xF0, 0x00, 0x70, 0xE0, 0x3C, 0x00, 0x1C,
  0x78, 0x0E, 0x00, 0x0F, 0x1E, 0x07, 0x80, 0x03, 0xC7, 0x81, 0xE0, 0x00,
  0xF1, 0xE0, 0x78, 0x00, 0x3C, 0x78, 0x1E, 0x00, 0x0E, 0x1C, 0x07, 0x00,
  0x03, 0x87, 0x03, 0xC0, 0x01, 0xE3, 0xC0, 0xF0, 0x00, 0x78, 0xF0, 0x3C,
  0x00, 0x1E, 0x3C, 0x0F, 0x00, 0x07, 0x8F, 0x03, 0xC0, 0x03, 0xC3, 0xC0,
  0xF0, 0x00, 0xF0, 0xE0, 0x3C, 0x00, 0x7C, 0x38, 0x07, 0x80, 0x3F, 0x0E,
  0x01, 0xE0, 0x1B, 0xC3, 0x80, 0x7C, 0x0E, 0xF0, 0xE0, 0x0F, 0xFF, 0x38,
  0x38, 0x03, 0xFF, 0x8E, 0x0E, 0x00, 0x7F, 0xE3, 0x83, 0x80, 0x0F, 0xE1,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xE0, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x0F,
  0xC0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x0C, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x04, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x03, 0xF0,
  0x07, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0xC0, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF,
  0xFC, 0x3C, 0x00, 0x3F, 0xFF, 0x8F, 0x80, 0x07, 0xFF, 0xF1, 0xF0, 0x00,
  0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0xDC, 0x03, 0xE0, 0x00, 0x37, 0x80, 0x3F, 0x00, 0x1E, 0xF0,
  0x07, 0xF8, 0x0F, 0x9E, 0x00, 0x7F, 0xFF, 0xE3, 0xC0, 0x07, 0xFF, 0xF8,
  0x78, 0x00, 0x3F, 0xFC, 0x0E, 0x00, 0x01, 0xFE, 0x02, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x01, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0xFC,
  0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x00, 0x03,
  0xC0, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x3E, 0xF8, 0x00, 0x00, 0x0F,
  0x7C, 0x78, 0x00, 0x00, 0x1E, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0xF0, 0x3C,
  0x00, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x1E, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x01, 0xEE, 0x00, 0x01, 0xDE, 0x01, 0xEE, 0x00, 0x03,
  0xDE, 0x01, 0xEF, 0x00, 0x07, 0x9C, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x01,
  0xC7, 0x00, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x0E, 0x3C, 0x03, 0xC7, 0x80,
  0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xC3, 0x80, 0x3C, 0x38,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x70, 0x78, 0x07, 0x81,
  0xC0, 0xF0, 0x78, 0x07, 0x81, 0xC1, 0xE0, 0x78, 0x07, 0x81, 0xE1, 0xE0,
  0x78, 0x07, 0x81, 0xE3, 0xC0, 0x70, 0x07, 0x80, 0xE3, 0x80, 0xF0, 0x07,
  0x00, 0xE7, 0x80, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0x00, 0xF0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x00, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x1E, 0x00,
  0x38, 0x01, 0xE0, 0x1E, 0x00, 0x30, 0x01, 0xE0, 0x1E, 0x00, 0x20, 0x01,
  0xE0, 0x1E, 0x00, 0x20, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x03, 0xF8, 0x00, 0x00, 0xF0,
  0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0xFE, 0x00,
  0x00, 0x78, 0x07, 0xBC, 0x00, 0x01, 0xE0, 0x1E, 0xF0, 0x00, 0x07, 0x80,
  0x7B, 0xC0, 0x00, 0x1E, 0x01, 0xE7, 0x80, 0x00, 0x78, 0x07, 0x9E, 0x00,
  0x01, 0xC0, 0x1C, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x03,
  0xC3, 0xC0, 0x00, 0xF0, 0x0F, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x3C, 0x00,
  0x0F, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x1E,
  0x07, 0x80, 0x07, 0x80, 0x78, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x1E, 0x00,
  0x1E, 0x07, 0x80, 0x78, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x00, 0xF0, 0xF0,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0xF0, 0x00,
  0x1E, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0xF0, 0x0F, 0x00, 0x01, 0xE3, 0x80,
  0x38, 0x00, 0x03, 0x9E, 0x01, 0xE0, 0x00, 0x0F, 0x78, 0x07, 0x80, 0x00,
  0x3D, 0xE0, 0x1E, 0x00, 0x00, 0xF7, 0x80, 0x78, 0x00, 0x01, 0xFE, 0x01,
  0xE0, 0x00, 0x07, 0xF0, 0x07, 0x00, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x00,
  0x7F, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00,
  0x78, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x04, 0x00, 0x01, 0xF0, 0x01, 0x80, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0x40, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x00, 0x07,
  0xC1, 0xC0, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x00, 0x70, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x1C, 0x00, 0xFC, 0x00, 0xF0, 0x1C, 0x00, 0xFC,
  0x00, 0xF0, 0x1C, 0x01, 0xFC, 0x00, 0xE0, 0x1C, 0x01, 0xDE, 0x01, 0xE0,
  0x3C, 0x01, 0xDE, 0x01, 0xE0, 0x3C, 0x03, 0xDE, 0x01, 0xE0, 0x3C, 0x03,
  0x8E, 0x01, 0xC0, 0x3C, 0x07, 0x8E, 0x03, 0xC0, 0x3C, 0x07, 0x0E, 0x03,
  0xC0, 0x3C, 0x0F, 0x0E, 0x03, 0xC0, 0x3C, 0x0F, 0x0E, 0x03, 0x80, 0x3C,
  0x0E, 0x0E, 0x07, 0x80, 0x38, 0x1E, 0x0E, 0x07, 0x80, 0x38, 0x1C, 0x0E,
  0x07, 0x80, 0x38, 0x3C, 0x0E, 0x07, 0x00, 0x38, 0x3C, 0x0F, 0x0F, 0x00,
  0x38, 0x38, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x0F, 0x0F, 0x00, 0x78, 0x70,
  0x0F, 0x0E, 0x00, 0x78, 0xF0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0x1E,
  0x00, 0x78, 0xE0, 0x07, 0x1E, 0x00, 0x79, 0xE0, 0x07, 0x1C, 0x00, 0x79,
  0xC0, 0x07, 0x3C, 0x00, 0x73, 0xC0, 0x07, 0x3C, 0x00, 0x73, 0xC0, 0x07,
  0x3C, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x77, 0x80, 0x07, 0xF8, 0x00,
  0x77, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x10, 0x3C, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x28, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x03, 0xC0, 0x1F, 0xFF, 0xE1, 0xE0, 0x1F, 0xFF, 0xF8, 0xF0,
  0x1F, 0xE0, 0x3E, 0x78, 0x1F, 0x80, 0x07, 0x38, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x17, 0x83, 0xC0, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x1B, 0xC0, 0x7C, 0x00, 0x1D, 0xE0, 0x3F, 0x00, 0x1C, 0xF0, 0x0F,
  0xE0, 0x7C, 0x7F, 0xC7, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0xFC, 0x1F, 0xF0,
  0x3F, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0xFF, 0x00, 0x03, 0xC0, 0xFF, 0xF0, 0x00, 0xF0, 0xFF, 0xFF,
  0x00, 0x3C, 0x7F, 0xFF, 0xE0, 0x0F, 0x3F, 0x03, 0xF8, 0x03, 0xCE, 0x00,
  0x3F, 0x00, 0xF7, 0x00, 0x07, 0xC0, 0x7B, 0x80, 0x00, 0xF8, 0x1E, 0xC0,
  0x00, 0x1E, 0x07, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x0E, 0x80, 0x00, 0x3E, 0x07,
  0xB0, 0x00, 0x1F, 0x81, 0xEE, 0x00, 0x0F, 0xC0, 0x79, 0xF0, 0x1F, 0xE0,
  0x1E, 0x3F, 0xFF, 0xF0, 0x07, 0x87, 0xFF, 0xF8, 0x01, 0xE0, 0xFF, 0xF8,
  0x00, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x30, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x61, 0xE0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x0F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0x1F,
  0xFF, 0x03, 0x80, 0x07, 0xFF, 0xF8, 0x78, 0x00, 0xFF, 0xFF, 0xC7, 0x80,
  0x1F, 0xE0, 0x3E, 0x78, 0x03, 0xF0, 0x00, 0xE7, 0x80, 0x7E, 0x00, 0x03,
  0x78, 0x07, 0xC0, 0x00, 0x17, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1C, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x03, 0x78, 0x07, 0xC0, 0x00, 0x67,
  0x80, 0x3E, 0x00, 0x0E, 0xF0, 0x03, 0xF0, 0x01, 0xCF, 0x00, 0x1F, 0xC0,
  0xF8, 0xF0, 0x01, 0xFF, 0xFF, 0x0F, 0x00, 0x0F, 0xFF, 0xE0, 0xF0, 0x00,
  0x3F, 0xFC, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x01, 0xF8, 0x78,
  0x00, 0x1F, 0xE0, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x21, 0xE0, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFC, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x3C, 0x00, 0xFF, 0xFF, 0x0F, 0x00, 0x3F, 0xFF, 0xF1, 0xE0,
  0x0F, 0xE0, 0x1F, 0x3C, 0x03, 0xF0, 0x00, 0xE7, 0x80, 0xFC, 0x00, 0x06,
  0xF0, 0x3F, 0x00, 0x00, 0x5C, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x1B,
  0xC0, 0x7C, 0x00, 0x03, 0x78, 0x07, 0xC0, 0x01, 0xCF, 0x00, 0xFC, 0x00,
  0x7B, 0xC0, 0x0F, 0xE0, 0x3E, 0x78, 0x01, 0xFF, 0xFF, 0x8F, 0x00, 0x1F,
  0xFF, 0xE1, 0xE0, 0x00, 0xFF, 0xF0, 0x3C, 0x00, 0x07, 0xF8, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x02, 0x00, 0x00, 0x7C, 0x00, 0xE0,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xC0, 0x03, 0xC1, 0xFF, 0xE0,
  0x07, 0x87, 0xFF, 0xE0, 0x1F, 0x1F, 0xFF, 0xE0, 0x3C, 0x7C, 0x0F, 0xC0,
  0x79, 0xC0, 0x07, 0xC0, 0xF3, 0x00, 0x0F, 0x81, 0xEC, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1E, 0x1F, 0x80, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x02, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x70, 0x01, 0xFC, 0x01,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x3F, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x0F,
  0x03, 0xF0, 0x00, 0x1C, 0x1F, 0xC0, 0x00, 0x78, 0x7E, 0x00, 0x00, 0xF1,
  0xF8, 0x00, 0x01, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x10, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xFE, 0x00,
  0x3C, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x0F, 0xC0,
  0x78, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x01, 0xF8,
  0x78, 0x00, 0x00, 0xFC, 0x78, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xFC, 0x00,
  0x03, 0xC1, 0xFF, 0xE0, 0x00, 0xF0, 0x7F, 0xFF, 0x00, 0x1E, 0x1F, 0xFF,
  0xE0, 0x03, 0xC7, 0xC0, 0x7E, 0x00, 0x79, 0xE0, 0x07, 0xC0, 0x0F, 0x70,
  0x00, 0x7C, 0x01, 0xEC, 0x00, 0x07, 0x80, 0x7B, 0x00, 0x00, 0xF0, 0x0F,
  0x40, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x03, 0xC0, 0x07, 0xF0, 0x00, 0x78, 0x07, 0xF8, 0x00, 0x1E,
  0x07, 0xFC, 0x00, 0x03, 0xC1, 0xFC, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x04, 0x3C, 0x07, 0x80,
  0x00, 0xCF, 0x00, 0x78, 0x00, 0x39, 0xE0, 0x0F, 0x00, 0x0F, 0xBC, 0x00,
  0xF0, 0x07, 0xE7, 0x80, 0x1E, 0x01, 0xF8, 0xF0, 0x01, 0xE0, 0x7E, 0x1E,
  0x00, 0x3C, 0x1F, 0x87, 0x80, 0x03, 0xC7, 0xE0, 0xF0, 0x00, 0x79, 0xF8,
  0x1E, 0x00, 0x07, 0xFE, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x04, 0x01, 0xE0, 0x00, 0xE0, 0x3C,
  0x00, 0x3F, 0x03, 0xC0, 0x07, 0xE0, 0x3C, 0x00, 0xFC, 0x03, 0xC0, 0x3F,
  0x00, 0x3C, 0x07, 0xE0, 0x03, 0x80, 0xFC, 0x00, 0x78, 0x3F, 0x00, 0x07,
  0x87, 0xE0, 0x00, 0x78, 0xFC, 0x00, 0x07, 0xBF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x0E, 0x3F, 0xE0, 0x7F, 0xC0, 0x79, 0xFF,
  0xC3, 0xFF, 0x81, 0xE7, 0xFF, 0x1F, 0xFE, 0x07, 0xB8, 0x7C, 0xF0, 0xF8,
  0x1F, 0xC0, 0xF7, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x03, 0xC1, 0xF0, 0x07,
  0xE0, 0x0F, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x38, 0x00, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x78, 0x00, 0xE0,
  0x01, 0xC1, 0xC0, 0x03, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x80,
  0x0E, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x01, 0xE0, 0xE0,
  0x03, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0x01, 0xC1, 0xE0, 0x03, 0x80, 0x07, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0x83, 0xFF, 0xC0, 0x0F, 0x0F, 0xFF, 0xC0, 0x3C, 0x3F, 0xFF, 0xC0,
  0x78, 0xF8, 0x1F, 0x80, 0xF3, 0x80, 0x0F, 0x81, 0xE6, 0x00, 0x1F, 0x03,
  0xD8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3C, 0x3F,
  0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x03, 0xFF,
  0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0x00, 0x0F, 0x1F, 0xFF, 0xF8, 0x00, 0xF3,
  0xF0, 0x3F, 0x80, 0x0F, 0x38, 0x00, 0xFC, 0x00, 0xF7, 0x00, 0x07, 0xC0,
  0x1E, 0xE0, 0x00, 0x3E, 0x01, 0xEC, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x0E, 0x80, 0x00, 0x3E, 0x01,
  0xEC, 0x00, 0x07, 0xE0, 0x1E, 0xE0, 0x00, 0xFC, 0x01, 0xE7, 0xC0, 0x7F,
  0x80, 0x1E, 0x3F, 0xFF, 0xF0, 0x01, 0xE1, 0xFF, 0xFE, 0x00, 0x1C, 0x0F,
  0xFF, 0x80, 0x03, 0xC0, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xC1, 0xF0, 0x07, 0xFF, 0xF8, 0x78, 0x03, 0xFF, 0xFF, 0x1E, 0x01,
  0xFE, 0x03, 0xE7, 0x80, 0xFC, 0x00, 0x39, 0xE0, 0x7E, 0x00, 0x03, 0x78,
  0x1F, 0x00, 0x00, 0x5C, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x70, 0xF8, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x00,
  0xDE, 0x07, 0xC0, 0x00, 0x77, 0x80, 0xF8, 0x00, 0x3B, 0xC0, 0x3F, 0x00,
  0x1C, 0xF0, 0x07, 0xF0, 0x3F, 0x3C, 0x01, 0xFF, 0xFF, 0x8F, 0x00, 0x3F,
  0xFF, 0xC3, 0xC0, 0x03, 0xFF, 0xC0, 0xF0, 0x00, 0x3F, 0xC0, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xEF, 0xFF, 0xE1, 0xFF, 0xFB, 0xFF, 0xF8, 0xFF, 0xFE,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x00, 0xF6, 0x00, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F,
  0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x04, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC2,
  0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0xF1,
  0xF8, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0x07, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x07, 0x80,
  0x01, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xC0, 0x03, 0xF8, 0x01, 0xE0,
  0x03, 0xF0, 0x00, 0xF0, 0x07, 0xF0, 0x00, 0x78, 0x0F, 0xE0, 0x00, 0x3C,
  0x0F, 0xE0, 0x00, 0x1E, 0x1F, 0xC0, 0x00, 0x1E, 0x1F, 0xC0, 0x00, 0x0F,
  0x3F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC,
  0x1F, 0x00, 0x03, 0x78, 0x1F, 0x00, 0x0C, 0xF0, 0x3E, 0x00, 0x39, 0xE0,
  0x7F, 0x03, 0xE3, 0xC0, 0x7F, 0xFF, 0x87, 0x80, 0x7F, 0xFE, 0x1E, 0x00,
  0x7F, 0xF8, 0x3C, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x06,
  0x7F, 0xF8, 0x00, 0x0F, 0x3F, 0xFC, 0x00, 0x03, 0xDF, 0xFE, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x07,
  0x80, 0x01, 0xF0, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xF8, 0x00,
  0xE0, 0x01, 0xF8, 0x00, 0x70, 0x01, 0xF8, 0x00, 0x78, 0x03, 0xF8, 0x00,
  0x3C, 0x07, 0xF8, 0x00, 0x1E, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0xC0, 0xF0, 0x01, 0xC0, 0x3C, 0x0F, 0x00,
  0x1C, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0x1E, 0x0E, 0x00, 0x3C, 0x01, 0xE0,
  0xE0, 0x03, 0xC0, 0x0E, 0x1E, 0x00, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0x80,
  0x0E, 0x1E, 0x00, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x80, 0x0F, 0x1C, 0x00,
  0x78, 0x00, 0xF1, 0xC0, 0x07, 0x80, 0x0F, 0x3C, 0x00, 0x70, 0x00, 0xF3,
  0xC0, 0x07, 0x00, 0x0F, 0x3C, 0x00, 0x70, 0x00, 0xF3, 0x80, 0x0F, 0x00,
  0x0F, 0x38, 0x00, 0xF0, 0x00, 0xE3, 0x80, 0x0F, 0x00, 0x0E, 0x78, 0x00,
  0xE0, 0x01, 0xE7, 0x80, 0x0E, 0x00, 0x1E, 0x78, 0x01, 0xE0, 0x01, 0xE7,
  0x00, 0x1E, 0x00, 0x1E, 0x70, 0x01, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x00,
  0x3C, 0xF0, 0x01, 0xC0, 0x03, 0xCF, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x03,
  0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x00, 0x78, 0xE0, 0x07, 0xC0, 0x0F, 0x0F,
  0x00, 0x7C, 0x00, 0xF0, 0xF0, 0x0D, 0xC0, 0x1E, 0x0F, 0x01, 0xDE, 0x03,
  0xE0, 0xF8, 0x39, 0xF0, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xF0,
  0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x01, 0xFC, 0xF0, 0x7C,
  0x3E, 0x03, 0xF0, 0x78, 0x70, 0x0F, 0x0F, 0xE0, 0x78, 0xE0, 0x0F, 0x1F,
  0x80, 0x78, 0xC0, 0x0F, 0x3E, 0x00, 0x39, 0xC0, 0x0F, 0x18, 0x00, 0x39,
  0x80, 0x07, 0x00, 0x00, 0x3B, 0x80, 0x0F, 0x00, 0x00, 0x3B, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0xDC, 0x00, 0x00, 0xF0, 0x00,
  0xDC, 0x00, 0x00, 0xF0, 0x00, 0xDC, 0x00, 0x10, 0xF0, 0x01, 0x9C, 0x00,
  0x38, 0xF0, 0x03, 0x9E, 0x00, 0xFC, 0xF0, 0x03, 0x9E, 0x01, 0xF0, 0xF0,
  0x07, 0x1E, 0x07, 0xE0, 0xF8, 0x0F, 0x0F, 0x0F, 0x80, 0x7C, 0x3E, 0x0F,
  0x3F, 0x00, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x01, 0x78, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x78, 0x00, 0x1B, 0xC0, 0x0F, 0x80, 0x07, 0x78, 0x01, 0xF0, 0x01,
  0xCF, 0x00, 0x1F, 0x80, 0xF1, 0xE0, 0x03, 0xFF, 0xFC, 0x3C, 0x00, 0x3F,
  0xFF, 0x0F, 0x80, 0x03, 0xFF, 0xC1, 0xE0, 0x00, 0x1F, 0xE0, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x10, 0x00, 0x01, 0xF0, 0x07, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x3C, 0x0F, 0xFF, 0xFC, 0x07, 0x03, 0xFF, 0xFF, 0xE1, 0xE0,
  0x7E, 0x03, 0xFF, 0x3C, 0x1F, 0x00, 0x0F, 0xFF, 0x83, 0xC0, 0x00, 0x3F,
  0xF0, 0x78, 0x00, 0x01, 0xFC, 0x0E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x00, 0x70, 0x03, 0xE0, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x00, 0x3C, 0x1F, 0xF8, 0x00, 0x07, 0x87, 0xFF, 0xF8,
  0x00, 0x70, 0xF7, 0xFF, 0xF8, 0x0F, 0x1E, 0x0F, 0xFF, 0xF1, 0xE3, 0xC0,
  0x3F, 0xFF, 0xFC, 0x78, 0x00, 0x7F, 0xFF, 0x0F, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x60, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0xFF, 0xE0, 0x00, 0x1C, 0x0F, 0xFF,
  0x80, 0x01, 0xE0, 0x7C, 0x7E, 0x00, 0x0F, 0x07, 0x80, 0xF8, 0x00, 0xF0,
  0x78, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0x7C,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x3C, 0x0E, 0x00, 0x0F, 0xC7, 0xC0, 0xF0,
  0x00, 0x3F, 0xFE, 0x07, 0x00, 0x00, 0xFF, 0xE0, 0x38, 0x00, 0x03, 0xFE,
  0x02, 0xC0, 0x00, 0x07, 0xC0, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 14, 49, 42, 14, -49 },
  { 87, 18, 19, 42, 16, -52 },
  { 130, 42, 49, 42, 1, -49 },
  { 388, 38, 65, 42, 2, -57 },
  { 697, 47, 51, 42, -1, -50 },
  { 997, 41, 51, 42, 0, -50 },
  { 1259, 7, 19, 42, 22, -52 },
  { 1276, 25, 63, 42, 15, -53 },
  { 1473, 24, 63, 42, 4, -53 },
  { 1662, 36, 35, 42, 4, -38 },
  { 1820, 33, 34, 42, 5, -38 },
  { 1961, 14, 19, 42, 10, -8 },
  { 1995, 21, 4, 42, 11, -23 },
  { 2006, 9, 8, 42, 14, -8 },
  { 2015, 39, 63, 42, 2, -53 },
  { 2323, 34, 51, 42, 5, -50 },
  { 2540, 33, 49, 42, 3, -49 },
  { 2743, 36, 50, 42, 2, -50 },
  { 2968, 36, 51, 42, 2, -50 },
  { 3198, 37, 49, 42, 1, -49 },
  { 3425, 35, 50, 42, 4, -49 },
  { 3644, 32, 50, 42, 5, -49 },
  { 3844, 34, 49, 42, 8, -49 },
  { 4053, 36, 51, 42, 3, -50 },
  { 4283, 32, 50, 42, 7, -50 },
  { 4483, 14, 38, 42, 14, -38 },
  { 4550, 18, 49, 42, 10, -38 },
  { 4661, 34, 39, 42, 6, -41 },
  { 4827, 35, 17, 42, 4, -30 },
  { 4902, 34, 39, 42, 3, -41 },
  { 5068, 29, 50, 42, 10, -50 },
  { 5250, 34, 58, 42, 5, -50 },
  { 5497, 36, 49, 42, 0, -49 },
  { 5718, 34, 49, 42, 4, -49 },
  { 5927, 34, 51, 42, 6, -50 },
  { 6144, 35, 49, 42, 4, -49 },
  { 6359, 37, 49, 42, 4, -49 },
  { 6586, 38, 49, 42, 4, -49 },
  { 6819, 35, 51, 42, 5, -50 },
  { 7043, 38, 49, 42, 3, -49 },
  { 7276, 38, 49, 42, 3, -49 },
  { 7509, 34, 50, 42, 4, -49 },
  { 7722, 40, 49, 42, 4, -49 },
  { 7967, 29, 49, 42, 6, -49 },
  { 8145, 40, 49, 42, 2, -49 },
  { 8390, 38, 49, 42, 3, -49 },
  { 8623, 34, 51, 42, 5, -50 },
  { 8840, 37, 49, 42, 4, -49 },
  { 9067, 34, 63, 42, 5, -50 },
  { 9335, 37, 49, 42, 4, -49 },
  { 9562, 38, 51, 42, 2, -50 },
  { 9805, 38, 49, 42, 7, -49 },
  { 10038, 36, 50, 42, 5, -49 },
  { 10263, 36, 49, 42, 8, -49 },
  { 10484, 40, 49, 42, 4, -49 },
  { 10729, 44, 49, 42, 0, -49 },
  { 10999, 39, 49, 42, 7, -49 },
  { 11238, 42, 49, 42, 0, -49 },
  { 11496, 29, 63, 42, 12, -53 },
  { 11725, 18, 63, 42, 13, -53 },
  { 11867, 29, 63, 42, 1, -53 },
  { 12096, 34, 28, 42, 5, -49 },
  { 12215, 34, 4, 42, 0, 7 },
  { 12232, 9, 13, 42, 16, -54 },
  { 12247, 33, 38, 42, 4, -37 },
  { 12404, 34, 53, 42, 4, -52 },
  { 12630, 31, 38, 42, 5, -37 },
  { 12778, 36, 53, 42, 4, -52 },
  { 13017, 31, 38, 42, 5, -37 },
  { 13165, 45, 67, 42, -1, -52 },
  { 13542, 35, 52, 42, 3, -37 },
  { 13770, 31, 52, 42, 5, -52 },
  { 13972, 31, 54, 42, 6, -53 },
  { 14182, 32, 67, 42, 5, -52 },
  { 14450, 35, 53, 42, 5, -52 },
  { 14682, 28, 53, 42, 8, -52 },
  { 14868, 38, 37, 42, 2, -37 },
  { 15044, 31, 37, 42, 5, -37 },
  { 15188, 32, 38, 42, 5, -37 },
  { 15340, 36, 51, 42, 2, -37 },
  { 15570, 34, 51, 42, 4, -37 },
  { 15787, 34, 36, 42, 8, -36 },
  { 15940, 33, 38, 42, 4, -37 },
  { 16097, 33, 50, 42, 5, -49 },
  { 16304, 31, 37, 42, 6, -36 },
  { 16448, 33, 36, 42, 5, -36 },
  { 16597, 36, 37, 42, 4, -36 },
  { 16764, 40, 38, 42, 1, -37 },
  { 16954, 35, 51, 42, 2, -36 },
  { 17178, 35, 38, 42, 4, -37 },
  { 17345, 32, 63, 42, 8, -53 },
  { 17597, 14, 63, 42, 15, -53 },
  { 17708, 32, 63, 42, 3, -53 },
  { 17960, 37, 15, 42, 3, -29 },
};

const GFXfont IBMPlexMono_LightItalic70pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic70pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic70pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _IBMPLEXMONO_LIGHTITALIC70PT7B_H_
