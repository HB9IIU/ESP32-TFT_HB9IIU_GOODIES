#ifndef _IBMPLEXMONO_LIGHTITALIC68PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x01, 0xF0, 0x00, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0x71, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x78,
  0x0F, 0x3C, 0x07, 0x9E, 0x03, 0x8F, 0x03, 0xC7, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1C, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x0E, 0x7F, 0xC0, 0x0F, 0xC0, 0x70, 0x7E, 0x00, 0xFC,
  0x03, 0x80, 0xF8, 0x07, 0xC0, 0x1C, 0x03, 0xE0, 0x7C, 0x01, 0xC0, 0x0E,
  0x03, 0xC0, 0x0E, 0x00, 0x20, 0x1E, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x03,
  0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x78, 0x03, 0x80,
  0x00, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x00, 0x7E,
  0x06, 0x00, 0x00, 0x03, 0xFC, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xBF, 0xF0, 0x00,
  0x00, 0x1C, 0x1F, 0xC0, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0x00,
  0xF8, 0x00, 0x00, 0x38, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x3E,
  0x00, 0x00, 0x38, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x78, 0x10, 0x00, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x00, 0x3E, 0x1F,
  0x00, 0x38, 0x01, 0xE0, 0x7C, 0x01, 0xC0, 0x1F, 0x03, 0xF0, 0x0E, 0x01,
  0xF0, 0x0F, 0xE0, 0xE0, 0x3F, 0x00, 0x3F, 0xE7, 0x0F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0xF8, 0x1E, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x78, 0x00, 0x38, 0x00,
  0x38, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x81, 0xE0,
  0x00, 0x03, 0xE0, 0xF8, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x08, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xC0,
  0xF8, 0x3E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x70, 0x00, 0x01, 0xC0, 0xF0,
  0x03, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x70, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x1C,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x1C, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0xF8, 0x01, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x00, 0xFF, 0xC7,
  0xC0, 0x00, 0x03, 0xF1, 0xFF, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x78, 0x00, 0x07, 0xE0, 0x0E, 0x78, 0x00,
  0x04, 0xF0, 0x1C, 0x78, 0x00, 0x0C, 0xF0, 0x3C, 0x78, 0x00, 0x1C, 0x78,
  0x38, 0x3C, 0x00, 0x18, 0x78, 0x78, 0x3E, 0x00, 0x78, 0x3C, 0xF0, 0x1F,
  0x81, 0xF0, 0x3C, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x1E, 0x3C, 0x71, 0xE3, 0xC7,
  0x8F, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x8E, 0x1C, 0x78, 0xF1, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x7C, 0x00, 0xE0, 0x07, 0xFF, 0xE0,
  0x38, 0x0F, 0xF3, 0xFF, 0x1E, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xF0,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0x80, 0x1F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F,
  0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x01, 0xF8, 0x03, 0xDE, 0x00, 0x78, 0x01,
  0xEF, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFB, 0x80,
  0x00, 0x07, 0xE7, 0x80, 0x00, 0x0F, 0xC7, 0x80, 0x00, 0x3F, 0x87, 0x80,
  0x00, 0x7E, 0x07, 0x80, 0x00, 0xFC, 0x07, 0x80, 0x01, 0xF8, 0x0F, 0x00,
  0x03, 0xF0, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x00, 0xF0, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x81, 0x80, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x1F, 0xE0, 0x00, 0x1E, 0x3F,
  0xFE, 0x00, 0x07, 0x1F, 0xFF, 0xE0, 0x01, 0xDF, 0xFF, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x02, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x0F, 0xF0, 0x00, 0x78, 0x7F, 0xFC, 0x01, 0xE3, 0xFF, 0xFC, 0x03, 0xCF,
  0xFF, 0xFE, 0x0F, 0x3E, 0x01, 0xFC, 0x1E, 0xE0, 0x00, 0xFC, 0x7B, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0xF7, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x01,
  0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3,
  0xC0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x7E, 0x78, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xBC, 0x3F, 0x00, 0x07, 0x7C,
  0x1F, 0xC0, 0x3F, 0x78, 0x0F, 0xFF, 0xFC, 0xF8, 0x07, 0xFF, 0xF8, 0xF0,
  0x03, 0xFF, 0xF1, 0xF0, 0x00, 0x7F, 0x81, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xF0, 0x1F,
  0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x07, 0x1E, 0x00, 0x3F, 0x07, 0x1E, 0x00, 0xFF, 0xC7, 0x1C,
  0x01, 0xFF, 0xE7, 0x1C, 0x03, 0xE0, 0x67, 0x3C, 0x07, 0xC0, 0x3F, 0x3C,
  0x07, 0x80, 0x1F, 0x38, 0x0F, 0x00, 0x1F, 0x38, 0x0F, 0x00, 0x0E, 0x78,
  0x0E, 0x00, 0x0E, 0x78, 0x1E, 0x00, 0x0E, 0x78, 0x1E, 0x00, 0x1E, 0x78,
  0x1C, 0x00, 0x1E, 0x70, 0x1C, 0x00, 0x1E, 0x70, 0x3C, 0x00, 0x1C, 0xF0,
  0x3C, 0x00, 0x1C, 0xF0, 0x3C, 0x00, 0x1C, 0xF0, 0x3C, 0x00, 0x3C, 0xF0,
  0x3C, 0x00, 0x3C, 0xE0, 0x38, 0x00, 0x3C, 0xE0, 0x38, 0x00, 0x78, 0xE0,
  0x38, 0x00, 0x78, 0xE0, 0x3C, 0x00, 0xF8, 0xE0, 0x3C, 0x00, 0xF8, 0xE0,
  0x3C, 0x01, 0x78, 0xE0, 0x1E, 0x03, 0x78, 0xE0, 0x1F, 0xFE, 0x70, 0xE0,
  0x0F, 0xFC, 0x70, 0xE0, 0x07, 0xF8, 0x70, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x78,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0xF8, 0x38, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3F, 0x07,
  0x80, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xC0, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x08, 0x0F, 0x00, 0x00, 0x03, 0x07, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xE0, 0x01, 0xFE, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x1E, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x03, 0xF0, 0x07, 0x80, 0x07, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x07,
  0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x00, 0x40, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F,
  0xFF, 0x3E, 0x00, 0x3F, 0xFF, 0x9F, 0x00, 0x1F, 0xFF, 0xCF, 0x00, 0x0F,
  0xFF, 0xE7, 0x80, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xDC, 0x07,
  0xC0, 0x00, 0xDE, 0x01, 0xF0, 0x01, 0xCF, 0x00, 0x7E, 0x03, 0xE7, 0x80,
  0x1F, 0xFF, 0xC3, 0xC0, 0x07, 0xFF, 0xC1, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00,
  0x07, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x7E, 0x00, 0x00, 0x01, 0xE1, 0xFC, 0x00, 0x00, 0x03, 0xC7,
  0xFC, 0x00, 0x00, 0x0F, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0xF8, 0x00,
  0x00, 0x3D, 0xF0, 0xF0, 0x00, 0x00, 0x7F, 0xC1, 0xF0, 0x00, 0x00, 0xFE,
  0x01, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xEF, 0x00, 0xE7, 0x00, 0x03,
  0xDC, 0x01, 0xCE, 0x00, 0x0F, 0x38, 0x07, 0x9E, 0x00, 0x1E, 0xF0, 0x0F,
  0x3C, 0x00, 0x79, 0xE0, 0x1E, 0x38, 0x00, 0xE3, 0xC0, 0x3C, 0x70, 0x03,
  0xC7, 0x80, 0x70, 0xF0, 0x0F, 0x0E, 0x00, 0xE1, 0xE0, 0x1E, 0x1C, 0x03,
  0xC1, 0xC0, 0x78, 0x78, 0x07, 0x83, 0x80, 0xE0, 0xF0, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0x1E, 0x0F, 0x0F, 0x03, 0xC0, 0x38, 0x0E, 0x1E, 0x07, 0x00,
  0x70, 0x1C, 0x78, 0x1E, 0x01, 0xE0, 0x3C, 0xE0, 0x3C, 0x03, 0xC0, 0x7B,
  0xC0, 0x78, 0x07, 0x80, 0x77, 0x00, 0xF0, 0x0F, 0x00, 0xFE, 0x01, 0xE0,
  0x1C, 0x01, 0xF8, 0x03, 0x80, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x07, 0x80, 0x08, 0x00, 0xE0, 0x0E, 0x00, 0x20, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x3F, 0x00,
  0x00, 0x1C, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0x00,
  0xF7, 0x00, 0x00, 0x78, 0x07, 0xBC, 0x00, 0x03, 0xC0, 0x39, 0xE0, 0x00,
  0x1E, 0x01, 0xCF, 0x00, 0x00, 0xE0, 0x1E, 0x38, 0x00, 0x0F, 0x00, 0xF1,
  0xE0, 0x00, 0x78, 0x07, 0x8F, 0x00, 0x03, 0xC0, 0x3C, 0x78, 0x00, 0x1E,
  0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x1E, 0x01,
  0xE0, 0x78, 0x00, 0xF0, 0x0E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x0E, 0x00,
  0x38, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x70, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x1E, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x1E, 0x01, 0xE0, 0x03,
  0xC0, 0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x3C, 0x03,
  0x80, 0x03, 0xC1, 0xE0, 0x3C, 0x00, 0x1E, 0x0E, 0x01, 0xE0, 0x00, 0xF0,
  0xF0, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x78, 0x00, 0x1E, 0x3C, 0x03, 0xC0,
  0x00, 0xF1, 0xE0, 0x1C, 0x00, 0x07, 0x8F, 0x01, 0xE0, 0x00, 0x1E, 0x70,
  0x0F, 0x00, 0x00, 0xF7, 0x80, 0x78, 0x00, 0x07, 0xBC, 0x03, 0xC0, 0x00,
  0x1D, 0xE0, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x0F,
  0x00, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1F, 0x3C, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x01, 0xFC, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0x3F, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x03, 0x00, 0x00, 0xF8,
  0x03, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x01, 0xFC, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x01, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x80, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x01, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00,
  0x0F, 0x03, 0x80, 0x1F, 0x00, 0x1C, 0x07, 0x00, 0x3F, 0x00, 0x78, 0x0E,
  0x00, 0x7E, 0x00, 0xF0, 0x1C, 0x01, 0xFC, 0x01, 0xE0, 0x78, 0x03, 0xB8,
  0x03, 0x80, 0xF0, 0x0F, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0xE0, 0x1E, 0x03,
  0xC0, 0x39, 0xC0, 0x3C, 0x07, 0x80, 0xF3, 0x80, 0x70, 0x0F, 0x01, 0xC7,
  0x01, 0xE0, 0x1C, 0x07, 0x8E, 0x03, 0xC0, 0x38, 0x0E, 0x1C, 0x07, 0x00,
  0x70, 0x3C, 0x38, 0x0E, 0x00, 0xE0, 0x78, 0x70, 0x3C, 0x01, 0xC0, 0xE0,
  0xF0, 0x78, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x0F, 0x07, 0x03, 0xC1, 0xC0,
  0x1E, 0x1E, 0x03, 0x87, 0x80, 0x3C, 0x38, 0x07, 0x0F, 0x00, 0x78, 0x70,
  0x0E, 0x1C, 0x00, 0xF1, 0xE0, 0x1C, 0x38, 0x01, 0xE3, 0x80, 0x38, 0xF0,
  0x03, 0x8F, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x38,
  0x01, 0xC7, 0x00, 0x1C, 0xF0, 0x03, 0x9E, 0x00, 0x39, 0xC0, 0x07, 0xBC,
  0x00, 0x77, 0x80, 0x0F, 0x70, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x07, 0xC0,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x38, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0x03, 0xC8, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x70, 0xF0, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x07,
  0x06, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x0F, 0x00, 0x7F, 0xFF,
  0x0F, 0x01, 0xFC, 0x07, 0x8F, 0x03, 0xF0, 0x01, 0xCF, 0x03, 0xC0, 0x00,
  0x7E, 0x07, 0x80, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x3E, 0x1E, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x38, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xF0, 0x70, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x06,
  0xE0, 0x7C, 0x00, 0x0D, 0xE0, 0x3C, 0x00, 0x1D, 0xE0, 0x3E, 0x00, 0x39,
  0xE0, 0x1F, 0x80, 0xF1, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x07, 0x83, 0xFF, 0xC0, 0x03,
  0xC3, 0xFF, 0xF8, 0x01, 0xE3, 0xC0, 0xFE, 0x00, 0xE3, 0x80, 0x1F, 0x00,
  0xF3, 0x00, 0x07, 0xC0, 0x7B, 0x00, 0x01, 0xE0, 0x3D, 0x00, 0x00, 0x78,
  0x1F, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07,
  0x07, 0xC0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xD8,
  0x00, 0x1F, 0x01, 0xEE, 0x00, 0x1F, 0x00, 0xF3, 0xC0, 0x3F, 0x00, 0x70,
  0xFF, 0xFF, 0x00, 0x78, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x30, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x87, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xF0, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x01,
  0xE0, 0x01, 0xFF, 0xF0, 0x78, 0x00, 0x7F, 0xFF, 0x8F, 0x00, 0x1F, 0x80,
  0xF9, 0xE0, 0x07, 0xC0, 0x03, 0x3C, 0x01, 0xE0, 0x00, 0x37, 0x80, 0x78,
  0x00, 0x02, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x03, 0x78, 0x07, 0xC0, 0x00, 0x4F, 0x00,
  0x78, 0x00, 0x19, 0xC0, 0x0F, 0x80, 0x0E, 0x78, 0x00, 0xFC, 0x07, 0x8F,
  0x00, 0x0F, 0xFF, 0xE1, 0xE0, 0x00, 0xFF, 0xF8, 0x3C, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1F, 0x9E,
  0x00, 0x01, 0xFC, 0x78, 0x00, 0x3F, 0xC1, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x87, 0x80, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x02, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x9E, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x81, 0xC0, 0x0F,
  0xFF, 0xF1, 0xE0, 0x1F, 0xC0, 0x7C, 0xF0, 0x1F, 0x80, 0x06, 0x78, 0x0F,
  0x00, 0x01, 0xBC, 0x0F, 0x00, 0x00, 0x5E, 0x0F, 0x00, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3F, 0x03, 0xC0, 0x00,
  0x17, 0x81, 0xF0, 0x00, 0x1B, 0xC0, 0x78, 0x00, 0x19, 0xE0, 0x3E, 0x00,
  0x38, 0xE0, 0x0F, 0xC0, 0x78, 0xF0, 0x03, 0xFF, 0xF8, 0x78, 0x00, 0xFF,
  0xF8, 0x3C, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x04,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x07,
  0xF0, 0x00, 0xE0, 0x7F, 0xF0, 0x07, 0x87, 0xFF, 0xE0, 0x1E, 0x3F, 0xFF,
  0xC0, 0x79, 0xF0, 0x3F, 0x81, 0xE7, 0x00, 0x3E, 0x07, 0xB0, 0x00, 0x78,
  0x1D, 0x80, 0x01, 0xF0, 0xF6, 0x00, 0x07, 0xC3, 0xD0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x10, 0x01, 0xE0, 0x00, 0xE0,
  0x07, 0x80, 0x0F, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xE0, 0x01,
  0xC0, 0x1E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0x39, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x07, 0xF0, 0x00, 0x1E, 0x07, 0xFF, 0x80, 0x07, 0x87, 0xFF,
  0xF0, 0x01, 0xE3, 0xC0, 0x7E, 0x00, 0x79, 0xC0, 0x0F, 0x80, 0x1C, 0xE0,
  0x01, 0xF0, 0x0F, 0x70, 0x00, 0x3C, 0x03, 0xD8, 0x00, 0x0F, 0x00, 0xFC,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x03, 0xC1, 0xF8, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x11, 0xE0,
  0x1E, 0x00, 0x06, 0x78, 0x07, 0x80, 0x03, 0xDE, 0x00, 0xF0, 0x01, 0xE7,
  0x80, 0x3C, 0x01, 0xF1, 0xC0, 0x07, 0x80, 0xF8, 0xF0, 0x01, 0xE0, 0x7C,
  0x3C, 0x00, 0x3C, 0x3E, 0x0F, 0x00, 0x0F, 0x1F, 0x03, 0xC0, 0x01, 0xEF,
  0x80, 0xF0, 0x00, 0x7F, 0xC0, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x08, 0x07, 0x80, 0x03, 0x80, 0xF0,
  0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x03, 0x80, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x03, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x7F, 0x81, 0xFF, 0x01, 0xE7, 0xFE, 0x1F, 0xF8, 0x0F, 0x70, 0xF1,
  0xC3, 0xE0, 0x7A, 0x03, 0xDC, 0x0F, 0x03, 0xA0, 0x1E, 0xC0, 0x38, 0x1E,
  0x00, 0xFC, 0x01, 0xE1, 0xF0, 0x03, 0xC0, 0x0F, 0x0F, 0x00, 0x3E, 0x00,
  0x70, 0x78, 0x01, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x00, 0x1C, 0x1C, 0x00,
  0x78, 0x01, 0xE0, 0xE0, 0x03, 0x80, 0x0F, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x78, 0x00, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0xE0, 0x03, 0xC0, 0x0F, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x78,
  0x00, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0xE0, 0x03, 0xC0, 0x07, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x38, 0x00,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0xF0, 0x03, 0xC0, 0x07, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x38, 0x00, 0xF0,
  0x03, 0xC1, 0xC0, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0xF0,
  0x01, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x01,
  0xC1, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0E, 0x0F,
  0xFF, 0x00, 0x78, 0x7F, 0xFE, 0x01, 0xE3, 0xC0, 0xFC, 0x07, 0x9C, 0x00,
  0xF8, 0x1E, 0xE0, 0x01, 0xE0, 0x7B, 0x00, 0x07, 0x81, 0xD8, 0x00, 0x1F,
  0x0F, 0x40, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1E, 0x0F, 0xFF, 0x00, 0x03, 0xC3, 0xFF, 0xF8, 0x00, 0x78,
  0xF0, 0x3F, 0x80, 0x0E, 0x38, 0x01, 0xF0, 0x03, 0xCC, 0x00, 0x1F, 0x00,
  0x7B, 0x00, 0x01, 0xE0, 0x0F, 0x40, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x01, 0xF0, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0xF6, 0x00, 0x07, 0xC0, 0x1E, 0xE0, 0x01, 0xF0, 0x03, 0xCF, 0x00,
  0xFC, 0x00, 0x70, 0xFF, 0xFF, 0x00, 0x1E, 0x07, 0xFF, 0xC0, 0x03, 0xC0,
  0x3F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x07, 0x00, 0x7F, 0xFF, 0x8F,
  0x00, 0xFC, 0x07, 0xCF, 0x01, 0xF0, 0x00, 0xCF, 0x03, 0xC0, 0x00, 0x6F,
  0x07, 0x80, 0x00, 0x2F, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF0,
  0x70, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x06, 0xF0,
  0x7C, 0x00, 0x06, 0xF0, 0x3C, 0x00, 0x0C, 0xE0, 0x3E, 0x00, 0x39, 0xE0,
  0x1F, 0x80, 0xF1, 0xE0, 0x0F, 0xFF, 0xE1, 0xE0, 0x07, 0xFF, 0xC1, 0xE0,
  0x00, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x3C, 0x7F, 0xFF,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x3D, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7A, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x04,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x20, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF0,
  0x3F, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x08, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80,
  0x01, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0xFC, 0x3C, 0x00, 0x02, 0xE0, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xDE,
  0x07, 0x80, 0x06, 0x78, 0x1F, 0x00, 0x39, 0xE0, 0x3F, 0x03, 0xC7, 0x80,
  0x7F, 0xFE, 0x1C, 0x00, 0xFF, 0xE0, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0C, 0xFF, 0xF0, 0x00, 0x3C, 0xFF, 0xF0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x07,
  0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x00, 0x03, 0xE0, 0x07, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x0F,
  0x03, 0xF8, 0x00, 0x0E, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x01, 0x81,
  0xC0, 0x07, 0x80, 0xF0, 0x38, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x1C, 0x01,
  0xE1, 0xE0, 0x03, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0x03, 0x87, 0x80, 0x1E,
  0x00, 0x70, 0xE0, 0x03, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0x80,
  0x0E, 0x00, 0x3C, 0xF0, 0x01, 0xC0, 0x07, 0x9E, 0x00, 0x78, 0x00, 0xF3,
  0xC0, 0x0F, 0x00, 0x1E, 0x78, 0x01, 0xE0, 0x03, 0xCE, 0x00, 0x38, 0x00,
  0x71, 0xC0, 0x07, 0x00, 0x0E, 0x78, 0x00, 0xE0, 0x01, 0xCF, 0x00, 0x3C,
  0x00, 0x39, 0xE0, 0x07, 0x80, 0x0F, 0x3C, 0x00, 0xF0, 0x01, 0xE7, 0x00,
  0x1C, 0x00, 0x3C, 0xE0, 0x03, 0x80, 0x07, 0x1C, 0x00, 0x70, 0x00, 0xE7,
  0x80, 0x1E, 0x00, 0x3C, 0xF0, 0x03, 0xC0, 0x07, 0x9E, 0x00, 0x78, 0x00,
  0xE3, 0x80, 0x0F, 0x00, 0x3C, 0x70, 0x03, 0xE0, 0x07, 0x8E, 0x00, 0x5C,
  0x01, 0xE1, 0xC0, 0x1B, 0x80, 0x3C, 0x38, 0x02, 0x70, 0x0F, 0x07, 0x80,
  0xCE, 0x03, 0xC0, 0xF8, 0x71, 0xE1, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xE7, 0x03, 0xC3, 0xE0, 0x3F, 0x0F, 0x0F, 0x01, 0xE1, 0xF8, 0x1E,
  0x18, 0x03, 0xC7, 0xC0, 0x1C, 0x70, 0x07, 0x9F, 0x00, 0x38, 0xC0, 0x0F,
  0x18, 0x00, 0x7B, 0x00, 0x1E, 0x00, 0x00, 0xF6, 0x00, 0x3C, 0x00, 0x00,
  0xEC, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x06, 0xE0, 0x00, 0x07, 0x80, 0x0D, 0xE0,
  0x01, 0x0F, 0x00, 0x3B, 0xC0, 0x07, 0x1E, 0x00, 0x63, 0x80, 0x3F, 0x3C,
  0x01, 0xC7, 0x00, 0xF8, 0x78, 0x07, 0x0F, 0x07, 0xE0, 0xF0, 0x1E, 0x1E,
  0x1F, 0x80, 0xF8, 0x78, 0x1C, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x0B, 0xC0, 0x3C, 0x00, 0x06, 0xE0, 0x07, 0x80, 0x03,
  0x78, 0x01, 0xE0, 0x01, 0xDE, 0x00, 0x7C, 0x00, 0xE7, 0x80, 0x0F, 0xC0,
  0xF1, 0xE0, 0x01, 0xFF, 0xF8, 0x78, 0x00, 0x3F, 0xFC, 0x1C, 0x00, 0x03,
  0xF8, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x02, 0x00, 0x00, 0x7C,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x3C,
  0x07, 0xFF, 0xFC, 0x07, 0x01, 0xF0, 0x1F, 0xE1, 0xE0, 0x3C, 0x00, 0x7F,
  0x3C, 0x0F, 0x00, 0x01, 0xFF, 0x81, 0xC0, 0x00, 0x0F, 0xE0, 0x38, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x38,
  0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x06, 0x00, 0x01, 0xE0, 0x01, 0xC0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x00,
  0x70, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x00, 0x3C, 0x0F, 0xFC, 0x00, 0x03, 0x83, 0xFF, 0xFC, 0x00, 0x78, 0x78,
  0x7F, 0xF8, 0x0F, 0x0F, 0x00, 0xFF, 0xF1, 0xE1, 0xE0, 0x03, 0xFF, 0xF8,
  0x38, 0x00, 0x07, 0xFF, 0x08, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0x03,
  0xFF, 0x80, 0x00, 0xE0, 0x78, 0x7C, 0x00, 0x1E, 0x0F, 0x03, 0xE0, 0x01,
  0xC1, 0xE0, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x03, 0x83, 0xC0, 0x07,
  0x80, 0x78, 0x38, 0x00, 0x7C, 0x0F, 0x07, 0x80, 0x03, 0xE1, 0xE0, 0x70,
  0x00, 0x1F, 0xFC, 0x07, 0x00, 0x00, 0xFF, 0x80, 0xB0, 0x00, 0x03, 0xE0,
  0x00,
};

const GFXglyph IBMPlexMono_LightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 13, 47, 41, 14, -47 },
  { 78, 17, 18, 41, 16, -50 },
  { 117, 41, 47, 41, 1, -47 },
  { 358, 37, 63, 41, 2, -55 },
  { 650, 45, 49, 41, -1, -48 },
  { 926, 40, 49, 41, 0, -48 },
  { 1171, 7, 18, 41, 21, -50 },
  { 1187, 23, 61, 41, 15, -52 },
  { 1363, 23, 61, 41, 4, -52 },
  { 1539, 34, 34, 41, 4, -37 },
  { 1684, 32, 33, 41, 5, -37 },
  { 1816, 13, 18, 41, 10, -8 },
  { 1846, 20, 4, 41, 11, -23 },
  { 1856, 8, 7, 41, 14, -7 },
  { 1863, 38, 61, 41, 2, -52 },
  { 2153, 33, 49, 41, 5, -48 },
  { 2356, 32, 47, 41, 3, -47 },
  { 2544, 35, 48, 41, 2, -48 },
  { 2754, 35, 49, 41, 2, -48 },
  { 2969, 36, 47, 41, 1, -47 },
  { 3181, 34, 48, 41, 4, -47 },
  { 3385, 31, 48, 41, 5, -47 },
  { 3571, 33, 47, 41, 7, -47 },
  { 3765, 35, 49, 41, 3, -48 },
  { 3980, 32, 48, 41, 6, -48 },
  { 4172, 13, 36, 41, 14, -36 },
  { 4231, 17, 46, 41, 10, -36 },
  { 4329, 33, 38, 41, 6, -40 },
  { 4486, 34, 16, 41, 4, -29 },
  { 4554, 33, 38, 41, 3, -40 },
  { 4711, 28, 48, 41, 9, -48 },
  { 4879, 32, 55, 41, 5, -48 },
  { 5099, 35, 47, 41, 0, -47 },
  { 5305, 34, 47, 41, 3, -47 },
  { 5505, 33, 49, 41, 6, -48 },
  { 5708, 34, 47, 41, 4, -47 },
  { 5908, 36, 47, 41, 4, -47 },
  { 6120, 37, 47, 41, 4, -47 },
  { 6338, 33, 49, 41, 5, -48 },
  { 6541, 37, 47, 41, 3, -47 },
  { 6759, 37, 47, 41, 3, -47 },
  { 6977, 33, 48, 41, 4, -47 },
  { 7175, 39, 47, 41, 4, -47 },
  { 7405, 28, 47, 41, 6, -47 },
  { 7570, 39, 47, 41, 2, -47 },
  { 7800, 37, 47, 41, 3, -47 },
  { 8018, 33, 49, 41, 5, -48 },
  { 8221, 35, 47, 41, 4, -47 },
  { 8427, 33, 60, 41, 5, -48 },
  { 8675, 35, 47, 41, 4, -47 },
  { 8881, 37, 49, 41, 2, -48 },
  { 9108, 37, 47, 41, 7, -47 },
  { 9326, 35, 48, 41, 5, -47 },
  { 9536, 35, 47, 41, 8, -47 },
  { 9742, 39, 47, 41, 4, -47 },
  { 9972, 43, 47, 41, 0, -47 },
  { 10225, 38, 47, 41, 6, -47 },
  { 10449, 41, 47, 41, 0, -47 },
  { 10690, 28, 61, 41, 12, -52 },
  { 10904, 17, 61, 41, 13, -52 },
  { 11034, 28, 61, 41, 1, -52 },
  { 11248, 33, 27, 41, 5, -47 },
  { 11360, 33, 4, 41, 0, 7 },
  { 11377, 8, 12, 41, 16, -52 },
  { 11389, 32, 37, 41, 4, -36 },
  { 11537, 33, 51, 41, 4, -50 },
  { 11748, 30, 37, 41, 5, -36 },
  { 11887, 35, 51, 41, 4, -50 },
  { 12111, 30, 37, 41, 5, -36 },
  { 12250, 44, 64, 41, -1, -50 },
  { 12602, 33, 50, 41, 3, -36 },
  { 12809, 30, 50, 41, 5, -50 },
  { 12997, 30, 51, 41, 6, -50 },
  { 13189, 31, 65, 41, 5, -51 },
  { 13441, 34, 51, 41, 5, -50 },
  { 13658, 27, 51, 41, 8, -50 },
  { 13831, 37, 36, 41, 2, -36 },
  { 13998, 30, 36, 41, 5, -36 },
  { 14133, 31, 37, 41, 5, -36 },
  { 14277, 35, 50, 41, 2, -36 },
  { 14496, 32, 50, 41, 4, -36 },
  { 14696, 32, 35, 41, 8, -35 },
  { 14836, 32, 37, 41, 4, -36 },
  { 14984, 32, 48, 41, 5, -47 },
  { 15176, 30, 36, 41, 6, -35 },
  { 15311, 32, 35, 41, 5, -35 },
  { 15451, 35, 36, 41, 4, -35 },
  { 15609, 39, 37, 41, 1, -36 },
  { 15790, 34, 49, 41, 2, -35 },
  { 15999, 35, 37, 41, 3, -36 },
  { 16161, 31, 61, 41, 8, -52 },
  { 16398, 14, 61, 41, 14, -52 },
  { 16505, 31, 61, 41, 3, -52 },
  { 16742, 36, 13, 41, 3, -27 },
};

const GFXfont IBMPlexMono_LightItalic68pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic68pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic68pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _IBMPLEXMONO_LIGHTITALIC68PT7B_H_
