#ifndef _IBMPLEXMONO_LIGHTITALIC15PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x80, 0xD8, 0x55, 0x59, 0x0D, 0x04, 0x82, 0x8E, 0x71,
  0x20, 0xA3, 0x9C, 0x48, 0x28, 0x24, 0x00, 0x04, 0x02, 0x07, 0x84, 0xA2,
  0x89, 0x40, 0xE0, 0x1C, 0x09, 0x44, 0x94, 0x87, 0x81, 0x00, 0x80, 0x38,
  0xD2, 0x24, 0x91, 0x28, 0x32, 0x05, 0xC2, 0x91, 0x24, 0x49, 0x21, 0x80,
  0x1C, 0x11, 0x08, 0x84, 0x43, 0x42, 0xC2, 0x21, 0x09, 0x8D, 0x39, 0x80,
  0xF0, 0x08, 0x88, 0x84, 0x42, 0x10, 0x84, 0x20, 0x82, 0x00, 0x20, 0x82,
  0x10, 0x84, 0x21, 0x10, 0x88, 0x88, 0x00, 0x08, 0x22, 0x4B, 0xE1, 0x05,
  0x33, 0x00, 0x18, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x69, 0x40, 0xF8,
  0xF0, 0x01, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x0C, 0x00, 0x1C, 0xC5, 0x0C, 0x18, 0x32, 0x60, 0xC1, 0x84,
  0xF0, 0x18, 0x71, 0xA4, 0x40, 0x82, 0x04, 0x08, 0x11, 0xFC, 0x3C, 0xC5,
  0x08, 0x10, 0x61, 0x84, 0x10, 0xC1, 0xF8, 0x1E, 0x31, 0x01, 0x03, 0x1C,
  0x02, 0x02, 0x02, 0xC2, 0x3C, 0x03, 0x05, 0x0A, 0x12, 0x12, 0x22, 0x42,
  0xFF, 0x04, 0x04, 0x3E, 0x81, 0x02, 0x07, 0xC8, 0xC0, 0x81, 0x84, 0xF0,
  0x0C, 0x20, 0x83, 0xE4, 0x70, 0x60, 0xC1, 0x84, 0xF0, 0xFF, 0x0A, 0x10,
  0x41, 0x02, 0x08, 0x10, 0x41, 0x00, 0x3E, 0x85, 0x0A, 0x13, 0xC8, 0xE0,
  0xC1, 0x84, 0xF0, 0x3C, 0x85, 0x0C, 0x14, 0x6F, 0xC1, 0x04, 0x10, 0xC0,
  0x6C, 0x00, 0x36, 0x33, 0x00, 0x00, 0x64, 0x48, 0x03, 0x04, 0x18, 0x60,
  0xC0, 0x20, 0x18, 0x04, 0xFE, 0x00, 0x07, 0xF0, 0x40, 0x60, 0x20, 0x30,
  0x63, 0x18, 0x40, 0x39, 0x18, 0x41, 0x08, 0xC2, 0x00, 0x61, 0x00, 0x1C,
  0x45, 0x0A, 0xF9, 0x34, 0x68, 0xD2, 0x9D, 0x03, 0x03, 0xC0, 0x04, 0x0C,
  0x0A, 0x12, 0x12, 0x22, 0x3E, 0x42, 0x41, 0x81, 0x7E, 0x85, 0x0A, 0x17,
  0xD0, 0xE0, 0xC1, 0x85, 0xF0, 0x1C, 0x22, 0x41, 0x40, 0x80, 0x80, 0x80,
  0x82, 0x44, 0x78, 0x3C, 0x85, 0x0A, 0x14, 0x28, 0x60, 0xC1, 0x85, 0xF0,
  0x7F, 0x40, 0x40, 0x40, 0x7E, 0x80, 0x80, 0x80, 0x80, 0xFC, 0x7F, 0x40,
  0x40, 0x40, 0x7E, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1C, 0x45, 0x0A, 0x08,
  0x11, 0xE0, 0xC1, 0xCC, 0xE8, 0x41, 0x41, 0x42, 0x42, 0x7E, 0x82, 0x82,
  0x84, 0x84, 0x84, 0x7F, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0xFC, 0x3E, 0x04, 0x08, 0x10, 0x40, 0x81, 0x42, 0x88, 0xF0, 0x41, 0xA1,
  0x11, 0x09, 0x05, 0x03, 0x43, 0x21, 0x08, 0x84, 0x41, 0x00, 0x20, 0x84,
  0x10, 0x41, 0x04, 0x10, 0x83, 0xF0, 0x21, 0x98, 0xCC, 0xAA, 0xA4, 0xD2,
  0x49, 0x24, 0x82, 0x42, 0x41, 0x00, 0x61, 0x61, 0x62, 0x52, 0x92, 0x92,
  0x8A, 0x8C, 0x8C, 0x84, 0x1C, 0xC5, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x84,
  0xF0, 0x7E, 0x43, 0x41, 0x41, 0x42, 0x7C, 0x80, 0x80, 0x80, 0x80, 0x1C,
  0xC5, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x84, 0xF0, 0x40, 0xB0, 0xC0, 0x7E,
  0x43, 0x41, 0x41, 0x42, 0x7C, 0x88, 0x88, 0x84, 0x84, 0x1E, 0x10, 0x88,
  0x24, 0x03, 0x80, 0x30, 0x05, 0x02, 0x42, 0x1E, 0x00, 0x7F, 0xC4, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x00, 0x41, 0x41, 0x42,
  0x42, 0x82, 0x82, 0x82, 0x84, 0x84, 0x78, 0x83, 0x06, 0x14, 0x28, 0x91,
  0x14, 0x28, 0x60, 0xC0, 0xC1, 0x81, 0x89, 0x9A, 0xAA, 0xAA, 0xAA, 0xCC,
  0xCC, 0x8C, 0x20, 0xC4, 0x41, 0x20, 0x38, 0x0C, 0x03, 0x01, 0x40, 0x88,
  0x42, 0x20, 0x40, 0xC1, 0xA0, 0x90, 0x84, 0x82, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x00, 0x3F, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x7F, 0x80, 0x3D, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20,
  0xF0, 0x88, 0x88, 0x44, 0x44, 0x22, 0x22, 0x30, 0x3C, 0x10, 0x41, 0x04,
  0x20, 0x82, 0x08, 0x20, 0x84, 0xF0, 0x08, 0x28, 0x92, 0x14, 0x30, 0x40,
  0xFE, 0xE0, 0x3A, 0x8E, 0x0C, 0x28, 0x50, 0xA3, 0x3B, 0x20, 0x81, 0x02,
  0xE6, 0x28, 0x50, 0xC1, 0x83, 0x8A, 0xE0, 0x3C, 0x89, 0x0C, 0x08, 0x10,
  0x91, 0x3C, 0x01, 0x02, 0x02, 0x3A, 0x46, 0x82, 0x82, 0x84, 0x84, 0x8C,
  0x74, 0x3C, 0x86, 0x1F, 0xC8, 0x10, 0x71, 0x3C, 0x07, 0x82, 0x01, 0x07,
  0xF0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x24, 0x12, 0x05, 0x01, 0x80,
  0x3A, 0x8E, 0x0C, 0x28, 0x50, 0xA3, 0x3A, 0x05, 0x13, 0xC0, 0x20, 0x41,
  0x02, 0xE6, 0x28, 0x50, 0xC2, 0x85, 0x0A, 0x10, 0x08, 0x20, 0x07, 0x81,
  0x02, 0x08, 0x12, 0x26, 0x50, 0xC0, 0x06, 0x00, 0x03, 0xE0, 0x40, 0x81,
  0x04, 0x08, 0x12, 0x26, 0x46, 0x82, 0x00, 0x20, 0x40, 0x40, 0x5C, 0x62,
  0x42, 0x44, 0xB8, 0x92, 0x97, 0x8C, 0xF0, 0x82, 0x08, 0x21, 0x04, 0x12,
  0x4D, 0xC6, 0x00, 0x5B, 0x36, 0x52, 0x49, 0x24, 0x92, 0x4A, 0x25, 0x22,
  0x5C, 0xC5, 0x0A, 0x18, 0x50, 0xA1, 0x42, 0x3C, 0x86, 0x0C, 0x18, 0x30,
  0xA1, 0x3C, 0x2E, 0x31, 0x21, 0x21, 0x41, 0x41, 0x62, 0x5C, 0x40, 0x40,
  0x80, 0x3A, 0x8E, 0x0C, 0x28, 0x50, 0xA3, 0x3A, 0x04, 0x10, 0x20, 0xEE,
  0x60, 0x82, 0x04, 0x08, 0x10, 0x20, 0x3C, 0x85, 0x03, 0x80, 0xC0, 0xA1,
  0x3C, 0x10, 0x23, 0xF9, 0x02, 0x04, 0x08, 0x13, 0x38, 0x60, 0x42, 0x85,
  0x0C, 0x28, 0x50, 0xA7, 0x3A, 0xE2, 0x45, 0x0A, 0x14, 0x28, 0x92, 0x38,
  0xCA, 0x92, 0x93, 0x92, 0x92, 0x92, 0xB2, 0xDC, 0x13, 0x36, 0x42, 0x21,
  0x00, 0x84, 0x42, 0x6C, 0xC8, 0x21, 0x21, 0x21, 0x42, 0x42, 0x42, 0x6E,
  0x3A, 0x06, 0x84, 0x78, 0x7A, 0x8E, 0x10, 0x43, 0x08, 0xB8, 0xCF, 0x1E,
  0x40, 0x81, 0x01, 0x02, 0x38, 0x18, 0x20, 0x81, 0x02, 0x07, 0x00, 0x24,
  0x94, 0x92, 0x52, 0x48, 0x38, 0x10, 0x20, 0x81, 0x02, 0x03, 0x98, 0x20,
  0x40, 0x40, 0x8E, 0x00, 0x63, 0x92, 0x8C,
};

const GFXglyph IBMPlexMono_LightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 10, 9, 3, -10 },
  { 5, 4, 4, 9, 3, -11 },
  { 7, 9, 10, 9, 0, -10 },
  { 19, 9, 14, 9, 0, -12 },
  { 35, 10, 10, 9, 0, -10 },
  { 48, 9, 10, 9, 0, -10 },
  { 60, 1, 4, 9, 5, -11 },
  { 61, 5, 13, 9, 3, -11 },
  { 70, 5, 13, 9, 1, -11 },
  { 79, 7, 7, 9, 1, -8 },
  { 86, 7, 7, 9, 1, -8 },
  { 93, 3, 4, 9, 2, -2 },
  { 95, 5, 1, 9, 2, -5 },
  { 96, 2, 2, 9, 3, -2 },
  { 97, 9, 13, 9, 0, -11 },
  { 112, 7, 10, 9, 1, -10 },
  { 121, 7, 10, 9, 1, -10 },
  { 130, 7, 10, 9, 1, -10 },
  { 139, 8, 10, 9, 0, -10 },
  { 149, 8, 10, 9, 0, -10 },
  { 159, 7, 10, 9, 1, -10 },
  { 168, 7, 10, 9, 1, -10 },
  { 177, 7, 10, 9, 2, -10 },
  { 186, 7, 10, 9, 1, -10 },
  { 195, 7, 10, 9, 1, -10 },
  { 204, 3, 8, 9, 3, -8 },
  { 207, 4, 10, 9, 2, -8 },
  { 212, 8, 8, 9, 1, -9 },
  { 220, 7, 4, 9, 1, -7 },
  { 224, 7, 8, 9, 1, -9 },
  { 231, 6, 10, 9, 2, -10 },
  { 239, 7, 12, 9, 1, -10 },
  { 250, 8, 10, 9, 0, -10 },
  { 260, 7, 10, 9, 1, -10 },
  { 269, 8, 10, 9, 1, -10 },
  { 279, 7, 10, 9, 1, -10 },
  { 288, 8, 10, 9, 1, -10 },
  { 298, 8, 10, 9, 1, -10 },
  { 308, 7, 10, 9, 1, -10 },
  { 317, 8, 10, 9, 1, -10 },
  { 327, 8, 10, 9, 1, -10 },
  { 337, 7, 10, 9, 1, -10 },
  { 346, 9, 10, 9, 1, -10 },
  { 358, 6, 10, 9, 1, -10 },
  { 366, 9, 10, 9, 0, -10 },
  { 378, 8, 10, 9, 1, -10 },
  { 388, 7, 10, 9, 1, -10 },
  { 397, 8, 10, 9, 1, -10 },
  { 407, 7, 13, 9, 1, -10 },
  { 419, 8, 10, 9, 1, -10 },
  { 429, 9, 10, 9, 0, -10 },
  { 441, 9, 10, 9, 1, -10 },
  { 453, 8, 10, 9, 1, -10 },
  { 463, 7, 10, 9, 2, -10 },
  { 472, 8, 10, 9, 1, -10 },
  { 482, 10, 10, 9, 0, -10 },
  { 495, 9, 10, 9, 1, -10 },
  { 507, 9, 10, 9, 0, -10 },
  { 519, 6, 13, 9, 3, -11 },
  { 529, 4, 13, 9, 3, -11 },
  { 536, 6, 13, 9, 0, -11 },
  { 546, 7, 6, 9, 1, -10 },
  { 552, 7, 1, 9, 0, 1 },
  { 553, 1, 3, 9, 4, -12 },
  { 554, 7, 8, 9, 1, -8 },
  { 561, 7, 11, 9, 1, -11 },
  { 571, 7, 8, 9, 1, -8 },
  { 578, 8, 11, 9, 1, -11 },
  { 589, 7, 8, 9, 1, -8 },
  { 596, 9, 14, 9, 0, -11 },
  { 612, 7, 11, 9, 1, -8 },
  { 622, 7, 11, 9, 1, -11 },
  { 632, 7, 11, 9, 1, -11 },
  { 642, 7, 14, 9, 1, -11 },
  { 655, 8, 11, 9, 1, -11 },
  { 666, 6, 11, 9, 2, -11 },
  { 675, 9, 8, 9, 0, -8 },
  { 684, 7, 8, 9, 1, -8 },
  { 691, 7, 8, 9, 1, -8 },
  { 698, 8, 11, 9, 0, -8 },
  { 709, 7, 11, 9, 1, -8 },
  { 719, 7, 8, 9, 2, -8 },
  { 726, 7, 8, 9, 1, -8 },
  { 733, 7, 10, 9, 1, -10 },
  { 742, 7, 8, 9, 1, -8 },
  { 749, 7, 8, 9, 1, -8 },
  { 756, 8, 8, 9, 1, -8 },
  { 764, 9, 8, 9, 0, -8 },
  { 773, 8, 11, 9, 0, -8 },
  { 784, 7, 8, 9, 1, -8 },
  { 791, 7, 13, 9, 2, -11 },
  { 803, 3, 13, 9, 3, -11 },
  { 808, 7, 13, 9, 1, -11 },
  { 820, 8, 3, 9, 1, -6 },
};

const GFXfont IBMPlexMono_LightItalic15pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic15pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _IBMPLEXMONO_LIGHTITALIC15PT7B_H_
