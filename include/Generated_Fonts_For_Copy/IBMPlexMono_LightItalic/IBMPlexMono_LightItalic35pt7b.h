#ifndef _IBMPLEXMONO_LIGHTITALIC35PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1,
  0x82, 0x04, 0x08, 0x00, 0x00, 0x00, 0x07, 0x1E, 0x3C, 0x38, 0x31, 0xB0,
  0xD8, 0x6C, 0x26, 0x33, 0x19, 0x0D, 0x86, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x01, 0x06, 0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0x80, 0x03, 0x0C, 0x07, 0xF0, 0x7F, 0x3F, 0x87, 0xF0, 0x0C, 0x30, 0x00,
  0xC1, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x06, 0x00, 0x18, 0x60,
  0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0xC0, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x10,
  0x60, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0F, 0xE0,
  0x07, 0xFF, 0x03, 0xC4, 0xF0, 0x60, 0x87, 0x18, 0x30, 0x63, 0x06, 0x00,
  0x60, 0xC0, 0x0C, 0x10, 0x01, 0x82, 0x00, 0x38, 0x40, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x08, 0xE0, 0x01, 0x0E, 0x00, 0x20, 0xC0,
  0x0C, 0x18, 0x01, 0x83, 0x10, 0x30, 0x66, 0x04, 0x1C, 0x60, 0x83, 0x07,
  0x31, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x01, 0xF0, 0x03, 0x03, 0xF8, 0x06, 0x06, 0x18,
  0x0C, 0x0C, 0x0C, 0x18, 0x0C, 0x0C, 0x18, 0x08, 0x0C, 0x30, 0x18, 0x0C,
  0x60, 0x18, 0x08, 0x40, 0x08, 0x18, 0xC0, 0x0C, 0x31, 0x80, 0x0F, 0xF3,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xC7, 0xF0, 0x01, 0x8C,
  0x30, 0x03, 0x18, 0x18, 0x03, 0x18, 0x18, 0x06, 0x30, 0x18, 0x0C, 0x30,
  0x18, 0x08, 0x30, 0x30, 0x18, 0x30, 0x30, 0x30, 0x18, 0x60, 0x60, 0x1F,
  0xE0, 0xE0, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xE1, 0xC0,
  0x06, 0x07, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0x61, 0x80, 0x1F, 0xF8, 0x03,
  0x8F, 0x00, 0x38, 0x70, 0x01, 0x81, 0x80, 0x1C, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x30, 0x07, 0x05, 0x80, 0x38, 0x76, 0x02, 0x66, 0x38,
  0x33, 0xB0, 0xFF, 0x0F, 0x03, 0xF0, 0x30, 0x6D, 0xB7, 0xB6, 0xC0, 0x00,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x0E, 0x0C, 0x1D, 0xF3, 0x7E, 0x0F, 0xFC, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1D, 0x80, 0x06, 0x70, 0x03, 0x0C, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x30,
  0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x70, 0x70, 0x38, 0x06, 0x1C, 0x01, 0x86, 0x00, 0x73,
  0x00, 0x0C, 0xC0, 0x03, 0x70, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1D, 0x83,
  0x86, 0x61, 0xE1, 0xB8, 0x70, 0x6C, 0x00, 0x1B, 0x00, 0x0E, 0xC0, 0x03,
  0x30, 0x00, 0xCE, 0x00, 0x61, 0x80, 0x38, 0x60, 0x1C, 0x0E, 0x0E, 0x03,
  0xFF, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xD8, 0x07, 0xB0,
  0x0E, 0x30, 0x1C, 0x30, 0x38, 0x30, 0x30, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x78, 0x38, 0x38,
  0x07, 0x0C, 0x00, 0xC6, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0xC0, 0x70, 0x38, 0x38, 0x07, 0x0C, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x33, 0x00, 0x1C, 0x60, 0x06, 0x1E, 0x07, 0x01,
  0xFF, 0x80, 0x3F, 0x80, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x36, 0x00, 0x19, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x01, 0x83,
  0x00, 0xE0, 0xC0, 0x30, 0x60, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x01, 0x83,
  0x00, 0x61, 0x80, 0x18, 0x40, 0x0C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x7E, 0x03, 0x7F, 0xC0, 0xF0,
  0x38, 0x38, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x73, 0x00, 0x18, 0xE0, 0x0E, 0x1C, 0x0F, 0x03,
  0xFF, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x19, 0xF8,
  0x37, 0xFC, 0x3C, 0x0E, 0x78, 0x07, 0x70, 0x03, 0x60, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x0E, 0x38, 0x3C,
  0x3F, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xD0, 0x00, 0xD8, 0x00,
  0xEC, 0x00, 0x66, 0x00, 0x63, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0,
  0xF0, 0x38, 0x70, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x18, 0x60,
  0x06, 0x18, 0x03, 0x03, 0x01, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x1C, 0x0E,
  0x1C, 0x01, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x33, 0x00, 0x1C, 0xE0, 0x0E, 0x1C, 0x0F, 0x03, 0xFF, 0x80, 0x7F,
  0x80, 0x03, 0xF8, 0x0F, 0xFC, 0x1C, 0x0E, 0x38, 0x07, 0x70, 0x03, 0x60,
  0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x60,
  0x0F, 0x78, 0x36, 0x3F, 0xE6, 0x0F, 0xCC, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x1C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0xF1, 0xE1, 0xC0, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x01, 0x81, 0x80, 0x00, 0x00, 0x80,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0xE3, 0x83, 0xDC, 0x03,
  0xE0, 0x0F, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x0E,
  0x03, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0xFC, 0x01, 0xFF, 0x01, 0xC1, 0xC1, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x0C,
  0x60, 0x02, 0x60, 0xF3, 0x30, 0xFD, 0x98, 0xE1, 0xC8, 0x60, 0x6C, 0x60,
  0x36, 0x30, 0x13, 0x18, 0x19, 0x8C, 0x0C, 0x86, 0x06, 0x42, 0x03, 0x61,
  0x83, 0xB0, 0xC2, 0x98, 0x7F, 0xCC, 0x1F, 0x66, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x76, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x30,
  0x0C, 0x0C, 0x03, 0x03, 0x01, 0x80, 0x60, 0x60, 0x18, 0x3F, 0xFE, 0x0F,
  0xFF, 0x86, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x0F, 0x00, 0x03, 0x0F, 0xFC, 0x07, 0xFF, 0x87, 0x00, 0xC3,
  0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x38, 0x03,
  0x98, 0x01, 0x8C, 0x03, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0x80, 0x31, 0xC0,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xEC,
  0x00, 0x66, 0x00, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0xF8, 0x01, 0xFF,
  0x03, 0xC1, 0xC3, 0x80, 0x61, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x02, 0x30, 0x01,
  0x9C, 0x01, 0x86, 0x01, 0xC3, 0xC1, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x0F,
  0xF8, 0x03, 0xFF, 0x80, 0xC0, 0xF0, 0x30, 0x0E, 0x18, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x1C, 0x60, 0x07, 0x18, 0x00, 0xCE, 0x00, 0x33, 0x00, 0x1C,
  0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x19, 0xC0, 0x0E, 0x60,
  0x03, 0x18, 0x00, 0xC6, 0x00, 0x71, 0x80, 0x18, 0x60, 0x0C, 0x38, 0x0E,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0x03, 0x83, 0x83, 0x80, 0x63, 0x80, 0x39, 0x80, 0x0D,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x0F, 0xF6, 0x07, 0xF3, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60,
  0x03, 0x30, 0x03, 0x98, 0x01, 0x8E, 0x01, 0xC3, 0x83, 0x60, 0xFF, 0x30,
  0x3F, 0x18, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x71, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x18, 0xFF, 0xFE, 0x3F, 0xFF, 0x18, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0xCE, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x38, 0x0F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x30, 0x03, 0x18, 0x03, 0x86,
  0x03, 0x83, 0x83, 0x80, 0xFF, 0x80, 0x1F, 0x80, 0x0C, 0x00, 0x70, 0xC0,
  0x0E, 0x1C, 0x01, 0xC1, 0x80, 0x38, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x18,
  0x18, 0x01, 0x83, 0x00, 0x38, 0x60, 0x03, 0x0C, 0x00, 0x31, 0xC0, 0x03,
  0x3C, 0x00, 0x36, 0xE0, 0x03, 0xC6, 0x00, 0x78, 0x70, 0x07, 0x03, 0x00,
  0x60, 0x38, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x06, 0x00, 0xC0, 0xE0, 0x0C,
  0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0xB0, 0x1E,
  0x1B, 0x01, 0x61, 0xB0, 0x36, 0x19, 0x06, 0x61, 0x98, 0x66, 0x19, 0x8C,
  0x41, 0x18, 0x8C, 0x30, 0xD8, 0xC3, 0x0F, 0x0C, 0x30, 0xF0, 0xC3, 0x06,
  0x0C, 0x30, 0x40, 0x82, 0x04, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60,
  0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x04, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0x0E, 0x00, 0xC7, 0x80, 0x31, 0xE0, 0x0C, 0x6C, 0x03, 0x1B,
  0x00, 0xC6, 0xC0, 0x31, 0x30, 0x18, 0xC6, 0x06, 0x31, 0x81, 0x8C, 0x60,
  0x63, 0x0C, 0x18, 0xC3, 0x06, 0x20, 0xC3, 0x18, 0x30, 0xC6, 0x06, 0x31,
  0x81, 0x8C, 0x60, 0x63, 0x18, 0x0C, 0xCC, 0x03, 0x63, 0x00, 0xD8, 0xC0,
  0x36, 0x30, 0x07, 0x8C, 0x01, 0xE3, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x70, 0x70, 0x38, 0x06, 0x1C, 0x01, 0x86, 0x00, 0x73, 0x00, 0x0C,
  0xC0, 0x03, 0x70, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x06, 0x60,
  0x01, 0xB8, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0E, 0xC0, 0x03, 0x30, 0x00,
  0xCE, 0x00, 0x61, 0x80, 0x38, 0x60, 0x1C, 0x0E, 0x0E, 0x03, 0xFF, 0x00,
  0x3F, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xC0, 0x18, 0x60, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x38, 0x00, 0xCC, 0x00,
  0x73, 0x00, 0x18, 0xC0, 0x1E, 0x3F, 0xFF, 0x0F, 0xFF, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x70, 0x70, 0x38, 0x06, 0x1C, 0x01, 0x86, 0x00, 0x73, 0x00, 0x0C,
  0xC0, 0x03, 0x70, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x06, 0x60,
  0x01, 0xB8, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0E, 0xC0, 0x03, 0x30, 0x00,
  0xC6, 0x00, 0x61, 0x80, 0x38, 0x60, 0x1C, 0x0E, 0x0E, 0x03, 0xFF, 0x00,
  0x3F, 0x00, 0x01, 0x80, 0x00, 0x70, 0x40, 0x0C, 0x78, 0x01, 0xB8, 0x00,
  0x7C, 0x00, 0x0E, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xC0, 0x18, 0x60,
  0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x38, 0x00,
  0xCC, 0x00, 0x73, 0x00, 0x18, 0xC0, 0x1C, 0x3F, 0xFE, 0x0F, 0xFE, 0x07,
  0x06, 0x01, 0x81, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x81, 0x80,
  0x60, 0xE0, 0x1C, 0x30, 0x03, 0x0C, 0x00, 0xE3, 0x00, 0x18, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x3C, 0x0F, 0x06, 0x00, 0x71, 0x80, 0x04, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x31, 0x00, 0x06, 0x60, 0x01, 0xC6, 0x00, 0x30,
  0x70, 0x1C, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x18, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x1D, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30,
  0x01, 0x98, 0x00, 0xCC, 0x00, 0xEE, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19,
  0x80, 0x0C, 0xC0, 0x0E, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x8C, 0x01,
  0x87, 0x83, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0xC0, 0x00, 0xF0, 0x00, 0x6C,
  0x00, 0x19, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80,
  0x30, 0x60, 0x0C, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x30,
  0x0C, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x80, 0x30, 0xC0, 0x06, 0x70, 0x01,
  0x98, 0x00, 0x6E, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30,
  0x00, 0x62, 0x00, 0x06, 0x20, 0x60, 0xC6, 0x0E, 0x0C, 0x60, 0xE0, 0xC6,
  0x1A, 0x0C, 0x61, 0xA1, 0x86, 0x12, 0x18, 0x63, 0x31, 0x86, 0x33, 0x18,
  0x66, 0x33, 0x06, 0x63, 0x30, 0x6C, 0x33, 0x04, 0xC3, 0x30, 0x48, 0x36,
  0x0D, 0x83, 0x60, 0xD8, 0x36, 0x0F, 0x01, 0x40, 0xF0, 0x1C, 0x0E, 0x01,
  0xC0, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0x70, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0xC0, 0x06, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xC0, 0x00,
  0xE6, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x06, 0x00,
  0x1C, 0x18, 0x00, 0xE0, 0x70, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x80, 0xC0,
  0x06, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xE0, 0x00, 0x76, 0x00, 0x0E,
  0x70, 0x01, 0xC3, 0x00, 0x18, 0x30, 0x03, 0x01, 0x80, 0x60, 0x18, 0x0E,
  0x00, 0xC1, 0xC0, 0x0C, 0x18, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x7E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x07, 0xFE,
  0x0F, 0xF8, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x80, 0xC0,
  0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30, 0x10,
  0x10, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x06, 0x06,
  0x06, 0x02, 0x03, 0x03, 0x03, 0x01, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x6C, 0x00, 0x73, 0x00, 0x31,
  0x80, 0x30, 0x60, 0x30, 0x30, 0x18, 0x18, 0x18, 0x06, 0x18, 0x03, 0x18,
  0x00, 0xCC, 0x00, 0x6C, 0x00, 0x34, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC6, 0x63, 0x31, 0x03, 0xE1, 0x87, 0xFD, 0x87, 0x82, 0xC7, 0x00,
  0xE3, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x0C, 0xE0, 0x06, 0x60,
  0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0xE1, 0x80, 0xF0,
  0xE0, 0xD8, 0x3F, 0xCF, 0x8F, 0xC7, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0xFC, 0x0C, 0xFF, 0x06, 0xC1, 0xC3, 0x80, 0x63, 0xC0, 0x39, 0xC0,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0xD8, 0x00, 0xCC,
  0x00, 0x66, 0x00, 0x33, 0x00, 0x31, 0xC0, 0x38, 0xF0, 0x78, 0xCF, 0xF8,
  0x61, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x70, 0x71, 0x80, 0x66, 0x00,
  0x6C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x4C, 0x00, 0xD8, 0x03, 0xB8, 0x0E, 0x38, 0x38, 0x3F, 0xE0, 0x1F,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x03, 0xE1, 0x83, 0xFE, 0x61,
  0xE0, 0xF0, 0xE0, 0x1C, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x0C, 0xE0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0E,
  0x38, 0x07, 0x86, 0x01, 0xC1, 0xC1, 0xB0, 0x3F, 0xCC, 0x07, 0xC3, 0x00,
  0x03, 0xF0, 0x1F, 0xF8, 0x70, 0x39, 0x80, 0x36, 0x00, 0x6C, 0x00, 0xF0,
  0x03, 0xE0, 0x7E, 0xFF, 0xF1, 0xFE, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x58, 0x01, 0xF8, 0x07, 0x38, 0x3C, 0x3F, 0xF0, 0x3F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x10, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x80, 0xC0,
  0x01, 0x81, 0x80, 0x07, 0x83, 0x00, 0x03, 0x86, 0x00, 0x03, 0x8C, 0x00,
  0x03, 0xB0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0xC1,
  0xFF, 0x30, 0xE0, 0x78, 0x70, 0x0E, 0x18, 0x01, 0x8C, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x06, 0x70, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x07, 0x1C, 0x02, 0x83, 0x00, 0xE0, 0xE0, 0xD8, 0x1F, 0xE6, 0x03,
  0xF1, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x10, 0x06, 0x0F, 0x07,
  0x81, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x78,
  0x19, 0xFE, 0x1B, 0x0E, 0x1A, 0x07, 0x1C, 0x03, 0x18, 0x03, 0x38, 0x03,
  0x30, 0x03, 0x30, 0x02, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x0C, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x04, 0x18, 0x18, 0x30, 0xE0,
  0xC3, 0x81, 0x9E, 0x03, 0x70, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x61, 0x00, 0xC3, 0x83, 0x03,
  0x86, 0x03, 0x8C, 0x03, 0x98, 0x03, 0xB0, 0x03, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x7C, 0x06, 0x7F, 0x81, 0xB0, 0x70,
  0x78, 0x0C, 0x1C, 0x03, 0x0E, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x38, 0x30,
  0x38, 0x0C, 0x7C, 0x03, 0x30, 0x01, 0x86, 0x00, 0x61, 0x80, 0xD8, 0x30,
  0x66, 0x0C, 0x71, 0x81, 0xB8, 0x60, 0x7C, 0x30, 0x0E, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x86, 0x07, 0x18, 0x38, 0x63,
  0x81, 0x9C, 0x0C, 0xE0, 0x3E, 0x00, 0x70, 0x00, 0x19, 0xC3, 0xC3, 0x7C,
  0xF8, 0xD1, 0xA3, 0x9C, 0x38, 0x33, 0x03, 0x06, 0x60, 0xC0, 0xCC, 0x18,
  0x11, 0x83, 0x06, 0x60, 0x60, 0xCC, 0x0C, 0x19, 0x81, 0x03, 0x30, 0x60,
  0x66, 0x0C, 0x08, 0x81, 0x83, 0x30, 0x30, 0x66, 0x06, 0x0C, 0xC0, 0x81,
  0x98, 0x30, 0x30, 0x18, 0x78, 0x19, 0xFE, 0x1B, 0x0E, 0x1A, 0x07, 0x1C,
  0x03, 0x18, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x02, 0x30, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0x83, 0x83, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x19, 0x80, 0x04, 0xC0, 0x07, 0x60, 0x03, 0x30, 0x01,
  0xB8, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0x70,
  0x70, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x0C, 0x7E, 0x03, 0x3F, 0xC0, 0xD8,
  0x38, 0x38, 0x06, 0x1E, 0x01, 0xC7, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x73, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0xC3, 0x80, 0x70, 0xF0, 0x78, 0x67, 0xFC, 0x18, 0x7C, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xE1, 0x87, 0xFC, 0xC7, 0x83, 0xC7, 0x00, 0xE3,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0xE0, 0x06, 0x60, 0x03,
  0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xE7, 0x00, 0xF1, 0x80, 0x70, 0xE0,
  0xD8, 0x3F, 0xCC, 0x0F, 0xC6, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0xFF, 0x1F, 0xFF,
  0x3F, 0xC1, 0xB0, 0x00, 0xD0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xF8, 0x07, 0xFF, 0x07, 0x01, 0xC3, 0x00, 0x33, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x24, 0x00, 0x33, 0x00, 0x18, 0xE0, 0x38, 0x3F, 0xF8,
  0x07, 0xF0, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x06, 0x0C, 0x1E, 0x0C, 0x38, 0x18, 0xF0, 0x1B, 0xC0, 0x1F,
  0x80, 0x0E, 0x00, 0x30, 0x07, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0xC0,
  0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x38, 0xE0, 0x58, 0x70, 0xD8, 0x7F,
  0x98, 0x3E, 0x18, 0xFC, 0x06, 0xFC, 0x06, 0x08, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x06, 0x18, 0x06, 0x10, 0x06, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x18, 0x30, 0x38, 0x30, 0xF0, 0x23, 0xE0, 0x3F,
  0x80, 0x3E, 0x00, 0x30, 0x61, 0x8C, 0x18, 0x23, 0x06, 0x0C, 0x81, 0x83,
  0x60, 0x40, 0xD8, 0x10, 0x36, 0x0C, 0x0D, 0x83, 0x03, 0x60, 0xC0, 0xD0,
  0x30, 0x3C, 0x08, 0x1B, 0x06, 0x06, 0xC1, 0x81, 0xB0, 0x60, 0xCC, 0x28,
  0x33, 0x1B, 0x18, 0xFC, 0xFC, 0x1E, 0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x3E,
  0x1F, 0x83, 0x99, 0x8C, 0x70, 0xD8, 0x33, 0x06, 0x81, 0x80, 0x14, 0x0C,
  0x00, 0xC0, 0x40, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0xC0, 0x0C, 0x07, 0x00, 0x60, 0x58, 0x31, 0x86, 0xC7, 0x0C,
  0x66, 0x70, 0x7F, 0x1F, 0x01, 0xE0, 0xE0, 0x00, 0x0C, 0x01, 0xC3, 0x00,
  0x60, 0xC0, 0x18, 0x30, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x30,
  0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x1C, 0x30,
  0x06, 0x0C, 0x03, 0x83, 0x81, 0x60, 0x70, 0xD8, 0x1F, 0xE6, 0x01, 0xF1,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x10, 0x06, 0x0E, 0x07, 0x81,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xC1, 0x8F, 0xFC, 0xCE, 0x0F, 0xE6,
  0x00, 0xF3, 0x00, 0x61, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xC1, 0x80, 0x61, 0x80, 0x13, 0xF0,
  0x0D, 0xFF, 0xC6, 0xC7, 0xFF, 0x60, 0x3F, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x01, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x41, 0x83,
  0x06, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83,
  0x06, 0x08, 0x10, 0x60, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xFF,
  0x00, 0xFE, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0xCF, 0xC0,
  0x23, 0x18, 0x19, 0x83, 0x06, 0xC0, 0xE3, 0x30, 0x1F, 0x88, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_LightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 7, 24, 21, 7, -24 },
  { 22, 9, 9, 21, 8, -26 },
  { 33, 21, 24, 21, 1, -24 },
  { 96, 19, 32, 21, 1, -28 },
  { 172, 24, 24, 21, -1, -24 },
  { 244, 21, 24, 21, 0, -24 },
  { 307, 3, 9, 21, 11, -26 },
  { 311, 12, 32, 21, 8, -27 },
  { 359, 12, 32, 21, 2, -27 },
  { 407, 18, 17, 21, 2, -19 },
  { 446, 17, 18, 21, 2, -20 },
  { 485, 7, 9, 21, 5, -4 },
  { 493, 10, 2, 21, 6, -12 },
  { 496, 4, 4, 21, 7, -4 },
  { 498, 19, 32, 21, 1, -27 },
  { 574, 18, 24, 21, 2, -24 },
  { 628, 16, 24, 21, 2, -24 },
  { 676, 18, 24, 21, 1, -24 },
  { 730, 18, 24, 21, 1, -24 },
  { 784, 18, 24, 21, 1, -24 },
  { 838, 18, 24, 21, 2, -24 },
  { 892, 16, 24, 21, 2, -24 },
  { 940, 17, 24, 21, 4, -24 },
  { 991, 18, 24, 21, 2, -24 },
  { 1045, 16, 24, 21, 3, -24 },
  { 1093, 7, 19, 21, 7, -19 },
  { 1110, 9, 24, 21, 5, -19 },
  { 1137, 17, 20, 21, 3, -21 },
  { 1180, 18, 9, 21, 2, -15 },
  { 1201, 16, 20, 21, 2, -21 },
  { 1241, 14, 24, 21, 5, -24 },
  { 1283, 17, 28, 21, 2, -24 },
  { 1343, 18, 24, 21, 0, -24 },
  { 1397, 17, 24, 21, 2, -24 },
  { 1448, 17, 24, 21, 3, -24 },
  { 1499, 18, 24, 21, 2, -24 },
  { 1553, 19, 24, 21, 2, -24 },
  { 1610, 19, 24, 21, 2, -24 },
  { 1667, 17, 24, 21, 3, -24 },
  { 1718, 18, 24, 21, 2, -24 },
  { 1772, 19, 24, 21, 2, -24 },
  { 1829, 17, 24, 21, 2, -24 },
  { 1880, 20, 24, 21, 2, -24 },
  { 1940, 14, 24, 21, 3, -24 },
  { 1982, 20, 24, 21, 1, -24 },
  { 2042, 18, 24, 21, 2, -24 },
  { 2096, 18, 24, 21, 2, -24 },
  { 2150, 18, 24, 21, 2, -24 },
  { 2204, 18, 30, 21, 2, -24 },
  { 2272, 18, 24, 21, 2, -24 },
  { 2326, 19, 24, 21, 1, -24 },
  { 2383, 19, 24, 21, 3, -24 },
  { 2440, 17, 24, 21, 3, -24 },
  { 2491, 18, 24, 21, 4, -24 },
  { 2545, 20, 24, 21, 2, -24 },
  { 2605, 22, 24, 21, 0, -24 },
  { 2671, 20, 24, 21, 3, -24 },
  { 2731, 21, 24, 21, 0, -24 },
  { 2794, 15, 32, 21, 6, -27 },
  { 2854, 8, 32, 21, 7, -27 },
  { 2886, 14, 32, 21, 1, -27 },
  { 2942, 17, 14, 21, 3, -24 },
  { 2972, 17, 2, 21, 0, 4 },
  { 2977, 4, 6, 21, 8, -27 },
  { 2980, 17, 18, 21, 2, -18 },
  { 3019, 17, 26, 21, 2, -26 },
  { 3075, 15, 18, 21, 3, -18 },
  { 3109, 18, 26, 21, 2, -26 },
  { 3168, 15, 18, 21, 3, -18 },
  { 3202, 23, 33, 21, -1, -26 },
  { 3297, 18, 25, 21, 1, -18 },
  { 3354, 16, 26, 21, 2, -26 },
  { 3406, 15, 25, 21, 3, -25 },
  { 3453, 15, 33, 21, 3, -26 },
  { 3515, 18, 26, 21, 2, -26 },
  { 3574, 14, 26, 21, 4, -26 },
  { 3620, 19, 18, 21, 1, -18 },
  { 3663, 16, 18, 21, 2, -18 },
  { 3699, 17, 18, 21, 2, -18 },
  { 3738, 18, 25, 21, 1, -18 },
  { 3795, 17, 25, 21, 2, -18 },
  { 3849, 17, 18, 21, 4, -18 },
  { 3888, 17, 18, 21, 2, -18 },
  { 3927, 16, 24, 21, 3, -24 },
  { 3975, 16, 18, 21, 3, -18 },
  { 4011, 16, 18, 21, 3, -18 },
  { 4047, 18, 18, 21, 2, -18 },
  { 4088, 21, 18, 21, 0, -18 },
  { 4136, 18, 25, 21, 1, -18 },
  { 4193, 17, 18, 21, 2, -18 },
  { 4232, 16, 32, 21, 4, -27 },
  { 4296, 7, 32, 21, 7, -27 },
  { 4324, 16, 32, 21, 2, -27 },
  { 4388, 18, 7, 21, 2, -14 },
};

const GFXfont IBMPlexMono_LightItalic35pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic35pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _IBMPLEXMONO_LIGHTITALIC35PT7B_H_
