#ifndef _IBMPLEXMONO_LIGHTITALIC53PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x78, 0x00,
  0x38, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE7, 0x03,
  0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0xE0, 0x73, 0x81,
  0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x0F, 0xFE, 0x07,
  0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x10, 0x1C, 0x0E,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xC0, 0xE0,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFC, 0x67, 0xF0, 0x07, 0x81, 0x83, 0xC0, 0x3C, 0x06, 0x07, 0x80, 0xE0,
  0x38, 0x0F, 0x07, 0x80, 0xE0, 0x10, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0C,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x03, 0xC1, 0x80, 0x00,
  0x07, 0xC6, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x31, 0xF8, 0x00, 0x00,
  0xC1, 0xF0, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x18, 0x07,
  0x80, 0x00, 0x60, 0x1E, 0x00, 0x01, 0x80, 0x70, 0x30, 0x0E, 0x01, 0xC3,
  0xC0, 0x38, 0x0F, 0x07, 0x80, 0xC0, 0x78, 0x0F, 0x83, 0x03, 0xC0, 0x1F,
  0x8C, 0x7E, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0xFF, 0xE0, 0x00, 0xC0, 0x1E,
  0x0F, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x07, 0x00, 0x70, 0x03, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x1C, 0x00, 0x60, 0x07, 0x01, 0x80, 0x06, 0x00, 0x70, 0x38, 0x00, 0x60,
  0x07, 0x07, 0x00, 0x06, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x0E, 0x0E, 0x00,
  0x07, 0x83, 0xC1, 0xC0, 0x00, 0x3F, 0xF8, 0x38, 0x00, 0x01, 0xFF, 0x03,
  0x00, 0x00, 0x0F, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1C, 0x1F, 0xF8, 0x00, 0x03, 0x83, 0xFF, 0xC0, 0x00, 0x30, 0x7C,
  0x3C, 0x00, 0x07, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0xE0, 0x0E, 0x00, 0x1C,
  0x0E, 0x00, 0xE0, 0x01, 0xC0, 0xC0, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x07, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x0E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x0F, 0x0F, 0x80, 0x70, 0x00, 0xFF, 0xF0, 0x0E, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x78, 0x7C, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0xB8, 0x00, 0x1E, 0x03, 0xF8, 0x00, 0x7C, 0x0E, 0x70, 0x00, 0x9C,
  0x1C, 0xE0, 0x03, 0x3C, 0x71, 0xE0, 0x0E, 0x38, 0xE1, 0xF0, 0x78, 0x7B,
  0x81, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x1C, 0xE3, 0x8E, 0x38, 0xE3, 0x9C, 0x71, 0xC7, 0x1C, 0x73, 0x80,
  0x00, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x0E, 0x01, 0xC0, 0x3F, 0xF8, 0x38, 0x3F, 0x9F, 0xE7, 0x3F,
  0xE0, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x8E, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x78, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x38,
  0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xC0,
  0x0F, 0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1E,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x03, 0xE0, 0x3F, 0x80,
  0xF8, 0x0E, 0xE0, 0x3E, 0x03, 0xB8, 0x07, 0x00, 0xEE, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x8E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x07,
  0x80, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xEE, 0x00, 0x03, 0xE7, 0x00, 0x03, 0xE3, 0x80, 0x03,
  0xE1, 0xC0, 0x07, 0xE1, 0xC0, 0x07, 0xC0, 0xE0, 0x07, 0xC0, 0x70, 0x03,
  0xC0, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0x40, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7C,
  0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x1E,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x08, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38,
  0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0C,
  0x07, 0x00, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x87, 0xF0, 0x00, 0x73, 0xFF,
  0x80, 0x0C, 0xFF, 0xFC, 0x03, 0xB8, 0x0F, 0xC0, 0x7C, 0x00, 0x78, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x08, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x1F,
  0xC0, 0x1C, 0xFF, 0xF0, 0x39, 0xFF, 0xF8, 0x3B, 0xC0, 0xFC, 0x76, 0x00,
  0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x3E, 0x03,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xC0, 0x00, 0x1E, 0x70,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x07,
  0xC0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x01, 0xC0,
  0x01, 0xE0, 0x3C, 0x00, 0x78, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xC0, 0x7C, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0xEE, 0x3E,
  0x03, 0xDC, 0x1F, 0xFF, 0x9C, 0x0F, 0xFF, 0x38, 0x03, 0xF8, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0x83,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xA0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xFF, 0x03, 0xE0, 0x7E, 0x1E, 0x00, 0x78, 0xF0, 0x00, 0xF7,
  0x80, 0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x80, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x3E, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x63, 0x00, 0x7C, 0x73, 0x80, 0xFF, 0x39, 0xC0, 0xFF, 0xDC,
  0xE0, 0xF8, 0x2E, 0x60, 0x70, 0x0F, 0x70, 0x78, 0x07, 0x38, 0x38, 0x03,
  0x9C, 0x1C, 0x01, 0xCE, 0x0C, 0x00, 0xE6, 0x0E, 0x00, 0x77, 0x07, 0x00,
  0x3B, 0x83, 0x80, 0x19, 0xC1, 0xC0, 0x0C, 0xE0, 0xC0, 0x0E, 0x70, 0x60,
  0x07, 0x38, 0x30, 0x03, 0x98, 0x18, 0x03, 0xCC, 0x0E, 0x02, 0xC6, 0x07,
  0x03, 0x63, 0x03, 0xF7, 0x71, 0x80, 0xFF, 0xB8, 0xC0, 0x3F, 0x9C, 0x60,
  0x02, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1C,
  0x0E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1C, 0x00, 0x3E, 0x07, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0F, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x0E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x3C,
  0x1C, 0x00, 0x3E, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x3C, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79,
  0xC0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x3E, 0x38, 0x00, 0x3F, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x00, 0xF8, 0x0F, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x0E, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0xF8, 0x0E, 0x00, 0x7E, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0x7C, 0x03,
  0xC0, 0x07, 0x01, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0x87, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0x38, 0x01, 0xFF, 0xCE, 0x00, 0x7F,
  0xF3, 0x80, 0x20, 0x1C, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x8F,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x17,
  0x03, 0xC0, 0x0D, 0xC0, 0xFC, 0x0E, 0x70, 0x1F, 0xFF, 0x1C, 0x03, 0xFF,
  0x8E, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x08, 0x00, 0x0E,
  0x0F, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x07, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x38, 0xFC, 0x00,
  0x00, 0x73, 0xBC, 0x00, 0x00, 0xEE, 0x38, 0x00, 0x03, 0xF8, 0x78, 0x00,
  0x07, 0xE0, 0x70, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x0E, 0xE0, 0x76, 0x00, 0x3B, 0x81, 0x9C, 0x01, 0xCC, 0x0E,
  0x70, 0x07, 0x70, 0x39, 0xC0, 0x39, 0xC0, 0xE3, 0x01, 0xC7, 0x03, 0x8E,
  0x07, 0x1C, 0x0E, 0x38, 0x38, 0x70, 0x30, 0x60, 0xE1, 0x81, 0xC1, 0x87,
  0x0E, 0x07, 0x07, 0x18, 0x38, 0x1C, 0x1C, 0xE0, 0xE0, 0x70, 0x37, 0x03,
  0x81, 0xC0, 0xDC, 0x0E, 0x06, 0x03, 0xE0, 0x30, 0x38, 0x0F, 0x01, 0xC0,
  0xE0, 0x1C, 0x07, 0x03, 0x80, 0x60, 0x1C, 0x0E, 0x01, 0x80, 0x70, 0x38,
  0x04, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x00,
  0x03, 0xE0, 0x00, 0x38, 0x1F, 0x00, 0x01, 0xC0, 0xFC, 0x00, 0x0E, 0x07,
  0xE0, 0x00, 0x60, 0x3F, 0x00, 0x07, 0x01, 0xDC, 0x00, 0x38, 0x1C, 0xE0,
  0x01, 0xC0, 0xE7, 0x00, 0x0E, 0x07, 0x38, 0x00, 0x70, 0x38, 0xE0, 0x03,
  0x01, 0xC7, 0x00, 0x38, 0x0E, 0x38, 0x01, 0xC0, 0xE0, 0xC0, 0x0E, 0x07,
  0x07, 0x00, 0x70, 0x38, 0x38, 0x03, 0x81, 0xC1, 0xC0, 0x18, 0x0E, 0x07,
  0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x06, 0x03,
  0x81, 0xC0, 0x38, 0x1C, 0x0E, 0x01, 0xC0, 0xC0, 0x70, 0x0E, 0x0E, 0x03,
  0x80, 0x38, 0x70, 0x38, 0x01, 0xC3, 0x81, 0xC0, 0x0E, 0x1C, 0x0E, 0x00,
  0x70, 0xE0, 0x70, 0x01, 0xC6, 0x03, 0x80, 0x0E, 0x70, 0x1C, 0x00, 0x73,
  0x81, 0xC0, 0x01, 0x9C, 0x0E, 0x00, 0x0E, 0xE0, 0x70, 0x00, 0x77, 0x03,
  0x80, 0x03, 0xF0, 0x1C, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x7C, 0x0E, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x78, 0x1C, 0x00, 0x1C, 0x07, 0x80, 0x1F, 0x00, 0xF8, 0x1F, 0x80,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x7C,
  0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0xC1, 0xC0, 0x00,
  0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x0F,
  0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1E, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x1E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x07, 0x80,
  0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x02, 0x00, 0x0F, 0x01,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x7C, 0x07, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0xF8, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xC0, 0x70,
  0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03,
  0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x07, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x38, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x3C, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x04, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x07,
  0x80, 0x7E, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x78, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x78,
  0x38, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x0F, 0x00,
  0x1E, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0F,
  0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80,
  0x70, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x01,
  0xC0, 0x3C, 0x00, 0x38, 0x07, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x60, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80,
  0x78, 0x07, 0x0E, 0x01, 0xE0, 0x18, 0x38, 0x0F, 0x80, 0xE0, 0xE0, 0x3E,
  0x03, 0x83, 0x81, 0xD8, 0x0E, 0x0E, 0x07, 0x60, 0x30, 0x38, 0x19, 0x81,
  0xC0, 0xC0, 0xE6, 0x07, 0x03, 0x03, 0x18, 0x1C, 0x0C, 0x1C, 0x70, 0x60,
  0x70, 0x71, 0xC3, 0x81, 0xC1, 0x87, 0x0E, 0x07, 0x0E, 0x1C, 0x38, 0x1C,
  0x30, 0x70, 0xC0, 0x71, 0xC1, 0xC7, 0x01, 0xC7, 0x07, 0x1C, 0x07, 0x38,
  0x0C, 0x70, 0x1C, 0xE0, 0x31, 0x80, 0x73, 0x00, 0xCE, 0x01, 0x9C, 0x03,
  0x38, 0x06, 0x70, 0x0C, 0xE0, 0x1B, 0x80, 0x33, 0x00, 0x6E, 0x00, 0xFC,
  0x03, 0xB0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x7D, 0xC0, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0,
  0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x80, 0x01,
  0xC0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x40, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x70, 0x06, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x40,
  0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF8, 0x21, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0C, 0x1C, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xE1, 0xC0, 0xFF, 0xF8, 0xE0, 0xFC, 0x0E, 0x70, 0xF8,
  0x01, 0xB8, 0x70, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x8E, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x01, 0x70, 0xF0, 0x01,
  0xF0, 0x78, 0x01, 0xB8, 0x1F, 0x03, 0x9F, 0xC7, 0xFF, 0x8F, 0xE1, 0xFF,
  0x83, 0xF0, 0x3F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x0F, 0xC0, 0x07, 0x0F, 0xFC, 0x01,
  0xCF, 0xFF, 0x80, 0xE7, 0x81, 0xF0, 0x39, 0x80, 0x3C, 0x0E, 0xC0, 0x07,
  0x83, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1E, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x3C, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xC1, 0xD8,
  0x01, 0xE0, 0x77, 0x81, 0xF8, 0x1C, 0xFF, 0xF8, 0x0E, 0x1F, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x3E, 0x03, 0xC0, 0xF0, 0x01, 0xC3, 0xC0, 0x03, 0xC7, 0x00, 0x03, 0x9E,
  0x00, 0x04, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x4E, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x9C, 0x00, 0x0E, 0x3C, 0x00, 0x38,
  0x3C, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xC1, 0xC0, 0x0F, 0xFE, 0x38, 0x07,
  0xFF, 0xE7, 0x01, 0xF8, 0x1C, 0xE0, 0x7C, 0x00, 0xDC, 0x0E, 0x00, 0x0B,
  0x83, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30,
  0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x81, 0xE0, 0x03,
  0x70, 0x3C, 0x00, 0xDC, 0x03, 0xE0, 0x73, 0x80, 0x3F, 0xFE, 0x70, 0x03,
  0xFF, 0x0E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x1E, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x3E, 0x70, 0x00, 0xFC, 0x70, 0x1F, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x08, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x3F, 0x03, 0xE0,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x02, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xF8,
  0x07, 0x00, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x00,
  0x7C, 0x1C, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFC,
  0x70, 0x1F, 0xFF, 0x9C, 0x0F, 0xC0, 0xE7, 0x07, 0xC0, 0x0D, 0xC1, 0xC0,
  0x01, 0x70, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x78,
  0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x83, 0xC0, 0x06, 0xE0, 0xF0, 0x03, 0x38,
  0x1F, 0x03, 0xDC, 0x03, 0xFF, 0xE7, 0x00, 0x7F, 0xE1, 0xC0, 0x07, 0xE0,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x08, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x03,
  0xF0, 0x1F, 0x80, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x3F, 0x00,
  0xE1, 0xFF, 0x81, 0xC7, 0xFF, 0x83, 0x9C, 0x1F, 0x07, 0x60, 0x0F, 0x1E,
  0x80, 0x1E, 0x3A, 0x00, 0x1C, 0x78, 0x00, 0x38, 0xF0, 0x00, 0x71, 0xC0,
  0x00, 0xE3, 0x80, 0x01, 0xCF, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x00, 0x01,
  0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0F, 0x80,
  0xC0, 0x7C, 0x03, 0x81, 0xF0, 0x07, 0x07, 0x80, 0x0E, 0x1E, 0x00, 0x1C,
  0xF8, 0x00, 0x3B, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x20, 0x03, 0x80, 0x70, 0x07,
  0x00, 0xF8, 0x07, 0x00, 0x7C, 0x07, 0x00, 0x3E, 0x07, 0x00, 0x1F, 0x07,
  0x00, 0x07, 0x87, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x1F, 0x80, 0x0E, 0x1F,
  0xF8, 0x03, 0x8F, 0xFF, 0x00, 0xE7, 0x03, 0xE0, 0x7B, 0x00, 0x78, 0x1D,
  0x80, 0x0E, 0x07, 0x40, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x38,
  0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x01,
  0xE0, 0x38, 0x01, 0xF0, 0x0E, 0x01, 0xF0, 0x03, 0x87, 0xF0, 0x01, 0xC3,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x09,
  0xC0, 0xE0, 0x07, 0x70, 0x1C, 0x03, 0xF8, 0x07, 0x01, 0xEE, 0x00, 0xE1,
  0xF3, 0x80, 0x38, 0xF8, 0xE0, 0x07, 0x78, 0x38, 0x01, 0xFC, 0x0E, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x01, 0x03, 0x80, 0x3C,
  0x1C, 0x03, 0xC0, 0xE0, 0x3C, 0x0E, 0x07, 0xC0, 0x70, 0x7C, 0x03, 0x87,
  0x80, 0x1C, 0xF8, 0x00, 0xEF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x3B, 0xFC, 0x7F, 0x81, 0x9F, 0xE3,
  0xFE, 0x1D, 0x87, 0x30, 0xF0, 0xF8, 0x1F, 0x03, 0x87, 0x80, 0xF0, 0x1C,
  0x38, 0x07, 0x80, 0xE1, 0xC0, 0x38, 0x07, 0x0C, 0x01, 0xC0, 0x38, 0xE0,
  0x0C, 0x01, 0xC7, 0x00, 0xE0, 0x0C, 0x38, 0x07, 0x00, 0xE1, 0xC0, 0x38,
  0x07, 0x0C, 0x01, 0xC0, 0x38, 0x60, 0x0E, 0x01, 0xC7, 0x00, 0x60, 0x0E,
  0x38, 0x07, 0x00, 0x61, 0xC0, 0x38, 0x07, 0x0E, 0x01, 0xC0, 0x38, 0x60,
  0x0E, 0x01, 0xC3, 0x00, 0x70, 0x0E, 0x38, 0x03, 0x00, 0x71, 0xC0, 0x38,
  0x03, 0x0E, 0x01, 0xC0, 0x38, 0x70, 0x0E, 0x01, 0xC3, 0x00, 0x70, 0x0E,
  0x38, 0x03, 0x80, 0x71, 0xC0, 0x18, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x1C,
  0x3F, 0xF0, 0x38, 0xFF, 0xF0, 0x73, 0x83, 0xE0, 0xEC, 0x01, 0xE3, 0xD0,
  0x03, 0xC7, 0x40, 0x03, 0x8F, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x39, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x03,
  0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80,
  0x01, 0xC7, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xF0,
  0x00, 0x38, 0x70, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x3E, 0x07, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x70, 0xFF, 0xC0, 0x0E, 0x7F, 0xFC, 0x01, 0xDE, 0x07, 0xC0, 0x73, 0x00,
  0x78, 0x0E, 0xC0, 0x07, 0x81, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x60,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x0F, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x3B, 0x00, 0x3C, 0x07, 0x78, 0x1F, 0x80,
  0xE7, 0xFF, 0xC0, 0x38, 0x7F, 0xF0, 0x07, 0x03, 0xF8, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xF1, 0xC0, 0xFF, 0xFC, 0xE0, 0xFC, 0x0E, 0x70, 0xF8, 0x01, 0xB8,
  0x78, 0x00, 0x5C, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x03, 0x8E, 0x00,
  0x03, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x01, 0x70, 0xF0, 0x01, 0xB8, 0x78,
  0x01, 0xBC, 0x1F, 0x03, 0x9C, 0x07, 0xFF, 0x8E, 0x01, 0xFF, 0x87, 0x00,
  0x3F, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0x1C, 0xE0, 0x00, 0x0E,
  0xC0, 0x00, 0x07, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0,
  0x70, 0x00, 0x78, 0x70, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x39, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3F, 0x80, 0x7C, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x38, 0x01,
  0xE0, 0x1C, 0x01, 0xF8, 0x0E, 0x03, 0xE0, 0x07, 0x03, 0xE0, 0x03, 0x87,
  0xC0, 0x01, 0x8F, 0xC0, 0x01, 0xCF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x18, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7,
  0x00, 0x07, 0x8E, 0x00, 0x17, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0xB8, 0x78,
  0x03, 0x70, 0x78, 0x1C, 0xE0, 0xFF, 0xF1, 0xC0, 0xFF, 0xC3, 0x80, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x0E,
  0x00, 0x78, 0x0C, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x1C,
  0x0F, 0x80, 0x1C, 0x7F, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x70, 0x38, 0x70, 0x0E, 0x03,
  0x0E, 0x01, 0xC0, 0x71, 0xC0, 0x38, 0x0E, 0x30, 0x06, 0x01, 0xCE, 0x01,
  0xC0, 0x39, 0xC0, 0x38, 0x07, 0x38, 0x07, 0x00, 0xE7, 0x00, 0xE0, 0x1C,
  0xE0, 0x1C, 0x03, 0x98, 0x03, 0x00, 0x77, 0x00, 0xE0, 0x0E, 0xE0, 0x1C,
  0x01, 0xDC, 0x03, 0x80, 0x3B, 0x80, 0x70, 0x07, 0x70, 0x0E, 0x01, 0xCC,
  0x01, 0x80, 0x39, 0x80, 0x70, 0x07, 0x70, 0x0E, 0x00, 0xEE, 0x01, 0xC0,
  0x39, 0xC0, 0x38, 0x07, 0x38, 0x0F, 0x01, 0xE7, 0x01, 0x60, 0x38, 0xE0,
  0x6C, 0x0E, 0x1E, 0x19, 0xC3, 0xC3, 0xFE, 0x3F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x81, 0xF3, 0x87, 0x0F, 0x0F, 0x8E, 0x38, 0x1C, 0xF8,
  0x1C, 0xC0, 0x77, 0x80, 0x76, 0x01, 0xC8, 0x01, 0xD8, 0x07, 0x00, 0x07,
  0x40, 0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x38, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xE0, 0x0B, 0x80, 0x03, 0x80,
  0x6E, 0x00, 0xCE, 0x01, 0xB8, 0x0F, 0x38, 0x0C, 0xE0, 0x78, 0xE0, 0x73,
  0x87, 0xC3, 0xC3, 0x87, 0x3C, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F,
  0x00, 0x1F, 0x00, 0x70, 0x00, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80,
  0x01, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0xB8, 0x1C, 0x00,
  0x3E, 0x07, 0x00, 0x17, 0x01, 0xE0, 0x0D, 0xC0, 0x3E, 0x0E, 0x70, 0x0F,
  0xFF, 0x1C, 0x01, 0xFF, 0x87, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x40, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x0F, 0x80, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x70, 0xFF, 0xFE, 0x1C, 0x3C, 0x0F, 0xE7, 0x1C, 0x00,
  0x7F, 0xC7, 0x00, 0x03, 0xE1, 0x80, 0x00, 0xF0, 0x60, 0x00, 0x78, 0x18,
  0x00, 0x3C, 0x06, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0x00, 0x3C, 0x00, 0xC0, 0x1E,
  0x00, 0x38, 0x0F, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x00, 0x61,
  0xFE, 0x00, 0x1C, 0xFF, 0xFC, 0x07, 0x38, 0x7F, 0xF9, 0xCE, 0x01, 0xFF,
  0xF3, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x7C, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x41, 0xFE, 0x00, 0x1C, 0x7F, 0xE0, 0x03, 0x0E,
  0x1E, 0x00, 0xE3, 0x81, 0xC0, 0x1C, 0x60, 0x1C, 0x07, 0x1C, 0x03, 0xC1,
  0xE3, 0x00, 0x3C, 0x78, 0xE0, 0x03, 0xFE, 0x18, 0x00, 0x3F, 0x83, 0x00,
  0x03, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 10, 37, 32, 11, -37 },
  { 48, 14, 14, 32, 12, -39 },
  { 73, 32, 37, 32, 1, -37 },
  { 221, 30, 49, 32, 1, -43 },
  { 405, 36, 39, 32, -1, -38 },
  { 581, 31, 39, 32, 0, -38 },
  { 733, 6, 14, 32, 16, -39 },
  { 744, 18, 47, 32, 12, -40 },
  { 850, 18, 47, 32, 3, -40 },
  { 956, 27, 26, 32, 3, -29 },
  { 1044, 25, 27, 32, 4, -30 },
  { 1129, 10, 14, 32, 8, -6 },
  { 1147, 15, 3, 32, 9, -18 },
  { 1153, 6, 6, 32, 11, -6 },
  { 1158, 29, 47, 32, 2, -40 },
  { 1329, 26, 39, 32, 4, -38 },
  { 1456, 25, 37, 32, 2, -37 },
  { 1572, 27, 38, 32, 2, -38 },
  { 1701, 27, 39, 32, 2, -38 },
  { 1833, 28, 37, 32, 1, -37 },
  { 1963, 27, 38, 32, 3, -37 },
  { 2092, 24, 38, 32, 4, -37 },
  { 2206, 26, 37, 32, 6, -37 },
  { 2327, 27, 39, 32, 3, -38 },
  { 2459, 24, 38, 32, 5, -38 },
  { 2573, 10, 28, 32, 11, -28 },
  { 2608, 13, 36, 32, 8, -28 },
  { 2667, 25, 30, 32, 5, -31 },
  { 2761, 27, 13, 32, 3, -23 },
  { 2805, 25, 30, 32, 3, -31 },
  { 2899, 22, 38, 32, 7, -38 },
  { 3004, 25, 44, 32, 4, -38 },
  { 3142, 28, 37, 32, 0, -37 },
  { 3272, 26, 37, 32, 3, -37 },
  { 3393, 26, 39, 32, 4, -38 },
  { 3520, 27, 37, 32, 3, -37 },
  { 3645, 28, 37, 32, 3, -37 },
  { 3775, 29, 37, 32, 3, -37 },
  { 3910, 26, 39, 32, 4, -38 },
  { 4037, 29, 37, 32, 2, -37 },
  { 4172, 29, 37, 32, 2, -37 },
  { 4307, 26, 38, 32, 3, -37 },
  { 4431, 31, 37, 32, 3, -37 },
  { 4575, 21, 37, 32, 5, -37 },
  { 4673, 30, 37, 32, 2, -37 },
  { 4812, 29, 37, 32, 2, -37 },
  { 4947, 26, 39, 32, 4, -38 },
  { 5074, 28, 37, 32, 3, -37 },
  { 5204, 26, 48, 32, 4, -38 },
  { 5360, 28, 37, 32, 3, -37 },
  { 5490, 29, 39, 32, 2, -38 },
  { 5632, 29, 37, 32, 5, -37 },
  { 5767, 27, 38, 32, 4, -37 },
  { 5896, 27, 37, 32, 6, -37 },
  { 6021, 30, 37, 32, 3, -37 },
  { 6160, 34, 37, 32, 0, -37 },
  { 6318, 30, 37, 32, 5, -37 },
  { 6457, 32, 37, 32, 0, -37 },
  { 6605, 22, 47, 32, 9, -40 },
  { 6735, 13, 47, 32, 10, -40 },
  { 6812, 22, 47, 32, 1, -40 },
  { 6942, 26, 21, 32, 4, -37 },
  { 7011, 26, 3, 32, 0, 5 },
  { 7021, 7, 10, 32, 12, -41 },
  { 7030, 25, 29, 32, 3, -28 },
  { 7121, 26, 40, 32, 3, -39 },
  { 7251, 23, 29, 32, 4, -28 },
  { 7335, 27, 40, 32, 3, -39 },
  { 7470, 24, 29, 32, 4, -28 },
  { 7557, 34, 50, 32, -1, -39 },
  { 7770, 26, 39, 32, 2, -28 },
  { 7897, 23, 39, 32, 4, -39 },
  { 8010, 23, 40, 32, 5, -39 },
  { 8125, 24, 50, 32, 4, -39 },
  { 8275, 26, 40, 32, 4, -39 },
  { 8405, 21, 40, 32, 6, -39 },
  { 8510, 29, 28, 32, 1, -28 },
  { 8612, 23, 28, 32, 4, -28 },
  { 8693, 24, 29, 32, 4, -28 },
  { 8780, 27, 39, 32, 2, -28 },
  { 8912, 25, 39, 32, 3, -28 },
  { 9034, 25, 27, 32, 6, -27 },
  { 9119, 25, 29, 32, 3, -28 },
  { 9210, 25, 38, 32, 4, -37 },
  { 9329, 23, 28, 32, 5, -27 },
  { 9410, 24, 28, 32, 4, -28 },
  { 9494, 27, 29, 32, 3, -28 },
  { 9592, 30, 29, 32, 1, -28 },
  { 9701, 26, 38, 32, 2, -27 },
  { 9825, 26, 29, 32, 3, -28 },
  { 9920, 24, 47, 32, 6, -40 },
  { 10061, 11, 47, 32, 11, -40 },
  { 10126, 25, 47, 32, 2, -40 },
  { 10273, 27, 11, 32, 3, -22 },
};

const GFXfont IBMPlexMono_LightItalic53pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic53pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic53pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _IBMPLEXMONO_LIGHTITALIC53PT7B_H_
