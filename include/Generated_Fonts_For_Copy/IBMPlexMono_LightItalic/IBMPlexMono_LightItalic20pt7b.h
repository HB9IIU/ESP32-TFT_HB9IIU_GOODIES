#ifndef _IBMPLEXMONO_LIGHTITALIC20PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x33, 0x22, 0x22, 0x44, 0x00, 0xCC, 0xCC, 0xA5, 0x29, 0x00,
  0x02, 0x20, 0x24, 0x06, 0x40, 0x44, 0x3C, 0xF0, 0xC8, 0x08, 0x80, 0x98,
  0x09, 0x0F, 0x1E, 0x13, 0x01, 0x20, 0x22, 0x02, 0x40, 0x02, 0x00, 0x40,
  0x7E, 0x19, 0x66, 0x46, 0x88, 0x11, 0x01, 0x20, 0x1C, 0x00, 0xE0, 0x22,
  0x04, 0x40, 0x89, 0x11, 0x32, 0x41, 0xF0, 0x10, 0x02, 0x00, 0x1C, 0x09,
  0x10, 0x88, 0x88, 0x84, 0xC4, 0x24, 0x13, 0x40, 0xF0, 0x00, 0x38, 0x0A,
  0x20, 0x91, 0x09, 0x08, 0x88, 0x44, 0x26, 0x41, 0xE0, 0x0F, 0x01, 0x88,
  0x10, 0xC1, 0x04, 0x10, 0xC0, 0x88, 0x19, 0x06, 0x60, 0xC4, 0x08, 0x20,
  0x83, 0x28, 0x33, 0x44, 0xA3, 0x8C, 0x57, 0x80, 0x06, 0x10, 0x60, 0x82,
  0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x20,
  0x18, 0x10, 0x10, 0x20, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x41,
  0x02, 0x08, 0x21, 0x80, 0x06, 0x01, 0x00, 0x42, 0x11, 0x77, 0x83, 0x01,
  0xC0, 0xC8, 0x22, 0x10, 0x40, 0x06, 0x01, 0x00, 0x40, 0x10, 0xFF, 0xC3,
  0x00, 0x80, 0x20, 0x08, 0x00, 0x36, 0x44, 0x80, 0xFC, 0xF0, 0x00, 0x60,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x00, 0x0F,
  0x84, 0x32, 0x05, 0x81, 0x40, 0x50, 0x14, 0xC7, 0x31, 0xC0, 0x70, 0x2C,
  0x09, 0x06, 0x63, 0x0F, 0x00, 0x07, 0x07, 0x04, 0x8C, 0x44, 0x20, 0x30,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x87, 0xFC, 0x0F, 0x0C, 0x22,
  0x05, 0x01, 0x00, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80,
  0xC0, 0x3F, 0xE0, 0x0F, 0x0C, 0x22, 0x04, 0x01, 0x00, 0x80, 0x61, 0xE0,
  0x0C, 0x00, 0x80, 0x20, 0x0A, 0x06, 0xC3, 0x1F, 0x00, 0x00, 0xC0, 0x18,
  0x05, 0x01, 0x20, 0x44, 0x11, 0x86, 0x20, 0x84, 0x20, 0x88, 0x11, 0xFF,
  0xC0, 0xC0, 0x10, 0x02, 0x00, 0x1F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x0B,
  0xC7, 0x18, 0x02, 0x00, 0x80, 0x20, 0x0A, 0x06, 0x43, 0x0F, 0x80, 0x03,
  0x81, 0x00, 0x80, 0x40, 0x20, 0x0B, 0xC7, 0x19, 0x02, 0xC0, 0xF0, 0x2C,
  0x09, 0x06, 0x63, 0x0F, 0x80, 0x7F, 0xD0, 0x28, 0x0A, 0x04, 0x03, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x00, 0x0F,
  0x8C, 0x32, 0x04, 0x81, 0x20, 0x4C, 0x20, 0xF1, 0xC6, 0x40, 0xA0, 0x38,
  0x0A, 0x02, 0x41, 0x0F, 0x80, 0x1E, 0x30, 0x90, 0x30, 0x18, 0x0C, 0x06,
  0x07, 0x86, 0x3D, 0x01, 0x01, 0x01, 0x81, 0x03, 0x00, 0x33, 0x00, 0x00,
  0x00, 0xCC, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x33, 0x10, 0x88, 0x00, 0x00,
  0x80, 0xC1, 0x83, 0x06, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x20, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x30, 0x18, 0x18, 0x18, 0x08, 0x00, 0x3C, 0x42, 0x81,
  0x81, 0x01, 0x03, 0x06, 0x3C, 0x20, 0x20, 0x20, 0x00, 0x60, 0x60, 0x0F,
  0x04, 0x32, 0x04, 0x81, 0x47, 0x53, 0x34, 0x85, 0x22, 0x58, 0xA4, 0x29,
  0x9A, 0x3A, 0x80, 0x10, 0x06, 0x00, 0xF8, 0x03, 0x00, 0xE0, 0x68, 0x12,
  0x04, 0x82, 0x20, 0x88, 0x42, 0x10, 0xCF, 0xF2, 0x05, 0x01, 0x40, 0x60,
  0x10, 0x3F, 0x88, 0x32, 0x04, 0x81, 0x20, 0xD8, 0x27, 0xF1, 0x06, 0x40,
  0x90, 0x24, 0x0B, 0x02, 0x81, 0x3F, 0x80, 0x0F, 0x18, 0xD8, 0x28, 0x0C,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x50, 0x2C, 0x21, 0xE0, 0x3F,
  0x08, 0x22, 0x04, 0x81, 0x20, 0x48, 0x16, 0x05, 0x01, 0x40, 0x50, 0x34,
  0x09, 0x06, 0xC3, 0x3F, 0x00, 0x3F, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x1F, 0xF2, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0xFF,
  0x00, 0x3F, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x1F, 0xE2, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x00, 0x0F, 0x86, 0x32,
  0x04, 0x80, 0x40, 0x10, 0x04, 0x01, 0x1F, 0x40, 0xB0, 0x24, 0x09, 0x06,
  0x62, 0x8F, 0x60, 0x20, 0x64, 0x08, 0x81, 0x10, 0x26, 0x04, 0x80, 0x9F,
  0xF2, 0x04, 0x40, 0x88, 0x13, 0x02, 0x40, 0x48, 0x19, 0x02, 0x00, 0x3F,
  0xE0, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x81, 0xFF, 0x00, 0x1F, 0xC0, 0x30, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x13, 0x04, 0x42, 0x0F,
  0x00, 0x30, 0x32, 0x04, 0x20, 0x82, 0x10, 0x22, 0x06, 0x40, 0x4C, 0x05,
  0x40, 0x62, 0x04, 0x20, 0x43, 0x0C, 0x10, 0x81, 0x88, 0x08, 0x20, 0x20,
  0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0xFF,
  0x30, 0x66, 0x0C, 0xC3, 0xA8, 0xE4, 0x94, 0x94, 0x92, 0x92, 0x62, 0x44,
  0xD1, 0x12, 0x02, 0x40, 0x48, 0x09, 0x01, 0x00, 0x30, 0x26, 0x08, 0xA1,
  0x14, 0x26, 0x84, 0x90, 0x91, 0x12, 0x24, 0x44, 0x88, 0xD3, 0x0A, 0x41,
  0x48, 0x29, 0x02, 0x00, 0x0F, 0x84, 0x32, 0x05, 0x81, 0x40, 0x50, 0x14,
  0x07, 0x01, 0xC0, 0x70, 0x2C, 0x09, 0x06, 0x63, 0x0F, 0x00, 0x3F, 0x84,
  0x08, 0x81, 0x90, 0x32, 0x04, 0xC0, 0x98, 0x33, 0xF8, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x00, 0x0F, 0x84, 0x32, 0x04, 0x81, 0x40,
  0x50, 0x14, 0x07, 0x01, 0xC0, 0x70, 0x2C, 0x09, 0x06, 0x63, 0x0F, 0x00,
  0x80, 0x12, 0x05, 0xC0, 0xC0, 0x3F, 0x84, 0x08, 0x81, 0x90, 0x32, 0x04,
  0xC0, 0x98, 0x33, 0xF8, 0x44, 0x08, 0x41, 0x08, 0x61, 0x8C, 0x11, 0x03,
  0x00, 0x1F, 0x86, 0x19, 0x81, 0xA0, 0x04, 0x00, 0x40, 0x07, 0x00, 0x18,
  0x00, 0x80, 0x10, 0x02, 0x40, 0x4C, 0x10, 0x7C, 0x00, 0xFF, 0xE0, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x00, 0x40, 0xD0, 0x24, 0x09, 0x02, 0xC0, 0xA0,
  0x28, 0x1A, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0x86, 0x1F, 0x00, 0xC0,
  0x68, 0x09, 0x02, 0x20, 0x44, 0x10, 0x82, 0x10, 0x83, 0x10, 0x26, 0x04,
  0x80, 0xB0, 0x14, 0x03, 0x80, 0x60, 0x00, 0x40, 0x34, 0x02, 0x40, 0x24,
  0x02, 0x46, 0x44, 0xA4, 0x4A, 0x44, 0xA4, 0x52, 0x85, 0x28, 0xA2, 0x8A,
  0x28, 0xA3, 0x0C, 0x30, 0x30, 0x18, 0x81, 0x02, 0x18, 0x11, 0x80, 0x48,
  0x02, 0x80, 0x08, 0x00, 0xC0, 0x0D, 0x00, 0x48, 0x04, 0x20, 0x41, 0x04,
  0x04, 0x60, 0x20, 0x80, 0x68, 0x19, 0x02, 0x30, 0x82, 0x30, 0x6C, 0x05,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x1F,
  0xF0, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x0F, 0xFC, 0x1F, 0x88, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x7E, 0x00, 0x84, 0x21, 0x04, 0x21, 0x08, 0x21, 0x08,
  0x42, 0x08, 0x42, 0x10, 0x40, 0x1F, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x7E, 0x00, 0x02, 0x01, 0x40, 0x90, 0x66, 0x10, 0x88, 0x24, 0x07, 0x01,
  0xFF, 0xC0, 0xA5, 0x1E, 0xC8, 0x64, 0x09, 0x02, 0xC0, 0xA0, 0x28, 0x1B,
  0x04, 0x47, 0x0E, 0x70, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x0B, 0xC3,
  0x08, 0x83, 0x60, 0x50, 0x14, 0x0D, 0x02, 0x40, 0x98, 0x49, 0xE0, 0x1E,
  0x63, 0xC1, 0x80, 0x80, 0x80, 0x82, 0x83, 0xC6, 0x78, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x47, 0x92, 0x19, 0x02, 0x40, 0xB0, 0x28, 0x0A, 0x06,
  0xC1, 0x10, 0xC3, 0xD0, 0x1E, 0x61, 0xC1, 0x81, 0x86, 0xF8, 0x80, 0x81,
  0xC2, 0x7C, 0x01, 0xF8, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x0F, 0xF8,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x10, 0x80, 0x4C, 0x01, 0x40, 0x06, 0x00, 0x1E, 0x48, 0x64,
  0x09, 0x02, 0xC0, 0xA0, 0x28, 0x1B, 0x04, 0x43, 0x0F, 0x40, 0x10, 0x0C,
  0x86, 0x1F, 0x00, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x38, 0xE2, 0x41,
  0x60, 0xA0, 0x50, 0x28, 0x14, 0x12, 0x0B, 0x04, 0x0C, 0x0C, 0x00, 0x00,
  0xF8, 0x18, 0x10, 0x10, 0x10, 0x10, 0x31, 0x26, 0x2C, 0x30, 0x01, 0x03,
  0x00, 0x00, 0x00, 0x7E, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x84, 0x48, 0x28, 0x18, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x09,
  0xC3, 0x88, 0x82, 0x60, 0x90, 0x45, 0xE1, 0x21, 0x44, 0x51, 0x6C, 0x30,
  0xF8, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x21, 0x23,
  0x26, 0x28, 0x30, 0x2E, 0xE6, 0x64, 0x88, 0x91, 0x14, 0x22, 0x84, 0x51,
  0x0A, 0x22, 0x44, 0x58, 0x88, 0x27, 0x1C, 0x48, 0x24, 0x14, 0x0A, 0x05,
  0x02, 0x82, 0x41, 0x60, 0x80, 0x1F, 0x0C, 0x66, 0x09, 0x03, 0x40, 0xF0,
  0x2C, 0x09, 0x06, 0x43, 0x0F, 0x80, 0x2F, 0x0C, 0x22, 0x0D, 0x81, 0x40,
  0x50, 0x34, 0x09, 0x02, 0x61, 0x27, 0x88, 0x02, 0x00, 0x80, 0x20, 0x00,
  0x1E, 0x48, 0x64, 0x09, 0x02, 0xC0, 0xA0, 0x28, 0x1B, 0x04, 0x43, 0x0F,
  0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0xFB, 0xC5, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x00, 0x1F, 0x08, 0x32, 0x01, 0x80,
  0x3C, 0x00, 0xE0, 0x08, 0x02, 0xC1, 0x0F, 0x80, 0x08, 0x04, 0x04, 0x02,
  0x0F, 0xF8, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x44, 0xC2, 0xC1, 0x80,
  0x41, 0xA0, 0x90, 0x50, 0x28, 0x14, 0x0A, 0x09, 0x04, 0x8E, 0x39, 0x00,
  0x70, 0xA4, 0x11, 0x04, 0x81, 0x20, 0x88, 0x22, 0x18, 0x8C, 0x26, 0x0E,
  0x00, 0x46, 0x51, 0x14, 0x45, 0x11, 0x44, 0x61, 0x18, 0x86, 0x23, 0x98,
  0x99, 0xC0, 0x1C, 0xE3, 0x53, 0x46, 0x10, 0x21, 0x02, 0x00, 0x60, 0x86,
  0x08, 0xA2, 0xCA, 0xC7, 0x38, 0x20, 0xC8, 0x22, 0x09, 0x02, 0x40, 0x90,
  0x24, 0x11, 0x04, 0x47, 0x0E, 0x40, 0x10, 0x08, 0x86, 0x1F, 0x00, 0x3E,
  0x50, 0x74, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x09, 0x82, 0xF8, 0xA3, 0xE0,
  0x07, 0x84, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0xF8, 0x04, 0x01,
  0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x1F, 0x00, 0x11, 0x11, 0x22,
  0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x1E, 0x01, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x10, 0x07, 0x86, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x7C, 0x00, 0x38, 0x52, 0x18, 0x4A, 0x0C,
};

const GFXglyph IBMPlexMono_LightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 14, 12, 4, -14 },
  { 8, 5, 5, 12, 5, -15 },
  { 12, 12, 14, 12, 0, -14 },
  { 33, 11, 18, 12, 1, -16 },
  { 58, 13, 14, 12, 0, -14 },
  { 81, 12, 14, 12, 0, -14 },
  { 102, 2, 5, 12, 6, -15 },
  { 104, 7, 18, 12, 4, -15 },
  { 120, 7, 18, 12, 1, -15 },
  { 136, 10, 10, 12, 1, -11 },
  { 149, 10, 9, 12, 1, -11 },
  { 161, 4, 5, 12, 3, -2 },
  { 164, 6, 1, 12, 3, -7 },
  { 165, 2, 2, 12, 4, -2 },
  { 166, 11, 18, 12, 1, -15 },
  { 191, 10, 14, 12, 1, -14 },
  { 209, 9, 14, 12, 1, -14 },
  { 225, 10, 14, 12, 1, -14 },
  { 243, 10, 14, 12, 1, -14 },
  { 261, 11, 14, 12, 0, -14 },
  { 281, 10, 14, 12, 1, -14 },
  { 299, 10, 14, 12, 1, -14 },
  { 317, 10, 14, 12, 2, -14 },
  { 335, 10, 14, 12, 1, -14 },
  { 353, 9, 14, 12, 2, -14 },
  { 369, 4, 10, 12, 4, -10 },
  { 374, 5, 13, 12, 3, -10 },
  { 383, 9, 11, 12, 2, -12 },
  { 396, 10, 5, 12, 1, -9 },
  { 403, 10, 11, 12, 1, -12 },
  { 417, 8, 14, 12, 3, -14 },
  { 431, 10, 16, 12, 1, -14 },
  { 451, 10, 14, 12, 0, -14 },
  { 469, 10, 14, 12, 1, -14 },
  { 487, 9, 14, 12, 2, -14 },
  { 503, 10, 14, 12, 1, -14 },
  { 521, 11, 14, 12, 1, -14 },
  { 541, 11, 14, 12, 1, -14 },
  { 561, 10, 14, 12, 1, -14 },
  { 579, 11, 14, 12, 1, -14 },
  { 599, 11, 14, 12, 1, -14 },
  { 619, 10, 14, 12, 1, -14 },
  { 637, 12, 14, 12, 1, -14 },
  { 658, 8, 14, 12, 2, -14 },
  { 672, 11, 14, 12, 1, -14 },
  { 692, 11, 14, 12, 1, -14 },
  { 712, 10, 14, 12, 1, -14 },
  { 730, 11, 14, 12, 1, -14 },
  { 750, 10, 18, 12, 1, -14 },
  { 773, 11, 14, 12, 1, -14 },
  { 793, 11, 14, 12, 1, -14 },
  { 813, 11, 14, 12, 2, -14 },
  { 833, 10, 14, 12, 2, -14 },
  { 851, 11, 14, 12, 2, -14 },
  { 871, 12, 14, 12, 1, -14 },
  { 892, 13, 14, 12, 0, -14 },
  { 915, 11, 14, 12, 2, -14 },
  { 935, 12, 14, 12, 0, -14 },
  { 956, 9, 18, 12, 3, -15 },
  { 977, 5, 18, 12, 4, -15 },
  { 989, 9, 18, 12, 0, -15 },
  { 1010, 10, 8, 12, 1, -14 },
  { 1020, 10, 1, 12, 0, 2 },
  { 1022, 2, 4, 12, 5, -16 },
  { 1023, 10, 10, 12, 1, -10 },
  { 1036, 10, 15, 12, 1, -15 },
  { 1055, 8, 10, 12, 2, -10 },
  { 1065, 10, 15, 12, 1, -15 },
  { 1084, 8, 10, 12, 2, -10 },
  { 1094, 13, 19, 12, 0, -15 },
  { 1125, 10, 14, 12, 1, -10 },
  { 1143, 9, 15, 12, 1, -15 },
  { 1160, 8, 14, 12, 2, -14 },
  { 1174, 8, 19, 12, 2, -15 },
  { 1193, 10, 15, 12, 1, -15 },
  { 1212, 8, 15, 12, 2, -15 },
  { 1227, 11, 10, 12, 0, -10 },
  { 1241, 9, 10, 12, 1, -10 },
  { 1253, 10, 10, 12, 1, -10 },
  { 1266, 10, 14, 12, 1, -10 },
  { 1284, 10, 14, 12, 1, -10 },
  { 1302, 10, 10, 12, 2, -10 },
  { 1315, 10, 10, 12, 1, -10 },
  { 1328, 9, 14, 12, 2, -14 },
  { 1344, 9, 10, 12, 2, -10 },
  { 1356, 10, 10, 12, 1, -10 },
  { 1369, 10, 10, 12, 1, -10 },
  { 1382, 12, 10, 12, 0, -10 },
  { 1397, 10, 14, 12, 1, -10 },
  { 1415, 10, 10, 12, 1, -10 },
  { 1428, 9, 18, 12, 2, -15 },
  { 1449, 4, 18, 12, 4, -15 },
  { 1458, 9, 18, 12, 1, -15 },
  { 1479, 10, 4, 12, 1, -8 },
};

const GFXfont IBMPlexMono_LightItalic20pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic20pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _IBMPLEXMONO_LIGHTITALIC20PT7B_H_
