#ifndef _IBMPLEXMONO_LIGHTITALIC38PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x0C, 0x38, 0x60, 0xC1,
  0x83, 0x04, 0x08, 0x10, 0x20, 0x00, 0x00, 0x00, 0x00, 0x38, 0xF1, 0xE3,
  0xC0, 0x71, 0xD8, 0x66, 0x19, 0x86, 0x61, 0x98, 0xEC, 0x33, 0x0C, 0xC3,
  0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x70,
  0x00, 0xC1, 0x80, 0xFF, 0x07, 0xF3, 0xFC, 0x3F, 0xC0, 0x60, 0xC0, 0x01,
  0x83, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0xFF, 0x0F,
  0xF3, 0xF8, 0x3F, 0xC0, 0x60, 0xC0, 0x03, 0x86, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x60, 0x01, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xE0, 0x1E, 0x33, 0xC1,
  0xC1, 0x06, 0x0C, 0x08, 0x18, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x30, 0x30,
  0x01, 0xC1, 0x80, 0x0E, 0x08, 0x00, 0x38, 0x40, 0x00, 0xF6, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0B, 0xE0, 0x00, 0x43, 0x80, 0x06, 0x0C,
  0x00, 0x30, 0x70, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x40, 0xE2, 0x02,
  0x06, 0x38, 0x30, 0x30, 0xE1, 0x83, 0x03, 0xCC, 0x78, 0x0F, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xF0, 0x01, 0xC0, 0xFF, 0x00, 0x60, 0x70, 0xC0, 0x30, 0x18,
  0x18, 0x18, 0x0C, 0x06, 0x0E, 0x03, 0x01, 0x83, 0x00, 0xC0, 0x61, 0x80,
  0x30, 0x18, 0xC0, 0x08, 0x0C, 0x30, 0x03, 0x03, 0x18, 0x00, 0xE1, 0x8C,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xC6, 0x1C, 0x00, 0x63, 0x03, 0x00,
  0x30, 0xC0, 0x40, 0x0C, 0x60, 0x30, 0x06, 0x18, 0x0C, 0x03, 0x06, 0x03,
  0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x0C, 0x38, 0x18, 0x03,
  0xFC, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x1C,
  0x38, 0x00, 0xE0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x18, 0x00,
  0x60, 0xE0, 0x07, 0xCF, 0x00, 0x7B, 0xF0, 0x03, 0x86, 0x00, 0x1C, 0x1C,
  0x00, 0x60, 0x30, 0x01, 0x80, 0xE0, 0x0E, 0x01, 0x80, 0x30, 0x03, 0x00,
  0xC0, 0x0E, 0x0F, 0x80, 0x38, 0x3E, 0x01, 0x71, 0x98, 0x04, 0xC6, 0x70,
  0x71, 0xB0, 0xFF, 0x87, 0xC0, 0xF8, 0x0E, 0x00, 0x76, 0x66, 0x6E, 0xCC,
  0xCC, 0x00, 0x3C, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x40, 0x60, 0x2F, 0x86, 0x1E, 0x3F, 0x7F, 0xD0, 0x7F, 0xE0, 0x00, 0xE0,
  0x00, 0x1F, 0x00, 0x03, 0xB0, 0x00, 0x73, 0x80, 0x0E, 0x18, 0x01, 0xC0,
  0xC0, 0x38, 0x0C, 0x03, 0x00, 0x60, 0x60, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x1E, 0x38, 0xE1, 0xC3, 0x0E, 0x18, 0x70, 0xC1, 0x80, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x70, 0x78, 0x30, 0x06, 0x1C, 0x01, 0xCE, 0x00, 0x33,
  0x00, 0x0D, 0xC0, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x83,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0E, 0xC0, 0x03, 0x30, 0x01, 0xCC,
  0x00, 0xE1, 0x80, 0x70, 0x70, 0x38, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0E, 0xC0, 0x0F, 0x70, 0x07, 0x9C, 0x03, 0x86,
  0x01, 0xC1, 0x80, 0xE0, 0x60, 0x10, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x0E, 0x00,
  0x60, 0xC0, 0x07, 0x04, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x1F,
  0xFC, 0x03, 0x81, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0x60, 0x40, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC4, 0x00, 0x18, 0xE0, 0x03, 0x87, 0x00, 0x70, 0x38, 0x0F, 0x01, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xC0, 0x03, 0x1C,
  0x00, 0x61, 0x80, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x38, 0x18, 0x07, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x30, 0x03, 0x07, 0x00,
  0x30, 0xE0, 0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x63, 0xF0, 0x0D, 0xFF, 0x01, 0xE0, 0x70, 0x70, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x80, 0x07, 0x38, 0x00, 0xC7, 0x00, 0x38, 0x78, 0x1E, 0x03,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0C, 0x7E, 0x0E, 0xFF, 0xC6, 0xC0, 0xF3, 0xC0, 0x3B, 0xC0,
  0x0F, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x36, 0x00, 0x1B, 0x00, 0x19, 0xC0, 0x1C, 0x78, 0x3C, 0x1F, 0xF8,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0x80, 0x03, 0x30, 0x00,
  0xC6, 0x00, 0x38, 0xC0, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xF0, 0x1E, 0x07, 0x07, 0x00, 0x70, 0xC0, 0x06, 0x38, 0x00, 0xC6, 0x00,
  0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x30, 0x07, 0x07, 0x03,
  0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0x81, 0xC1, 0xC0, 0x0C, 0x60, 0x01,
  0xDC, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03,
  0xB8, 0x00, 0xE7, 0x00, 0x3C, 0x78, 0x1F, 0x07, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0x03, 0x87, 0x00, 0x67, 0x00, 0x3B,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x77, 0x00, 0x79, 0xE0, 0xFC, 0x7F, 0xEC, 0x0F,
  0xCE, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x3C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x71, 0xE3, 0xC7, 0x80, 0x07, 0x83, 0xC3, 0xE0, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x0E, 0x0E, 0x07, 0x03, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0x60, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x01, 0x80,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x10,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0xFC, 0x3C, 0x1E, 0x30, 0x06, 0x60, 0x07, 0xE0, 0x03, 0x40,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0xF8, 0x07, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x38,
  0x38, 0x06, 0x1C, 0x01, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x7C, 0xD8, 0x3F, 0xB6, 0x1C, 0x2D, 0x86, 0x06, 0x63, 0x01, 0xB0, 0xC0,
  0x6C, 0x30, 0x1B, 0x0C, 0x06, 0xC7, 0x01, 0xB1, 0x80, 0xCC, 0x60, 0x33,
  0x18, 0x0C, 0xC7, 0x07, 0x20, 0xE2, 0xC8, 0x3F, 0x33, 0x03, 0x90, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xB0, 0x00, 0x1B, 0x00, 0x03, 0x38, 0x00, 0x31, 0x80, 0x06, 0x18, 0x00,
  0x61, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x18, 0x01, 0x81, 0xC0,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x0C, 0x06, 0x00, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC1, 0xC0, 0x0E, 0x18, 0x00, 0xE1, 0x80, 0x06, 0x30, 0x00,
  0x63, 0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x30, 0x07, 0x06, 0x00, 0x60, 0xC0, 0x0E, 0x38,
  0x01, 0xC7, 0x00, 0x38, 0xC0, 0x07, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60,
  0x06, 0x1C, 0x01, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0C, 0x00, 0xC1, 0x80,
  0x0C, 0x30, 0x01, 0xCE, 0x00, 0x19, 0xC0, 0x03, 0x30, 0x00, 0xE6, 0x00,
  0x1C, 0xC0, 0x03, 0x18, 0x00, 0x67, 0x00, 0x18, 0xE0, 0x0F, 0x1F, 0xFF,
  0xC3, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1E, 0x0E, 0x07,
  0x00, 0xE0, 0xC0, 0x0C, 0x30, 0x01, 0xCE, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x01, 0xC3, 0x80,
  0x70, 0x38, 0x1C, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0xE0, 0x30, 0x0E, 0x06, 0x00, 0xE0, 0xC0, 0x0C, 0x18, 0x01, 0xC3,
  0x00, 0x18, 0xE0, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C,
  0x00, 0x31, 0x80, 0x06, 0x70, 0x00, 0xCE, 0x00, 0x39, 0x80, 0x07, 0x30,
  0x00, 0xE6, 0x00, 0x18, 0xC0, 0x03, 0x38, 0x00, 0xE7, 0x00, 0x18, 0xC0,
  0x07, 0x18, 0x01, 0xC3, 0x00, 0x70, 0x60, 0x1C, 0x1F, 0xFF, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0x83, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x1E, 0x0E, 0x07, 0x00, 0xE1, 0xC0, 0x0C, 0x30, 0x01, 0x8C,
  0x00, 0x09, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x1F, 0xE6, 0x03, 0xFC, 0xC0,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x0E, 0x60, 0x01, 0x8C, 0x00, 0x31, 0xC0,
  0x0E, 0x38, 0x01, 0xC3, 0x80, 0x58, 0x78, 0x37, 0x07, 0xFC, 0xC0, 0x3F,
  0x18, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07,
  0x1C, 0x00, 0x71, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00,
  0x61, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0C, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x30, 0x00, 0xC3, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x18, 0x60,
  0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x38, 0xE0, 0x03, 0x8E,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x61, 0xC0, 0x0C, 0x18, 0x03,
  0x83, 0x80, 0xE0, 0x38, 0x38, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x30, 0x00, 0xE0, 0xC0, 0x07, 0x03, 0x00, 0x38, 0x0C, 0x01,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x06, 0x03, 0x80, 0x18, 0x1C, 0x00,
  0x60, 0xC0, 0x01, 0x86, 0x00, 0x0E, 0x38, 0x00, 0x39, 0xE0, 0x00, 0xCD,
  0x80, 0x03, 0x63, 0x00, 0x0F, 0x0C, 0x00, 0x38, 0x38, 0x00, 0xC0, 0x60,
  0x07, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0x80, 0x18, 0x06,
  0x00, 0x70, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x3C, 0x3C,
  0x00, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0D, 0x80, 0xF8, 0x36, 0x03,
  0x60, 0xD8, 0x19, 0x86, 0x60, 0x6C, 0x18, 0xC3, 0x30, 0x63, 0x1C, 0xC1,
  0x8C, 0x63, 0x06, 0x33, 0x0C, 0x18, 0x6C, 0x30, 0xC1, 0xE1, 0xC3, 0x07,
  0x86, 0x0C, 0x1C, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x81, 0x83, 0x04, 0x06,
  0x18, 0x00, 0x38, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC3, 0x80, 0x07, 0x0C, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x30, 0xF0, 0x03, 0x0F, 0x00, 0x30, 0xF0, 0x03, 0x1B, 0x80, 0x71,
  0x98, 0x06, 0x19, 0x80, 0x61, 0x98, 0x06, 0x18, 0xC0, 0x61, 0x8C, 0x06,
  0x30, 0xC0, 0xE3, 0x0C, 0x0C, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x30, 0x60,
  0xC3, 0x07, 0x0C, 0x70, 0x31, 0xC6, 0x03, 0x18, 0x60, 0x31, 0x86, 0x01,
  0x98, 0x60, 0x19, 0x86, 0x01, 0x98, 0xE0, 0x1B, 0x8C, 0x00, 0xF0, 0xC0,
  0x0F, 0x0C, 0x00, 0xF0, 0xC0, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x70, 0x78, 0x30, 0x06, 0x1C, 0x01, 0xCE, 0x00, 0x33, 0x00, 0x0D, 0xC0,
  0x03, 0x60, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xB0, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x0E, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0xE1, 0x80,
  0x70, 0x70, 0x38, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0C, 0x00, 0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x1C,
  0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x71, 0x80, 0x07, 0x18, 0x00, 0x61,
  0x80, 0x0E, 0x38, 0x01, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x78, 0x30,
  0x06, 0x1C, 0x01, 0xCE, 0x00, 0x33, 0x00, 0x0D, 0xC0, 0x03, 0x60, 0x00,
  0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x0C, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0xE1, 0x80, 0x70, 0x70, 0x38,
  0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x01, 0x81, 0x00, 0x30, 0x60,
  0x0E, 0x30, 0x01, 0xB8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0C, 0x00, 0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x1C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x71, 0x80, 0x07, 0x18, 0x00,
  0x61, 0x80, 0x0E, 0x38, 0x01, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0x07,
  0x00, 0x30, 0x30, 0x03, 0x03, 0x80, 0x70, 0x18, 0x07, 0x01, 0x80, 0x60,
  0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0E, 0x06, 0x00, 0x60, 0xE0, 0x07, 0x0E,
  0x00, 0x30, 0xC0, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xE0,
  0x3C, 0x1C, 0x00, 0x60, 0xC0, 0x01, 0x8E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x20, 0x00, 0x63, 0x80, 0x07, 0x0E, 0x00, 0x70, 0x3C, 0x07, 0x00, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x73, 0x80, 0x0E,
  0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x39,
  0xC0, 0x07, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x67,
  0x00, 0x1C, 0xE0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C,
  0x00, 0x71, 0x80, 0x0C, 0x30, 0x03, 0x87, 0x00, 0x60, 0x70, 0x3C, 0x07,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x00, 0x76, 0x00, 0x06, 0x60, 0x00,
  0xE6, 0x00, 0x0C, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x87, 0x00,
  0x30, 0x30, 0x03, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0xE0, 0x30,
  0x0C, 0x03, 0x01, 0xC0, 0x38, 0x18, 0x01, 0x83, 0x80, 0x18, 0x30, 0x01,
  0x87, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x01, 0xCC, 0x00,
  0x0D, 0x80, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30,
  0x70, 0x30, 0xC1, 0xC0, 0xC3, 0x0F, 0x06, 0x18, 0x34, 0x18, 0x60, 0xD8,
  0x61, 0x86, 0x61, 0x86, 0x19, 0x8C, 0x18, 0xC6, 0x30, 0x63, 0x18, 0xC1,
  0x8C, 0x63, 0x06, 0x61, 0x98, 0x19, 0x86, 0x60, 0x6C, 0x19, 0x81, 0xB0,
  0x66, 0x06, 0xC0, 0xB0, 0x16, 0x02, 0xC0, 0xD8, 0x0F, 0x03, 0xC0, 0x3C,
  0x0F, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x03, 0x00,
  0x1C, 0x03, 0x80, 0x18, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x70, 0x00, 0xC0,
  0xE0, 0x00, 0xE1, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x63, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xC6, 0x00, 0x01, 0x83,
  0x00, 0x03, 0x03, 0x00, 0x07, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x70, 0x00, 0x60, 0xE0, 0x00,
  0x70, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0x98, 0x00, 0x38, 0xC0, 0x01, 0x87,
  0x00, 0x18, 0x18, 0x01, 0xC0, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x0C,
  0x00, 0x60, 0xE0, 0x03, 0x0E, 0x00, 0x1C, 0x60, 0x00, 0x66, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xC0, 0x10,
  0x04, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00,
  0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06,
  0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60,
  0x18, 0x06, 0x00, 0x80, 0x30, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x0F, 0xC0, 0x07, 0x30, 0x01, 0x8C, 0x00, 0xC1, 0x80, 0x70,
  0x60, 0x18, 0x1C, 0x0C, 0x03, 0x06, 0x00, 0xC3, 0x80, 0x18, 0xC0, 0x06,
  0x60, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x4C, 0x66, 0x33, 0x10, 0x01, 0xF0, 0xC1, 0xFF, 0x30, 0xE0, 0x6C, 0x70,
  0x0B, 0x38, 0x01, 0x8C, 0x00, 0x67, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01,
  0x98, 0x00, 0x6E, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x38, 0x00, 0xCE,
  0x00, 0x71, 0x80, 0x3C, 0x70, 0x1F, 0x1E, 0x0D, 0x83, 0xFE, 0x7C, 0x3E,
  0x0F, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x7E, 0x03, 0x3F, 0xC1,
  0x98, 0x38, 0x68, 0x07, 0x1C, 0x00, 0xC7, 0x00, 0x31, 0x80, 0x0C, 0x60,
  0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01,
  0xCC, 0x00, 0x67, 0x00, 0x19, 0xC0, 0x0E, 0x70, 0x07, 0x1B, 0x07, 0x86,
  0x7F, 0xC3, 0x8F, 0xC0, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x18, 0x03,
  0x30, 0x03, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x02, 0xC0, 0x07, 0xE0, 0x0E,
  0x60, 0x1C, 0x38, 0x38, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x01, 0xF0, 0xC0, 0x7F, 0xCC, 0x0E, 0x06, 0xC1,
  0xC0, 0x2C, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x70, 0x01, 0x86, 0x00, 0x18,
  0x60, 0x01, 0x86, 0x00, 0x18, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xC0, 0x03,
  0x0E, 0x00, 0x30, 0xE0, 0x07, 0x06, 0x00, 0xB0, 0x70, 0x1F, 0x03, 0x83,
  0x70, 0x3F, 0xE6, 0x00, 0xF8, 0x60, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0x81,
  0xC3, 0x00, 0x73, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x0C, 0xC0, 0x0E, 0xC0,
  0x7E, 0x7F, 0xFC, 0x3F, 0xE0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x13,
  0x00, 0x0D, 0xC0, 0x0C, 0x70, 0x0E, 0x3C, 0x1E, 0x0F, 0xFE, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x08, 0x06, 0x00, 0x06, 0x03, 0x00, 0x07, 0x81, 0x80, 0x00, 0xE0,
  0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x60, 0x7F, 0xCC, 0x1C,
  0x0D, 0x87, 0x00, 0xB1, 0xC0, 0x0E, 0x30, 0x01, 0x8E, 0x00, 0x31, 0x80,
  0x06, 0x30, 0x00, 0xC6, 0x00, 0x19, 0xC0, 0x03, 0x38, 0x00, 0xE7, 0x00,
  0x18, 0xE0, 0x03, 0x1C, 0x00, 0xE1, 0x80, 0x2C, 0x38, 0x0D, 0x83, 0x83,
  0x70, 0x7F, 0xCC, 0x03, 0xF1, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x60, 0x0C, 0x1E, 0x07, 0x80, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x7C, 0x19, 0xFE, 0x1B, 0x07, 0x3A,
  0x03, 0x3C, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x70,
  0x03, 0x60, 0x03, 0x60, 0x07, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0,
  0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x10, 0x18, 0x1C, 0x1C, 0x1C, 0x0C, 0x1C,
  0x06, 0x3C, 0x03, 0x38, 0x01, 0xB8, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x04, 0x03,
  0x07, 0x03, 0x81, 0xC1, 0x80, 0x70, 0xC0, 0x1C, 0x60, 0x07, 0x30, 0x01,
  0xD8, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x7C, 0x03, 0x3F, 0xC0, 0xEC, 0x1C, 0x1B, 0x01, 0x83, 0x40,
  0x38, 0x70, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x38, 0x70, 0x0E, 0x0C, 0x07,
  0x81, 0x87, 0xC0, 0x31, 0xC0, 0x06, 0x38, 0x00, 0xC3, 0x00, 0xB8, 0x70,
  0x3E, 0x06, 0x0C, 0xC0, 0xE3, 0x18, 0x0D, 0xC3, 0x01, 0xF0, 0x60, 0x1C,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x04, 0x0C, 0x06, 0x0C, 0x0F, 0x0C, 0x38, 0x18,
  0x70, 0x18, 0xE0, 0x1B, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x19, 0xE1, 0xE0,
  0xDF, 0x9F, 0x87, 0x8D, 0x8C, 0x38, 0x68, 0x73, 0x83, 0x83, 0x9C, 0x1C,
  0x18, 0xC0, 0xC0, 0xC6, 0x06, 0x06, 0x30, 0x30, 0x31, 0x81, 0x81, 0x98,
  0x0C, 0x0C, 0xC0, 0xC0, 0xC6, 0x06, 0x06, 0x30, 0x30, 0x31, 0x81, 0x81,
  0x8C, 0x0C, 0x0C, 0xC0, 0x60, 0x66, 0x06, 0x06, 0x30, 0x30, 0x31, 0x81,
  0x81, 0x80, 0x18, 0x7C, 0x19, 0xFE, 0x3B, 0x07, 0x3A, 0x03, 0x3C, 0x03,
  0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x70, 0x03, 0x60, 0x03,
  0x60, 0x07, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x06, 0xC0, 0x06,
  0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0x83,
  0xC7, 0x00, 0x63, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x1B,
  0x00, 0x1D, 0x80, 0x0C, 0x60, 0x0C, 0x3C, 0x1E, 0x0F, 0xFC, 0x01, 0xF8,
  0x00, 0x06, 0x3F, 0x01, 0xCF, 0xF0, 0x33, 0x07, 0x06, 0x80, 0x70, 0xE0,
  0x06, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0E, 0x70, 0x01, 0x8E, 0x00,
  0x31, 0xC0, 0x0E, 0x38, 0x03, 0x86, 0xC1, 0xE0, 0xCF, 0xF8, 0x18, 0xFC,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF0, 0xC1, 0xFF,
  0x30, 0xF0, 0x6C, 0x70, 0x0B, 0x38, 0x01, 0xCC, 0x00, 0x77, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x0E, 0xC0,
  0x03, 0x38, 0x00, 0xCE, 0x00, 0x71, 0x80, 0x2C, 0x70, 0x1F, 0x0E, 0x0D,
  0xC3, 0xFE, 0x60, 0x3E, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x7F,
  0x8F, 0xFF, 0xE3, 0xF8, 0x0C, 0xC0, 0x01, 0xA0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0xE0, 0x3C, 0x70, 0x03, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x19, 0x00, 0x0E, 0xE0,
  0x03, 0x1E, 0x03, 0xC3, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x04, 0x0E, 0x07, 0x83, 0x03, 0x80, 0xC3, 0xC0,
  0x31, 0xC0, 0x0D, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x18, 0x01, 0x9C,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x73, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C,
  0xE0, 0x06, 0x60, 0x03, 0x30, 0x03, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0x67, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x3C, 0x60, 0x2C, 0x38, 0x26, 0x0F,
  0xF3, 0x03, 0xE1, 0x80, 0xFE, 0x01, 0xFE, 0x01, 0xC3, 0x00, 0x61, 0x80,
  0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x70, 0xC0, 0x30,
  0x60, 0x38, 0x30, 0x78, 0x18, 0xF0, 0x0F, 0xF0, 0x07, 0xC0, 0x00, 0x38,
  0x30, 0x63, 0x03, 0x06, 0x30, 0x30, 0x63, 0x03, 0x06, 0x30, 0x30, 0x23,
  0x03, 0x03, 0x20, 0x60, 0x36, 0x06, 0x03, 0x60, 0x60, 0x66, 0x06, 0x06,
  0x60, 0x60, 0x66, 0x04, 0x06, 0x40, 0xC0, 0x6C, 0x0C, 0x0E, 0xC0, 0xC0,
  0xCC, 0x1C, 0x1C, 0xC1, 0xC1, 0x8E, 0x26, 0x38, 0x7E, 0x7F, 0x07, 0x83,
  0xC0, 0x03, 0x81, 0xE0, 0x3E, 0x1F, 0x87, 0xB9, 0x86, 0x70, 0xC8, 0x36,
  0x06, 0x81, 0x80, 0x34, 0x0C, 0x01, 0xC0, 0x60, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60,
  0x50, 0x03, 0x02, 0xC0, 0x98, 0x36, 0x0E, 0xC1, 0x30, 0xE6, 0x19, 0x9C,
  0x3F, 0x87, 0xC0, 0xF8, 0x38, 0x00, 0x06, 0x00, 0x61, 0xC0, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x70, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0xE0,
  0x06, 0x18, 0x00, 0xC3, 0x00, 0x38, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80,
  0x18, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0xC0, 0x3C, 0x18, 0x0B, 0x03, 0x83,
  0x60, 0x3F, 0xCC, 0x03, 0xE1, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x40, 0x1C, 0x1E, 0x07, 0x01, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x63, 0xFF, 0x8C, 0x60, 0x7F, 0x98, 0x01, 0xE3, 0x00,
  0x18, 0x60, 0x0E, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x30, 0x1C, 0x02, 0x06, 0x00,
  0x61, 0x80, 0x0C, 0xFF, 0x01, 0x9F, 0xFF, 0x33, 0x0F, 0xFE, 0x60, 0x1F,
  0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x40, 0xC0, 0xC0, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x70, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x21, 0xF8, 0x07, 0x39, 0xC0,
  0x63, 0x0E, 0x0C, 0x60, 0x60, 0xC4, 0x07, 0x18, 0xC0, 0x3F, 0x0C, 0x01,
  0xE0,
};

const GFXglyph IBMPlexMono_LightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 27, 23, 8, -27 },
  { 25, 10, 10, 23, 9, -28 },
  { 38, 22, 27, 23, 1, -27 },
  { 113, 21, 35, 23, 1, -31 },
  { 205, 26, 27, 23, -1, -27 },
  { 293, 22, 27, 23, 0, -27 },
  { 368, 4, 10, 23, 12, -28 },
  { 373, 14, 34, 23, 8, -29 },
  { 433, 13, 34, 23, 2, -29 },
  { 489, 20, 19, 23, 2, -21 },
  { 537, 18, 18, 23, 3, -21 },
  { 578, 7, 10, 23, 6, -4 },
  { 587, 11, 2, 23, 6, -13 },
  { 590, 4, 4, 23, 8, -4 },
  { 592, 21, 34, 23, 1, -29 },
  { 682, 18, 27, 23, 3, -27 },
  { 743, 18, 27, 23, 2, -27 },
  { 804, 20, 27, 23, 1, -27 },
  { 872, 20, 27, 23, 1, -27 },
  { 940, 20, 27, 23, 1, -27 },
  { 1008, 19, 27, 23, 2, -27 },
  { 1073, 17, 27, 23, 3, -27 },
  { 1131, 19, 27, 23, 4, -27 },
  { 1196, 19, 27, 23, 2, -27 },
  { 1261, 17, 27, 23, 4, -27 },
  { 1319, 7, 20, 23, 8, -20 },
  { 1337, 9, 26, 23, 6, -20 },
  { 1367, 19, 21, 23, 3, -22 },
  { 1417, 19, 9, 23, 2, -16 },
  { 1439, 18, 21, 23, 2, -22 },
  { 1487, 16, 27, 23, 5, -27 },
  { 1541, 18, 31, 23, 3, -27 },
  { 1611, 20, 27, 23, 0, -27 },
  { 1679, 19, 27, 23, 2, -27 },
  { 1744, 19, 27, 23, 3, -27 },
  { 1809, 19, 27, 23, 2, -27 },
  { 1874, 20, 27, 23, 2, -27 },
  { 1942, 21, 27, 23, 2, -27 },
  { 2013, 19, 27, 23, 3, -27 },
  { 2078, 20, 27, 23, 2, -27 },
  { 2146, 20, 27, 23, 2, -27 },
  { 2214, 19, 27, 23, 2, -27 },
  { 2279, 22, 27, 23, 2, -27 },
  { 2354, 16, 27, 23, 3, -27 },
  { 2408, 22, 27, 23, 1, -27 },
  { 2483, 20, 27, 23, 2, -27 },
  { 2551, 18, 27, 23, 3, -27 },
  { 2612, 20, 27, 23, 2, -27 },
  { 2680, 18, 34, 23, 3, -27 },
  { 2757, 20, 27, 23, 2, -27 },
  { 2825, 21, 27, 23, 1, -27 },
  { 2896, 20, 27, 23, 4, -27 },
  { 2964, 19, 27, 23, 3, -27 },
  { 3029, 20, 27, 23, 4, -27 },
  { 3097, 22, 27, 23, 2, -27 },
  { 3172, 24, 27, 23, 0, -27 },
  { 3253, 21, 27, 23, 4, -27 },
  { 3324, 23, 27, 23, 0, -27 },
  { 3402, 15, 34, 23, 7, -29 },
  { 3466, 10, 34, 23, 7, -29 },
  { 3509, 15, 34, 23, 1, -29 },
  { 3573, 18, 15, 23, 3, -27 },
  { 3607, 18, 2, 23, 0, 4 },
  { 3612, 4, 7, 23, 9, -29 },
  { 3616, 18, 20, 23, 2, -20 },
  { 3661, 18, 28, 23, 2, -28 },
  { 3724, 16, 20, 23, 3, -20 },
  { 3764, 20, 28, 23, 2, -28 },
  { 3834, 17, 20, 23, 3, -20 },
  { 3877, 25, 36, 23, -1, -28 },
  { 3990, 19, 28, 23, 1, -20 },
  { 4057, 16, 28, 23, 3, -28 },
  { 4113, 17, 29, 23, 3, -29 },
  { 4175, 17, 37, 23, 3, -29 },
  { 4254, 19, 28, 23, 3, -28 },
  { 4321, 16, 28, 23, 4, -28 },
  { 4377, 21, 20, 23, 1, -20 },
  { 4430, 16, 20, 23, 3, -20 },
  { 4470, 17, 20, 23, 3, -20 },
  { 4513, 19, 28, 23, 1, -20 },
  { 4580, 18, 28, 23, 2, -20 },
  { 4643, 19, 20, 23, 4, -20 },
  { 4691, 18, 20, 23, 2, -20 },
  { 4736, 18, 27, 23, 3, -27 },
  { 4797, 17, 20, 23, 3, -20 },
  { 4840, 17, 20, 23, 3, -20 },
  { 4883, 20, 20, 23, 2, -20 },
  { 4933, 21, 20, 23, 1, -20 },
  { 4986, 19, 28, 23, 1, -20 },
  { 5053, 19, 20, 23, 2, -20 },
  { 5101, 18, 34, 23, 4, -29 },
  { 5178, 8, 34, 23, 8, -29 },
  { 5212, 17, 34, 23, 2, -29 },
  { 5285, 20, 8, 23, 2, -15 },
};

const GFXfont IBMPlexMono_LightItalic38pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic38pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic38pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _IBMPLEXMONO_LIGHTITALIC38PT7B_H_
