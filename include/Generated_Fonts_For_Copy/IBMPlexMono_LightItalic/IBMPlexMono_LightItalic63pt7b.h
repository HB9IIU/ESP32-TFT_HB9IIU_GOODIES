#ifndef _IBMPLEXMONO_LIGHTITALIC63PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x3C, 0x0F, 0x3C, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x78, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xC7, 0x3F, 0xC0, 0x0F, 0x81, 0xC1, 0xF8, 0x07, 0xC0, 0x70,
  0x1F, 0x03, 0xE0, 0x1C, 0x03, 0xC0, 0xF0, 0x07, 0x00, 0x60, 0x38, 0x01,
  0x80, 0x10, 0x1E, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x30, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x00, 0x7E, 0x1C, 0x00,
  0x00, 0x0F, 0xF6, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0x87, 0xE0, 0x00, 0x00, 0xC0, 0xF8, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x1E, 0x00,
  0x00, 0x70, 0x07, 0x80, 0x00, 0x18, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x82, 0x00, 0x38, 0x03,
  0xC1, 0x80, 0x0E, 0x00, 0xF0, 0xF0, 0x03, 0x00, 0x7C, 0x3E, 0x00, 0xC0,
  0x1E, 0x07, 0xC0, 0x70, 0x0F, 0x00, 0xFC, 0x1C, 0x0F, 0x80, 0x1F, 0xE7,
  0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x38, 0x01, 0xE0, 0xF8,
  0x00, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0x0F, 0x03,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x80, 0x1C, 0x1E, 0x00, 0x00, 0xE0,
  0x0E, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x83, 0x80, 0x00, 0x07, 0xFF, 0xC1,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x78,
  0x3F, 0xFE, 0x00, 0x00, 0x3C, 0x1F, 0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0x03, 0x80, 0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x07, 0x00,
  0x01, 0xE0, 0x70, 0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x00, 0x38,
  0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x03, 0x80, 0x01,
  0xE0, 0x78, 0x01, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0xC3, 0xC0,
  0x00, 0x0F, 0xFE, 0xFC, 0x00, 0x00, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x09, 0xE0, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x07, 0x38, 0x00,
  0x0D, 0xC0, 0x39, 0xE0, 0x00, 0x6F, 0x03, 0x8F, 0x00, 0x06, 0x3C, 0x3C,
  0x3C, 0x00, 0x71, 0xE1, 0xC1, 0xE0, 0x07, 0x07, 0x9E, 0x07, 0xC0, 0xF8,
  0x3C, 0xE0, 0x1F, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0x00, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x8F, 0x1C, 0x38,
  0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x40, 0x01, 0xC0, 0x02, 0xF8, 0x03, 0xC0, 0x1E, 0xFF, 0x03, 0xC1,
  0xFF, 0x7F, 0xE3, 0x8F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x3E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x3C,
  0x01, 0xEF, 0x00, 0xFC, 0x03, 0xDE, 0x01, 0xF8, 0x07, 0xBC, 0x03, 0xF0,
  0x0F, 0x78, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x7F, 0xC0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xDC, 0x00, 0x00, 0xFC, 0xE0, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF8, 0x1E, 0x00,
  0x1F, 0x00, 0xE0, 0x01, 0xF0, 0x07, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x01,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x20,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xC1, 0xFE, 0x00, 0x01, 0xE3, 0xFF, 0xC0, 0x00, 0xE7, 0xFF, 0xF8, 0x00,
  0x77, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x01, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x0F, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x1F, 0xC0,
  0x03, 0xC7, 0xFF, 0xC0, 0x3C, 0xFF, 0xFF, 0x01, 0xEF, 0x80, 0xFC, 0x1E,
  0xE0, 0x01, 0xF0, 0xFE, 0x00, 0x07, 0xC7, 0x60, 0x00, 0x1E, 0x7E, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xF8, 0x07, 0xE0,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0x3C, 0x00, 0x01, 0x71,
  0xF0, 0x00, 0x3F, 0x87, 0xC0, 0x03, 0xBC, 0x1F, 0x80, 0x79, 0xC0, 0x7F,
  0xFF, 0x9E, 0x01, 0xFF, 0xF1, 0xE0, 0x01, 0xFE, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF2, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xF8, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0xE1, 0xC0, 0x0F, 0xC3, 0xC3, 0x80, 0x3F, 0xE7, 0x8F, 0x01,
  0xFF, 0xEE, 0x1C, 0x03, 0xC0, 0xDC, 0x38, 0x0F, 0x00, 0xB8, 0x70, 0x3C,
  0x00, 0xF1, 0xE0, 0x70, 0x01, 0xE3, 0x80, 0xE0, 0x03, 0xC7, 0x03, 0xC0,
  0x07, 0x0E, 0x07, 0x00, 0x0E, 0x1C, 0x0E, 0x00, 0x1C, 0x78, 0x1C, 0x00,
  0x38, 0xF0, 0x78, 0x00, 0x71, 0xC0, 0xF0, 0x01, 0xE3, 0x81, 0xC0, 0x03,
  0x87, 0x03, 0x80, 0x07, 0x0E, 0x07, 0x00, 0x0E, 0x1C, 0x0E, 0x00, 0x1C,
  0x78, 0x1C, 0x00, 0x78, 0xF0, 0x38, 0x00, 0xF1, 0xE0, 0x70, 0x03, 0xC3,
  0x80, 0xF0, 0x0F, 0x87, 0x01, 0xE0, 0x37, 0x0E, 0x01, 0xF1, 0xCE, 0x1C,
  0x03, 0xFF, 0x9C, 0x38, 0x03, 0xFE, 0x78, 0x70, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1E,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x03, 0x80, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1C,
  0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1F,
  0x80, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x01,
  0xFF, 0xF9, 0xE0, 0x03, 0xFF, 0xE3, 0xC0, 0x07, 0xFF, 0xC7, 0x80, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x06, 0xE0,
  0x3C, 0x00, 0x1B, 0xC0, 0x7C, 0x00, 0x77, 0x80, 0x7E, 0x03, 0xCE, 0x00,
  0x7F, 0xFF, 0x1C, 0x00, 0x7F, 0xF8, 0x38, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x78, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x10, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C,
  0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x38, 0x1F,
  0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x1E, 0x1F, 0x80, 0x00, 0x00,
  0xF1, 0xFE, 0x00, 0x00, 0x07, 0x9F, 0xF0, 0x00, 0x00, 0x3D, 0xF3, 0xC0,
  0x00, 0x01, 0xDF, 0x1E, 0x00, 0x00, 0x1F, 0xF0, 0x78, 0x00, 0x00, 0xFF,
  0x03, 0xC0, 0x00, 0x07, 0xF0, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x39, 0xC0, 0x03, 0xDC, 0x03, 0x9C, 0x00,
  0x3D, 0xC0, 0x39, 0xC0, 0x07, 0x9C, 0x03, 0x9E, 0x00, 0x73, 0xC0, 0x78,
  0xE0, 0x0F, 0x3C, 0x07, 0x8E, 0x00, 0xE3, 0xC0, 0x70, 0xE0, 0x1E, 0x38,
  0x07, 0x0F, 0x03, 0xC3, 0x80, 0x70, 0x70, 0x38, 0x38, 0x07, 0x07, 0x07,
  0x87, 0x80, 0xF0, 0x70, 0x70, 0x78, 0x0F, 0x07, 0x8F, 0x07, 0x80, 0xE0,
  0x39, 0xE0, 0x70, 0x0E, 0x03, 0x9C, 0x07, 0x00, 0xE0, 0x3B, 0xC0, 0x70,
  0x0E, 0x01, 0xF8, 0x0F, 0x01, 0xE0, 0x1F, 0x80, 0xF0, 0x1E, 0x01, 0xF0,
  0x0F, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x1E, 0x03, 0xC0, 0x08, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x7E, 0x00, 0x00, 0xF0,
  0x1F, 0x80, 0x00, 0x38, 0x07, 0xE0, 0x00, 0x0E, 0x03, 0xFC, 0x00, 0x03,
  0x80, 0xF7, 0x00, 0x01, 0xE0, 0x3D, 0xC0, 0x00, 0x78, 0x0E, 0x78, 0x00,
  0x1E, 0x03, 0x9E, 0x00, 0x07, 0x00, 0xE3, 0x80, 0x01, 0xC0, 0x78, 0xE0,
  0x00, 0x70, 0x1E, 0x3C, 0x00, 0x3C, 0x07, 0x8F, 0x00, 0x0F, 0x01, 0xC1,
  0xC0, 0x03, 0xC0, 0x70, 0x78, 0x00, 0xE0, 0x1C, 0x1E, 0x00, 0x38, 0x0F,
  0x03, 0x80, 0x0E, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xF0, 0x3C, 0x01, 0xE0,
  0x38, 0x0F, 0x00, 0x78, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x78, 0x03, 0x80, 0x70, 0x1E, 0x00, 0xE0,
  0x3C, 0x07, 0x00, 0x3C, 0x0F, 0x01, 0xC0, 0x0F, 0x03, 0x80, 0x70, 0x01,
  0xC0, 0xE0, 0x3C, 0x00, 0x70, 0x38, 0x0F, 0x00, 0x1E, 0x0E, 0x03, 0xC0,
  0x07, 0x87, 0x80, 0xE0, 0x00, 0xE1, 0xE0, 0x38, 0x00, 0x38, 0x70, 0x0E,
  0x00, 0x0F, 0x1C, 0x07, 0x80, 0x01, 0xC7, 0x01, 0xE0, 0x00, 0x71, 0xC0,
  0x78, 0x00, 0x1E, 0xF0, 0x1C, 0x00, 0x07, 0xBC, 0x07, 0x00, 0x00, 0xEE,
  0x01, 0xC0, 0x00, 0x3B, 0x80, 0xF0, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x03,
  0xF8, 0x0F, 0x00, 0x00, 0x7E, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xF8,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3C, 0x00,
  0x07, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x08, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3C, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00,
  0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x06,
  0x03, 0xC0, 0x00, 0x01, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x20,
  0x00, 0x00, 0x3C, 0x18, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x00, 0xF8,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xB8, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x01, 0xF0,
  0x07, 0x03, 0xC0, 0x1F, 0x00, 0x70, 0x38, 0x03, 0xF0, 0x07, 0x03, 0x80,
  0x3F, 0x00, 0xF0, 0x38, 0x07, 0xF0, 0x0E, 0x03, 0x80, 0x77, 0x00, 0xE0,
  0x38, 0x07, 0x70, 0x0E, 0x03, 0x80, 0xE7, 0x01, 0xE0, 0x38, 0x0E, 0x70,
  0x1C, 0x03, 0x81, 0xE7, 0x01, 0xC0, 0x78, 0x1C, 0x70, 0x1C, 0x07, 0x81,
  0xC7, 0x03, 0xC0, 0x78, 0x38, 0x70, 0x38, 0x07, 0x83, 0x83, 0x83, 0x80,
  0x70, 0x78, 0x38, 0x38, 0x07, 0x07, 0x03, 0x87, 0x80, 0x70, 0x70, 0x38,
  0x70, 0x07, 0x0E, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x38, 0x70, 0x07, 0x1C,
  0x03, 0x8F, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x07, 0x3C, 0x03, 0x8E, 0x00,
  0x73, 0x80, 0x38, 0xE0, 0x0F, 0x38, 0x03, 0x9E, 0x00, 0xF7, 0x00, 0x39,
  0xC0, 0x0E, 0x70, 0x03, 0xDC, 0x00, 0xEF, 0x00, 0x1D, 0xC0, 0x0E, 0xE0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x0E, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x07, 0x1F, 0x00, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x61,
  0xE1, 0xC3, 0xC3, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x10, 0x00, 0x1F, 0xE0,
  0x38, 0x03, 0xFF, 0xC1, 0xC0, 0x7F, 0xFF, 0x0E, 0x07, 0xE0, 0x3C, 0xF0,
  0x7C, 0x00, 0x37, 0x87, 0xC0, 0x00, 0xBC, 0x3C, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x02, 0xE0, 0xF0,
  0x00, 0x3F, 0x07, 0x80, 0x03, 0x78, 0x1E, 0x00, 0x33, 0xC0, 0xFC, 0x0F,
  0x1F, 0xE3, 0xFF, 0xF0, 0xFF, 0x0F, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xE0, 0x01, 0xE0, 0xFF,
  0xE0, 0x07, 0x8F, 0xFF, 0xC0, 0x1C, 0x78, 0x1F, 0x80, 0x73, 0x80, 0x1F,
  0x01, 0xDC, 0x00, 0x3E, 0x0F, 0x60, 0x00, 0x78, 0x3F, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x0F, 0x07, 0x60, 0x00, 0x78, 0x1D, 0xC0, 0x07, 0xC0, 0xF3, 0xC0,
  0x7E, 0x03, 0xC7, 0xFF, 0xF0, 0x0F, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x78, 0xF0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0C, 0xF0, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x3C, 0x00, 0x7F, 0xF8, 0x3C,
  0x00, 0xFF, 0xFE, 0x38, 0x03, 0xF8, 0x0F, 0x38, 0x07, 0xC0, 0x03, 0x38,
  0x07, 0x80, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1B, 0x80, 0x78, 0x00, 0x33, 0x80,
  0x3C, 0x00, 0x77, 0x80, 0x3F, 0x01, 0xE7, 0x80, 0x1F, 0xFF, 0xC7, 0x80,
  0x07, 0xFF, 0x07, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x03, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x1E, 0x78, 0x00, 0x03, 0xE7, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x7F,
  0x8F, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x08, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x87, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x80, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x1C,
  0x00, 0x00, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x87, 0x00, 0x00,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0x00, 0x1F, 0xFE, 0x0F, 0x00,
  0x7F, 0xFF, 0x8E, 0x00, 0xFE, 0x03, 0xCE, 0x01, 0xF0, 0x00, 0xCE, 0x03,
  0xE0, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x07,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xF0, 0x1E,
  0x00, 0x06, 0xE0, 0x1E, 0x00, 0x0C, 0xE0, 0x0F, 0x00, 0x1C, 0xE0, 0x0F,
  0xC0, 0x79, 0xE0, 0x07, 0xFF, 0xF1, 0xE0, 0x01, 0xFF, 0xC1, 0xE0, 0x00,
  0x7F, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x20, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0xFE, 0x00,
  0x38, 0x3F, 0xF8, 0x07, 0x87, 0xFF, 0xC0, 0x78, 0xE0, 0x7E, 0x07, 0x98,
  0x01, 0xE0, 0x7B, 0x00, 0x0F, 0x07, 0xA0, 0x00, 0xF0, 0x74, 0x00, 0x0F,
  0x0F, 0x40, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1C, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x38, 0x78, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x06, 0x00, 0x78,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x07, 0xC0, 0x07, 0x00, 0xF8,
  0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x0E,
  0x1F, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x02, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x0F,
  0x80, 0x0E, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0xF8, 0x1C, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x3E, 0x1C, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0xFE, 0x00, 0x07, 0x83, 0xFF, 0x80, 0x07, 0x8F,
  0xFF, 0xE0, 0x07, 0x9E, 0x03, 0xE0, 0x07, 0xB8, 0x01, 0xF0, 0x07, 0x30,
  0x00, 0xF0, 0x07, 0x60, 0x00, 0x70, 0x0F, 0xC0, 0x00, 0x70, 0x0F, 0x80,
  0x00, 0x70, 0x0F, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1C, 0x01,
  0xF8, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x04, 0x38, 0x07,
  0x00, 0x06, 0x38, 0x07, 0x80, 0x0F, 0x78, 0x03, 0x80, 0x1E, 0x78, 0x03,
  0xC0, 0x3C, 0x78, 0x01, 0xC0, 0xF8, 0x78, 0x01, 0xE1, 0xF0, 0x70, 0x00,
  0xE3, 0xE0, 0x70, 0x00, 0xF7, 0xC0, 0xF0, 0x00, 0x7F, 0x80, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x78, 0x00, 0xF0, 0x38,
  0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x07,
  0x81, 0xE0, 0x03, 0xC3, 0xE0, 0x01, 0xC3, 0xE0, 0x00, 0xE3, 0xC0, 0x00,
  0xF3, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x0F, 0x80, 0x7E, 0x01, 0xC7, 0xF8, 0x3F, 0xC0, 0x73, 0xFE, 0x1F,
  0xF8, 0x3D, 0x83, 0xCE, 0x1E, 0x0F, 0xC0, 0xF6, 0x03, 0xC3, 0xA0, 0x1D,
  0x00, 0xF0, 0xF0, 0x07, 0xC0, 0x3C, 0x3C, 0x01, 0xE0, 0x0F, 0x0E, 0x00,
  0x78, 0x03, 0xC7, 0x80, 0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x00, 0x38, 0x70,
  0x03, 0xC0, 0x0E, 0x1C, 0x00, 0xF0, 0x03, 0x87, 0x00, 0x38, 0x01, 0xE1,
  0xC0, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0x80, 0x1C, 0x3C, 0x00, 0xE0, 0x07,
  0x0E, 0x00, 0x78, 0x01, 0xC3, 0x80, 0x1E, 0x00, 0x70, 0xE0, 0x07, 0x00,
  0x3C, 0x38, 0x01, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0x03, 0x87, 0x80, 0x1C,
  0x00, 0xE1, 0xC0, 0x0F, 0x00, 0x38, 0x70, 0x03, 0xC0, 0x0E, 0x1C, 0x00,
  0xE0, 0x07, 0x87, 0x00, 0x38, 0x01, 0xE3, 0xC0, 0x0E, 0x00, 0x70, 0xF0,
  0x03, 0x80, 0x1C, 0x38, 0x01, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0x01, 0xC3,
  0x80, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x03, 0x80, 0xFE,
  0x00, 0x38, 0x3F, 0xF8, 0x07, 0x87, 0xFF, 0xC0, 0x78, 0xE0, 0x7E, 0x07,
  0x98, 0x01, 0xE0, 0x7B, 0x00, 0x0F, 0x07, 0x20, 0x00, 0xF0, 0x74, 0x00,
  0x0F, 0x0F, 0x40, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x38, 0x78,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x79, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x3F,
  0x80, 0x01, 0xE0, 0xFF, 0xE0, 0x01, 0xE3, 0xFF, 0xF0, 0x01, 0xC7, 0x81,
  0xF8, 0x01, 0xCE, 0x00, 0x7C, 0x01, 0xDC, 0x00, 0x3E, 0x03, 0xD8, 0x00,
  0x1E, 0x03, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0xF0, 0x1D, 0x80, 0x01, 0xE0, 0x1D, 0xC0, 0x07, 0xC0, 0x3C, 0xF0, 0x1F,
  0x80, 0x3C, 0x7F, 0xFF, 0x00, 0x3C, 0x3F, 0xFE, 0x00, 0x3C, 0x07, 0xF0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x3C, 0x01, 0xFF, 0xE0, 0xF0, 0x0F, 0xFF, 0xE3,
  0x80, 0xFE, 0x03, 0xCE, 0x07, 0xC0, 0x03, 0x38, 0x1E, 0x00, 0x07, 0xE0,
  0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x38, 0xF0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x06, 0xE0, 0x78, 0x00,
  0x33, 0x80, 0xF0, 0x01, 0xDE, 0x03, 0xF0, 0x1E, 0x78, 0x07, 0xFF, 0xF1,
  0xE0, 0x07, 0xFF, 0x07, 0x00, 0x07, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xC0, 0x0F, 0x3C, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0xA0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0xFE, 0x01, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0x81, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xFC, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x0F, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x60, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0xE0, 0x3E, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x78, 0x7E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x1E,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x38, 0xF0, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF8, 0xE0,
  0x00, 0x1E, 0x1C, 0x00, 0x05, 0xC3, 0xC0, 0x01, 0xF8, 0x78, 0x00, 0x2F,
  0x0F, 0x00, 0x0D, 0xE0, 0xF0, 0x07, 0x3C, 0x1F, 0x83, 0xC7, 0x01, 0xFF,
  0xF0, 0xE0, 0x1F, 0xFC, 0x1C, 0x00, 0xFE, 0x04, 0x00, 0xFF, 0xE0, 0x00,
  0x67, 0xFF, 0x00, 0x07, 0xBF, 0xF8, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38,
  0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xE0,
  0x0E, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xF0, 0x03, 0x80, 0x1F, 0x00, 0x3C,
  0x03, 0xF0, 0x01, 0xE0, 0x7E, 0x00, 0x0F, 0x1F, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x06, 0x07, 0x80, 0x3C, 0x07, 0x03, 0x80, 0x1C, 0x03, 0xC1, 0xC0, 0x0E,
  0x00, 0xE0, 0xE0, 0x07, 0x00, 0x70, 0x70, 0x03, 0x80, 0x38, 0x38, 0x01,
  0xC0, 0x1E, 0x3C, 0x01, 0xE0, 0x0F, 0x1C, 0x00, 0xF0, 0x07, 0x8E, 0x00,
  0x70, 0x03, 0xC7, 0x00, 0x38, 0x00, 0xE3, 0x80, 0x1C, 0x00, 0xF1, 0xC0,
  0x0E, 0x00, 0x79, 0xE0, 0x0F, 0x00, 0x3C, 0xF0, 0x07, 0x80, 0x1E, 0x70,
  0x03, 0x80, 0x0E, 0x38, 0x01, 0xC0, 0x07, 0x1C, 0x00, 0xE0, 0x03, 0x8E,
  0x00, 0x70, 0x01, 0xCF, 0x00, 0x38, 0x00, 0xE7, 0x80, 0x3C, 0x00, 0xF3,
  0x80, 0x1C, 0x00, 0x71, 0xC0, 0x0E, 0x00, 0x38, 0xE0, 0x07, 0x00, 0x3C,
  0x70, 0x07, 0x80, 0x1C, 0x38, 0x03, 0xC0, 0x0E, 0x3C, 0x01, 0xE0, 0x0F,
  0x1E, 0x01, 0xF0, 0x07, 0x0F, 0x00, 0xB8, 0x07, 0x83, 0x80, 0xDE, 0x07,
  0x81, 0xE1, 0xC7, 0x0F, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xBC, 0x1E, 0x1E,
  0x07, 0xE1, 0xC3, 0x80, 0xF1, 0xF8, 0x1E, 0x30, 0x0F, 0x3E, 0x00, 0xE6,
  0x00, 0x73, 0x80, 0x0E, 0x60, 0x07, 0x10, 0x00, 0xEC, 0x00, 0x70, 0x00,
  0x0E, 0xC0, 0x07, 0x00, 0x00, 0xE8, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xF0,
  0x00, 0x0E, 0x00, 0x37, 0x00, 0x00, 0xE0, 0x03, 0x70, 0x00, 0x0E, 0x00,
  0x37, 0x00, 0x18, 0xE0, 0x06, 0x70, 0x03, 0xCE, 0x00, 0xE7, 0x00, 0xF8,
  0xF0, 0x0C, 0x78, 0x3F, 0x0F, 0x01, 0xC3, 0x87, 0xC0, 0x78, 0x78, 0x3D,
  0xF8, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x7C, 0x07, 0x00, 0x00, 0xF8,
  0x0E, 0x00, 0x02, 0xE0, 0x1E, 0x00, 0x05, 0xC0, 0x3C, 0x00, 0x17, 0x80,
  0x78, 0x00, 0x6F, 0x00, 0x78, 0x01, 0x9E, 0x00, 0xFC, 0x0E, 0x3C, 0x00,
  0xFF, 0xF8, 0x70, 0x00, 0xFF, 0xE0, 0xE0, 0x00, 0x7F, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x10, 0x00,
  0x07, 0x80, 0x60, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0x01, 0xFF, 0xF8, 0x0F, 0x03, 0xFF,
  0xFF, 0x0E, 0x07, 0xC0, 0x7F, 0xCE, 0x07, 0x80, 0x0F, 0xFE, 0x0F, 0x00,
  0x03, 0xFE, 0x0E, 0x00, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0xF8, 0x0E, 0x00,
  0x01, 0xF0, 0x0E, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x0E, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x60, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0xE0, 0x03, 0xE0,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0x70, 0x3F, 0xC0, 0x00, 0x78, 0x7F, 0xFC, 0x00, 0x38, 0x71, 0xFF,
  0xE0, 0x38, 0x70, 0x1F, 0xFE, 0x38, 0xF0, 0x03, 0xFF, 0xF8, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0x01, 0xFE, 0x00, 0x03, 0xC1, 0xFF, 0x80, 0x01, 0xC1, 0xE1, 0xE0,
  0x00, 0xE0, 0xE0, 0x78, 0x00, 0xE0, 0xE0, 0x1E, 0x00, 0x70, 0xF0, 0x07,
  0x00, 0x70, 0x70, 0x03, 0xC0, 0x38, 0x78, 0x00, 0xF0, 0x38, 0x38, 0x00,
  0x3C, 0x7C, 0x1C, 0x00, 0x1F, 0xFC, 0x1C, 0x00, 0x07, 0xFC, 0x06, 0x00,
  0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 12, 44, 38, 13, -44 },
  { 67, 16, 17, 38, 15, -47 },
  { 101, 38, 44, 38, 1, -44 },
  { 310, 34, 58, 38, 2, -51 },
  { 557, 42, 46, 38, -1, -45 },
  { 799, 37, 46, 38, 0, -45 },
  { 1012, 7, 17, 38, 19, -47 },
  { 1027, 22, 57, 38, 14, -48 },
  { 1184, 22, 57, 38, 3, -48 },
  { 1341, 32, 31, 38, 4, -35 },
  { 1465, 31, 31, 38, 4, -35 },
  { 1586, 12, 17, 38, 9, -7 },
  { 1612, 18, 3, 38, 10, -21 },
  { 1619, 7, 7, 38, 13, -7 },
  { 1626, 35, 57, 38, 2, -48 },
  { 1876, 31, 46, 38, 4, -45 },
  { 2055, 29, 44, 38, 3, -44 },
  { 2215, 32, 45, 38, 2, -45 },
  { 2395, 32, 46, 38, 2, -45 },
  { 2579, 33, 44, 38, 1, -44 },
  { 2761, 33, 45, 38, 3, -44 },
  { 2947, 29, 45, 38, 4, -44 },
  { 3111, 30, 44, 38, 7, -44 },
  { 3276, 32, 46, 38, 3, -45 },
  { 3460, 29, 45, 38, 6, -45 },
  { 3624, 12, 34, 38, 13, -34 },
  { 3675, 16, 44, 38, 9, -34 },
  { 3763, 30, 35, 38, 6, -37 },
  { 3895, 33, 15, 38, 3, -27 },
  { 3957, 30, 35, 38, 3, -37 },
  { 4089, 26, 45, 38, 9, -45 },
  { 4236, 31, 52, 38, 4, -45 },
  { 4438, 33, 44, 38, 0, -44 },
  { 4620, 31, 44, 38, 3, -44 },
  { 4791, 31, 46, 38, 5, -45 },
  { 4970, 31, 44, 38, 4, -44 },
  { 5141, 34, 44, 38, 3, -44 },
  { 5328, 35, 44, 38, 3, -44 },
  { 5521, 31, 46, 38, 5, -45 },
  { 5700, 34, 44, 38, 3, -44 },
  { 5887, 34, 44, 38, 3, -44 },
  { 6074, 30, 45, 38, 4, -44 },
  { 6243, 37, 44, 38, 3, -44 },
  { 6447, 25, 44, 38, 6, -44 },
  { 6585, 36, 44, 38, 2, -44 },
  { 6783, 34, 44, 38, 3, -44 },
  { 6970, 31, 46, 38, 4, -45 },
  { 7149, 33, 44, 38, 3, -44 },
  { 7331, 31, 56, 38, 4, -45 },
  { 7548, 33, 44, 38, 3, -44 },
  { 7730, 34, 46, 38, 2, -45 },
  { 7926, 34, 44, 38, 6, -44 },
  { 8113, 32, 45, 38, 5, -44 },
  { 8293, 33, 44, 38, 7, -44 },
  { 8475, 36, 44, 38, 4, -44 },
  { 8673, 40, 44, 38, 0, -44 },
  { 8893, 35, 44, 38, 6, -44 },
  { 9086, 38, 44, 38, 0, -44 },
  { 9295, 26, 57, 38, 11, -48 },
  { 9481, 16, 57, 38, 12, -48 },
  { 9595, 26, 57, 38, 1, -48 },
  { 9781, 30, 25, 38, 5, -44 },
  { 9875, 31, 3, 38, 0, 7 },
  { 9887, 7, 11, 38, 15, -48 },
  { 9897, 29, 34, 38, 4, -33 },
  { 10021, 30, 48, 38, 4, -47 },
  { 10201, 27, 34, 38, 5, -33 },
  { 10316, 32, 48, 38, 4, -47 },
  { 10508, 28, 34, 38, 5, -33 },
  { 10627, 41, 60, 38, -1, -47 },
  { 10935, 32, 46, 38, 2, -33 },
  { 11119, 28, 47, 38, 4, -47 },
  { 11284, 28, 49, 38, 5, -48 },
  { 11456, 28, 61, 38, 5, -48 },
  { 11670, 32, 48, 38, 4, -47 },
  { 11862, 25, 48, 38, 7, -47 },
  { 12012, 34, 33, 38, 2, -33 },
  { 12153, 28, 33, 38, 4, -33 },
  { 12269, 29, 34, 38, 4, -33 },
  { 12393, 32, 46, 38, 2, -33 },
  { 12577, 30, 46, 38, 4, -33 },
  { 12750, 30, 33, 38, 7, -33 },
  { 12874, 30, 34, 38, 3, -33 },
  { 13002, 29, 45, 38, 5, -44 },
  { 13166, 27, 34, 38, 6, -33 },
  { 13281, 29, 33, 38, 5, -33 },
  { 13401, 33, 34, 38, 3, -33 },
  { 13542, 36, 34, 38, 1, -33 },
  { 13695, 31, 46, 38, 2, -33 },
  { 13874, 32, 34, 38, 3, -33 },
  { 14010, 29, 57, 38, 7, -48 },
  { 14217, 13, 57, 38, 13, -48 },
  { 14310, 29, 57, 38, 3, -48 },
  { 14517, 33, 13, 38, 3, -25 },
};

const GFXfont IBMPlexMono_LightItalic63pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic63pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic63pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _IBMPLEXMONO_LIGHTITALIC63PT7B_H_
