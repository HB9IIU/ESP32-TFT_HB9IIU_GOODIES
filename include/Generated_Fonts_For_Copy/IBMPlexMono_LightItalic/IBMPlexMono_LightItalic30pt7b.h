#ifndef _IBMPLEXMONO_LIGHTITALIC30PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x18, 0x41, 0x04, 0x10, 0x80,
  0x00, 0x00, 0x07, 0x3C, 0xE0, 0x63, 0x62, 0x42, 0x46, 0xC6, 0xC6, 0xC6,
  0xC4, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x04, 0x30, 0x03, 0x08, 0x00, 0xC6,
  0x00, 0x61, 0x01, 0xF8, 0x7C, 0x7E, 0x3F, 0x01, 0x0C, 0x00, 0xC2, 0x00,
  0x31, 0x80, 0x08, 0x60, 0x06, 0x10, 0x1F, 0x8F, 0xC7, 0xC3, 0xF2, 0x30,
  0xC0, 0x0C, 0x60, 0x02, 0x18, 0x01, 0x84, 0x00, 0x63, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x03, 0xF8, 0x0F, 0xFC, 0x1E,
  0x4E, 0x18, 0x43, 0x30, 0x42, 0x30, 0x40, 0x30, 0xC0, 0x38, 0xC0, 0x1C,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0x8C, 0x01, 0x06, 0x01,
  0x06, 0x01, 0x06, 0xC1, 0x0C, 0xE3, 0x0C, 0x73, 0x38, 0x3F, 0xF0, 0x0F,
  0xC0, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x18, 0x3F, 0x01,
  0x03, 0x0C, 0x18, 0x30, 0x61, 0x81, 0x83, 0x08, 0x0C, 0x18, 0xC0, 0x60,
  0xCC, 0x03, 0x0C, 0x40, 0x0F, 0xC4, 0x00, 0x3C, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x11, 0xF8, 0x01, 0x18, 0x60, 0x19, 0x83, 0x01, 0x8C,
  0x18, 0x08, 0x60, 0xC0, 0xC2, 0x04, 0x0C, 0x18, 0x60, 0xC0, 0x7E, 0x0C,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x70, 0xC0, 0x18, 0x10,
  0x0C, 0x06, 0x01, 0x01, 0x00, 0x40, 0x40, 0x18, 0x30, 0x02, 0x0C, 0x03,
  0xCE, 0x03, 0xFF, 0x01, 0xC6, 0x00, 0x60, 0x80, 0x30, 0x30, 0x0C, 0x06,
  0x03, 0x01, 0x82, 0xC0, 0x70, 0xF0, 0x16, 0x66, 0x09, 0xB1, 0xFE, 0x3C,
  0x1E, 0x0E, 0x00, 0x6D, 0xB4, 0xB6, 0x01, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20,
  0x08, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08,
  0x0C, 0x00, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x18,
  0x20, 0xDE, 0x5F, 0x07, 0xF0, 0x03, 0x00, 0x0F, 0x00, 0x32, 0x00, 0xC6,
  0x03, 0x06, 0x0C, 0x0C, 0x10, 0x08, 0x00, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x3F, 0xFF, 0xFF, 0xFC, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x1C,
  0x63, 0x8C, 0x31, 0x86, 0x30, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0,
  0x78, 0x70, 0xC0, 0x63, 0x00, 0x66, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60,
  0x07, 0x87, 0x0F, 0x0E, 0x1E, 0x1C, 0x2C, 0x00, 0xD8, 0x01, 0xB0, 0x03,
  0x60, 0x0C, 0xC0, 0x19, 0xC0, 0x61, 0xC3, 0x81, 0xFE, 0x01, 0xF8, 0x00,
  0x00, 0xF0, 0x07, 0xC0, 0x3A, 0x01, 0xC8, 0x0E, 0x60, 0xF1, 0x81, 0x86,
  0x08, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x1F, 0xFF, 0xFF,
  0xFC, 0x01, 0xF0, 0x0F, 0xF8, 0x38, 0x38, 0xE0, 0x31, 0x80, 0x62, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x07, 0xFF, 0xEF, 0xFF, 0xC0, 0x01, 0xF0, 0x0F, 0xF8, 0x38, 0x38, 0xC0,
  0x30, 0x80, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x0F, 0xE0,
  0x1F, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x40,
  0x0D, 0x80, 0x31, 0xC1, 0xE1, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xD0, 0x03, 0x60, 0x04, 0xC0, 0x19, 0x80, 0x63, 0x01, 0x84,
  0x06, 0x08, 0x08, 0x30, 0x20, 0x60, 0x80, 0xC3, 0x01, 0x8C, 0x02, 0x10,
  0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x37, 0xE0, 0x5F, 0xE0, 0xE0, 0xE3, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x80, 0x19, 0x80, 0x63, 0x81,
  0xC3, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0xF8, 0x2F, 0xF1, 0xE0, 0xE5, 0x01,
  0x98, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x06, 0xC0, 0x1B, 0x00,
  0xC7, 0x07, 0x0F, 0xF8, 0x1F, 0x80, 0x7F, 0xFE, 0xFF, 0xFD, 0x80, 0x32,
  0x00, 0x4C, 0x01, 0x98, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xFE, 0x0E, 0x06, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03,
  0x18, 0x06, 0x0C, 0x0C, 0x07, 0xF8, 0x0F, 0xF0, 0x18, 0x1C, 0x30, 0x0C,
  0x60, 0x06, 0x40, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0x60, 0x0C, 0x70, 0x38,
  0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0xC3, 0x83, 0x98, 0x06, 0x60,
  0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x02, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x9C,
  0x34, 0x7F, 0xB0, 0x7D, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x00, 0x1C, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xCF, 0x38, 0x07, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x60,
  0x60, 0xC0, 0x00, 0x04, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x20, 0x7F, 0xFE, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0x10,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x30, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0x0C, 0x1C,
  0xC0, 0x6C, 0x01, 0x20, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x1E, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x38, 0x70,
  0xC0, 0x63, 0x00, 0x46, 0x00, 0xC8, 0x39, 0x30, 0xFA, 0x63, 0x14, 0xCC,
  0x19, 0x18, 0x32, 0x30, 0x6C, 0x40, 0xD8, 0x81, 0x31, 0x06, 0x62, 0x0C,
  0xC7, 0x79, 0x8F, 0xB3, 0x06, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0F,
  0xF8, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xD8, 0x00,
  0xD8, 0x01, 0x88, 0x01, 0x88, 0x03, 0x0C, 0x03, 0x0C, 0x06, 0x0C, 0x06,
  0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x0F, 0xFC, 0x1F, 0xFE, 0x18, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x02, 0xC0, 0x03, 0x1F, 0xF0, 0x7F,
  0xE1, 0x01, 0xCC, 0x03, 0x30, 0x04, 0xC0, 0x13, 0x00, 0xC8, 0x03, 0x20,
  0x19, 0xFF, 0x87, 0xFF, 0x18, 0x06, 0x60, 0x09, 0x80, 0x34, 0x00, 0xF0,
  0x03, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x3F, 0xF8, 0xFF, 0xC0, 0x01, 0xF0,
  0x0F, 0xF0, 0x38, 0x30, 0xE0, 0x31, 0x80, 0x66, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x20, 0x06, 0x60, 0x18, 0xC0, 0x61, 0xC1, 0xC1, 0xFF, 0x00,
  0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x60, 0x70, 0x80, 0x63, 0x00, 0x66,
  0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x40, 0x0D, 0x80, 0x1B, 0x00,
  0x26, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x20, 0x0C, 0xC0, 0x19, 0x80, 0x63,
  0x03, 0xC7, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x3F, 0xFC, 0x7F, 0xFC, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0,
  0x1F, 0xFF, 0x1F, 0xFF, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x38, 0x70,
  0xC0, 0x23, 0x00, 0x66, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x0F, 0xEC, 0x1F, 0xD8, 0x01, 0xB0, 0x02, 0x60, 0x0C,
  0xC0, 0x18, 0xC0, 0x71, 0xC1, 0x61, 0xFE, 0xC1, 0xF1, 0x00, 0x0C, 0x01,
  0x84, 0x00, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x40,
  0x08, 0x20, 0x0C, 0x30, 0x06, 0x1F, 0xFF, 0x0F, 0xFF, 0x86, 0x00, 0xC3,
  0x00, 0x41, 0x00, 0x21, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06,
  0x18, 0x02, 0x08, 0x01, 0x0C, 0x01, 0x80, 0x0F, 0xFF, 0x87, 0xFF, 0x80,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x1F,
  0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0xC0, 0x33, 0x01, 0x86,
  0x0E, 0x1F, 0xF0, 0x1F, 0x00, 0x18, 0x03, 0x8C, 0x03, 0x04, 0x03, 0x06,
  0x03, 0x03, 0x03, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x23, 0x00,
  0x33, 0x80, 0x1B, 0x60, 0x0F, 0x30, 0x07, 0x0C, 0x03, 0x06, 0x01, 0x01,
  0x81, 0x80, 0xC0, 0xC0, 0x20, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x03, 0x08,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1C, 0x03,
  0x8E, 0x01, 0xC7, 0x01, 0xE2, 0xC0, 0xA1, 0x60, 0xD0, 0x90, 0xD8, 0xC8,
  0x6C, 0x66, 0x66, 0x33, 0x23, 0x10, 0xB1, 0x08, 0x50, 0x84, 0x38, 0xC6,
  0x18, 0x63, 0x08, 0x31, 0x84, 0x18, 0xC0, 0x08, 0x40, 0x04, 0x20, 0x06,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC0, 0x0E, 0x01, 0x87, 0x00, 0x87,
  0x80, 0xC3, 0x40, 0x61, 0xB0, 0x30, 0xD8, 0x18, 0x44, 0x08, 0x22, 0x04,
  0x31, 0x86, 0x18, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0xC2, 0x0C, 0x41, 0x06,
  0x21, 0x81, 0x10, 0xC0, 0xD8, 0x60, 0x6C, 0x30, 0x16, 0x10, 0x0A, 0x08,
  0x07, 0x0C, 0x03, 0x80, 0x03, 0xF0, 0x0F, 0xF0, 0x78, 0x70, 0xC0, 0x63,
  0x00, 0x66, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x2C, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x0C, 0xC0, 0x19,
  0xC0, 0x61, 0xC3, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF8,
  0x60, 0x39, 0x80, 0x33, 0x00, 0x26, 0x00, 0x4C, 0x01, 0x98, 0x03, 0x20,
  0x06, 0x40, 0x39, 0xFF, 0xE3, 0xFF, 0x86, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x78, 0x70, 0xC0, 0x63, 0x00, 0x66, 0x00, 0xD8,
  0x01, 0xB0, 0x03, 0x60, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x2C, 0x00,
  0xD8, 0x01, 0xB0, 0x03, 0x60, 0x0C, 0xC0, 0x19, 0xC0, 0x61, 0xC3, 0x81,
  0xFE, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0xC2, 0x00, 0xCE, 0x01, 0xB8, 0x01,
  0xE0, 0x03, 0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0x60, 0x39, 0x80, 0x33, 0x00,
  0x26, 0x00, 0x4C, 0x01, 0x98, 0x03, 0x20, 0x06, 0x40, 0x39, 0xFF, 0xE3,
  0xFF, 0x06, 0x18, 0x0C, 0x10, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x61, 0x80,
  0xC3, 0x00, 0xC6, 0x01, 0x88, 0x01, 0x80, 0x03, 0xF8, 0x0F, 0xFC, 0x1E,
  0x0E, 0x18, 0x03, 0x30, 0x02, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0xC0, 0x0C, 0xE0, 0x0C, 0x70, 0x38, 0x3F, 0xF0, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x03, 0x10, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x20, 0x04, 0x20, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x08, 0x40, 0x18, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x38, 0xE0, 0x30, 0x60, 0x70, 0x7F, 0xE0, 0x1F,
  0x80, 0xC0, 0x03, 0x40, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x18, 0x60, 0x18, 0x20, 0x30, 0x20, 0x30, 0x30, 0x20, 0x30, 0x60, 0x30,
  0x40, 0x30, 0xC0, 0x30, 0x80, 0x11, 0x80, 0x11, 0x80, 0x1B, 0x00, 0x1B,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xB0, 0x00, 0x98,
  0x00, 0x4C, 0x00, 0x66, 0x00, 0x33, 0x00, 0x11, 0x86, 0x08, 0x87, 0x0C,
  0x43, 0x86, 0x21, 0x42, 0x11, 0xB1, 0x08, 0x99, 0x8C, 0xCC, 0xC6, 0x66,
  0x43, 0x23, 0x21, 0xB0, 0xB0, 0xD0, 0x58, 0x78, 0x28, 0x3C, 0x14, 0x1C,
  0x0E, 0x0E, 0x07, 0x00, 0x0C, 0x00, 0xE1, 0x80, 0x18, 0x18, 0x06, 0x03,
  0x01, 0x80, 0x30, 0x60, 0x06, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1B, 0x00, 0x06,
  0x60, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x1C, 0x0C, 0x03, 0x01, 0x80, 0xC0,
  0x18, 0x30, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0xE0, 0x03, 0x18, 0x01,
  0x8C, 0x01, 0x83, 0x01, 0x81, 0x81, 0x80, 0x40, 0xC0, 0x30, 0xC0, 0x18,
  0xC0, 0x06, 0xC0, 0x03, 0x60, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFC,
  0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x83, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x07, 0xF8, 0x3F, 0xC0, 0x81,
  0x03, 0x06, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0x81, 0x83, 0x02, 0x04,
  0x0C, 0x18, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x02, 0x06, 0x0C, 0x08, 0x0F,
  0xF0, 0xFF, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03,
  0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x80, 0x19, 0x80,
  0x63, 0x01, 0x82, 0x02, 0x06, 0x0C, 0x04, 0x30, 0x0C, 0xC0, 0x19, 0x00,
  0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xF8, 0xC4, 0x62, 0x30, 0x0F, 0x8C,
  0x7F, 0xB3, 0x82, 0xDC, 0x06, 0x60, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06,
  0xC0, 0x13, 0x00, 0xCC, 0x03, 0x30, 0x1C, 0xE0, 0xB1, 0xFC, 0xF3, 0xE3,
  0xC0, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x7C, 0x37, 0xF8, 0xD0, 0x73, 0x80, 0xCC, 0x03, 0x60, 0x0D,
  0x80, 0x36, 0x00, 0xD8, 0x03, 0x40, 0x0D, 0x00, 0x6E, 0x03, 0xBC, 0x1C,
  0xDF, 0xE3, 0x3E, 0x00, 0x07, 0xE0, 0x7F, 0x86, 0x0E, 0x60, 0x36, 0x01,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xB0, 0x06, 0xC0, 0x67,
  0x0E, 0x1F, 0xE0, 0x7C, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x03, 0xE6, 0x1F, 0xEC, 0x70, 0x79,
  0xC0, 0x63, 0x00, 0x4C, 0x00, 0x98, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0,
  0x11, 0x80, 0x63, 0x01, 0xC7, 0x05, 0x87, 0xFB, 0x07, 0xC6, 0x00, 0x03,
  0xE0, 0x3F, 0xE1, 0x81, 0x8C, 0x03, 0x60, 0x19, 0x01, 0xE7, 0xFE, 0x3F,
  0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x01, 0x98, 0x0C, 0x70, 0x70, 0xFF, 0x81,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x01, 0x03, 0x00, 0x30, 0x60, 0x07, 0x0C, 0x00, 0x71,
  0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE6, 0x1F,
  0xEC, 0x70, 0x79, 0xC0, 0x63, 0x00, 0x4C, 0x00, 0x98, 0x03, 0x30, 0x06,
  0x60, 0x0C, 0xC0, 0x11, 0x80, 0x63, 0x01, 0xC7, 0x05, 0x87, 0xFB, 0x07,
  0xC6, 0x00, 0x08, 0x00, 0x31, 0x00, 0x63, 0x83, 0x83, 0xFE, 0x01, 0xF0,
  0x00, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x3C, 0x33, 0xF9, 0xB0, 0xCE, 0x06, 0x60, 0x13, 0x00, 0x90, 0x0D,
  0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0x90, 0x05, 0x80, 0x6C, 0x03, 0x60,
  0x18, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x82, 0x08, 0x30, 0x43, 0xC6, 0x70, 0x37, 0x01, 0xF0, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC1, 0x03, 0x06, 0x08, 0x3C, 0x20, 0x39, 0x80, 0x76, 0x00, 0xF8,
  0x00, 0xC0, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0xF8, 0x33, 0xF8, 0x6C, 0x30, 0xE0, 0x21, 0x80,
  0x43, 0x01, 0x8C, 0x06, 0x18, 0x78, 0x33, 0x80, 0x62, 0x04, 0xC6, 0x0D,
  0x04, 0x36, 0x0D, 0xCC, 0x0F, 0x18, 0x1C, 0x00, 0x7F, 0x0F, 0xF0, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x81, 0x18, 0x71, 0x8E, 0x11,
  0xC1, 0x70, 0x3E, 0x01, 0xC0, 0x37, 0x8E, 0x3F, 0xBF, 0x38, 0xE3, 0x30,
  0xC3, 0x20, 0xC3, 0x60, 0x83, 0x60, 0x82, 0x61, 0x82, 0x41, 0x82, 0x41,
  0x86, 0xC1, 0x06, 0xC1, 0x06, 0xC1, 0x04, 0xC3, 0x04, 0x83, 0x0C, 0x11,
  0xE1, 0x9F, 0xCD, 0x86, 0x70, 0x33, 0x00, 0x98, 0x04, 0x80, 0x6C, 0x03,
  0x60, 0x1B, 0x00, 0xD8, 0x04, 0x80, 0x24, 0x03, 0x60, 0x1B, 0x00, 0xC0,
  0x07, 0xE0, 0x7F, 0xC3, 0x83, 0x8C, 0x03, 0x60, 0x0D, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x6C, 0x01, 0xB0, 0x0C, 0x70, 0x70, 0xFF,
  0x81, 0xF8, 0x00, 0x18, 0xF8, 0x37, 0xF8, 0x68, 0x38, 0xE0, 0x31, 0x80,
  0x62, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x40, 0x0C, 0x80, 0x31,
  0x80, 0xE7, 0x83, 0x8D, 0xFE, 0x19, 0xF0, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xCC, 0x7F, 0xB3, 0x83,
  0xDC, 0x07, 0x60, 0x0B, 0x00, 0x2C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00,
  0x4C, 0x03, 0x30, 0x1C, 0xE0, 0xB1, 0xFE, 0xC3, 0xE3, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x7E, 0x3F, 0xFD, 0xFC,
  0x1E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x07, 0xE0, 0x7F, 0xE3, 0x81, 0xCC, 0x02, 0x20, 0x00, 0xC0, 0x03,
  0xF8, 0x07, 0xFC, 0x00, 0x78, 0x00, 0x60, 0x01, 0xA0, 0x06, 0xE0, 0x31,
  0xFF, 0x81, 0xF8, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x07, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x06, 0x08, 0x3C, 0x23, 0xC1,
  0xBC, 0x07, 0xC0, 0x0E, 0x00, 0x60, 0x1B, 0x00, 0xD8, 0x04, 0x80, 0x24,
  0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x24, 0x03, 0x20, 0x19, 0x83,
  0xCC, 0x36, 0x7F, 0x30, 0xF1, 0x00, 0xFC, 0x0F, 0xE0, 0x30, 0x80, 0xC6,
  0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xC4, 0x03, 0x10, 0x18, 0xC0, 0xE3,
  0x03, 0x0C, 0x38, 0x33, 0xC0, 0xFE, 0x03, 0xE0, 0x00, 0x20, 0x84, 0xC1,
  0x0D, 0x86, 0x1B, 0x0C, 0x34, 0x18, 0x68, 0x20, 0xF0, 0x41, 0xE1, 0x83,
  0xC3, 0x07, 0x06, 0x0A, 0x0C, 0x34, 0x38, 0x6C, 0xF1, 0x9F, 0x3E, 0x1C,
  0x78, 0x00, 0x03, 0x07, 0x01, 0xE7, 0xE1, 0xD9, 0x98, 0xC2, 0xC3, 0x40,
  0xE0, 0xC0, 0x30, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x30,
  0x0C, 0x1C, 0x13, 0x0D, 0x0E, 0x66, 0x6E, 0x1F, 0x9E, 0x03, 0x83, 0x00,
  0x18, 0x06, 0x30, 0x0C, 0x60, 0x10, 0xC0, 0x21, 0x00, 0xC6, 0x01, 0x8C,
  0x03, 0x18, 0x06, 0x30, 0x08, 0x40, 0x30, 0x80, 0x61, 0x81, 0xC3, 0x85,
  0x87, 0xF3, 0x03, 0xC4, 0x00, 0x18, 0x00, 0x31, 0x00, 0xE3, 0x83, 0x83,
  0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x86, 0x7F, 0xE9, 0xC1, 0xF3, 0x00, 0xE6,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x20, 0xC0,
  0x67, 0x00, 0xCF, 0xF8, 0x93, 0xFF, 0x20, 0x7E, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0xE0, 0x7E, 0x01, 0xF8, 0x08, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x04, 0x30, 0xC3,
  0x0C, 0x20, 0x86, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x0C, 0x30, 0x82, 0x18,
  0x61, 0x86, 0x10, 0x43, 0x0C, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xFC, 0x07, 0xF0, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0E, 0x01, 0x1F, 0x03, 0x33, 0x82,
  0x21, 0x86, 0x60, 0xCC, 0x40, 0xFC, 0xC0, 0x38,
};

const GFXglyph IBMPlexMono_LightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 21, 18, 6, -21 },
  { 17, 8, 8, 18, 7, -22 },
  { 25, 18, 21, 18, 0, -21 },
  { 73, 16, 27, 18, 1, -24 },
  { 127, 21, 21, 18, -1, -21 },
  { 183, 18, 21, 18, 0, -21 },
  { 231, 3, 8, 18, 9, -22 },
  { 234, 10, 27, 18, 7, -23 },
  { 268, 10, 27, 18, 2, -23 },
  { 302, 15, 15, 18, 2, -16 },
  { 331, 14, 16, 18, 2, -17 },
  { 359, 6, 8, 18, 4, -3 },
  { 365, 9, 2, 18, 5, -10 },
  { 368, 4, 3, 18, 6, -3 },
  { 370, 17, 27, 18, 1, -23 },
  { 428, 15, 21, 18, 2, -21 },
  { 468, 14, 21, 18, 1, -21 },
  { 505, 15, 21, 18, 1, -21 },
  { 545, 15, 21, 18, 1, -21 },
  { 585, 15, 21, 18, 1, -21 },
  { 625, 15, 21, 18, 2, -21 },
  { 665, 14, 21, 18, 2, -21 },
  { 702, 15, 21, 18, 3, -21 },
  { 742, 16, 21, 18, 1, -21 },
  { 784, 14, 21, 18, 3, -21 },
  { 821, 6, 16, 18, 6, -16 },
  { 833, 8, 21, 18, 4, -16 },
  { 854, 14, 17, 18, 3, -18 },
  { 884, 15, 8, 18, 2, -13 },
  { 899, 15, 17, 18, 1, -18 },
  { 931, 13, 21, 18, 4, -21 },
  { 966, 15, 24, 18, 2, -21 },
  { 1011, 16, 21, 18, 0, -21 },
  { 1053, 14, 21, 18, 2, -21 },
  { 1090, 15, 21, 18, 2, -21 },
  { 1130, 15, 21, 18, 2, -21 },
  { 1170, 16, 21, 18, 2, -21 },
  { 1212, 16, 21, 18, 2, -21 },
  { 1254, 15, 21, 18, 2, -21 },
  { 1294, 17, 21, 18, 1, -21 },
  { 1339, 17, 21, 18, 1, -21 },
  { 1384, 14, 21, 18, 2, -21 },
  { 1421, 17, 21, 18, 2, -21 },
  { 1466, 12, 21, 18, 3, -21 },
  { 1498, 17, 21, 18, 1, -21 },
  { 1543, 17, 21, 18, 1, -21 },
  { 1588, 15, 21, 18, 2, -21 },
  { 1628, 15, 21, 18, 2, -21 },
  { 1668, 15, 27, 18, 2, -21 },
  { 1719, 15, 21, 18, 2, -21 },
  { 1759, 16, 21, 18, 1, -21 },
  { 1801, 16, 21, 18, 3, -21 },
  { 1843, 16, 21, 18, 2, -21 },
  { 1885, 16, 21, 18, 3, -21 },
  { 1927, 17, 21, 18, 2, -21 },
  { 1972, 19, 21, 18, 0, -21 },
  { 2022, 17, 21, 18, 3, -21 },
  { 2067, 18, 21, 18, 0, -21 },
  { 2115, 13, 27, 18, 5, -23 },
  { 2159, 7, 27, 18, 6, -23 },
  { 2183, 12, 27, 18, 1, -23 },
  { 2224, 15, 12, 18, 2, -21 },
  { 2247, 15, 2, 18, 0, 3 },
  { 2251, 4, 5, 18, 7, -23 },
  { 2254, 14, 15, 18, 2, -15 },
  { 2281, 14, 22, 18, 2, -22 },
  { 2320, 13, 15, 18, 2, -15 },
  { 2345, 15, 22, 18, 2, -22 },
  { 2387, 14, 15, 18, 2, -15 },
  { 2414, 19, 28, 18, 0, -22 },
  { 2481, 15, 21, 18, 1, -15 },
  { 2521, 13, 22, 18, 2, -22 },
  { 2557, 13, 22, 18, 3, -22 },
  { 2593, 14, 28, 18, 2, -22 },
  { 2642, 15, 22, 18, 2, -22 },
  { 2684, 12, 22, 18, 3, -22 },
  { 2717, 16, 15, 18, 1, -15 },
  { 2747, 13, 15, 18, 2, -15 },
  { 2772, 14, 15, 18, 2, -15 },
  { 2799, 15, 21, 18, 1, -15 },
  { 2839, 14, 21, 18, 2, -15 },
  { 2876, 15, 15, 18, 3, -15 },
  { 2905, 14, 15, 18, 2, -15 },
  { 2932, 14, 21, 18, 2, -21 },
  { 2969, 13, 15, 18, 3, -15 },
  { 2994, 14, 15, 18, 2, -15 },
  { 3021, 15, 15, 18, 2, -15 },
  { 3050, 18, 15, 18, 0, -15 },
  { 3084, 15, 21, 18, 1, -15 },
  { 3124, 15, 15, 18, 2, -15 },
  { 3153, 14, 27, 18, 3, -23 },
  { 3201, 6, 27, 18, 6, -23 },
  { 3222, 14, 27, 18, 1, -23 },
  { 3270, 16, 7, 18, 1, -12 },
};

const GFXfont IBMPlexMono_LightItalic30pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic30pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic30pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _IBMPLEXMONO_LIGHTITALIC30PT7B_H_
