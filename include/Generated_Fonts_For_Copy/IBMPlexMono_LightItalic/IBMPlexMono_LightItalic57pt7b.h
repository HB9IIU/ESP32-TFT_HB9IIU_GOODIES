#ifndef _IBMPLEXMONO_LIGHTITALIC57PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x1C, 0x0E, 0x78, 0x3C,
  0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x3C, 0x1E, 0x70,
  0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x9E, 0x0E, 0x38, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0x80, 0xE0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xF8, 0xE7, 0xF0, 0x07, 0x81, 0xC1, 0xF0, 0x1E, 0x03,
  0x81, 0xE0, 0x78, 0x06, 0x01, 0xE0, 0xF0, 0x0C, 0x01, 0x01, 0xC0, 0x18,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x3C, 0x03, 0x00, 0x00, 0x78, 0x06, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xF8, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x39, 0xFC, 0x00, 0x00, 0x60, 0x78, 0x00,
  0x00, 0xC0, 0x78, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x30, 0x07, 0x80, 0x00,
  0x60, 0x0F, 0x00, 0x00, 0xC0, 0x1E, 0x10, 0x03, 0x80, 0x38, 0x70, 0x07,
  0x00, 0xF0, 0xF0, 0x0E, 0x01, 0xC0, 0xF0, 0x1C, 0x07, 0x81, 0xF8, 0x30,
  0x3E, 0x00, 0xFC, 0x61, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0xFF,
  0x80, 0x00, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0x00, 0x7C, 0x1E, 0x00, 0x1C,
  0x01, 0xC0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x38, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x38, 0x00, 0x70, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0x0E,
  0x07, 0x00, 0x07, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x01, 0xE1, 0xC0, 0x00,
  0x70, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x38, 0x00, 0x03, 0xFF, 0xC1,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x83, 0xFF, 0xC0, 0x00,
  0x1C, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x1E, 0x00, 0x03, 0x83, 0x80,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x01, 0xE0, 0xF0, 0x07, 0x00, 0x03, 0xFF, 0xC0, 0x38, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xF9, 0xF8, 0x00, 0x07, 0xEF, 0xF8,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x13, 0xC0, 0x00, 0xF0, 0x06,
  0xF0, 0x00, 0x3E, 0x03, 0xDC, 0x00, 0x1B, 0x81, 0xC7, 0x00, 0x06, 0xF0,
  0x71, 0xE0, 0x03, 0x1C, 0x38, 0x3C, 0x01, 0xC7, 0x9E, 0x0F, 0x81, 0xE0,
  0xE7, 0x01, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xF8, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xF0, 0x00, 0x39, 0xCE, 0x77, 0xB9, 0xCE, 0x73, 0xB9, 0xCE, 0x73,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x02, 0x00, 0x1C, 0x00, 0x5E, 0x00, 0xE0, 0x3F, 0xFE, 0x0E, 0x0F,
  0xF1, 0xFE, 0x73, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x10, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x78, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0F, 0x70, 0x0F, 0x00, 0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0xFF,
  0x01, 0xF0, 0x0E, 0xF0, 0x0F, 0x00, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0xE0, 0x00,
  0x3F, 0x78, 0x00, 0x1F, 0x1C, 0x00, 0x0F, 0x87, 0x00, 0x07, 0xC1, 0xC0,
  0x07, 0xE0, 0x70, 0x03, 0xF0, 0x1C, 0x01, 0xF0, 0x0F, 0x00, 0x38, 0x03,
  0x80, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x0F,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x78, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xC0,
  0x1F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x30,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x1C,
  0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x0F, 0xF0, 0x00, 0x71, 0xFF,
  0xE0, 0x03, 0x9F, 0xFF, 0x80, 0x1D, 0xC0, 0x7E, 0x00, 0xF8, 0x00, 0xF8,
  0x07, 0x80, 0x03, 0xE0, 0x50, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x3F, 0x80, 0x1E, 0x7F, 0xF8, 0x07, 0x3F, 0xFF, 0x83,
  0xDE, 0x03, 0xF0, 0xEE, 0x00, 0x3C, 0x7E, 0x00, 0x07, 0x9F, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x7C, 0x0F, 0xC0, 0x7E, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x1E, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xC0, 0x0F, 0x80, 0x78, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x07, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0xC3,
  0xC0, 0x03, 0xB8, 0x3E, 0x01, 0xEE, 0x07, 0xFF, 0xF9, 0xC0, 0x3F, 0xFC,
  0x70, 0x01, 0xFE, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1E, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0xFC, 0x07, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x03, 0xDE,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x7C, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x31, 0xC0, 0x1F, 0x8E, 0x38, 0x0F, 0xF9,
  0xCE, 0x03, 0xFF, 0xB9, 0xC0, 0x78, 0x37, 0x38, 0x1E, 0x01, 0xE7, 0x03,
  0x80, 0x3D, 0xC0, 0xE0, 0x07, 0x38, 0x1C, 0x00, 0xE7, 0x03, 0x80, 0x1C,
  0xE0, 0xE0, 0x03, 0x9C, 0x1C, 0x00, 0x73, 0x83, 0x80, 0x0E, 0xE0, 0x70,
  0x03, 0x9C, 0x0E, 0x00, 0x73, 0x83, 0x80, 0x0E, 0x70, 0x70, 0x01, 0xCE,
  0x07, 0x00, 0x79, 0xC0, 0xE0, 0x1F, 0x38, 0x1C, 0x03, 0xC7, 0x03, 0xC1,
  0xB8, 0xE0, 0x7F, 0xF7, 0x1C, 0x07, 0xFC, 0xE3, 0x80, 0x7F, 0x1C, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x0E, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0x80,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0F, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x3E, 0x03, 0x80, 0x01,
  0xE0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x78, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0xF8,
  0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x08, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x02, 0x0E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x70,
  0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x38, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x78, 0x07, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x04, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xFC, 0xF0, 0x03, 0xFF, 0xCF, 0x00,
  0x3F, 0xFC, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0x70, 0x3E, 0x00, 0x67, 0x01,
  0xF8, 0x1E, 0xF0, 0x0F, 0xFF, 0xCE, 0x00, 0x7F, 0xF0, 0xE0, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0x81, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x78, 0x07, 0x80, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0x70, 0x00,
  0x0F, 0x80, 0x38, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x03,
  0x8F, 0xC0, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0x01, 0xEF, 0x38, 0x00, 0x00,
  0xEF, 0x1E, 0x00, 0x00, 0x7F, 0x07, 0x00, 0x00, 0x3F, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0xFE, 0x07, 0x70, 0x00, 0xEE, 0x07, 0x38, 0x01, 0xCE, 0x07, 0x38, 0x01,
  0xCE, 0x07, 0x38, 0x03, 0x9C, 0x07, 0x38, 0x07, 0x9C, 0x07, 0x1C, 0x07,
  0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x1C,
  0x1C, 0x0E, 0x0E, 0x3C, 0x38, 0x0E, 0x0E, 0x38, 0x38, 0x0E, 0x0E, 0x70,
  0x38, 0x1C, 0x06, 0x70, 0x38, 0x1C, 0x07, 0xE0, 0x38, 0x1C, 0x07, 0xE0,
  0x38, 0x1C, 0x07, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0x70, 0x38, 0x03, 0x00, 0x70, 0x38, 0x03, 0x00, 0x70, 0x38, 0x02, 0x00,
  0x70, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x1C, 0x0F, 0x80, 0x00,
  0x70, 0x3F, 0x00, 0x01, 0xC0, 0xFC, 0x00, 0x07, 0x07, 0xF0, 0x00, 0x3C,
  0x1D, 0xE0, 0x00, 0xE0, 0x73, 0x80, 0x03, 0x81, 0xCE, 0x00, 0x0E, 0x07,
  0x38, 0x00, 0x38, 0x1C, 0xF0, 0x00, 0xE0, 0xF1, 0xC0, 0x07, 0x83, 0x87,
  0x00, 0x1C, 0x0E, 0x1C, 0x00, 0x70, 0x38, 0x38, 0x01, 0xC0, 0xE0, 0xE0,
  0x07, 0x03, 0x83, 0x80, 0x1C, 0x1E, 0x0F, 0x00, 0xF0, 0x70, 0x1C, 0x03,
  0x81, 0xC0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0xE0,
  0x70, 0x0E, 0x03, 0x83, 0xC0, 0x38, 0x1E, 0x0E, 0x00, 0xE0, 0x70, 0x38,
  0x01, 0xC1, 0xC0, 0xE0, 0x07, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x0E, 0x00,
  0x78, 0x70, 0x78, 0x00, 0xE1, 0xC1, 0xC0, 0x03, 0x8E, 0x07, 0x00, 0x0E,
  0x38, 0x1C, 0x00, 0x1C, 0xE0, 0x70, 0x00, 0x73, 0x81, 0xC0, 0x01, 0xCE,
  0x0F, 0x00, 0x07, 0xB8, 0x38, 0x00, 0x0F, 0xC0, 0xE0, 0x00, 0x3F, 0x03,
  0x80, 0x00, 0xFC, 0x0E, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC0,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x78, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xE0,
  0x00, 0x7C, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x7E, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x78, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0xE0, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x7E, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xC0,
  0x3C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xF0, 0x07,
  0x80, 0x03, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x1E, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x04, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x40, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x07,
  0xC0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x1C, 0x07, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70,
  0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0xE0, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x78, 0x03, 0x81, 0xC0, 0x3C, 0x01,
  0xC0, 0xE0, 0x3E, 0x01, 0xC0, 0xE0, 0x1F, 0x80, 0xE0, 0x70, 0x0D, 0xC0,
  0x70, 0x38, 0x0E, 0xE0, 0x38, 0x1C, 0x07, 0x70, 0x38, 0x0E, 0x07, 0x38,
  0x1C, 0x07, 0x03, 0x9C, 0x0E, 0x03, 0x81, 0x8E, 0x07, 0x01, 0xC1, 0xC7,
  0x07, 0x00, 0xE0, 0xE3, 0x83, 0x80, 0x70, 0xE0, 0xC1, 0xC0, 0x38, 0x70,
  0x60, 0xE0, 0x1C, 0x30, 0x30, 0xE0, 0x1C, 0x38, 0x18, 0x70, 0x0E, 0x1C,
  0x0E, 0x38, 0x07, 0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x9C, 0x01, 0xCE,
  0x01, 0xCE, 0x00, 0xE7, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x73, 0x80, 0x3B,
  0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x1D, 0xC0, 0x0F, 0xC0, 0x0E, 0xE0, 0x07,
  0xE0, 0x07, 0x70, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x71, 0xE1, 0xC1, 0xC3, 0x83,
  0x87, 0x06, 0x0E, 0x08, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x70, 0x3F,
  0xFF, 0x1C, 0x1F, 0x81, 0xE7, 0x0F, 0x80, 0x1B, 0xC7, 0x80, 0x03, 0xF1,
  0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x3C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x38,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E,
  0x38, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xE3, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x7C, 0x3C, 0x00, 0x37, 0x07, 0x80, 0x19, 0xC1, 0xF8, 0x1C, 0x7F, 0x3F,
  0xFF, 0x1F, 0xC7, 0xFF, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x3F, 0x80, 0x1E, 0x1F, 0xFC, 0x03, 0x8F, 0xFF, 0xC0,
  0x73, 0xC0, 0xFC, 0x0E, 0x60, 0x07, 0x81, 0xD8, 0x00, 0x78, 0x3E, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0xE1, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x3C, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xE1, 0xF8, 0x00, 0x3C, 0x3B, 0x80, 0x1F, 0x07, 0x3C, 0x0F, 0xC0,
  0xE3, 0xFF, 0xF0, 0x1C, 0x3F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7E, 0x07, 0xC0,
  0x7C, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x06,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x1E, 0x03,
  0xE0, 0x3E, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xF8, 0x1E, 0x00,
  0x7F, 0xF0, 0xE0, 0x0F, 0xFF, 0xC7, 0x00, 0xFC, 0x0F, 0x38, 0x0F, 0x80,
  0x0D, 0xC0, 0xF0, 0x00, 0x2E, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x7C, 0x0F, 0x00,
  0x07, 0xE0, 0x78, 0x00, 0x6E, 0x01, 0xE0, 0x06, 0x70, 0x07, 0xC0, 0xF3,
  0x80, 0x3F, 0xFF, 0x1C, 0x00, 0x7F, 0xE0, 0xE0, 0x00, 0xFC, 0x08, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xC0,
  0x7C, 0x07, 0xC0, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x78,
  0x00, 0x0F, 0x1C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x39,
  0xE0, 0x00, 0x1E, 0x70, 0x00, 0x1F, 0x1C, 0x00, 0x3F, 0x87, 0x01, 0xFF,
  0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x87,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x07,
  0x83, 0xE0, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x00, 0x1F, 0x01, 0xC0,
  0x00, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x00, 0x7D, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xC3, 0xC0, 0x3F,
  0xFF, 0x1C, 0x03, 0xF0, 0x1C, 0xE0, 0x3E, 0x00, 0x37, 0x03, 0xC0, 0x00,
  0xB8, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x3E, 0x07, 0x80, 0x03, 0x70, 0x3C, 0x00, 0x37, 0x80, 0xF0, 0x03,
  0xB8, 0x03, 0xE0, 0x79, 0xC0, 0x1F, 0xFF, 0x8E, 0x00, 0x3F, 0xF8, 0x70,
  0x00, 0x7F, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x02, 0x00, 0x07, 0x80, 0x38, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x3F, 0x00, 0x38, 0x7F, 0xE0, 0x1C, 0x7F, 0xF8, 0x1E,
  0x70, 0x3E, 0x0F, 0x60, 0x0F, 0x07, 0x60, 0x03, 0xC3, 0xA0, 0x01, 0xE1,
  0xF0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xC7, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00,
  0x3C, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xF1, 0xC0,
  0x00, 0x71, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x08, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x80, 0x70, 0x0F, 0x00, 0x78,
  0x0F, 0x00, 0x38, 0x1F, 0x00, 0x1C, 0x1F, 0x00, 0x0E, 0x1E, 0x00, 0x07,
  0x3E, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x08, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x03, 0xE0,
  0x07, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x38, 0x00,
  0x1E, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x78,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x3F, 0x80, 0x03, 0x87,
  0xFF, 0x00, 0x3C, 0x7F, 0xFC, 0x01, 0xC7, 0x03, 0xE0, 0x0E, 0x70, 0x07,
  0x80, 0x76, 0x00, 0x1C, 0x03, 0xA0, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x01,
  0xF0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x1E,
  0x00, 0x70, 0x07, 0xC0, 0x03, 0x81, 0xF8, 0x00, 0x1C, 0x3E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x23, 0x80,
  0xE0, 0x03, 0x9C, 0x03, 0x80, 0x3E, 0xE0, 0x1C, 0x03, 0xC7, 0x00, 0x70,
  0x3C, 0x38, 0x03, 0x83, 0xC3, 0xC0, 0x0E, 0x3C, 0x1C, 0x00, 0x7B, 0xC0,
  0xE0, 0x01, 0xFC, 0x07, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x04, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x01, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x3E, 0x07, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x1F, 0x00, 0x70, 0x7C, 0x00, 0xE1, 0xE0,
  0x01, 0xCF, 0x80, 0x07, 0xBE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x0E, 0x7F, 0x87, 0xF8, 0x1C,
  0xFF, 0x1F, 0xF8, 0x3B, 0x0F, 0x70, 0xF0, 0x7C, 0x0E, 0xC0, 0xE1, 0xF0,
  0x1F, 0x01, 0xC3, 0xC0, 0x3C, 0x03, 0x87, 0x80, 0x78, 0x07, 0x0E, 0x00,
  0xE0, 0x0E, 0x1C, 0x01, 0xC0, 0x1C, 0x38, 0x03, 0x80, 0x38, 0xE0, 0x07,
  0x00, 0x71, 0xC0, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x03, 0x87, 0x00, 0x70,
  0x07, 0x0E, 0x00, 0xE0, 0x0E, 0x1C, 0x01, 0xC0, 0x1C, 0x70, 0x03, 0x80,
  0x38, 0xE0, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x03,
  0x87, 0x00, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0x0E, 0x38, 0x01, 0xC0, 0x1C,
  0x70, 0x07, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0x03, 0x87, 0x00, 0x70, 0x07, 0x1C, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0x87, 0xFE, 0x01, 0xC7, 0xFF, 0x81, 0xE7, 0x03,
  0xE0, 0xF6, 0x00, 0xF0, 0x76, 0x00, 0x3C, 0x3A, 0x00, 0x1E, 0x1F, 0x00,
  0x07, 0x0F, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x78,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0xC7,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x07,
  0x1E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0F,
  0x3C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1E, 0x1F, 0xFC, 0x00, 0xF3,
  0xFF, 0xF0, 0x07, 0x3C, 0x0F, 0xC0, 0x39, 0x80, 0x1E, 0x01, 0xD8, 0x00,
  0x78, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0x70,
  0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0x81, 0xF8, 0x00,
  0x3C, 0x0E, 0xE0, 0x07, 0xC0, 0x73, 0xC0, 0xFC, 0x03, 0x8F, 0xFF, 0xC0,
  0x1C, 0x3F, 0xFC, 0x01, 0xE0, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xFC, 0x3C, 0x0F, 0xFF, 0xC7, 0x03, 0xF0, 0x3C, 0xE0, 0xF8, 0x00,
  0xDC, 0x3E, 0x00, 0x0B, 0x87, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3C,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00,
  0x07, 0x87, 0x00, 0x01, 0x70, 0xF0, 0x00, 0x7E, 0x1E, 0x00, 0x1B, 0x81,
  0xE0, 0x07, 0x70, 0x1F, 0x03, 0xCE, 0x03, 0xFF, 0xF1, 0xC0, 0x1F, 0xF8,
  0x38, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x7F, 0xF8, 0x1F, 0xF7, 0xFF, 0x87, 0xFF, 0x7F, 0xF9,
  0xFF, 0xE8, 0x07, 0x3C, 0x00, 0x00, 0x73, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x7C,
  0x00, 0x3E, 0x0E, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x20, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE1, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x9F, 0x00, 0x00,
  0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0xC0, 0x3F, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x02, 0x00,
  0x70, 0x00, 0xE0, 0x0E, 0x00, 0x7E, 0x01, 0xC0, 0x1F, 0x00, 0x38, 0x0F,
  0x80, 0x07, 0x03, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0x38, 0xFC, 0x00, 0x07,
  0x3E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0xF1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0x87,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38,
  0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xE3, 0x80, 0x01,
  0xE1, 0xE0, 0x01, 0x70, 0xF0, 0x01, 0xB8, 0x3C, 0x01, 0x9C, 0x1F, 0x03,
  0x9E, 0x07, 0xFF, 0x8F, 0x01, 0xFF, 0x87, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x8F, 0xF8, 0x00, 0x7B, 0xFF, 0x00, 0x07, 0x7F, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x1C,
  0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xF0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x1C, 0x00,
  0x78, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x07, 0xC0, 0x0E, 0x01, 0xF0, 0x01,
  0xC0, 0xFC, 0x00, 0x70, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x70, 0x07, 0x03,
  0x83, 0x80, 0x70, 0x0C, 0x38, 0x03, 0x80, 0x71, 0xC0, 0x1C, 0x03, 0x8E,
  0x00, 0xE0, 0x1C, 0x70, 0x07, 0x00, 0xE3, 0x80, 0x38, 0x07, 0x1C, 0x03,
  0x80, 0x39, 0xC0, 0x1C, 0x01, 0xCE, 0x00, 0xE0, 0x0E, 0x70, 0x07, 0x00,
  0x73, 0x80, 0x38, 0x03, 0x9C, 0x01, 0xC0, 0x1C, 0xE0, 0x1C, 0x00, 0xEE,
  0x00, 0xE0, 0x07, 0x70, 0x07, 0x00, 0x3B, 0x80, 0x38, 0x01, 0xDC, 0x01,
  0xC0, 0x1C, 0xE0, 0x0E, 0x00, 0xE7, 0x00, 0xE0, 0x07, 0x70, 0x07, 0x00,
  0x7B, 0x80, 0x38, 0x03, 0x9C, 0x01, 0xC0, 0x1C, 0xE0, 0x16, 0x01, 0xC7,
  0x01, 0xB0, 0x1E, 0x38, 0x09, 0x81, 0xE1, 0xE1, 0xCE, 0x1F, 0x07, 0xFC,
  0x7F, 0xF0, 0x3F, 0xC1, 0xFE, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x7C,
  0xE1, 0xE1, 0xE0, 0xF8, 0x78, 0xE0, 0x70, 0xF8, 0x1C, 0xE0, 0x38, 0xF0,
  0x0E, 0x60, 0x1E, 0x60, 0x07, 0x60, 0x07, 0x00, 0x03, 0xB0, 0x03, 0x80,
  0x00, 0xD0, 0x03, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x7C, 0x00,
  0x07, 0x00, 0x2E, 0x00, 0x03, 0x80, 0x17, 0x00, 0x21, 0xC0, 0x1B, 0x80,
  0x38, 0xE0, 0x1D, 0xC0, 0x3E, 0x70, 0x0C, 0x70, 0x7C, 0x38, 0x0E, 0x38,
  0x78, 0x1E, 0x1E, 0x1C, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0,
  0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1C,
  0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x3C, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x1E,
  0x00, 0x17, 0x01, 0xE0, 0x03, 0x70, 0x0F, 0x00, 0x67, 0x00, 0xF8, 0x1C,
  0x70, 0x07, 0xFF, 0xCF, 0x00, 0x3F, 0xF0, 0xF0, 0x00, 0xFC, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x06, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x03, 0xC1, 0xFF, 0xFC, 0x1C, 0x1F, 0x03, 0xF8, 0xE0, 0xE0, 0x03, 0xF7,
  0x07, 0x00, 0x03, 0xF8, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x1C,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x40, 0x03, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0x30, 0x03, 0xC0,
  0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x70, 0x3E, 0x00, 0x01,
  0xC3, 0xFF, 0x00, 0x0E, 0x3D, 0xFF, 0xC0, 0x71, 0xE1, 0xFF, 0xE3, 0x8E,
  0x00, 0xFF, 0xFC, 0x70, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x10, 0x3F, 0xC0,
  0x01, 0xC3, 0xFF, 0x00, 0x0E, 0x3C, 0x3C, 0x00, 0xE1, 0xC0, 0xE0, 0x07,
  0x1C, 0x07, 0x80, 0x30, 0xE0, 0x1E, 0x03, 0x8E, 0x00, 0x70, 0x38, 0x70,
  0x03, 0xE3, 0xC7, 0x00, 0x0F, 0xFC, 0x38, 0x00, 0x3F, 0xC0, 0x80, 0x00,
  0x78, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 11, 40, 34, 12, -40 },
  { 56, 15, 15, 34, 13, -42 },
  { 85, 34, 40, 34, 1, -40 },
  { 255, 31, 53, 34, 2, -46 },
  { 461, 38, 41, 34, -1, -40 },
  { 656, 34, 41, 34, 0, -40 },
  { 831, 5, 15, 34, 18, -42 },
  { 841, 20, 51, 34, 12, -43 },
  { 969, 20, 51, 34, 3, -43 },
  { 1097, 29, 28, 34, 3, -31 },
  { 1199, 27, 27, 34, 4, -31 },
  { 1291, 11, 15, 34, 8, -6 },
  { 1312, 17, 3, 34, 9, -19 },
  { 1319, 6, 6, 34, 12, -6 },
  { 1324, 31, 51, 34, 2, -43 },
  { 1522, 28, 41, 34, 4, -40 },
  { 1666, 26, 40, 34, 3, -40 },
  { 1796, 29, 40, 34, 2, -40 },
  { 1941, 29, 41, 34, 2, -40 },
  { 2090, 30, 40, 34, 1, -40 },
  { 2240, 29, 41, 34, 3, -40 },
  { 2389, 26, 41, 34, 4, -40 },
  { 2523, 28, 40, 34, 6, -40 },
  { 2663, 29, 41, 34, 3, -40 },
  { 2812, 27, 40, 34, 5, -40 },
  { 2947, 10, 30, 34, 12, -30 },
  { 2985, 14, 39, 34, 8, -30 },
  { 3054, 27, 32, 34, 5, -33 },
  { 3162, 29, 13, 34, 3, -24 },
  { 3210, 27, 32, 34, 3, -33 },
  { 3318, 23, 40, 34, 8, -40 },
  { 3433, 27, 46, 34, 4, -40 },
  { 3589, 30, 40, 34, 0, -40 },
  { 3739, 28, 40, 34, 3, -40 },
  { 3879, 28, 41, 34, 5, -40 },
  { 4023, 29, 40, 34, 3, -40 },
  { 4168, 31, 40, 34, 3, -40 },
  { 4323, 31, 40, 34, 3, -40 },
  { 4478, 28, 41, 34, 4, -40 },
  { 4622, 30, 40, 34, 3, -40 },
  { 4772, 30, 40, 34, 3, -40 },
  { 4922, 27, 41, 34, 4, -40 },
  { 5061, 33, 40, 34, 3, -40 },
  { 5226, 23, 40, 34, 5, -40 },
  { 5341, 32, 40, 34, 2, -40 },
  { 5501, 30, 40, 34, 3, -40 },
  { 5651, 28, 41, 34, 4, -40 },
  { 5795, 30, 40, 34, 3, -40 },
  { 5945, 28, 50, 34, 4, -40 },
  { 6120, 30, 40, 34, 3, -40 },
  { 6270, 31, 41, 34, 2, -40 },
  { 6429, 32, 40, 34, 5, -40 },
  { 6589, 29, 41, 34, 4, -40 },
  { 6738, 29, 40, 34, 7, -40 },
  { 6883, 33, 40, 34, 3, -40 },
  { 7048, 36, 40, 34, 0, -40 },
  { 7228, 32, 40, 34, 5, -40 },
  { 7388, 35, 40, 34, 0, -40 },
  { 7563, 23, 51, 34, 10, -43 },
  { 7710, 14, 51, 34, 11, -43 },
  { 7800, 23, 51, 34, 1, -43 },
  { 7947, 28, 22, 34, 4, -40 },
  { 8024, 28, 3, 34, 0, 6 },
  { 8035, 7, 10, 34, 13, -44 },
  { 8044, 26, 31, 34, 4, -30 },
  { 8145, 27, 43, 34, 4, -42 },
  { 8291, 25, 31, 34, 4, -30 },
  { 8388, 29, 43, 34, 4, -42 },
  { 8544, 26, 31, 34, 4, -30 },
  { 8645, 37, 54, 34, -1, -42 },
  { 8895, 29, 42, 34, 2, -30 },
  { 9048, 25, 42, 34, 4, -42 },
  { 9180, 25, 43, 34, 5, -42 },
  { 9315, 26, 54, 34, 4, -42 },
  { 9491, 29, 43, 34, 4, -42 },
  { 9647, 23, 43, 34, 6, -42 },
  { 9771, 31, 30, 34, 1, -30 },
  { 9888, 25, 30, 34, 4, -30 },
  { 9982, 26, 31, 34, 4, -30 },
  { 10083, 29, 41, 34, 2, -30 },
  { 10232, 27, 41, 34, 4, -30 },
  { 10371, 28, 29, 34, 6, -29 },
  { 10473, 27, 31, 34, 3, -30 },
  { 10578, 27, 41, 34, 4, -40 },
  { 10717, 25, 30, 34, 5, -29 },
  { 10811, 27, 30, 34, 4, -30 },
  { 10913, 29, 31, 34, 3, -30 },
  { 11026, 33, 31, 34, 1, -30 },
  { 11154, 28, 41, 34, 2, -29 },
  { 11298, 29, 31, 34, 3, -30 },
  { 11411, 26, 51, 34, 7, -43 },
  { 11577, 11, 51, 34, 12, -43 },
  { 11648, 26, 51, 34, 3, -43 },
  { 11814, 29, 12, 34, 3, -23 },
};

const GFXfont IBMPlexMono_LightItalic57pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic57pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic57pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _IBMPLEXMONO_LIGHTITALIC57PT7B_H_
