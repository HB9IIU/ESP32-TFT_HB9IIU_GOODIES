#ifndef _IBMPLEXMONO_LIGHTITALIC39PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0xF8, 0xF0, 0xF0, 0x30, 0xDC, 0x36, 0x1D, 0x86, 0x61, 0x98, 0x66,
  0x1B, 0x86, 0xC3, 0xB0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x60, 0x00, 0x61, 0xC0, 0x3F, 0x83, 0xFC, 0xFF, 0x07,
  0xF8, 0x06, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80,
  0x01, 0x83, 0x00, 0xFF, 0x07, 0xF1, 0xFC, 0x1F, 0xE0, 0x18, 0x30, 0x00,
  0x30, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x80, 0x78, 0xCF, 0x03, 0x83, 0x0E, 0x0C, 0x0C, 0x1C,
  0x30, 0x20, 0x01, 0xC0, 0x80, 0x07, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x30,
  0x60, 0x00, 0xE1, 0x80, 0x01, 0xE4, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x0C, 0x70, 0x00, 0x20, 0xE0, 0x00, 0x81, 0x80,
  0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x61, 0x01, 0x81, 0x8E, 0x04,
  0x0E, 0x1C, 0x10, 0x70, 0x3C, 0xC7, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0xC0, 0xFF, 0x00, 0x60, 0x70, 0xE0, 0x18, 0x18, 0x18,
  0x0C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x83, 0x00, 0xC0, 0x60, 0xC0, 0x30,
  0x18, 0x60, 0x0C, 0x06, 0x30, 0x03, 0x03, 0x1C, 0x00, 0xE1, 0xC6, 0x00,
  0x1F, 0xE3, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0x8F, 0xF0, 0x00, 0xC7, 0x0C, 0x00, 0x63, 0x81, 0x80, 0x30,
  0xC0, 0x60, 0x0C, 0x30, 0x18, 0x06, 0x0C, 0x06, 0x03, 0x06, 0x01, 0x81,
  0xC1, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x30, 0x0C, 0x18, 0x18, 0x01, 0xFC,
  0x0E, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x07,
  0x00, 0x1C, 0x06, 0x00, 0x30, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0xE0, 0x07, 0x01, 0x80, 0x06, 0x07, 0x00,
  0x0E, 0x0C, 0x00, 0x7C, 0x70, 0x03, 0xFF, 0x80, 0x0E, 0x18, 0x00, 0x38,
  0x18, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x30, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x5C, 0x01, 0xE1, 0xF8, 0x02, 0xC3, 0x30, 0x09,
  0xCC, 0x78, 0x71, 0xB8, 0x7F, 0xC3, 0xE0, 0x3E, 0x03, 0x80, 0x37, 0x76,
  0x66, 0x66, 0xCC, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x40, 0x70,
  0x17, 0x86, 0x0F, 0xBF, 0x67, 0xE0, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xB0, 0x00, 0x31, 0x80, 0x06, 0x18, 0x00, 0xC0, 0xC0, 0x1C,
  0x0E, 0x03, 0x80, 0x60, 0x30, 0x06, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x1E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x30, 0xC1,
  0x80, 0x7F, 0xFF, 0xFE, 0x77, 0xFD, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xE0, 0x1E, 0x0E, 0x07, 0x00, 0xE1, 0xC0, 0x0C, 0x70, 0x01, 0xCC, 0x00,
  0x19, 0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xF0, 0x70,
  0x7E, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x38, 0x36, 0x00, 0x06, 0xC0, 0x00,
  0xD8, 0x00, 0x3B, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06,
  0x38, 0x01, 0x83, 0x00, 0x70, 0x78, 0x3C, 0x07, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0E, 0xC0, 0x07, 0x30, 0x07, 0x8C,
  0x03, 0xC3, 0x01, 0xC1, 0xC0, 0xE0, 0x60, 0x10, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xC1, 0xE0, 0x70, 0x07,
  0x06, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x03, 0xC1, 0xE0, 0x70, 0x07, 0x0E, 0x00, 0x70, 0x40,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC4, 0x00, 0x1C, 0xE0, 0x01, 0x87, 0x00, 0x38, 0x3C, 0x0F,
  0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x76, 0x00, 0x0E, 0xE0, 0x00, 0xCC, 0x00, 0x18, 0xC0,
  0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x0C, 0x01, 0xC1, 0xC0, 0x38, 0x18,
  0x03, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x38, 0x30, 0x03,
  0x87, 0x00, 0x30, 0x60, 0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0xFC, 0x01, 0xBF, 0xF0, 0x1E, 0x07, 0x81, 0xC0,
  0x38, 0x20, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC4, 0x00, 0x18, 0xE0, 0x03, 0x87,
  0x00, 0x70, 0x78, 0x1E, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x1F, 0x80, 0xDF,
  0xF8, 0x6E, 0x0F, 0x1E, 0x00, 0xEF, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01,
  0xB0, 0x00, 0x7C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0xB0, 0x00, 0xCC,
  0x00, 0x71, 0x80, 0x38, 0x78, 0x3C, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0x80, 0x03, 0xB0, 0x00, 0x66, 0x00, 0x18, 0xC0,
  0x07, 0x38, 0x00, 0xC6, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0x81, 0xE0,
  0xE0, 0x06, 0x0C, 0x00, 0x71, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x07,
  0x18, 0x00, 0x61, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0xF0, 0x38, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x1E, 0x07, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xC6, 0x00,
  0x0C, 0xE0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xE0,
  0x01, 0xC6, 0x00, 0x38, 0x78, 0x0F, 0x03, 0xFF, 0xE0, 0x0F, 0xF0, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x81, 0xE0, 0xF0, 0xE0, 0x0E, 0x70, 0x01, 0x98,
  0x00, 0x6E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x0E, 0xE0, 0x07, 0xB8, 0x03, 0xC7, 0x81, 0xB0, 0xFF, 0xDC,
  0x0F, 0xC6, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x0E, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE3, 0xE7, 0x8F, 0x00, 0x03, 0x83, 0xC1, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x60,
  0x60, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x10, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1C, 0x0E, 0x38, 0x07, 0x70, 0x03,
  0x60, 0x03, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x78, 0x38, 0x38, 0x07, 0x1C, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C,
  0xC0, 0x01, 0x30, 0x3C, 0xD8, 0x3F, 0xB6, 0x0E, 0x1D, 0x86, 0x07, 0x61,
  0x80, 0xD8, 0xC0, 0x3C, 0x30, 0x1B, 0x0C, 0x06, 0xC3, 0x01, 0xB0, 0xC0,
  0x6C, 0x30, 0x1B, 0x0C, 0x0E, 0xC3, 0x07, 0x30, 0xE3, 0xCC, 0x1F, 0xB3,
  0x03, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x01, 0xD8, 0x00, 0x19, 0x80, 0x03, 0x98, 0x00, 0x31, 0x80,
  0x07, 0x18, 0x00, 0x61, 0x80, 0x0E, 0x1C, 0x00, 0xC1, 0xC0, 0x1C, 0x0C,
  0x01, 0x80, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x00,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0x80,
  0x06, 0x38, 0x00, 0x73, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x03, 0xE0,
  0x00, 0x30, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x30, 0x07, 0x06, 0x00, 0x70,
  0xC0, 0x06, 0x18, 0x00, 0xC7, 0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x1C, 0x60, 0x07, 0x0C, 0x01, 0xC3, 0xFF, 0xE0, 0x7F, 0xFE, 0x0C,
  0x00, 0xE1, 0x80, 0x0E, 0x30, 0x00, 0xC6, 0x00, 0x19, 0xC0, 0x03, 0x38,
  0x00, 0x66, 0x00, 0x0C, 0xC0, 0x03, 0x98, 0x00, 0x63, 0x00, 0x1C, 0xE0,
  0x07, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x0E, 0x0F, 0x03, 0x00, 0x60, 0xC0, 0x06, 0x38, 0x00, 0xC6, 0x00, 0x21,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x18, 0xC0, 0x07, 0x18,
  0x01, 0xC3, 0x80, 0x70, 0x3C, 0x1C, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x0E, 0x03, 0xC0, 0xE0, 0x0C, 0x0C, 0x00,
  0xE0, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0xC0, 0x07, 0x1C, 0x00, 0x31, 0xC0,
  0x03, 0x18, 0x00, 0x31, 0x80, 0x07, 0x18, 0x00, 0x71, 0x80, 0x07, 0x38,
  0x00, 0x63, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xE3,
  0x00, 0x0C, 0x70, 0x01, 0xC7, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x70,
  0x60, 0x1E, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1E,
  0x0F, 0x07, 0x00, 0x61, 0xC0, 0x0E, 0x30, 0x00, 0xCE, 0x00, 0x21, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x1F, 0xF6, 0x03, 0xFE, 0xC0, 0x01, 0x98, 0x00,
  0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x39, 0xC0, 0x07, 0x18, 0x01,
  0xC3, 0x80, 0x58, 0x38, 0x3B, 0x07, 0xFE, 0x60, 0x3F, 0x1C, 0x00, 0x0E,
  0x00, 0x38, 0x60, 0x01, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03,
  0x0E, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0,
  0x03, 0x0E, 0x00, 0x18, 0x70, 0x00, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x80, 0x06, 0x18, 0x00,
  0x70, 0xC0, 0x03, 0x86, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x80, 0x06, 0x1C,
  0x00, 0x30, 0xC0, 0x03, 0x86, 0x00, 0x1C, 0x30, 0x00, 0xC0, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x71, 0xC0,
  0x0C, 0x18, 0x03, 0x83, 0x80, 0x70, 0x38, 0x3C, 0x03, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0x30, 0x01, 0xC0, 0x60,
  0x07, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x70, 0x07, 0x01, 0xC0, 0x0E, 0x07,
  0x00, 0x18, 0x1C, 0x00, 0x30, 0x70, 0x00, 0x61, 0xC0, 0x00, 0xC7, 0x00,
  0x03, 0x9E, 0x00, 0x07, 0x7E, 0x00, 0x0D, 0xCC, 0x00, 0x1F, 0x1C, 0x00,
  0x3C, 0x18, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x70, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0xE0,
  0x01, 0x81, 0xC0, 0x03, 0x83, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0x60,
  0x1B, 0x0D, 0x80, 0x7C, 0x36, 0x03, 0x60, 0xD8, 0x19, 0x87, 0x30, 0x66,
  0x18, 0xC3, 0x18, 0x63, 0x1C, 0x61, 0x8C, 0x63, 0x86, 0x1B, 0x0C, 0x18,
  0x6C, 0x30, 0xE1, 0xE0, 0xC3, 0x03, 0x83, 0x0C, 0x0C, 0x0C, 0x30, 0x20,
  0x70, 0xC0, 0x81, 0x83, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x61,
  0x80, 0x01, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x80,
  0x03, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x18, 0x78, 0x01, 0xC3, 0xC0,
  0x0C, 0x1F, 0x00, 0x60, 0xD8, 0x03, 0x0C, 0xC0, 0x18, 0x66, 0x00, 0xC3,
  0x18, 0x0E, 0x18, 0xC0, 0x60, 0xC6, 0x03, 0x0E, 0x38, 0x18, 0x60, 0xC0,
  0xC3, 0x06, 0x06, 0x18, 0x30, 0x70, 0xC1, 0xC3, 0x06, 0x06, 0x18, 0x70,
  0x30, 0xC3, 0x01, 0x86, 0x18, 0x06, 0x30, 0xC0, 0x33, 0x86, 0x01, 0x98,
  0x30, 0x0E, 0xC3, 0x80, 0x36, 0x18, 0x01, 0xB0, 0xC0, 0x0F, 0x86, 0x00,
  0x3C, 0x30, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1E, 0x0E, 0x07,
  0x00, 0xE1, 0xC0, 0x0C, 0x70, 0x01, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x70,
  0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x00,
  0x06, 0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x38, 0x01, 0x83, 0x00,
  0x70, 0x78, 0x3C, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x7F, 0xFF, 0x03, 0x80, 0x3C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00,
  0x1C, 0x30, 0x00, 0xE3, 0x80, 0x07, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x1C, 0x30, 0x01, 0xC1, 0x80, 0x1C, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xE0, 0x1E, 0x0E, 0x07, 0x00, 0xE1, 0xC0, 0x0C, 0x70, 0x01, 0xCC, 0x00,
  0x19, 0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00,
  0xD8, 0x00, 0x3B, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06,
  0x38, 0x01, 0x83, 0x00, 0x70, 0x78, 0x3C, 0x07, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x08, 0x01, 0x83, 0x80, 0x18, 0xE0, 0x03, 0xB8,
  0x00, 0x3E, 0x00, 0x03, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0x80,
  0x3C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x1C, 0x30, 0x00, 0xE3,
  0x80, 0x07, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x1C, 0x30, 0x01,
  0xC1, 0x80, 0x1C, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x06, 0x06, 0x00, 0x30,
  0x38, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xC0,
  0x30, 0x07, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xE0, 0x60, 0x03, 0x07, 0x00,
  0x1C, 0x38, 0x00, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xE0, 0x3C,
  0x1C, 0x00, 0x70, 0xE0, 0x01, 0x86, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x20,
  0x00, 0x33, 0x80, 0x03, 0x8E, 0x00, 0x38, 0x3C, 0x07, 0x80, 0xFF, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x71, 0x80, 0x07, 0x18, 0x00, 0x61, 0x80, 0x06,
  0x38, 0x00, 0x63, 0x80, 0x06, 0x30, 0x00, 0xE3, 0x00, 0x0E, 0x30, 0x00,
  0xC3, 0x00, 0x0C, 0x70, 0x00, 0xC7, 0x00, 0x0C, 0x60, 0x01, 0xC6, 0x00,
  0x1C, 0x60, 0x01, 0x86, 0x00, 0x18, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xC0,
  0x03, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x0E, 0x00, 0x70, 0xE0, 0x06, 0x06,
  0x00, 0xE0, 0x70, 0x3C, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0x60, 0x00, 0xEC, 0x00, 0x19, 0xC0, 0x07,
  0x38, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x30,
  0x30, 0x06, 0x07, 0x01, 0xC0, 0xE0, 0x30, 0x0C, 0x0E, 0x01, 0x81, 0x80,
  0x30, 0x70, 0x06, 0x0C, 0x00, 0xC3, 0x80, 0x1C, 0x60, 0x01, 0x9C, 0x00,
  0x33, 0x00, 0x06, 0xE0, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x0E,
  0x06, 0x30, 0x78, 0x30, 0xC1, 0xE0, 0xC3, 0x07, 0x83, 0x0C, 0x36, 0x0C,
  0x30, 0xD8, 0x61, 0x86, 0x61, 0x86, 0x19, 0x86, 0x18, 0x66, 0x18, 0x63,
  0x18, 0xC1, 0x8C, 0x23, 0x06, 0x60, 0x8C, 0x19, 0x83, 0x30, 0x6C, 0x0D,
  0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x1E, 0x03, 0x60, 0x78, 0x0F, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x03, 0x83, 0x80, 0x03,
  0x00, 0xC0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x18, 0x03, 0x80, 0x0E, 0x03,
  0x80, 0x03, 0x01, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x39,
  0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x18, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x38, 0x00, 0x60,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0x98, 0x00, 0x1C, 0xE0, 0x01, 0xC3, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0xE0,
  0x0C, 0x03, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x86, 0x00,
  0x0C, 0x70, 0x00, 0x67, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x30,
  0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x04,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x07, 0xFF, 0x07,
  0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xB0, 0x00, 0x66, 0x00, 0x18, 0x60, 0x07, 0x0C, 0x00, 0xC1, 0xC0,
  0x30, 0x18, 0x0E, 0x03, 0x03, 0x80, 0x30, 0x60, 0x06, 0x18, 0x00, 0xE7,
  0x00, 0x0D, 0xC0, 0x01, 0xB0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x47, 0x18, 0x63, 0x08, 0x60, 0x01, 0xF8, 0xE0, 0xFF, 0x98, 0x3C, 0x1B,
  0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x60, 0x03, 0x9C, 0x00, 0x73, 0x00, 0x0C,
  0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x70, 0x00, 0xCE, 0x00, 0x39,
  0xC0, 0x06, 0x18, 0x01, 0xC3, 0x00, 0x38, 0x70, 0x0B, 0x07, 0x06, 0x60,
  0xFF, 0x8F, 0x87, 0xE1, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x87, 0xC0, 0x33, 0xFE, 0x0E, 0xC1, 0xE1, 0xF0, 0x0C,
  0x34, 0x01, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x67, 0x00, 0x0C,
  0xC0, 0x01, 0x98, 0x00, 0x73, 0x00, 0x0E, 0x60, 0x01, 0x8C, 0x00, 0x33,
  0x80, 0x0C, 0x70, 0x03, 0x8D, 0x00, 0xE1, 0xB0, 0x38, 0x33, 0xFE, 0x0E,
  0x1F, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0x81, 0xC3, 0x00, 0x63, 0x80,
  0x1B, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x0C,
  0x70, 0x0C, 0x1C, 0x1E, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x1F, 0x86, 0x07, 0xFC,
  0x60, 0xF0, 0x6C, 0x1C, 0x01, 0xC3, 0x80, 0x1C, 0x30, 0x00, 0xC7, 0x00,
  0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0xE0,
  0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x86, 0x00, 0x70, 0x60, 0x07, 0x07,
  0x00, 0xB0, 0x38, 0x33, 0x03, 0xFE, 0x30, 0x0F, 0xC7, 0x00, 0x01, 0xFC,
  0x03, 0xFF, 0x83, 0x81, 0xE3, 0x80, 0x33, 0x00, 0x1B, 0x80, 0x0D, 0x80,
  0x0E, 0xC0, 0x0E, 0xE0, 0x7E, 0x7F, 0xFC, 0x3F, 0xE0, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x13, 0x80, 0x0E, 0xC0, 0x0E, 0x70, 0x0E, 0x1C, 0x0E,
  0x07, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x40, 0x38, 0x00, 0x18, 0x0C, 0x00, 0x0F, 0x03, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x1C, 0x30, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x30, 0x3F, 0xE7, 0x07,
  0x83, 0x70, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0x80, 0x06, 0x38, 0x00, 0x63,
  0x80, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC7, 0x00, 0x0C,
  0x70, 0x00, 0xC7, 0x00, 0x1C, 0x30, 0x03, 0x83, 0x00, 0x38, 0x38, 0x05,
  0x81, 0xC1, 0x98, 0x0F, 0xF1, 0x80, 0x7E, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x60, 0x0E, 0x0F, 0x03, 0xC0, 0x3F,
  0xF8, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x3E, 0x06, 0x7F, 0xC3, 0x20, 0xE3, 0xA0, 0x39, 0xE0, 0x1C, 0xE0, 0x06,
  0x70, 0x03, 0x30, 0x01, 0x98, 0x01, 0xDC, 0x00, 0xCE, 0x00, 0x66, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x0E, 0xE0, 0x06, 0x70, 0x03, 0x30,
  0x01, 0x98, 0x00, 0xCC, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x0E, 0x0E, 0x1C, 0x06, 0x1C, 0x03,
  0x3C, 0x01, 0xB8, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x04, 0x03, 0x07, 0x01, 0x81,
  0xC0, 0xC0, 0x70, 0xE0, 0x1C, 0x60, 0x07, 0x30, 0x01, 0xD8, 0x00, 0x7C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x0F, 0x80, 0x67, 0xFC, 0x1D, 0xC3, 0xC3, 0xE0, 0x38, 0x68, 0x03,
  0x0E, 0x00, 0x61, 0xC0, 0x1C, 0x30, 0x03, 0x0E, 0x00, 0xC1, 0xC0, 0x70,
  0x30, 0x78, 0x06, 0x38, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x1F, 0x06, 0x07,
  0xE0, 0xC1, 0xD8, 0x0C, 0x73, 0x01, 0xDC, 0x60, 0x1F, 0x0C, 0x03, 0x80,
  0x7F, 0xC0, 0x7F, 0xC0, 0x80, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x02, 0x0C, 0x07, 0x0C, 0x0E, 0x0C, 0x1C,
  0x1C, 0x70, 0x1C, 0xE0, 0x19, 0xC0, 0x1F, 0x00, 0x0E, 0x00, 0x19, 0xE0,
  0xF0, 0xDF, 0x9F, 0xC6, 0x8E, 0x8E, 0x38, 0x38, 0x31, 0x81, 0x81, 0x9C,
  0x0C, 0x0C, 0xC0, 0x60, 0x66, 0x06, 0x03, 0x30, 0x30, 0x31, 0x81, 0x81,
  0x8C, 0x0C, 0x0C, 0xC0, 0x60, 0x66, 0x07, 0x03, 0x30, 0x30, 0x19, 0x81,
  0x81, 0x8C, 0x0C, 0x0C, 0x60, 0x60, 0x66, 0x03, 0x03, 0x30, 0x38, 0x19,
  0x81, 0x81, 0xC0, 0x18, 0x7C, 0x0C, 0xFF, 0x86, 0x41, 0xC7, 0x40, 0x73,
  0xC0, 0x39, 0xC0, 0x0C, 0xE0, 0x06, 0x60, 0x03, 0x30, 0x03, 0xB8, 0x01,
  0x9C, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x1D, 0xC0,
  0x0C, 0xE0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0xC0, 0x01, 0xF8,
  0x01, 0xFF, 0x81, 0xE0, 0x70, 0x60, 0x0E, 0x30, 0x01, 0x9C, 0x00, 0x66,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x33, 0x80, 0x1C, 0x60, 0x0E,
  0x1E, 0x0F, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x06, 0x1F, 0x00, 0x67, 0xFC,
  0x0E, 0xC1, 0xE0, 0xD8, 0x06, 0x0D, 0x00, 0x70, 0xE0, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x71, 0x80,
  0x07, 0x18, 0x00, 0x61, 0x80, 0x06, 0x38, 0x00, 0xC3, 0x80, 0x1C, 0x34,
  0x03, 0x83, 0x60, 0x70, 0x33, 0xFE, 0x03, 0x0F, 0x80, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x60, 0xFF, 0x9C, 0x3C, 0x1B,
  0x8E, 0x00, 0xE3, 0x80, 0x1C, 0x60, 0x01, 0x9C, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x01, 0xCC, 0x00, 0x31, 0x80, 0x06, 0x70, 0x00, 0xCE, 0x00, 0x39,
  0xC0, 0x07, 0x18, 0x01, 0xE3, 0x00, 0x38, 0x70, 0x0B, 0x07, 0x06, 0x60,
  0xFF, 0x8C, 0x07, 0xE3, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x7F, 0x87, 0xFF, 0xF3, 0xFC, 0x0E, 0xC0, 0x01, 0xA0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3C, 0x0F, 0x0E, 0x00, 0x71, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x62,
  0x00, 0x0C, 0xE0, 0x03, 0x8F, 0x01, 0xE0, 0xFF, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x02, 0x06, 0x03, 0x83,
  0x83, 0xC0, 0xC1, 0xC0, 0x31, 0xE0, 0x0D, 0xE0, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0x18, 0x01, 0xCE, 0x00, 0x63, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x01,
  0x8C, 0x00, 0x63, 0x00, 0x39, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x1C, 0x60, 0x07, 0x38, 0x01, 0x8E, 0x00, 0xE1, 0x80,
  0x58, 0x60, 0x36, 0x1C, 0x1B, 0x83, 0xFC, 0xE0, 0x7C, 0x30, 0xFE, 0x01,
  0xBF, 0x80, 0x60, 0xC0, 0x1C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x07, 0x1C, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x0E, 0x18, 0x03, 0x06, 0x01, 0x81, 0x80, 0xE0, 0xC0, 0x70, 0x30, 0x78,
  0x0C, 0x7C, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x18, 0x18, 0x63, 0x01, 0x87,
  0x30, 0x30, 0x33, 0x03, 0x03, 0x30, 0x30, 0x33, 0x03, 0x03, 0x30, 0x30,
  0x36, 0x03, 0x03, 0x60, 0x60, 0x36, 0x06, 0x03, 0x60, 0x60, 0x36, 0x06,
  0x07, 0x60, 0x60, 0x6C, 0x0C, 0x06, 0xC0, 0xC0, 0xEC, 0x14, 0x0C, 0xC1,
  0x41, 0xCE, 0x26, 0x38, 0x7E, 0x7F, 0x03, 0xC3, 0xE0, 0x03, 0xC0, 0xF0,
  0x1F, 0x8F, 0xE1, 0xE6, 0x71, 0xCE, 0x19, 0x83, 0x70, 0x6C, 0x0D, 0x00,
  0xA0, 0x30, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x01, 0xC0, 0x0C,
  0x0B, 0x01, 0x30, 0x2C, 0x1E, 0xC1, 0xB0, 0xE3, 0x0C, 0x6F, 0x0F, 0xE1,
  0xF0, 0x1F, 0x03, 0x80, 0x06, 0x00, 0x70, 0x60, 0x06, 0x0E, 0x00, 0x60,
  0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xE1, 0xC0, 0x0C,
  0x1C, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x18, 0x01,
  0xC1, 0x80, 0x18, 0x18, 0x03, 0x81, 0x80, 0x58, 0x18, 0x05, 0x81, 0xC1,
  0xB8, 0x0F, 0xF3, 0x80, 0x7E, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x40, 0x0E, 0x0F, 0x03, 0xC0, 0x3F, 0xF8, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x70, 0xFF, 0xE6, 0x1C, 0x1F, 0xE3, 0x80, 0x3E,
  0x30, 0x01, 0xC3, 0x00, 0x38, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x01, 0x80, 0xE0,
  0x18, 0x1C, 0x01, 0x83, 0x00, 0x18, 0xFF, 0x00, 0xCF, 0xFF, 0x8C, 0xC1,
  0xFF, 0xCC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x03, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0x03, 0x03, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0x0F, 0x00, 0x31, 0xF8, 0x03, 0x39, 0xC0, 0x63, 0x0E, 0x06, 0x60,
  0x70, 0xC6, 0x03, 0x9C, 0xC0, 0x1F, 0x8C, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_LightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 8, 27, 23, 8, -27 },
  { 28, 10, 10, 23, 9, -29 },
  { 41, 23, 27, 23, 1, -27 },
  { 119, 22, 35, 23, 1, -31 },
  { 216, 26, 27, 23, -1, -27 },
  { 304, 23, 27, 23, 0, -27 },
  { 382, 4, 10, 23, 12, -29 },
  { 387, 14, 35, 23, 8, -30 },
  { 449, 14, 35, 23, 2, -30 },
  { 511, 20, 19, 23, 2, -21 },
  { 559, 18, 20, 23, 3, -22 },
  { 604, 7, 10, 23, 6, -4 },
  { 613, 12, 2, 23, 6, -13 },
  { 616, 5, 4, 23, 8, -4 },
  { 619, 22, 35, 23, 1, -30 },
  { 716, 19, 27, 23, 3, -27 },
  { 781, 18, 27, 23, 2, -27 },
  { 842, 20, 27, 23, 1, -27 },
  { 910, 20, 27, 23, 1, -27 },
  { 978, 20, 27, 23, 1, -27 },
  { 1046, 20, 27, 23, 2, -27 },
  { 1114, 18, 27, 23, 3, -27 },
  { 1175, 19, 27, 23, 4, -27 },
  { 1240, 20, 27, 23, 2, -27 },
  { 1308, 18, 27, 23, 4, -27 },
  { 1369, 7, 21, 23, 8, -21 },
  { 1388, 9, 27, 23, 6, -21 },
  { 1419, 19, 22, 23, 3, -23 },
  { 1472, 20, 10, 23, 2, -17 },
  { 1497, 19, 22, 23, 2, -23 },
  { 1550, 16, 27, 23, 5, -27 },
  { 1604, 18, 31, 23, 3, -27 },
  { 1674, 20, 27, 23, 0, -27 },
  { 1742, 19, 27, 23, 2, -27 },
  { 1807, 19, 27, 23, 3, -27 },
  { 1872, 20, 27, 23, 2, -27 },
  { 1940, 21, 27, 23, 2, -27 },
  { 2011, 21, 27, 23, 2, -27 },
  { 2082, 19, 27, 23, 3, -27 },
  { 2147, 21, 27, 23, 2, -27 },
  { 2218, 21, 27, 23, 2, -27 },
  { 2289, 19, 27, 23, 2, -27 },
  { 2354, 23, 27, 23, 2, -27 },
  { 2432, 16, 27, 23, 3, -27 },
  { 2486, 22, 27, 23, 1, -27 },
  { 2561, 21, 27, 23, 2, -27 },
  { 2632, 19, 27, 23, 3, -27 },
  { 2697, 21, 27, 23, 2, -27 },
  { 2768, 19, 34, 23, 3, -27 },
  { 2849, 21, 27, 23, 2, -27 },
  { 2920, 21, 27, 23, 1, -27 },
  { 2991, 21, 27, 23, 4, -27 },
  { 3062, 20, 27, 23, 3, -27 },
  { 3130, 19, 27, 23, 5, -27 },
  { 3195, 22, 27, 23, 2, -27 },
  { 3270, 25, 27, 23, 0, -27 },
  { 3355, 21, 27, 23, 4, -27 },
  { 3426, 24, 27, 23, 0, -27 },
  { 3507, 16, 35, 23, 7, -30 },
  { 3577, 10, 35, 23, 7, -30 },
  { 3621, 16, 35, 23, 1, -30 },
  { 3691, 19, 15, 23, 3, -27 },
  { 3727, 19, 2, 23, 0, 4 },
  { 3732, 5, 7, 23, 9, -30 },
  { 3737, 19, 20, 23, 2, -20 },
  { 3785, 19, 29, 23, 2, -29 },
  { 3854, 17, 20, 23, 3, -20 },
  { 3897, 20, 29, 23, 2, -29 },
  { 3970, 17, 20, 23, 3, -20 },
  { 4013, 26, 37, 23, -1, -29 },
  { 4134, 20, 28, 23, 1, -20 },
  { 4204, 17, 29, 23, 3, -29 },
  { 4266, 17, 29, 23, 3, -29 },
  { 4328, 17, 37, 23, 3, -29 },
  { 4407, 19, 29, 23, 3, -29 },
  { 4476, 16, 29, 23, 4, -29 },
  { 4534, 21, 20, 23, 1, -20 },
  { 4587, 17, 20, 23, 3, -20 },
  { 4630, 18, 20, 23, 3, -20 },
  { 4675, 20, 28, 23, 1, -20 },
  { 4745, 19, 28, 23, 2, -20 },
  { 4812, 19, 20, 23, 4, -20 },
  { 4860, 19, 20, 23, 2, -20 },
  { 4908, 18, 27, 23, 3, -27 },
  { 4969, 18, 20, 23, 3, -20 },
  { 5014, 18, 20, 23, 3, -20 },
  { 5059, 20, 20, 23, 2, -20 },
  { 5109, 22, 20, 23, 1, -20 },
  { 5164, 20, 28, 23, 1, -20 },
  { 5234, 20, 20, 23, 2, -20 },
  { 5284, 17, 35, 23, 5, -30 },
  { 5359, 8, 35, 23, 8, -30 },
  { 5394, 18, 35, 23, 2, -30 },
  { 5473, 20, 8, 23, 2, -16 },
};

const GFXfont IBMPlexMono_LightItalic39pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic39pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _IBMPLEXMONO_LIGHTITALIC39PT7B_H_
