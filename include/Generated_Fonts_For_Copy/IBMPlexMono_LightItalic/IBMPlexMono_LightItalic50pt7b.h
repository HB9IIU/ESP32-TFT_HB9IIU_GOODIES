#ifndef _IBMPLEXMONO_LIGHTITALIC50PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC1, 0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x38, 0x37, 0x07,
  0x70, 0x77, 0x07, 0x70, 0x77, 0x06, 0x60, 0x6E, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE0, 0xEE, 0x0C, 0xC1, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0xC0, 0xE0, 0x03, 0xFF,
  0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0x81,
  0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x60, 0x03,
  0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x01,
  0x80, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xF8, 0xCF,
  0xC0, 0x3C, 0x0C, 0x1E, 0x03, 0x80, 0xC0, 0xF0, 0x70, 0x1C, 0x06, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0xF0, 0x18,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x78, 0x30, 0x00, 0x03, 0xE3, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x63, 0xE0,
  0x00, 0x06, 0x0F, 0x00, 0x00, 0x60, 0x78, 0x00, 0x06, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0xC0, 0x38, 0x20, 0x0C, 0x07, 0x87, 0x01, 0xC0, 0x70, 0xF8,
  0x1C, 0x0F, 0x03, 0xC1, 0x81, 0xE0, 0x1F, 0x98, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x70, 0x1F,
  0xFC, 0x00, 0x38, 0x0F, 0x07, 0x80, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x18, 0x01, 0x80, 0xE0,
  0x06, 0x00, 0x60, 0x30, 0x03, 0x80, 0x38, 0x18, 0x00, 0xE0, 0x0E, 0x0E,
  0x00, 0x18, 0x03, 0x07, 0x00, 0x06, 0x01, 0xC1, 0x80, 0x01, 0xE1, 0xE0,
  0xE0, 0x00, 0x3F, 0xF0, 0x70, 0x00, 0x0F, 0xF8, 0x38, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0E, 0x1F, 0xFC, 0x00,
  0x03, 0x0F, 0x07, 0x00, 0x01, 0xC3, 0x80, 0xE0, 0x00, 0xE1, 0xC0, 0x18,
  0x00, 0x30, 0x70, 0x06, 0x00, 0x18, 0x18, 0x01, 0x80, 0x0E, 0x06, 0x00,
  0x60, 0x07, 0x03, 0x80, 0x38, 0x01, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x38,
  0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x70, 0x0C, 0x00,
  0x70, 0x78, 0x07, 0x00, 0x0F, 0xFC, 0x03, 0x80, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x70,
  0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x18, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x30, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x78, 0x78, 0x00, 0x1F, 0xEF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x2E, 0x00, 0x0E,
  0x01, 0xF0, 0x00, 0xF8, 0x1D, 0xC0, 0x05, 0xE1, 0xCE, 0x00, 0x67, 0x0E,
  0x78, 0x07, 0x3C, 0xE1, 0xE0, 0x70, 0xE7, 0x0F, 0xFF, 0x83, 0xF0, 0x1F,
  0xF8, 0x1F, 0x00, 0x7F, 0x00, 0x70, 0x00, 0x19, 0xCE, 0x73, 0x98, 0xCE,
  0x73, 0x9C, 0xCE, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x40, 0x0C, 0x01, 0xFC, 0x06, 0x07, 0xDF,
  0xC7, 0x1F, 0xE3, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x03, 0x80, 0x70, 0x00, 0xC0, 0x10, 0x00, 0x40, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70,
  0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x60, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xF0, 0x3D, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x3C, 0x00, 0xF0,
  0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x1E,
  0x03, 0xB8, 0x0F, 0x01, 0xDC, 0x0F, 0x80, 0xEE, 0x07, 0xC0, 0xF7, 0x01,
  0xC0, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x87,
  0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xE0,
  0x3C, 0x01, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x3E, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0xF8, 0xC0, 0x01, 0xF1,
  0xC0, 0x03, 0xE1, 0xC0, 0x0F, 0x81, 0xC0, 0x1F, 0x01, 0xC0, 0x0E, 0x01,
  0xC0, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3E,
  0x07, 0xE0, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x1E,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x07, 0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x1C, 0x00, 0x0E, 0x04, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE2, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x70, 0x78, 0x00,
  0xF8, 0x1F, 0x01, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x80,
  0x07, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x00,
  0x07, 0x01, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x61, 0xFC, 0x00, 0x33, 0xFF, 0x80, 0x3B, 0xFF, 0xE0, 0x1F, 0x80,
  0xF8, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x84,
  0x00, 0x03, 0xC7, 0x00, 0x01, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0x7E, 0x03, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC3, 0xF0, 0x07, 0x1F, 0xFC, 0x0E, 0xFF, 0xFC, 0x3B,
  0xC0, 0xFC, 0x7E, 0x00, 0x78, 0xD0, 0x00, 0x7B, 0xC0, 0x00, 0x77, 0x80,
  0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xE7, 0x00, 0x01,
  0xCE, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x3E, 0x03, 0xE0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC6, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x60, 0x00,
  0x38, 0x30, 0x00, 0x38, 0x20, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xE0, 0x3E,
  0x03, 0xC0, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x06, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0xF0,
  0x0F, 0x80, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0x01, 0xF0, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x71, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x0F, 0xC0,
  0x7E, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0xC1,
  0xE0, 0x03, 0x87, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0xE0, 0x00,
  0x3D, 0xE0, 0x00, 0xB1, 0xE0, 0x07, 0xE3, 0xF0, 0x3D, 0xC3, 0xFF, 0xF7,
  0x03, 0xFF, 0x8E, 0x01, 0xFC, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x83, 0xF0, 0xFC,
  0x3E, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07,
  0xC3, 0xF0, 0xFC, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x10, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xF0, 0x3E, 0x07, 0xC3, 0xC0, 0x0F, 0x3C, 0x00, 0x39, 0xC0, 0x01,
  0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC7, 0x00, 0xF8, 0xC3, 0x81, 0xFE, 0x61, 0x81, 0xFF, 0xB0, 0xC0, 0xF0,
  0xD8, 0xE0, 0xE0, 0x3C, 0x70, 0x70, 0x0E, 0x38, 0x70, 0x07, 0x18, 0x38,
  0x03, 0x9C, 0x18, 0x01, 0x8E, 0x0C, 0x00, 0xC7, 0x0E, 0x00, 0xE3, 0x87,
  0x00, 0x71, 0xC3, 0x80, 0x38, 0xC1, 0xC0, 0x1C, 0x60, 0xE0, 0x1C, 0x30,
  0x70, 0x0E, 0x38, 0x38, 0x0F, 0x1C, 0x1C, 0x0F, 0x8E, 0x07, 0x8D, 0xC7,
  0x03, 0xFE, 0xE3, 0x80, 0xFE, 0x61, 0xC0, 0x1C, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x0E, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E,
  0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x1C, 0x01, 0xC0,
  0x07, 0x00, 0xF0, 0x01, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x03, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0x00, 0x1E, 0x07,
  0x00, 0x0F, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x38, 0x00, 0x78, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x01, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x3C, 0x00, 0xE0,
  0x3C, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x1E, 0x00, 0x02,
  0x8E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x0E,
  0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0x3C, 0x01, 0xE0, 0x1F, 0x81, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0xE0, 0x0F, 0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x1C,
  0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03,
  0xC7, 0x00, 0x01, 0xE3, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x18, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0x83, 0x80,
  0x03, 0xC1, 0xC0, 0x07, 0xC0, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xF0, 0x3C, 0x07, 0xC0, 0x1E, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x02, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x0F, 0xFE, 0xE0, 0x0F, 0xFC, 0xE0, 0x0F, 0xFC, 0xE0, 0x10,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0x70, 0x00, 0xB8, 0x78, 0x01, 0xB0, 0x3E, 0x07, 0x70, 0x1F, 0xFE,
  0x70, 0x0F, 0xFC, 0x70, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xF0, 0x00,
  0x1C, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0E,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x20, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x70,
  0x01, 0xE0, 0x78, 0x03, 0xC0, 0x3C, 0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x07,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x38, 0x0F, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03,
  0x8F, 0x80, 0x00, 0x1C, 0xFC, 0x00, 0x01, 0xCF, 0x70, 0x00, 0x0E, 0xF3,
  0x80, 0x00, 0x7F, 0x1E, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x06, 0xC0,
  0x07, 0xE0, 0xEE, 0x00, 0x6E, 0x0E, 0xE0, 0x0E, 0xE0, 0xEE, 0x01, 0xCE,
  0x0E, 0x60, 0x1C, 0xC0, 0xE7, 0x03, 0x8C, 0x0C, 0x70, 0x31, 0xC1, 0xC3,
  0x07, 0x1C, 0x1C, 0x30, 0xE1, 0xC1, 0xC3, 0x8E, 0x1C, 0x1C, 0x39, 0xC1,
  0x81, 0xC1, 0x98, 0x18, 0x18, 0x1B, 0x83, 0x83, 0x81, 0xF0, 0x38, 0x38,
  0x1F, 0x03, 0x83, 0x80, 0xE0, 0x38, 0x38, 0x0C, 0x03, 0x03, 0x80, 0xC0,
  0x30, 0x30, 0x08, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x7C, 0x00, 0x1C, 0x0F, 0x80, 0x03, 0x83, 0xB0, 0x00,
  0x70, 0x77, 0x00, 0x0E, 0x0E, 0xE0, 0x01, 0x81, 0xDC, 0x00, 0x70, 0x39,
  0x80, 0x0E, 0x06, 0x38, 0x01, 0xC1, 0xC7, 0x00, 0x38, 0x38, 0xE0, 0x07,
  0x07, 0x0C, 0x00, 0xC0, 0xE1, 0xC0, 0x38, 0x1C, 0x38, 0x07, 0x03, 0x03,
  0x00, 0xE0, 0xE0, 0x70, 0x1C, 0x1C, 0x0E, 0x03, 0x83, 0x81, 0xC0, 0x60,
  0x70, 0x18, 0x1C, 0x0E, 0x03, 0x83, 0x81, 0x80, 0x70, 0x70, 0x70, 0x0E,
  0x0E, 0x0E, 0x00, 0xE1, 0xC1, 0xC0, 0x1C, 0x30, 0x38, 0x03, 0x8E, 0x07,
  0x00, 0x31, 0xC0, 0xC0, 0x07, 0x38, 0x38, 0x00, 0xE7, 0x07, 0x00, 0x1C,
  0xE0, 0xE0, 0x01, 0x98, 0x1C, 0x00, 0x3F, 0x03, 0x80, 0x07, 0xE0, 0x60,
  0x00, 0x7C, 0x1C, 0x00, 0x0F, 0x83, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x3C,
  0x00, 0xF0, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1C, 0x00, 0x3E, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x1C, 0x00,
  0x3E, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x07,
  0xC0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03,
  0x9C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xC0, 0x20, 0x00,
  0xE0, 0x18, 0x00, 0x38, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xBC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1C, 0x00, 0x3E, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0F,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00,
  0x3C, 0x1C, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00,
  0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x0E, 0x00,
  0x0F, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x82, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x07, 0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E,
  0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x03,
  0x80, 0xE0, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x0F, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x07, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x0F, 0x01, 0xC3, 0x00, 0xF0,
  0x1C, 0x30, 0x1F, 0x01, 0x83, 0x01, 0xB0, 0x38, 0x30, 0x3B, 0x03, 0x83,
  0x03, 0x30, 0x38, 0x70, 0x73, 0x03, 0x07, 0x07, 0x30, 0x70, 0x70, 0x63,
  0x07, 0x07, 0x0E, 0x30, 0x70, 0x70, 0xC3, 0x86, 0x07, 0x1C, 0x38, 0xE0,
  0x71, 0xC3, 0x8E, 0x06, 0x18, 0x38, 0xE0, 0x63, 0x83, 0x8C, 0x06, 0x30,
  0x19, 0xC0, 0x67, 0x01, 0x9C, 0x06, 0x70, 0x19, 0x80, 0x66, 0x01, 0x98,
  0x0E, 0xE0, 0x1B, 0x80, 0xEC, 0x01, 0xB8, 0x0F, 0xC0, 0x1B, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0x38, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x70, 0x1E, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x39, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0x70,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x40, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x63, 0x8E, 0x1C, 0x70, 0xE3, 0x86,
  0x1C, 0x00, 0x7E, 0x07, 0x01, 0xFF, 0x86, 0x07, 0xFF, 0xCE, 0x0F, 0xC0,
  0xEE, 0x0F, 0x00, 0x2E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0xF0, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0xF0, 0x70, 0x01, 0xF0, 0x78, 0x03, 0x70, 0x3C, 0x0E,
  0x7F, 0x3F, 0xFC, 0x7E, 0x1F, 0xF8, 0x3E, 0x07, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x07, 0xE0, 0x0E, 0x1F,
  0xF8, 0x0E, 0x7F, 0xFC, 0x0E, 0x70, 0x3C, 0x0E, 0xC0, 0x1E, 0x0F, 0x80,
  0x0E, 0x1D, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00,
  0x07, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30, 0x00,
  0x0E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0x7C, 0x00, 0xF0, 0x67, 0x03, 0xE0, 0xE3, 0xFF, 0xC0, 0xE1, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE,
  0x03, 0xF0, 0x3C, 0x0E, 0x00, 0x78, 0x70, 0x00, 0xE3, 0x80, 0x01, 0x8E,
  0x00, 0x01, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x8E, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0xE0,
  0x00, 0xF1, 0xC0, 0x07, 0x87, 0x80, 0x3C, 0x0F, 0x83, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x01, 0xF8, 0x1C, 0x01, 0xFF,
  0x87, 0x00, 0xFF, 0xF1, 0x80, 0x7C, 0x0E, 0x60, 0x3C, 0x00, 0xF8, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30,
  0x70, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x83,
  0xC0, 0x02, 0xC0, 0x70, 0x01, 0xF0, 0x1E, 0x00, 0xDC, 0x03, 0xC0, 0xE7,
  0x00, 0xFF, 0xF9, 0xC0, 0x1F, 0xF8, 0x70, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xF0, 0x1E, 0x0F, 0x00,
  0x3C, 0x70, 0x00, 0x73, 0x80, 0x01, 0xCC, 0x00, 0x07, 0x70, 0x00, 0x1D,
  0xC0, 0x01, 0xE6, 0x00, 0x1F, 0xB8, 0x0F, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xF8, 0x0F, 0xFC, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x01, 0x38, 0x00, 0x0E, 0xF0, 0x00, 0x71, 0xC0, 0x03, 0xC7,
  0x80, 0x1E, 0x0F, 0x81, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x03, 0x80,
  0x7F, 0xE1, 0xC0, 0xFF, 0xF8, 0xC0, 0xFC, 0x0E, 0x60, 0x78, 0x01, 0xF0,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x06,
  0x1C, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x83, 0x80,
  0x0D, 0x81, 0xE0, 0x0D, 0xC0, 0x78, 0x1E, 0xE0, 0x3F, 0xFE, 0x70, 0x0F,
  0xFE, 0x38, 0x01, 0xFC, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x80, 0x03, 0xC0,
  0xE0, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x3F, 0x00, 0x61, 0xFF, 0x01, 0xC7, 0xFF, 0x03, 0x9C, 0x1F, 0x07,
  0x60, 0x0E, 0x0E, 0x80, 0x1C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0xF0,
  0x00, 0x61, 0xC0, 0x00, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x61, 0xC0, 0x01,
  0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x30, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x8E,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x02, 0x01, 0xC0, 0x18, 0x07,
  0x00, 0xF0, 0x1C, 0x07, 0x80, 0x70, 0x7C, 0x01, 0x83, 0xC0, 0x0E, 0x1E,
  0x00, 0x39, 0xF0, 0x00, 0xEF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x01, 0x00, 0x18, 0x06,
  0x00, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0E, 0x00, 0xF0, 0x38, 0x01, 0xE0,
  0xE0, 0x03, 0xC3, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x70, 0x00, 0x1F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x1F, 0x80, 0x0E, 0x1F, 0xF8,
  0x03, 0x8F, 0xFF, 0x00, 0xE7, 0x03, 0xC0, 0x3B, 0x00, 0x70, 0x0F, 0x80,
  0x0E, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x30, 0x1C,
  0x00, 0x1C, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x07, 0x80,
  0x38, 0x07, 0xC0, 0x0E, 0x1F, 0xC0, 0x03, 0x8F, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0x30, 0x01, 0x0C, 0x0E, 0x00, 0x67, 0x01, 0xC0, 0x3D, 0xC0,
  0x70, 0x3C, 0x70, 0x0E, 0x1E, 0x1C, 0x03, 0x8F, 0x07, 0x00, 0x77, 0x81,
  0x80, 0x1F, 0xC0, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x40, 0x60, 0x06, 0x0E, 0x01, 0xF0, 0xE0,
  0x3C, 0x0E, 0x07, 0x80, 0xC1, 0xF0, 0x0C, 0x3C, 0x01, 0xC7, 0x80, 0x1D,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x3E, 0x07,
  0x81, 0xCF, 0xE3, 0xF8, 0x3B, 0xFC, 0xFF, 0x87, 0xC3, 0xB8, 0x70, 0xF0,
  0x3E, 0x0E, 0x1C, 0x07, 0x80, 0xC7, 0x80, 0xE0, 0x18, 0xE0, 0x1C, 0x03,
  0x1C, 0x03, 0x80, 0xE3, 0x80, 0x60, 0x1C, 0x70, 0x1C, 0x03, 0x8C, 0x03,
  0x80, 0x63, 0x80, 0x70, 0x0C, 0x70, 0x0E, 0x01, 0x8E, 0x01, 0x80, 0x71,
  0xC0, 0x30, 0x0E, 0x30, 0x0E, 0x01, 0xC6, 0x01, 0xC0, 0x31, 0xC0, 0x38,
  0x06, 0x38, 0x07, 0x01, 0xC7, 0x00, 0xC0, 0x38, 0xE0, 0x18, 0x07, 0x18,
  0x07, 0x00, 0xE3, 0x00, 0xE0, 0x18, 0xE0, 0x1C, 0x03, 0x1C, 0x03, 0x80,
  0xE0, 0x07, 0x07, 0xE0, 0x0C, 0x3F, 0xE0, 0x38, 0xFF, 0xE0, 0x73, 0x83,
  0xE0, 0xEC, 0x01, 0xC1, 0xD0, 0x03, 0x83, 0xC0, 0x07, 0x87, 0x80, 0x07,
  0x1E, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1,
  0xC0, 0x01, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x38,
  0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0x80, 0x01, 0xC7, 0x00,
  0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00,
  0x71, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF,
  0x03, 0xE0, 0x3C, 0x1E, 0x00, 0x78, 0x70, 0x00, 0xF3, 0x80, 0x01, 0xDE,
  0x00, 0x07, 0x70, 0x00, 0x0D, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xEC, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xE0,
  0x00, 0x73, 0xC0, 0x03, 0x87, 0x80, 0x1E, 0x0F, 0x01, 0xF0, 0x3F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x81, 0xF8, 0x00, 0xE1,
  0xFF, 0x80, 0x39, 0xFF, 0xF0, 0x0E, 0x70, 0x3C, 0x03, 0xB0, 0x07, 0x80,
  0xF8, 0x00, 0xE0, 0x74, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0x83, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0x67, 0x03,
  0xE0, 0x38, 0xFF, 0xF0, 0x0E, 0x1F, 0xF8, 0x03, 0x81, 0xF8, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x07, 0x01, 0xFF, 0x87, 0x03, 0xFF,
  0xC6, 0x07, 0xC0, 0xE6, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x78, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0xB0, 0x70, 0x01, 0xF0, 0x78, 0x03,
  0x70, 0x3C, 0x0E, 0x70, 0x3F, 0xFE, 0x70, 0x1F, 0xF8, 0x70, 0x07, 0xF0,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0xC7,
  0xFE, 0x01, 0xCE, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xD0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0x7E, 0x0F, 0x00,
  0x0F, 0x0E, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x40, 0x00,
  0x1C, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0x7E, 0x01, 0xF0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x10, 0x0E, 0x00,
  0xF0, 0x18, 0x03, 0xE0, 0x70, 0x1F, 0x00, 0xE0, 0x7C, 0x01, 0xC3, 0xE0,
  0x03, 0x8F, 0x80, 0x07, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70,
  0xE0, 0x00, 0xE1, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xC0, 0x00, 0xE1, 0x80,
  0x01, 0xC7, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x60, 0x00, 0x70, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x0F,
  0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x5C, 0x1C, 0x01, 0x38, 0x3E, 0x0E, 0x70,
  0x3F, 0xF8, 0xC0, 0x3F, 0xE3, 0x80, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x0D,
  0xFE, 0x00, 0x3B, 0xFC, 0x00, 0x70, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x0C,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x38, 0x01,
  0xE0, 0x70, 0x07, 0x80, 0xE0, 0x1E, 0x01, 0x80, 0x78, 0x03, 0x03, 0xE0,
  0x06, 0x1F, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x1C, 0x07, 0x03, 0x0C, 0x03, 0x83, 0x86, 0x01, 0xC0, 0xE7, 0x00, 0xC0,
  0x73, 0x80, 0x60, 0x19, 0xC0, 0x30, 0x0C, 0xE0, 0x38, 0x06, 0x60, 0x1C,
  0x03, 0x30, 0x0E, 0x01, 0xB8, 0x06, 0x00, 0xDC, 0x03, 0x00, 0x6E, 0x03,
  0x80, 0x37, 0x01, 0xC0, 0x3B, 0x00, 0xE0, 0x1D, 0x80, 0x70, 0x0E, 0xC0,
  0x30, 0x07, 0xE0, 0x18, 0x03, 0x70, 0x1C, 0x03, 0xB8, 0x0E, 0x01, 0xD8,
  0x07, 0x00, 0xEC, 0x07, 0x80, 0xE6, 0x02, 0xC0, 0xF3, 0x83, 0x60, 0x71,
  0xC3, 0x38, 0xF8, 0xFF, 0x9F, 0xF8, 0x3F, 0x87, 0xF8, 0x0F, 0x81, 0xF0,
  0x00, 0x00, 0x70, 0x07, 0xC0, 0x1F, 0x81, 0xFE, 0x03, 0xFC, 0x3F, 0xE0,
  0x7D, 0xC7, 0x8F, 0x1F, 0x0E, 0x60, 0x73, 0xC0, 0xEE, 0x03, 0x70, 0x0E,
  0xC0, 0x34, 0x00, 0x68, 0x03, 0x00, 0x07, 0x80, 0x30, 0x00, 0x78, 0x03,
  0x00, 0x07, 0x00, 0x40, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x1E, 0x00, 0x0C, 0x01, 0x70, 0x04, 0xC0,
  0x37, 0x01, 0xCC, 0x03, 0x70, 0x3E, 0xE0, 0x63, 0x0F, 0x0F, 0x1E, 0x3B,
  0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0x1F, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0xE0, 0x60, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x18, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x00, 0x03, 0x83, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38,
  0x00, 0x38, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x1E, 0x06, 0x00, 0x1E, 0x03,
  0x80, 0x0F, 0x01, 0xC0, 0x0F, 0x80, 0xF0, 0x0D, 0xC0, 0x7C, 0x1C, 0xE0,
  0x1F, 0xFC, 0x70, 0x07, 0xFC, 0x38, 0x01, 0xFC, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x80, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x03, 0x83,
  0xFF, 0xC1, 0x83, 0xFF, 0xFD, 0xC3, 0xC0, 0xFF, 0xE1, 0xC0, 0x0F, 0xF1,
  0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x38, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x18, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x03, 0x83, 0x80,
  0x01, 0xC3, 0xF8, 0x00, 0xE3, 0xFF, 0xC0, 0x31, 0xC7, 0xFF, 0x18, 0xE0,
  0x3F, 0xFC, 0x60, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xC1, 0xFC, 0x00, 0x30, 0xFF, 0x80, 0x1C,
  0x78, 0xF0, 0x06, 0x1C, 0x1C, 0x03, 0x8E, 0x03, 0x80, 0xE3, 0x00, 0xF0,
  0x71, 0xC0, 0x1E, 0x38, 0x70, 0x03, 0xFE, 0x18, 0x00, 0x7F, 0x0E, 0x00,
  0x0F, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 10, 35, 30, 10, -35 },
  { 45, 12, 13, 30, 12, -37 },
  { 65, 30, 35, 30, 1, -35 },
  { 197, 28, 47, 30, 1, -41 },
  { 362, 34, 37, 30, -1, -36 },
  { 520, 29, 37, 30, 0, -36 },
  { 655, 5, 13, 30, 15, -37 },
  { 664, 17, 45, 30, 11, -38 },
  { 760, 17, 45, 30, 3, -38 },
  { 856, 25, 25, 30, 3, -27 },
  { 935, 24, 25, 30, 3, -28 },
  { 1010, 10, 14, 30, 7, -6 },
  { 1028, 15, 3, 30, 8, -17 },
  { 1034, 6, 5, 30, 10, -5 },
  { 1038, 28, 45, 30, 1, -38 },
  { 1196, 25, 37, 30, 3, -36 },
  { 1312, 24, 35, 30, 2, -35 },
  { 1417, 25, 36, 30, 2, -36 },
  { 1530, 25, 37, 30, 2, -36 },
  { 1646, 26, 35, 30, 1, -35 },
  { 1760, 25, 36, 30, 3, -35 },
  { 1873, 23, 36, 30, 3, -35 },
  { 1977, 25, 35, 30, 5, -35 },
  { 2087, 26, 37, 30, 2, -36 },
  { 2208, 23, 36, 30, 5, -36 },
  { 2312, 10, 26, 30, 10, -26 },
  { 2345, 13, 34, 30, 7, -26 },
  { 2401, 24, 28, 30, 4, -29 },
  { 2485, 25, 13, 30, 3, -22 },
  { 2526, 24, 28, 30, 2, -29 },
  { 2610, 21, 36, 30, 7, -36 },
  { 2705, 25, 42, 30, 3, -36 },
  { 2837, 26, 35, 30, 0, -35 },
  { 2951, 24, 35, 30, 3, -35 },
  { 3056, 25, 37, 30, 4, -36 },
  { 3172, 25, 35, 30, 3, -35 },
  { 3282, 27, 35, 30, 3, -35 },
  { 3401, 27, 35, 30, 3, -35 },
  { 3520, 24, 37, 30, 4, -36 },
  { 3631, 27, 35, 30, 2, -35 },
  { 3750, 27, 35, 30, 2, -35 },
  { 3869, 24, 36, 30, 3, -35 },
  { 3977, 29, 35, 30, 3, -35 },
  { 4104, 21, 35, 30, 4, -35 },
  { 4196, 28, 35, 30, 2, -35 },
  { 4319, 27, 35, 30, 2, -35 },
  { 4438, 25, 37, 30, 3, -36 },
  { 4554, 26, 35, 30, 3, -35 },
  { 4668, 25, 45, 30, 3, -36 },
  { 4809, 26, 35, 30, 3, -35 },
  { 4923, 28, 37, 30, 1, -36 },
  { 5053, 27, 35, 30, 5, -35 },
  { 5172, 25, 36, 30, 4, -35 },
  { 5285, 25, 35, 30, 6, -35 },
  { 5395, 28, 35, 30, 3, -35 },
  { 5518, 32, 35, 30, 0, -35 },
  { 5658, 28, 35, 30, 5, -35 },
  { 5781, 30, 35, 30, 0, -35 },
  { 5913, 20, 45, 30, 9, -38 },
  { 6026, 13, 45, 30, 9, -38 },
  { 6100, 20, 45, 30, 1, -38 },
  { 6213, 24, 20, 30, 4, -35 },
  { 6273, 24, 3, 30, 0, 5 },
  { 6282, 6, 9, 30, 12, -39 },
  { 6289, 24, 27, 30, 3, -26 },
  { 6370, 24, 38, 30, 3, -37 },
  { 6484, 22, 27, 30, 4, -26 },
  { 6559, 26, 38, 30, 3, -37 },
  { 6683, 22, 27, 30, 4, -26 },
  { 6758, 33, 48, 30, -1, -37 },
  { 6956, 25, 37, 30, 2, -26 },
  { 7072, 23, 37, 30, 3, -37 },
  { 7179, 22, 39, 30, 4, -38 },
  { 7287, 22, 49, 30, 4, -38 },
  { 7422, 26, 38, 30, 3, -37 },
  { 7546, 20, 38, 30, 6, -37 },
  { 7641, 27, 26, 30, 1, -26 },
  { 7729, 23, 26, 30, 3, -26 },
  { 7804, 22, 27, 30, 4, -26 },
  { 7879, 26, 36, 30, 1, -26 },
  { 7996, 24, 36, 30, 3, -26 },
  { 8104, 24, 26, 30, 6, -26 },
  { 8182, 24, 27, 30, 3, -26 },
  { 8263, 23, 36, 30, 4, -35 },
  { 8367, 23, 27, 30, 4, -26 },
  { 8445, 23, 26, 30, 4, -26 },
  { 8520, 25, 27, 30, 3, -26 },
  { 8605, 28, 27, 30, 1, -26 },
  { 8700, 25, 37, 30, 2, -26 },
  { 8816, 25, 27, 30, 3, -26 },
  { 8901, 23, 45, 30, 6, -38 },
  { 9031, 10, 45, 30, 10, -38 },
  { 9088, 23, 45, 30, 2, -38 },
  { 9218, 26, 11, 30, 2, -21 },
};

const GFXfont IBMPlexMono_LightItalic50pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic50pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic50pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _IBMPLEXMONO_LIGHTITALIC50PT7B_H_
