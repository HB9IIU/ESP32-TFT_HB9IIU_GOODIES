#ifndef _IBMPLEXMONO_LIGHTITALIC8PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x31, 0x96, 0xCF, 0x50, 0x37, 0x58, 0x65, 0x69, 0x80,
  0x6D, 0xAC, 0xAF, 0xD8, 0x22, 0x95, 0xCA, 0x6C, 0xC0, 0x72, 0x49, 0x20,
  0x24, 0x92, 0xB0, 0x27, 0xD9, 0x60, 0x5D, 0x40, 0xE0, 0xE0, 0x80, 0x18,
  0x88, 0x44, 0x22, 0x00, 0x6A, 0xBE, 0xAC, 0x26, 0x22, 0x2F, 0x3D, 0x12,
  0x4F, 0x35, 0x13, 0x1F, 0x13, 0x59, 0xF2, 0x3A, 0x11, 0x61, 0x78, 0x3A,
  0x7B, 0xC0, 0xFA, 0x24, 0x48, 0x32, 0x96, 0xE9, 0x78, 0x76, 0xF5, 0x00,
  0x90, 0x43, 0x80, 0x16, 0x84, 0x20, 0x7F, 0x80, 0x86, 0x12, 0xC0, 0x74,
  0xA1, 0x00, 0x77, 0xDB, 0xB0, 0x22, 0x55, 0xB9, 0x75, 0x9F, 0x9F, 0x69,
  0x88, 0x8E, 0x65, 0x59, 0x9E, 0x7A, 0x21, 0xE8, 0x78, 0x7A, 0x21, 0xE8,
  0x40, 0x69, 0x8A, 0xEE, 0x4A, 0x65, 0xE9, 0x48, 0x79, 0x08, 0x42, 0x78,
  0x64, 0x93, 0x80, 0x4A, 0xA8, 0xCA, 0x48, 0x92, 0x49, 0xC0, 0x4E, 0x7D,
  0x69, 0x48, 0x4A, 0x6D, 0x6B, 0x48, 0x6A, 0xBA, 0xAC, 0x72, 0x64, 0xC8,
  0x40, 0x6A, 0xBA, 0xAC, 0x60, 0x72, 0x64, 0xCA, 0x48, 0x36, 0x50, 0x61,
  0x78, 0xF4, 0x44, 0x48, 0x99, 0xAA, 0xAE, 0x99, 0xAA, 0xC4, 0x8C, 0x6B,
  0xE7, 0x48, 0x4A, 0x98, 0x46, 0x48, 0x9A, 0xA4, 0x48, 0x78, 0x88, 0x84,
  0x78, 0x74, 0x48, 0x88, 0xE0, 0xAA, 0xAC, 0x64, 0x92, 0x70, 0x56, 0xD0,
  0xF0, 0x80, 0x79, 0x9F, 0x93, 0xDB, 0xC0, 0xF2, 0x70, 0x08, 0x9D, 0x29,
  0x78, 0xF7, 0x70, 0x39, 0x1E, 0x42, 0x23, 0x08, 0x79, 0x99, 0x6E, 0x93,
  0xDB, 0x40, 0x43, 0x4A, 0x80, 0x23, 0x94, 0xB2, 0x88, 0xEA, 0xCF, 0xCA,
  0x4B, 0x80, 0xFD, 0xAD, 0xA0, 0xF6, 0xD0, 0xF6, 0xF0, 0x79, 0x95, 0xA8,
  0x79, 0x99, 0x72, 0xF8, 0x88, 0x74, 0x3F, 0x4A, 0xCB, 0x80, 0xB6, 0xF0,
  0xB6, 0xE0, 0xB5, 0x6D, 0xE0, 0xF9, 0x09, 0xE0, 0x59, 0x99, 0x6E, 0xF2,
  0x5F, 0x74, 0x48, 0x48, 0xC0, 0xFE, 0x62, 0x43, 0x62, 0xC0, 0xF8,
};

const GFXglyph IBMPlexMono_LightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 2, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 5, 7, 5, 0, -6 },
  { 12, 5, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 2, 5, 2, -6 },
  { 21, 3, 7, 5, 2, -6 },
  { 24, 3, 7, 5, 0, -6 },
  { 27, 5, 4, 5, 0, -4 },
  { 30, 3, 4, 5, 1, -4 },
  { 32, 2, 2, 5, 1, -1 },
  { 33, 3, 1, 5, 1, -3 },
  { 34, 1, 1, 5, 2, -1 },
  { 35, 5, 7, 5, 0, -6 },
  { 40, 4, 6, 5, 1, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 4, 6, 5, 0, -6 },
  { 49, 4, 6, 5, 0, -6 },
  { 52, 4, 6, 5, 0, -6 },
  { 55, 5, 6, 5, 0, -6 },
  { 59, 3, 6, 5, 1, -6 },
  { 62, 4, 6, 5, 1, -6 },
  { 65, 5, 6, 5, 0, -6 },
  { 69, 3, 6, 5, 1, -6 },
  { 72, 1, 4, 5, 2, -4 },
  { 73, 2, 5, 5, 1, -4 },
  { 75, 4, 5, 5, 1, -5 },
  { 78, 5, 2, 5, 0, -3 },
  { 80, 4, 5, 5, 0, -5 },
  { 83, 3, 6, 5, 1, -6 },
  { 86, 3, 7, 5, 1, -6 },
  { 89, 4, 6, 5, 0, -6 },
  { 92, 4, 6, 5, 0, -6 },
  { 95, 4, 6, 5, 1, -6 },
  { 98, 4, 6, 5, 0, -6 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 5, 6, 5, 0, -6 },
  { 109, 4, 6, 5, 1, -6 },
  { 112, 5, 6, 5, 0, -6 },
  { 116, 5, 6, 5, 0, -6 },
  { 120, 3, 6, 5, 1, -6 },
  { 123, 5, 6, 5, 0, -6 },
  { 127, 3, 6, 5, 1, -6 },
  { 130, 5, 6, 5, 0, -6 },
  { 134, 5, 6, 5, 0, -6 },
  { 138, 4, 6, 5, 1, -6 },
  { 141, 5, 6, 5, 0, -6 },
  { 145, 4, 7, 5, 1, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 4, 6, 5, 1, -6 },
  { 160, 4, 6, 5, 1, -6 },
  { 163, 4, 6, 5, 1, -6 },
  { 166, 5, 6, 5, 0, -6 },
  { 170, 5, 6, 5, 0, -6 },
  { 174, 4, 6, 5, 1, -6 },
  { 177, 5, 6, 5, 0, -6 },
  { 181, 4, 7, 5, 1, -6 },
  { 185, 2, 7, 5, 2, -6 },
  { 187, 3, 7, 5, 0, -6 },
  { 190, 3, 4, 5, 1, -6 },
  { 192, 4, 1, 5, 0, 1 },
  { 193, 1, 1, 5, 2, -6 },
  { 194, 4, 4, 5, 0, -4 },
  { 196, 3, 6, 5, 1, -6 },
  { 199, 3, 4, 5, 1, -4 },
  { 201, 5, 6, 5, 0, -6 },
  { 205, 3, 4, 5, 1, -4 },
  { 207, 5, 8, 5, 0, -6 },
  { 212, 4, 6, 5, 0, -4 },
  { 215, 3, 6, 5, 1, -6 },
  { 218, 3, 6, 5, 1, -6 },
  { 221, 3, 8, 5, 1, -6 },
  { 224, 4, 6, 5, 1, -6 },
  { 227, 3, 6, 5, 1, -6 },
  { 230, 5, 4, 5, 0, -4 },
  { 233, 3, 4, 5, 1, -4 },
  { 235, 3, 4, 5, 1, -4 },
  { 237, 4, 6, 5, 0, -4 },
  { 240, 4, 6, 5, 0, -4 },
  { 243, 4, 4, 5, 1, -4 },
  { 245, 4, 4, 5, 0, -4 },
  { 247, 3, 6, 5, 1, -6 },
  { 250, 3, 4, 5, 1, -4 },
  { 252, 3, 4, 5, 1, -4 },
  { 254, 5, 4, 5, 0, -4 },
  { 257, 5, 4, 5, 0, -4 },
  { 260, 4, 6, 5, 0, -4 },
  { 263, 4, 4, 5, 0, -4 },
  { 265, 4, 7, 5, 1, -6 },
  { 269, 1, 7, 5, 2, -6 },
  { 270, 4, 7, 5, 0, -6 },
  { 274, 5, 1, 5, 0, -3 },
};

const GFXfont IBMPlexMono_LightItalic8pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic8pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _IBMPLEXMONO_LIGHTITALIC8PT7B_H_
