#ifndef _IBMPLEXMONO_LIGHTITALIC71PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE3, 0xC0, 0x78,
  0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x00, 0xE1,
  0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7,
  0x80, 0x70, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0E,
  0x01, 0xE3, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x1C, 0x7F, 0x80, 0x07, 0xE0, 0x38,
  0x1F, 0x80, 0x1F, 0x80, 0x70, 0x1F, 0x80, 0x7C, 0x00, 0xE0, 0x0F, 0x80,
  0xF8, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x07, 0x00, 0x18, 0x07, 0xC0, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x00,
  0x07, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x00, 0x0F, 0xC0,
  0xE0, 0x00, 0x00, 0x0F, 0xF1, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xEF, 0xFC,
  0x00, 0x00, 0x01, 0xC1, 0xFC, 0x00, 0x00, 0x03, 0x80, 0xFC, 0x00, 0x00,
  0x07, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x01,
  0xF0, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0xF8, 0x18,
  0x00, 0x70, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xC0,
  0x0F, 0x81, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x0E, 0x00, 0xF8, 0x01,
  0xF8, 0x1C, 0x07, 0xF0, 0x01, 0xFE, 0x38, 0x7F, 0xC0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x70, 0x00, 0x00, 0x1F, 0xFF, 0x81, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x1F, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0x00,
  0x0F, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x70, 0x00, 0x03,
  0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x87, 0xE0, 0x00, 0x01, 0xFF, 0xEF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xF0, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x8F, 0x80,
  0x00, 0x1E, 0x00, 0x33, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0x78, 0x00, 0x03,
  0xF0, 0x07, 0x9E, 0x00, 0x00, 0x9E, 0x03, 0xE7, 0x80, 0x00, 0x67, 0x80,
  0xF1, 0xF0, 0x00, 0x38, 0xF0, 0x78, 0x3C, 0x00, 0x1C, 0x3E, 0x1E, 0x0F,
  0x80, 0x0F, 0x07, 0x8F, 0x01, 0xF8, 0x0F, 0x81, 0xF7, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x3C, 0x79, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0xF1, 0xE3, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x04, 0x00, 0x07,
  0x80, 0x01, 0x78, 0x00, 0x78, 0x00, 0xF7, 0xF0, 0x07, 0x00, 0x7F, 0xFF,
  0xE0, 0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x3C, 0x00, 0xFB,
  0xC0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x00,
  0x7B, 0xE0, 0x0F, 0xE0, 0x0F, 0x7C, 0x01, 0xF8, 0x03, 0xEF, 0x00, 0x1E,
  0x00, 0x7D, 0xE0, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFD, 0xE0,
  0x00, 0x00, 0xFC, 0xF0, 0x00, 0x00, 0x7E, 0x3C, 0x00, 0x00, 0x7F, 0x0F,
  0x00, 0x00, 0x3F, 0x83, 0xC0, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x0F, 0xC0,
  0x3C, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x01, 0xF0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x04, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x10, 0x00, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x1F, 0xF0, 0x00, 0x07, 0x87,
  0xFF, 0xE0, 0x00, 0x79, 0xFF, 0xFF, 0x00, 0x07, 0xBF, 0xFF, 0xF8, 0x00,
  0x77, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x20, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x81,
  0xFE, 0x00, 0x0F, 0x07, 0xFF, 0xC0, 0x0F, 0x1F, 0xFF, 0xF0, 0x1E, 0x7F,
  0xFF, 0xF8, 0x1E, 0xFC, 0x03, 0xFC, 0x3D, 0xE0, 0x00, 0xFC, 0x3D, 0xC0,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x78,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xDE, 0x7C,
  0x00, 0x01, 0xBC, 0x3F, 0x00, 0x07, 0xBC, 0x3F, 0xC0, 0x3F, 0x7C, 0x1F,
  0xFF, 0xFE, 0x78, 0x0F, 0xFF, 0xF8, 0xF8, 0x03, 0xFF, 0xF0, 0xF0, 0x00,
  0xFF, 0x81, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x40, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE,
  0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xF3, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x7E, 0x0F, 0x1E, 0x00, 0x7F, 0xE3, 0xC7,
  0x80, 0x3F, 0xFC, 0xF1, 0xE0, 0x1F, 0xFF, 0xBC, 0x70, 0x0F, 0xC0, 0xEE,
  0x3C, 0x03, 0xE0, 0x0B, 0x8F, 0x01, 0xF0, 0x03, 0xE3, 0xC0, 0x78, 0x00,
  0x78, 0xF0, 0x1C, 0x00, 0x1E, 0x38, 0x0F, 0x00, 0x07, 0x9E, 0x03, 0xC0,
  0x01, 0xC7, 0x80, 0xE0, 0x00, 0x71, 0xE0, 0x78, 0x00, 0x1C, 0x78, 0x1E,
  0x00, 0x0F, 0x1E, 0x07, 0x80, 0x03, 0xC7, 0x01, 0xE0, 0x00, 0xF3, 0xC0,
  0x78, 0x00, 0x38, 0xF0, 0x1C, 0x00, 0x0E, 0x3C, 0x07, 0x00, 0x07, 0x8F,
  0x01, 0xC0, 0x01, 0xE3, 0xC0, 0x70, 0x00, 0xF8, 0xF0, 0x1C, 0x00, 0x3E,
  0x38, 0x07, 0x80, 0x17, 0x0E, 0x01, 0xE0, 0x0D, 0xC3, 0x80, 0x7E, 0x0E,
  0xF0, 0xE0, 0x0F, 0xFF, 0xBC, 0x38, 0x03, 0xFF, 0xCF, 0x0E, 0x00, 0x7F,
  0xE3, 0xC3, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x03, 0xF8, 0x03, 0xC0, 0x00, 0x1F,
  0x80, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3F, 0x07, 0x80,
  0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0xD0, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x20, 0x3C,
  0x00, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xF8,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFE,
  0x3C, 0x00, 0x3F, 0xFF, 0xC7, 0x80, 0x07, 0xFF, 0xF1, 0xF0, 0x00, 0xFF,
  0xFE, 0x3E, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x38, 0x7C,
  0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x00, 0xDE, 0x03, 0xF0, 0x00, 0x3B, 0xC0, 0x3F, 0x00, 0x0E, 0x78, 0x07,
  0xF8, 0x0F, 0x9E, 0x00, 0x7F, 0xFF, 0xE3, 0xC0, 0x07, 0xFF, 0xF8, 0x78,
  0x00, 0x3F, 0xFE, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x00,
  0x3C, 0x1F, 0xC0, 0x00, 0x00, 0x1E, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0x9F, 0x3C, 0x00, 0x00, 0x03, 0xDF, 0x1F, 0x00,
  0x00, 0x03, 0xFF, 0x07, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xEE, 0x00, 0x01,
  0xEE, 0x01, 0xEF, 0x00, 0x01, 0xFE, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x01,
  0xE7, 0x00, 0x07, 0xDE, 0x01, 0xE7, 0x00, 0x07, 0x9E, 0x01, 0xC7, 0x80,
  0x0F, 0x9E, 0x03, 0xC7, 0x80, 0x0F, 0x1C, 0x03, 0xC3, 0x80, 0x1E, 0x3C,
  0x03, 0xC3, 0x80, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3,
  0xC0, 0x7C, 0x3C, 0x03, 0x81, 0xC0, 0x78, 0x3C, 0x07, 0x81, 0xC0, 0xF0,
  0x38, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x07,
  0x80, 0xE1, 0xE0, 0x78, 0x07, 0x80, 0xE3, 0xC0, 0x78, 0x07, 0x00, 0xF7,
  0x80, 0x78, 0x0F, 0x00, 0xF7, 0x80, 0x70, 0x0F, 0x00, 0x7F, 0x00, 0xF0,
  0x0F, 0x00, 0x7F, 0x00, 0xF0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x0F, 0x00,
  0x7C, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x38, 0x00,
  0xE0, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x1E, 0x00, 0x30, 0x01, 0xE0, 0x1E,
  0x00, 0x20, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x03, 0xF8,
  0x00, 0x00, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x1D, 0xE0, 0x00, 0x07, 0x80, 0x7B, 0xC0, 0x00, 0x0E, 0x00, 0xF3,
  0xC0, 0x00, 0x3C, 0x01, 0xE7, 0x80, 0x00, 0x78, 0x03, 0xCF, 0x00, 0x00,
  0xF0, 0x07, 0x9E, 0x00, 0x01, 0xE0, 0x0E, 0x1E, 0x00, 0x03, 0xC0, 0x3C,
  0x3C, 0x00, 0x07, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x70, 0x00,
  0x3C, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x07,
  0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x0F, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x1E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x1E, 0x00, 0x1E, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x00, 0x70, 0x78,
  0x07, 0x80, 0x00, 0xF1, 0xE0, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x78, 0x00, 0x07, 0x9E,
  0x01, 0xE0, 0x00, 0x0F, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0xF0, 0x07, 0x80,
  0x00, 0x1F, 0xE0, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x00, 0x7F,
  0x80, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xF8,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x78,
  0x1F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0xFE, 0x00,
  0xF0, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x00, 0x3F, 0x01, 0xE0,
  0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xF8,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x78,
  0x1F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x20, 0x00, 0x07, 0x80, 0x0C,
  0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0x00, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x3C, 0x00,
  0x00, 0x3F, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x30,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0xF8, 0x01, 0xE0, 0x3C, 0x00, 0xFC, 0x00,
  0xF0, 0x1E, 0x00, 0x7E, 0x00, 0x70, 0x0F, 0x00, 0x7F, 0x00, 0x78, 0x07,
  0x00, 0x3F, 0x80, 0x3C, 0x03, 0x80, 0x3D, 0xC0, 0x1E, 0x01, 0xC0, 0x1E,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x1C, 0x03, 0xC0, 0x3C, 0x07, 0x8E, 0x01, 0xC0, 0x1E,
  0x03, 0xC7, 0x00, 0xE0, 0x0F, 0x01, 0xC3, 0x80, 0xF0, 0x07, 0x81, 0xE1,
  0xE0, 0x78, 0x03, 0xC0, 0xE0, 0xF0, 0x38, 0x01, 0xE0, 0xF0, 0x78, 0x1C,
  0x00, 0xE0, 0x78, 0x3C, 0x1E, 0x00, 0x70, 0x38, 0x1E, 0x0F, 0x00, 0x38,
  0x3C, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x1E, 0x1E, 0x01,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x70, 0xE0,
  0x03, 0xC7, 0x80, 0x38, 0x70, 0x01, 0xE3, 0x80, 0x1C, 0x78, 0x00, 0xF3,
  0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xC0, 0x07, 0x9C, 0x00, 0x3D, 0xE0, 0x03,
  0xCE, 0x00, 0x1C, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0x70, 0x00, 0xF7, 0x80,
  0x07, 0x78, 0x00, 0x7B, 0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x9F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x07, 0x90, 0x00, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x30, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x3C,
  0x1C, 0x1E, 0x0E, 0x0E, 0x07, 0x06, 0x00, 0x03, 0xF8, 0x03, 0xC0, 0x07,
  0xFF, 0xC1, 0xE0, 0x07, 0xFF, 0xF8, 0x78, 0x03, 0xFF, 0xFF, 0x1E, 0x01,
  0xFE, 0x03, 0xE7, 0x80, 0xFC, 0x00, 0x1D, 0xE0, 0x7E, 0x00, 0x03, 0x78,
  0x1F, 0x00, 0x00, 0x5C, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x00,
  0xDE, 0x07, 0xC0, 0x00, 0x37, 0x80, 0xF8, 0x00, 0x39, 0xE0, 0x3F, 0x00,
  0x1C, 0xF0, 0x07, 0xF0, 0x1F, 0x3F, 0xF1, 0xFF, 0xFF, 0x8F, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0x80, 0x03, 0xC0,
  0xFF, 0xF8, 0x01, 0xE0, 0xFF, 0xFE, 0x00, 0xF0, 0xFF, 0xFF, 0x80, 0x78,
  0xF8, 0x0F, 0xE0, 0x3C, 0xE0, 0x01, 0xF0, 0x1E, 0xE0, 0x00, 0x7C, 0x1F,
  0x60, 0x00, 0x1E, 0x0F, 0x60, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x03, 0xE1, 0xEC, 0x00, 0x03, 0xE0, 0xF3, 0x80, 0x07, 0xE0, 0x79, 0xF0,
  0x0F, 0xF0, 0x3C, 0x7F, 0xFF, 0xE0, 0x1E, 0x1F, 0xFF, 0xE0, 0x0F, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x7F,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x03,
  0xC0, 0x00, 0xFF, 0xF8, 0x1E, 0x00, 0x1F, 0xFF, 0xF0, 0xF0, 0x01, 0xFF,
  0xFF, 0xC7, 0x00, 0x1F, 0xE0, 0x3E, 0x78, 0x01, 0xF8, 0x00, 0x3B, 0xC0,
  0x1F, 0x80, 0x00, 0xDE, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x3C, 0x00,
  0x00, 0xBC, 0x01, 0xF0, 0x00, 0x0D, 0xE0, 0x07, 0xC0, 0x00, 0xCF, 0x00,
  0x3F, 0x00, 0x1C, 0x78, 0x00, 0xFE, 0x03, 0xE3, 0xC0, 0x03, 0xFF, 0xFE,
  0x3C, 0x00, 0x0F, 0xFF, 0xE1, 0xE0, 0x00, 0x3F, 0xFC, 0x0F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x0F, 0xF0,
  0x78, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x10,
  0x78, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xE0,
  0x01, 0xFF, 0xF0, 0x3C, 0x00, 0xFF, 0xFF, 0x07, 0x80, 0x3F, 0xFF, 0xF8,
  0xF0, 0x0F, 0xF0, 0x1F, 0x3C, 0x03, 0xF0, 0x00, 0x77, 0x80, 0xFC, 0x00,
  0x06, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x00, 0x2F, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x03, 0x78, 0x07, 0xC0, 0x00, 0xEF, 0x00, 0xFC,
  0x00, 0x79, 0xE0, 0x0F, 0xE0, 0x3E, 0x3C, 0x00, 0xFF, 0xFF, 0x87, 0x80,
  0x0F, 0xFF, 0xE1, 0xE0, 0x00, 0xFF, 0xF8, 0x3C, 0x00, 0x07, 0xF8, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x02, 0x00, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x3F,
  0x80, 0x07, 0x83, 0xFF, 0xC0, 0x0F, 0x0F, 0xFF, 0xC0, 0x1E, 0x3F, 0xFF,
  0xC0, 0x7C, 0xF8, 0x1F, 0xC0, 0xF3, 0xC0, 0x0F, 0x81, 0xE6, 0x00, 0x0F,
  0x83, 0xD8, 0x00, 0x1F, 0x07, 0xA0, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x3C,
  0x3F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xC0, 0x0F, 0xC0,
  0x07, 0x80, 0x7F, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x1E, 0x07, 0xE0, 0x00,
  0x3C, 0x1F, 0x80, 0x00, 0x70, 0xFC, 0x00, 0x01, 0xE3, 0xF0, 0x00, 0x03,
  0xCF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x02, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0xF0, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x7E, 0x07, 0x80, 0x00,
  0x7E, 0x0F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xC0, 0x00,
  0x3C, 0x0F, 0xFF, 0x00, 0x07, 0xC3, 0xFF, 0xF8, 0x00, 0x78, 0x7F, 0xFF,
  0xC0, 0x07, 0x8F, 0x80, 0xFE, 0x00, 0x79, 0xE0, 0x03, 0xE0, 0x07, 0xB8,
  0x00, 0x1E, 0x00, 0x7B, 0x00, 0x01, 0xE0, 0x0F, 0xE0, 0x00, 0x1E, 0x00,
  0xF4, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x01, 0xF0, 0x01,
  0xE0, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x0F, 0xE0,
  0x00, 0x3E, 0x0F, 0xF8, 0x00, 0x03, 0xC1, 0xFC, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x83,
  0xC0, 0x78, 0x00, 0x0C, 0x7C, 0x03, 0xC0, 0x01, 0xE7, 0x80, 0x3E, 0x00,
  0x3F, 0x78, 0x01, 0xE0, 0x07, 0xC7, 0x80, 0x1F, 0x00, 0xF8, 0x78, 0x00,
  0xF0, 0x1F, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x78, 0xFC, 0x0F,
  0x00, 0x07, 0xDF, 0x80, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0x00, 0x03, 0xFE,
  0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x04, 0x01,
  0xE0, 0x00, 0x60, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xF0, 0x3C, 0x00,
  0x7E, 0x03, 0xC0, 0x0F, 0xC0, 0x3C, 0x03, 0xF0, 0x03, 0xC0, 0x7E, 0x00,
  0x3C, 0x0F, 0xC0, 0x07, 0x81, 0xF8, 0x00, 0x78, 0x7E, 0x00, 0x07, 0x8F,
  0xC0, 0x00, 0x79, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC3, 0xF0, 0x07, 0xE0,
  0x0E, 0x1F, 0xE0, 0x7F, 0xC0, 0x78, 0xFF, 0xC3, 0xFF, 0x81, 0xE7, 0xFF,
  0x1F, 0xFF, 0x07, 0xB8, 0x3E, 0xF0, 0x7C, 0x1F, 0xC0, 0x7B, 0x80, 0xF0,
  0x7E, 0x01, 0xFC, 0x03, 0xC1, 0xF0, 0x07, 0xE0, 0x0F, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC3,
  0xC0, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x70,
  0x00, 0xE1, 0xE0, 0x01, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC0,
  0x07, 0x87, 0x00, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x00, 0x70, 0xF0,
  0x01, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x87, 0x80,
  0x07, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x01,
  0xE1, 0xE0, 0x03, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0xF0, 0x01, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x80, 0x0F,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x3F, 0x80, 0x07, 0x83, 0xFF, 0xC0, 0x0F,
  0x0F, 0xFF, 0xC0, 0x3E, 0x3F, 0xFF, 0xC0, 0x78, 0xF8, 0x1F, 0xC0, 0xF3,
  0xC0, 0x0F, 0x81, 0xE6, 0x00, 0x0F, 0x83, 0xD8, 0x00, 0x1F, 0x07, 0xA0,
  0x00, 0x1E, 0x1F, 0xC0, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x00, 0xF0, 0xF8, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x07, 0xF0, 0x00, 0x0F, 0x03, 0xFF,
  0xE0, 0x00, 0xF0, 0x7F, 0xFF, 0x00, 0x0F, 0x0F, 0xFF, 0xF8, 0x00, 0xF1,
  0xF0, 0x1F, 0xC0, 0x0F, 0x38, 0x00, 0x7C, 0x00, 0xF7, 0x00, 0x03, 0xE0,
  0x1F, 0x60, 0x00, 0x1E, 0x01, 0xEC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x01,
  0xEC, 0x00, 0x03, 0xE0, 0x1E, 0x70, 0x00, 0xFC, 0x01, 0xE7, 0xC0, 0x3F,
  0xC0, 0x1E, 0x3F, 0xFF, 0xF0, 0x01, 0xE1, 0xFF, 0xFE, 0x00, 0x1E, 0x0F,
  0xFF, 0xC0, 0x03, 0xC0, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xC0, 0x07,
  0xFF, 0xC0, 0xF0, 0x07, 0xFF, 0xFC, 0x3C, 0x03, 0xFF, 0xFF, 0x8F, 0x01,
  0xFE, 0x03, 0xE7, 0x80, 0xFE, 0x00, 0x1D, 0xE0, 0x7E, 0x00, 0x03, 0x78,
  0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x37, 0x80, 0xF8, 0x00, 0x19, 0xE0, 0x3F, 0x00,
  0x1E, 0x78, 0x07, 0xF0, 0x1F, 0x1E, 0x00, 0xFF, 0xFF, 0x8F, 0x00, 0x1F,
  0xFF, 0xC3, 0xC0, 0x03, 0xFF, 0xE0, 0xF0, 0x00, 0x3F, 0xC0, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x00, 0x1E, 0x7E, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x20, 0x00, 0x00, 0x1E,
  0x0C, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x01,
  0xF0, 0x7F, 0x00, 0x00, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x80,
  0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x07, 0xF0, 0x00, 0x78, 0x07, 0xE0,
  0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x1E, 0x1F, 0xC0, 0x00, 0x0F, 0x1F, 0xC0,
  0x00, 0x07, 0xBF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x05, 0xE0, 0xF8, 0x00, 0x0D, 0xE0, 0x78, 0x00,
  0x19, 0xE0, 0x7C, 0x00, 0x3B, 0xC0, 0x7E, 0x00, 0x73, 0xC0, 0x3F, 0x01,
  0xE3, 0xC0, 0x3F, 0xFF, 0xE3, 0xC0, 0x1F, 0xFF, 0x83, 0xC0, 0x0F, 0xFF,
  0x03, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x06, 0x3F, 0xFC,
  0x00, 0x0F, 0xBF, 0xFE, 0x00, 0x03, 0xDF, 0xFE, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x07, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x1C, 0x01,
  0xFC, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x0F, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0xC0, 0xF0, 0x01, 0xE0, 0x1E,
  0x0F, 0x00, 0x1E, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x1C,
  0x00, 0xF0, 0xE0, 0x03, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x00, 0xF1, 0xE0,
  0x03, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0x80, 0x07,
  0x1C, 0x00, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x80, 0x07, 0x1C, 0x00, 0x78,
  0x00, 0x73, 0xC0, 0x07, 0x80, 0x07, 0x3C, 0x00, 0x78, 0x00, 0x73, 0xC0,
  0x07, 0x00, 0x0F, 0x38, 0x00, 0x70, 0x00, 0xF3, 0x80, 0x0F, 0x00, 0x0F,
  0x38, 0x00, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x00, 0x0F, 0x78, 0x00, 0xF0,
  0x00, 0xF7, 0x80, 0x0E, 0x00, 0x0E, 0x70, 0x00, 0xE0, 0x01, 0xE7, 0x00,
  0x1E, 0x00, 0x1E, 0x70, 0x01, 0xE0, 0x01, 0xEF, 0x00, 0x1E, 0x00, 0x3C,
  0xF0, 0x01, 0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x00, 0x3C, 0xF0, 0x03, 0xE0,
  0x07, 0x8F, 0x00, 0x3E, 0x00, 0x78, 0xF0, 0x07, 0xE0, 0x0F, 0x0F, 0x00,
  0xFE, 0x01, 0xF0, 0xF0, 0x1C, 0xE0, 0x3E, 0x0F, 0x83, 0xCF, 0x07, 0xC0,
  0x7F, 0xF8, 0xFF, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x07, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x07, 0xFF, 0xE0, 0x0F, 0xCF, 0x83, 0xC1, 0xF0, 0x1F, 0xC3, 0xC3, 0xC0,
  0x78, 0x1F, 0x81, 0xE3, 0xC0, 0x1E, 0x3F, 0x00, 0x71, 0xC0, 0x0F, 0x3E,
  0x00, 0x39, 0xC0, 0x07, 0x8E, 0x00, 0x1E, 0xC0, 0x03, 0xC0, 0x00, 0x0F,
  0x60, 0x01, 0xE0, 0x00, 0x07, 0xB0, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x37, 0x00, 0x00,
  0x1E, 0x00, 0x1B, 0xC0, 0x01, 0x0F, 0x00, 0x1D, 0xE0, 0x03, 0xC7, 0x80,
  0x0C, 0xF0, 0x03, 0xE3, 0xC0, 0x0E, 0x78, 0x07, 0xE1, 0xE0, 0x0E, 0x1E,
  0x0F, 0xC0, 0xF8, 0x0F, 0x0F, 0x0F, 0xC0, 0x3E, 0x1F, 0x07, 0x9F, 0xC0,
  0x1F, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x07, 0x80, 0x00, 0xDE, 0x00, 0x78, 0x00, 0x1D, 0xE0,
  0x07, 0xC0, 0x03, 0x9E, 0x00, 0x7E, 0x00, 0x73, 0xC0, 0x03, 0xF0, 0x1F,
  0x3C, 0x00, 0x3F, 0xFF, 0xE3, 0xC0, 0x01, 0xFF, 0xFC, 0x3C, 0x00, 0x07,
  0xFF, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xE0, 0x1F, 0xFF, 0xC0, 0x3C,
  0x07, 0xFF, 0xFF, 0x07, 0x81, 0xFF, 0xFF, 0xF8, 0xF0, 0x7E, 0x03, 0xFF,
  0xFE, 0x0F, 0x00, 0x07, 0xFF, 0xC3, 0xC0, 0x00, 0x3F, 0xF0, 0x78, 0x00,
  0x00, 0xFC, 0x0E, 0x00, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x7C, 0x00,
  0x00, 0x1C, 0x1F, 0xF8, 0x00, 0x03, 0xC7, 0xFF, 0xF8, 0x00, 0x78, 0xFF,
  0xFF, 0xF8, 0x0F, 0x1E, 0x0F, 0xFF, 0xF9, 0xE3, 0xC0, 0x1F, 0xFF, 0xFC,
  0x78, 0x00, 0x7F, 0xFF, 0x8F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x30, 0x07,
  0xF8, 0x00, 0x01, 0xC0, 0x7F, 0xF0, 0x00, 0x1E, 0x07, 0xFF, 0x80, 0x00,
  0xE0, 0x7C, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0xF8, 0x00, 0x78, 0x3C, 0x03,
  0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x7C, 0x03, 0xC1,
  0xE0, 0x01, 0xF0, 0x3E, 0x0E, 0x00, 0x07, 0xC3, 0xE0, 0xF0, 0x00, 0x3F,
  0xFE, 0x07, 0x00, 0x00, 0xFF, 0xE0, 0x38, 0x00, 0x03, 0xFE, 0x02, 0xC0,
  0x00, 0x07, 0xC0, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 14, 51, 43, 15, -50 },
  { 91, 19, 19, 43, 16, -53 },
  { 137, 43, 50, 43, 1, -50 },
  { 406, 39, 65, 43, 2, -57 },
  { 723, 47, 51, 43, -1, -50 },
  { 1023, 42, 51, 43, 0, -50 },
  { 1291, 7, 19, 43, 22, -53 },
  { 1308, 25, 64, 43, 15, -54 },
  { 1508, 24, 64, 43, 4, -54 },
  { 1700, 36, 35, 43, 4, -39 },
  { 1858, 34, 36, 43, 5, -40 },
  { 2011, 14, 19, 43, 10, -8 },
  { 2045, 20, 4, 43, 12, -24 },
  { 2055, 8, 8, 43, 15, -7 },
  { 2063, 40, 64, 43, 2, -54 },
  { 2383, 35, 51, 43, 5, -50 },
  { 2607, 34, 50, 43, 3, -50 },
  { 2820, 37, 50, 43, 2, -50 },
  { 3052, 36, 51, 43, 2, -50 },
  { 3282, 38, 50, 43, 1, -50 },
  { 3520, 36, 51, 43, 4, -50 },
  { 3750, 32, 51, 43, 5, -50 },
  { 3954, 34, 50, 43, 8, -50 },
  { 4167, 37, 51, 43, 3, -50 },
  { 4403, 32, 50, 43, 7, -50 },
  { 4603, 13, 38, 43, 15, -37 },
  { 4665, 18, 48, 43, 10, -37 },
  { 4773, 34, 40, 43, 6, -42 },
  { 4943, 36, 17, 43, 4, -30 },
  { 5020, 34, 40, 43, 3, -42 },
  { 5190, 29, 51, 43, 10, -50 },
  { 5375, 34, 58, 43, 5, -50 },
  { 5622, 37, 50, 43, 0, -50 },
  { 5854, 35, 50, 43, 4, -50 },
  { 6073, 35, 51, 43, 6, -50 },
  { 6297, 36, 50, 43, 4, -50 },
  { 6522, 38, 50, 43, 4, -50 },
  { 6760, 38, 50, 43, 4, -50 },
  { 6998, 35, 51, 43, 5, -50 },
  { 7222, 39, 50, 43, 3, -50 },
  { 7466, 39, 50, 43, 3, -50 },
  { 7710, 34, 51, 43, 5, -50 },
  { 7927, 41, 50, 43, 4, -50 },
  { 8184, 29, 50, 43, 6, -50 },
  { 8366, 40, 50, 43, 2, -50 },
  { 8616, 39, 50, 43, 3, -50 },
  { 8860, 35, 51, 43, 5, -50 },
  { 9084, 37, 50, 43, 4, -50 },
  { 9316, 35, 63, 43, 5, -50 },
  { 9592, 37, 50, 43, 4, -50 },
  { 9824, 39, 51, 43, 2, -50 },
  { 10073, 39, 50, 43, 7, -50 },
  { 10317, 36, 51, 43, 6, -50 },
  { 10547, 37, 50, 43, 8, -50 },
  { 10779, 41, 50, 43, 4, -50 },
  { 11036, 46, 50, 43, -1, -50 },
  { 11324, 39, 50, 43, 7, -50 },
  { 11568, 43, 50, 43, 0, -50 },
  { 11837, 30, 64, 43, 12, -54 },
  { 12077, 18, 64, 43, 13, -54 },
  { 12221, 29, 64, 43, 1, -54 },
  { 12453, 35, 28, 43, 5, -50 },
  { 12576, 34, 4, 43, 0, 7 },
  { 12593, 8, 13, 43, 17, -55 },
  { 12606, 34, 38, 43, 4, -37 },
  { 12768, 33, 54, 43, 5, -53 },
  { 12991, 30, 38, 43, 6, -37 },
  { 13134, 37, 54, 43, 4, -53 },
  { 13384, 32, 38, 43, 5, -37 },
  { 13536, 46, 68, 43, -1, -53 },
  { 13927, 35, 52, 43, 3, -37 },
  { 14155, 31, 53, 43, 5, -53 },
  { 14361, 31, 55, 43, 6, -54 },
  { 14575, 31, 68, 43, 6, -53 },
  { 14839, 36, 54, 43, 5, -53 },
  { 15082, 28, 54, 43, 8, -53 },
  { 15271, 38, 37, 43, 2, -37 },
  { 15447, 31, 37, 43, 5, -37 },
  { 15591, 33, 38, 43, 5, -37 },
  { 15748, 36, 51, 43, 2, -37 },
  { 15978, 34, 51, 43, 4, -37 },
  { 16195, 34, 37, 43, 8, -37 },
  { 16353, 34, 38, 43, 4, -37 },
  { 16515, 33, 51, 43, 6, -50 },
  { 16726, 32, 38, 43, 6, -37 },
  { 16878, 33, 37, 43, 5, -37 },
  { 17031, 36, 38, 43, 4, -37 },
  { 17202, 41, 38, 43, 1, -37 },
  { 17397, 36, 52, 43, 2, -37 },
  { 17631, 35, 38, 43, 4, -37 },
  { 17798, 33, 64, 43, 8, -54 },
  { 18062, 14, 64, 43, 15, -54 },
  { 18174, 33, 64, 43, 3, -54 },
  { 18438, 37, 15, 43, 3, -29 },
};

const GFXfont IBMPlexMono_LightItalic71pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic71pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic71pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _IBMPLEXMONO_LIGHTITALIC71PT7B_H_
