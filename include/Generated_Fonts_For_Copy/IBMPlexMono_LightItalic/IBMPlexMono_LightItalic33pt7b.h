#ifndef _IBMPLEXMONO_LIGHTITALIC33PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x18, 0x41, 0x04, 0x30, 0x82,
  0x00, 0x00, 0x00, 0x38, 0xF3, 0xCE, 0x00, 0x63, 0x63, 0x43, 0xC3, 0xC2,
  0xC6, 0xC6, 0xC6, 0x86, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x20, 0x80,
  0x06, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x10, 0x00, 0xC3, 0x01, 0xFC, 0x3F,
  0x1F, 0x83, 0xF0, 0x18, 0x60, 0x01, 0x86, 0x00, 0x10, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x7E, 0x1F, 0xC7, 0xE1, 0xFC, 0x86, 0x18, 0x00, 0x43,
  0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x08, 0x60, 0x01, 0x86, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x07, 0xF0, 0x07,
  0xFF, 0x03, 0x8C, 0xE1, 0xC2, 0x1C, 0x60, 0x82, 0x18, 0x20, 0x06, 0x18,
  0x01, 0x86, 0x00, 0x61, 0x80, 0x1E, 0x40, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0xC7, 0x00, 0x20, 0xC0, 0x08, 0x30, 0x02, 0x0C, 0x01,
  0x83, 0x30, 0x60, 0xCE, 0x18, 0x61, 0xE4, 0x78, 0x1F, 0xF8, 0x01, 0xF8,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x0E, 0x0F,
  0xE0, 0x10, 0x38, 0x60, 0x60, 0x60, 0xC1, 0x80, 0x81, 0x86, 0x03, 0x03,
  0x0C, 0x06, 0x06, 0x30, 0x0C, 0x08, 0xC0, 0x0C, 0x31, 0x00, 0x1F, 0xC6,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x31, 0xFC,
  0x00, 0xC6, 0x18, 0x01, 0x18, 0x10, 0x06, 0x30, 0x30, 0x18, 0x60, 0x40,
  0x20, 0x80, 0x80, 0xC1, 0x03, 0x03, 0x03, 0x0C, 0x0C, 0x03, 0xF8, 0x30,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x0C, 0x18, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x1E, 0x70, 0x0F, 0xF8, 0x03, 0x0C, 0x00, 0xC1, 0x80,
  0x18, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x07, 0x07, 0x00, 0xE1,
  0xB0, 0x36, 0x67, 0x0C, 0xEC, 0x7F, 0x0F, 0x07, 0xC0, 0xC0, 0x2D, 0xB6,
  0xD6, 0xC0, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x04, 0x04, 0x0B, 0xC2, 0x1E, 0x7F, 0xFC, 0x07, 0xF0,
  0x01, 0xC0, 0x01, 0xB0, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0xC1, 0x80, 0xC0,
  0xC0, 0xC0, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x1C,
  0xE3, 0x8C, 0x71, 0x86, 0x30, 0xC0, 0x7F, 0xFF, 0xF0, 0xEF, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03,
  0xC3, 0x83, 0x80, 0x61, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0xD8, 0x70, 0xDC, 0x38, 0x6C, 0x1C, 0x36, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x07, 0x18, 0x03, 0x0C,
  0x03, 0x07, 0x07, 0x81, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0xF8,
  0x01, 0xD8, 0x03, 0x98, 0x07, 0x10, 0x1E, 0x30, 0x18, 0x30, 0x10, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xC1,
  0xC1, 0x80, 0x71, 0xC0, 0x18, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0x01,
  0xC1, 0xC1, 0x80, 0x70, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x10, 0x01, 0x9C,
  0x01, 0x87, 0x03, 0xC1, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x20, 0x03, 0x30, 0x03, 0x18, 0x03,
  0x0C, 0x03, 0x06, 0x01, 0x03, 0x01, 0x81, 0x01, 0x81, 0x81, 0x80, 0xC1,
  0x80, 0x61, 0x80, 0x30, 0x80, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x0F, 0xFF, 0x87,
  0xFF, 0x83, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x33, 0xF0, 0x1B, 0xFC, 0x0F, 0x07, 0x06, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x30,
  0x03, 0x1C, 0x03, 0x87, 0x07, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x19, 0xF0, 0x6F, 0xF8, 0xB0, 0x73, 0x80, 0x76, 0x00, 0x6C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x33, 0x00, 0xE7,
  0x03, 0x87, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xC0, 0x06,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x80, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0x81, 0xC3, 0x00,
  0x61, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x0C, 0x60, 0x06, 0x18, 0x06, 0x0E,
  0x06, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0x81, 0xC3, 0x00, 0x33, 0x00, 0x19,
  0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0x8F, 0x03,
  0xC3, 0xFF, 0x80, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x70, 0x71, 0x80,
  0x76, 0x00, 0x6C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3B, 0x00, 0xE7, 0x03, 0xC7, 0xF9, 0x07, 0xE6, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x1E, 0x00,
  0x00, 0x1C, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x3C, 0xF3, 0x80, 0x07, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x60, 0x60,
  0xC0, 0xC0, 0x00, 0x01, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x08, 0x7F, 0xFF, 0xBF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFD, 0xFF, 0xFC, 0x20, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x01, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x9C, 0x1E, 0xC0, 0x3C,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x80, 0x70, 0x1F,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F,
  0x0E, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x30, 0x01, 0x30, 0x7B, 0x21,
  0xFF, 0x61, 0x87, 0x63, 0x03, 0x63, 0x02, 0x62, 0x02, 0x46, 0x06, 0x46,
  0x06, 0xC6, 0x06, 0xC6, 0x0E, 0xC6, 0x14, 0xC3, 0xF4, 0xC3, 0xEC, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x38, 0x00, 0x3F, 0xF0, 0x0F,
  0xF0, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x06, 0xC0,
  0x06, 0x20, 0x03, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x01, 0x83, 0x00, 0xC1,
  0x80, 0xC0, 0x40, 0x60, 0x30, 0x20, 0x18, 0x3F, 0xFC, 0x1F, 0xFE, 0x18,
  0x03, 0x0C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0F,
  0x00, 0x06, 0x1F, 0xF8, 0x1F, 0xFE, 0x18, 0x07, 0x18, 0x03, 0x18, 0x03,
  0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x06, 0x30, 0x0C, 0x3F, 0xF8,
  0x3F, 0xF8, 0x60, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x40, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x1C, 0xFF, 0xF8, 0xFF, 0xE0,
  0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x06, 0x38, 0x03, 0x30, 0x02,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x08, 0xC0, 0x0C,
  0xC0, 0x18, 0xE0, 0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0xF0,
  0x0F, 0xFC, 0x18, 0x0E, 0x18, 0x07, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03,
  0x10, 0x01, 0x30, 0x01, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x20, 0x03, 0x60, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0C,
  0x40, 0x18, 0xC0, 0x78, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0x8F, 0xFF,
  0xC6, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC2, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF1, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xC1, 0x81, 0x80, 0x61, 0x80, 0x31,
  0xC0, 0x0C, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x0F, 0xF3, 0x07, 0xF3, 0x00, 0x19, 0x80, 0x0C, 0x40,
  0x06, 0x30, 0x03, 0x18, 0x03, 0x0C, 0x03, 0x83, 0x82, 0xC1, 0xFF, 0x60,
  0x3E, 0x30, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x08,
  0x00, 0xC6, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00,
  0x61, 0xFF, 0xF8, 0xFF, 0xFC, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x03, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x06, 0x18, 0x01, 0x8E, 0x00, 0x60, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0xE0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x40, 0x18, 0xC0, 0x18,
  0xE0, 0x30, 0x70, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x18, 0x00, 0xE3, 0x00,
  0x30, 0x60, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x0C, 0x0C,
  0x01, 0x83, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0xCE, 0x00, 0x1B, 0x60,
  0x06, 0xCC, 0x00, 0xF0, 0xC0, 0x1C, 0x18, 0x03, 0x03, 0x80, 0x60, 0x30,
  0x0C, 0x07, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x18,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0xE1, 0xC0, 0x38, 0x78, 0x07,
  0x0D, 0x01, 0xE1, 0xA0, 0x2C, 0x36, 0x0D, 0x86, 0xC3, 0x30, 0x88, 0x64,
  0x31, 0x99, 0x86, 0x32, 0x30, 0xC6, 0xC6, 0x18, 0x70, 0xC3, 0x0E, 0x18,
  0x41, 0x82, 0x18, 0x20, 0xC3, 0x04, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61,
  0x80, 0x0C, 0x20, 0x01, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x80,
  0x0E, 0x00, 0xC3, 0xC0, 0x30, 0xF0, 0x0C, 0x3C, 0x03, 0x09, 0x00, 0xC6,
  0x60, 0x21, 0x98, 0x18, 0x66, 0x06, 0x18, 0x81, 0x86, 0x30, 0x61, 0x0C,
  0x18, 0xC3, 0x04, 0x30, 0x63, 0x0C, 0x18, 0xC3, 0x06, 0x30, 0xC0, 0x8C,
  0x20, 0x33, 0x18, 0x0C, 0x86, 0x03, 0x61, 0x80, 0x78, 0x60, 0x1E, 0x18,
  0x07, 0x8C, 0x00, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xC3, 0x83, 0x80,
  0x61, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0,
  0x00, 0xD8, 0x00, 0xDC, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D,
  0x80, 0x0C, 0xC0, 0x06, 0x60, 0x07, 0x18, 0x03, 0x0C, 0x03, 0x07, 0x07,
  0x81, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0x86, 0x00, 0xC3,
  0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x60, 0x03, 0x30, 0x01,
  0x98, 0x01, 0x8C, 0x01, 0xC7, 0xFF, 0xC3, 0xFF, 0x83, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xC3,
  0x83, 0x80, 0x61, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x06, 0xC0, 0x03, 0x60,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0xDC, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x07, 0x18, 0x03, 0x0C, 0x03,
  0x07, 0x07, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x06, 0x00, 0x01, 0x82, 0x00,
  0xE3, 0x00, 0x33, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x0F, 0xFC, 0x0F, 0xFF,
  0x86, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x60,
  0x03, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x01, 0xC7, 0xFF, 0xC3, 0xFF, 0x83,
  0x06, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x0C,
  0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xE3, 0x00, 0x30, 0x01, 0xFC, 0x01,
  0xFF, 0xC0, 0xE0, 0x38, 0x70, 0x07, 0x18, 0x00, 0x86, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xCC, 0x00, 0x33, 0x80, 0x18, 0x78, 0x1E, 0x07, 0xFE, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30,
  0x03, 0x20, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x40, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xE0, 0x70, 0x7F,
  0xE0, 0x3F, 0x80, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xCC,
  0x00, 0x62, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x0C, 0x02, 0x06, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x02, 0x40, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x64, 0x00, 0x08, 0x80, 0x03, 0x10,
  0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x18, 0x30, 0x63, 0x06, 0x0C, 0x61,
  0xC1, 0x8C, 0x2C, 0x21, 0x8D, 0x8C, 0x31, 0xB1, 0x86, 0x26, 0x30, 0x8C,
  0xC4, 0x11, 0x19, 0x82, 0x63, 0x30, 0xCC, 0x26, 0x1B, 0x04, 0x83, 0x60,
  0xB0, 0x68, 0x16, 0x0F, 0x02, 0xC1, 0xE0, 0x70, 0x38, 0x0E, 0x00, 0x0C,
  0x00, 0x38, 0x30, 0x03, 0x81, 0x80, 0x18, 0x06, 0x01, 0x80, 0x30, 0x18,
  0x00, 0xC1, 0x80, 0x06, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00,
  0x06, 0x60, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00, 0x70, 0x30, 0x07, 0x01,
  0x80, 0x30, 0x06, 0x03, 0x00, 0x30, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0xEC, 0x00, 0x31, 0x80, 0x0E, 0x18, 0x01, 0x83, 0x00, 0x60,
  0x60, 0x18, 0x06, 0x07, 0x00, 0xC0, 0xC0, 0x0C, 0x30, 0x01, 0x8C, 0x00,
  0x1B, 0x80, 0x03, 0x60, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xC3, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x60,
  0x20, 0x20, 0x30, 0x30, 0x10, 0x10, 0x18, 0x18, 0x18, 0x08, 0x08, 0x0C,
  0x0C, 0x04, 0x04, 0x06, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03, 0x01, 0x01,
  0x0F, 0xF8, 0x7F, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x70, 0x00, 0x78, 0x00, 0x34, 0x00, 0x33, 0x00, 0x31, 0x80,
  0x30, 0x60, 0x18, 0x30, 0x18, 0x0C, 0x18, 0x06, 0x18, 0x01, 0x0C, 0x00,
  0xCC, 0x00, 0x6C, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xCC, 0x46, 0x23,
  0x07, 0xE3, 0x0F, 0xF6, 0x1C, 0x1E, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x06,
  0x60, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C,
  0xC0, 0x18, 0xE0, 0x38, 0x70, 0xD8, 0x3F, 0x9E, 0x1F, 0x0E, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0xF8, 0x1B, 0xFC, 0x16, 0x0E, 0x34, 0x06, 0x38, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x20, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x0C, 0x60, 0x1C, 0x58, 0x38, 0xCF, 0xF0, 0xC7, 0xC0, 0x07, 0xE0,
  0x7F, 0xC3, 0x83, 0x9C, 0x03, 0x60, 0x0B, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x06, 0xC0, 0x1B, 0x00, 0xC7, 0x0E,
  0x0F, 0xF0, 0x1F, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x0F, 0xC6, 0x0F, 0xF2, 0x0E,
  0x0F, 0x0C, 0x03, 0x8E, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x33, 0x00, 0x11,
  0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x8E, 0x02,
  0x83, 0x87, 0xC0, 0xFF, 0x60, 0x3E, 0x30, 0x03, 0xF0, 0x3F, 0xE3, 0xC1,
  0xCC, 0x03, 0x60, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x3E, 0xFF, 0xE3, 0xF8,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0x00, 0xE7, 0x07, 0x1F, 0xF8, 0x1F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x10, 0x18, 0x00, 0x60, 0x60, 0x03, 0xC1, 0x00,
  0x03, 0x8C, 0x00, 0x07, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xF1, 0x83, 0xFC, 0x83, 0x83, 0xC3, 0x00, 0xE3,
  0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x04, 0x60, 0x06, 0x30, 0x03,
  0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xE3, 0x80, 0xA0, 0xE1, 0xB0, 0x3F,
  0xD8, 0x0F, 0x8C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x04, 0x03, 0x87,
  0x03, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x7C, 0x19, 0xFC, 0x36,
  0x18, 0x70, 0x19, 0xC0, 0x33, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x02,
  0x20, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x10,
  0x06, 0x60, 0x0C, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x30, 0xC1,
  0xC3, 0x1C, 0x0C, 0xE0, 0x27, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x80, 0xC3, 0x03, 0x0E, 0x0C, 0x1C, 0x60, 0x39, 0x80,
  0x76, 0x00, 0xF8, 0x01, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x31, 0xF0, 0x19, 0xFC,
  0x0D, 0x87, 0x0D, 0x01, 0x87, 0x00, 0xC3, 0x80, 0x61, 0x80, 0x60, 0xC0,
  0x60, 0x61, 0xE0, 0x67, 0xC0, 0x31, 0x80, 0x18, 0x40, 0x4C, 0x30, 0x76,
  0x0C, 0x73, 0x06, 0xE3, 0x01, 0xE1, 0x80, 0xE0, 0xFF, 0x07, 0xF8, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x10,
  0xC0, 0xC6, 0x1C, 0x61, 0xC3, 0x3C, 0x1B, 0x80, 0xF8, 0x07, 0x00, 0x13,
  0x87, 0x8D, 0xF3, 0xE3, 0xCD, 0x9C, 0xE1, 0xC3, 0x30, 0x60, 0xCC, 0x18,
  0x22, 0x04, 0x09, 0x83, 0x06, 0x60, 0xC1, 0x98, 0x30, 0x66, 0x0C, 0x19,
  0x02, 0x04, 0x40, 0x81, 0x30, 0x60, 0xCC, 0x18, 0x33, 0x06, 0x0C, 0xC1,
  0x83, 0x00, 0x18, 0xF8, 0x33, 0xF8, 0x6C, 0x30, 0xE0, 0x33, 0x80, 0x67,
  0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x04, 0x40, 0x19, 0x80, 0x33, 0x00,
  0x66, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x20, 0x0C, 0xC0, 0x18, 0x03, 0xF0,
  0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x33, 0x00, 0x6C, 0x00, 0x58, 0x00, 0xB0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x74, 0x00, 0xCC, 0x03,
  0x9C, 0x0E, 0x1F, 0xF8, 0x0F, 0xC0, 0x0C, 0x7C, 0x06, 0xFF, 0x02, 0xC1,
  0xC3, 0x40, 0x61, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x10,
  0x01, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x61, 0x80, 0x70,
  0xB0, 0x70, 0xCF, 0xF0, 0x63, 0xE0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x07, 0xE3, 0x0F,
  0xF2, 0x1C, 0x1E, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x06, 0x60, 0x06, 0xC0,
  0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xE0,
  0x2C, 0x70, 0xD8, 0x3F, 0x98, 0x1F, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0xFE, 0x3F, 0xFE,
  0x7E, 0x06, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x70,
  0x39, 0x80, 0x13, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x0F, 0xF8,
  0x00, 0x78, 0x00, 0x30, 0x00, 0x20, 0x00, 0x58, 0x01, 0xBC, 0x0F, 0x1F,
  0xFC, 0x0F, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x04, 0x30,
  0x38, 0x61, 0xE0, 0xC7, 0x01, 0xBC, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x30,
  0x04, 0x80, 0x36, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x80, 0x36, 0x00, 0x90,
  0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x0E, 0xC0, 0x33, 0x01, 0xCE,
  0x1B, 0x1F, 0xCC, 0x3E, 0x30, 0x7C, 0x06, 0xFC, 0x06, 0x0C, 0x03, 0x0C,
  0x03, 0x0C, 0x03, 0x08, 0x03, 0x08, 0x03, 0x18, 0x06, 0x18, 0x06, 0x18,
  0x06, 0x18, 0x0C, 0x18, 0x1C, 0x10, 0x38, 0x10, 0x70, 0x31, 0xE0, 0x3F,
  0xC0, 0x1E, 0x00, 0x30, 0x63, 0x10, 0x20, 0x88, 0x30, 0x4C, 0x18, 0x36,
  0x0C, 0x1B, 0x06, 0x0D, 0x82, 0x06, 0x81, 0x03, 0x41, 0x81, 0x60, 0xC1,
  0xB0, 0x60, 0xD8, 0x30, 0x6C, 0x30, 0x66, 0x1C, 0x33, 0x16, 0x31, 0xFB,
  0xF8, 0x78, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0xF8, 0xFC, 0x3B, 0x31, 0x9C,
  0x2C, 0x16, 0x07, 0x02, 0x00, 0xE0, 0x40, 0x18, 0x08, 0x03, 0x02, 0x00,
  0x60, 0x00, 0x0C, 0x01, 0x01, 0x80, 0x60, 0x70, 0x0C, 0x0E, 0x0C, 0x82,
  0xC3, 0x18, 0xCD, 0xC3, 0xF1, 0xF0, 0x3C, 0x18, 0x00, 0x0C, 0x01, 0x08,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x02, 0x10,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x30, 0x0C, 0x30,
  0x1C, 0x38, 0x6C, 0x1F, 0xCC, 0x0F, 0x8C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x40, 0x38, 0xE0, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0xC3, 0x1F,
  0xFB, 0x30, 0x7F, 0x20, 0x0E, 0x60, 0x0C, 0x60, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x0C, 0x18, 0x0C, 0x30, 0x04, 0xF8,
  0x06, 0xFF, 0xC6, 0xCF, 0xFE, 0xC0, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x3F, 0x80, 0x7F,
  0x00, 0x07, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x82, 0x04, 0x18,
  0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18,
  0x30, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x3F, 0x80,
  0xFE, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x0F,
  0xF0, 0x1F, 0xC0, 0x00, 0x1E, 0x01, 0x9F, 0x80, 0x9C, 0xE0, 0xCC, 0x30,
  0x4C, 0x0C, 0x66, 0x07, 0xE2, 0x00, 0xE0,
};

const GFXglyph IBMPlexMono_LightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 23, 20, 7, -23 },
  { 19, 8, 9, 20, 8, -24 },
  { 28, 20, 23, 20, 0, -23 },
  { 86, 18, 29, 20, 1, -26 },
  { 152, 23, 23, 20, -1, -23 },
  { 219, 19, 23, 20, 0, -23 },
  { 274, 3, 9, 20, 10, -24 },
  { 278, 12, 30, 20, 7, -25 },
  { 323, 11, 30, 20, 2, -25 },
  { 365, 17, 16, 20, 2, -18 },
  { 399, 16, 16, 20, 2, -18 },
  { 431, 6, 9, 20, 5, -4 },
  { 438, 10, 2, 20, 5, -11 },
  { 441, 4, 4, 20, 7, -4 },
  { 443, 18, 30, 20, 1, -25 },
  { 511, 17, 23, 20, 2, -23 },
  { 560, 16, 23, 20, 1, -23 },
  { 606, 17, 23, 20, 1, -23 },
  { 655, 17, 23, 20, 1, -23 },
  { 704, 17, 23, 20, 1, -23 },
  { 753, 17, 23, 20, 2, -23 },
  { 802, 15, 23, 20, 2, -23 },
  { 846, 16, 23, 20, 4, -23 },
  { 892, 17, 23, 20, 2, -23 },
  { 941, 15, 23, 20, 3, -23 },
  { 985, 6, 18, 20, 7, -18 },
  { 999, 8, 23, 20, 5, -18 },
  { 1022, 16, 18, 20, 3, -19 },
  { 1058, 17, 8, 20, 2, -14 },
  { 1075, 15, 18, 20, 2, -19 },
  { 1109, 13, 23, 20, 5, -23 },
  { 1147, 16, 27, 20, 2, -23 },
  { 1201, 17, 23, 20, 0, -23 },
  { 1250, 16, 23, 20, 2, -23 },
  { 1296, 16, 23, 20, 3, -23 },
  { 1342, 16, 23, 20, 2, -23 },
  { 1388, 17, 23, 20, 2, -23 },
  { 1437, 18, 23, 20, 2, -23 },
  { 1489, 17, 23, 20, 2, -23 },
  { 1538, 18, 23, 20, 1, -23 },
  { 1590, 18, 23, 20, 1, -23 },
  { 1642, 16, 23, 20, 2, -23 },
  { 1688, 19, 23, 20, 2, -23 },
  { 1743, 13, 23, 20, 3, -23 },
  { 1781, 19, 23, 20, 1, -23 },
  { 1836, 18, 23, 20, 1, -23 },
  { 1888, 17, 23, 20, 2, -23 },
  { 1937, 17, 23, 20, 2, -23 },
  { 1986, 17, 29, 20, 2, -23 },
  { 2048, 17, 23, 20, 2, -23 },
  { 2097, 18, 23, 20, 1, -23 },
  { 2149, 18, 23, 20, 3, -23 },
  { 2201, 16, 23, 20, 3, -23 },
  { 2247, 17, 23, 20, 4, -23 },
  { 2296, 19, 23, 20, 2, -23 },
  { 2351, 21, 23, 20, 0, -23 },
  { 2412, 19, 23, 20, 3, -23 },
  { 2467, 20, 23, 20, 0, -23 },
  { 2525, 13, 30, 20, 6, -25 },
  { 2574, 8, 30, 20, 6, -25 },
  { 2604, 13, 30, 20, 1, -25 },
  { 2653, 17, 13, 20, 2, -23 },
  { 2681, 16, 2, 20, 0, 3 },
  { 2685, 4, 6, 20, 8, -25 },
  { 2688, 16, 17, 20, 2, -17 },
  { 2722, 16, 24, 20, 2, -24 },
  { 2770, 14, 17, 20, 3, -17 },
  { 2800, 17, 24, 20, 2, -24 },
  { 2851, 14, 17, 20, 3, -17 },
  { 2881, 22, 31, 20, -1, -24 },
  { 2967, 17, 24, 20, 1, -17 },
  { 3018, 15, 24, 20, 2, -24 },
  { 3063, 14, 24, 20, 3, -24 },
  { 3105, 14, 32, 20, 3, -25 },
  { 3161, 17, 24, 20, 2, -24 },
  { 3212, 13, 24, 20, 4, -24 },
  { 3251, 18, 17, 20, 1, -17 },
  { 3290, 15, 17, 20, 2, -17 },
  { 3322, 15, 17, 20, 2, -17 },
  { 3354, 17, 24, 20, 1, -17 },
  { 3405, 16, 24, 20, 2, -17 },
  { 3453, 16, 17, 20, 4, -17 },
  { 3487, 15, 17, 20, 2, -17 },
  { 3519, 15, 23, 20, 3, -23 },
  { 3563, 14, 17, 20, 3, -17 },
  { 3593, 16, 17, 20, 2, -17 },
  { 3627, 17, 17, 20, 2, -17 },
  { 3664, 19, 17, 20, 0, -17 },
  { 3705, 16, 24, 20, 1, -17 },
  { 3753, 16, 17, 20, 2, -17 },
  { 3787, 15, 30, 20, 4, -25 },
  { 3844, 7, 30, 20, 7, -25 },
  { 3871, 15, 30, 20, 2, -25 },
  { 3928, 17, 7, 20, 2, -14 },
};

const GFXfont IBMPlexMono_LightItalic33pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic33pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic33pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _IBMPLEXMONO_LIGHTITALIC33PT7B_H_
