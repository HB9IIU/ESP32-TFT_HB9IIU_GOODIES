#ifndef _IBMPLEXMONO_LIGHTITALIC36PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x00, 0x00, 0x00, 0x00, 0x70, 0x78,
  0xF8, 0x70, 0x31, 0xCC, 0x66, 0x19, 0x86, 0x61, 0x98, 0x66, 0x31, 0x8C,
  0xC3, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00,
  0xC1, 0x80, 0x06, 0x18, 0x00, 0x20, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x60,
  0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xC0, 0x61, 0x80, 0x02, 0x0C, 0x00, 0x30,
  0x60, 0x01, 0x86, 0x00, 0x18, 0x30, 0x1F, 0xC1, 0xFC, 0xFE, 0x1F, 0xC0,
  0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x10,
  0x00, 0x61, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0x19, 0xE0, 0xE1, 0x86, 0x1C, 0x10, 0x31, 0x81, 0x00, 0x18, 0x30,
  0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0xC3, 0x00, 0x0F, 0x20, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x63, 0x80, 0x04, 0x1C, 0x00,
  0x40, 0xC0, 0x04, 0x0C, 0x00, 0xC0, 0xC4, 0x0C, 0x1C, 0xE0, 0xC1, 0x87,
  0x08, 0x38, 0x38, 0x8F, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x01, 0xF0, 0x03, 0x03,
  0xF8, 0x06, 0x06, 0x1C, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x0C,
  0x0C, 0x18, 0x08, 0x0C, 0x30, 0x08, 0x0C, 0x60, 0x08, 0x18, 0xC0, 0x0C,
  0x38, 0xC0, 0x0F, 0xF1, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xC7, 0xF0, 0x01, 0x8E, 0x38, 0x03, 0x18, 0x18, 0x03,
  0x18, 0x08, 0x06, 0x18, 0x18, 0x0C, 0x10, 0x18, 0x08, 0x10, 0x18, 0x18,
  0x18, 0x30, 0x30, 0x18, 0x70, 0x60, 0x0F, 0xE0, 0xE0, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0xE0, 0x06, 0x03, 0x00, 0x30, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18,
  0x1C, 0x00, 0x60, 0xC0, 0x0F, 0x9C, 0x01, 0xFF, 0x80, 0x1C, 0x60, 0x01,
  0x81, 0x80, 0x0C, 0x06, 0x00, 0xE0, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x07,
  0x05, 0x80, 0x38, 0x3E, 0x01, 0x63, 0x30, 0x13, 0x19, 0xC1, 0x8D, 0x87,
  0xF8, 0x7C, 0x1F, 0x81, 0xC0, 0x36, 0x66, 0x66, 0x6C, 0xCC, 0x00, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x06,
  0x0C, 0x0F, 0xF3, 0x1F, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x0D,
  0x80, 0x06, 0x30, 0x03, 0x8C, 0x01, 0xC1, 0x80, 0xE0, 0x60, 0x70, 0x0C,
  0x08, 0x02, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0E, 0x38, 0x70, 0xC3,
  0x86, 0x1C, 0x30, 0x61, 0x80, 0xFF, 0xFF, 0xF0, 0x73, 0xFE, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x78, 0x38, 0x38, 0x06, 0x1C, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xC0,
  0x03, 0x30, 0x00, 0xDC, 0x00, 0x36, 0x00, 0x0D, 0x83, 0x83, 0x60, 0xE0,
  0xD8, 0x38, 0x7E, 0x00, 0x1F, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0xEE,
  0x00, 0x31, 0x80, 0x1C, 0x60, 0x06, 0x1C, 0x03, 0x83, 0x83, 0xC0, 0x7F,
  0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x76, 0x00, 0x73,
  0x00, 0xF1, 0x80, 0xF1, 0x80, 0xE0, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x1E, 0x0F, 0x03, 0x00, 0xE0, 0xC0, 0x0C, 0x38, 0x01,
  0xC2, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x7F, 0xE0, 0x78, 0x3C, 0x38, 0x03, 0x0C, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0xC0, 0x03, 0x18, 0x01, 0xC7,
  0x81, 0xE0, 0x7F, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x06, 0xC0, 0x01, 0x98, 0x00, 0x73, 0x00, 0x0C, 0x60,
  0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x03, 0x81, 0x80,
  0x60, 0x30, 0x18, 0x0E, 0x06, 0x01, 0x81, 0x80, 0x30, 0x60, 0x06, 0x18,
  0x00, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x7E, 0x01, 0x7F, 0xE0, 0xF8, 0x38, 0x38, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0xC0, 0x06, 0x38, 0x03, 0x87, 0x83, 0xC0, 0xFF,
  0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0xFC, 0x0C, 0xFF, 0x86, 0xC1, 0xE6, 0x80, 0x33, 0x80, 0x1D, 0x80, 0x06,
  0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xCC, 0x00, 0x66, 0x00,
  0x73, 0x80, 0x70, 0xE0, 0x70, 0x3F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xD8, 0x00, 0x78, 0x00, 0x6C, 0x00, 0x76, 0x00, 0x33, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0xF0, 0x38, 0x30,
  0x07, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01,
  0x86, 0x00, 0x60, 0xE0, 0x70, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0x03, 0x83,
  0x00, 0x31, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x0E, 0xC0, 0x03, 0x38, 0x01, 0xC7, 0x81, 0xE0, 0xFF, 0xF0, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0x83, 0xC7, 0x00, 0x63, 0x00, 0x3B,
  0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xEC, 0x00, 0xE7, 0x00, 0xF1, 0xC0, 0xF0, 0xFF, 0xD8, 0x1F, 0x98, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x3C, 0x78, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x79, 0xF1, 0xC0,
  0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x03,
  0x81, 0x80, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x10, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0x73, 0x80, 0x76, 0x00, 0xF8, 0x00,
  0xD0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x1F, 0x00,
  0xF8, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x78, 0x38, 0x38, 0x06, 0x0C, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x0C, 0x40, 0xF3, 0x30, 0xFE, 0xCC, 0x30, 0xB3, 0x18,
  0x19, 0x86, 0x06, 0x61, 0x01, 0x98, 0xC0, 0x66, 0x30, 0x19, 0x8C, 0x06,
  0x63, 0x03, 0x10, 0xC0, 0xCC, 0x30, 0x73, 0x0E, 0x2C, 0xC1, 0xFB, 0x30,
  0x3C, 0xC4, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x07,
  0x18, 0x00, 0xC3, 0x00, 0x38, 0x60, 0x06, 0x0C, 0x01, 0xC0, 0xC0, 0x30,
  0x18, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x70, 0x07, 0x0C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x01, 0x9C, 0x00,
  0x33, 0x00, 0x06, 0xC0, 0x00, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xC0,
  0x38, 0x70, 0x06, 0x18, 0x01, 0xC6, 0x00, 0x31, 0x80, 0x1C, 0x60, 0x06,
  0x18, 0x01, 0x8E, 0x00, 0xE3, 0x00, 0x70, 0xFF, 0xF0, 0x3F, 0xFC, 0x0C,
  0x01, 0xC3, 0x00, 0x31, 0xC0, 0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00,
  0x39, 0x80, 0x0C, 0x60, 0x03, 0x38, 0x01, 0xCC, 0x00, 0xE3, 0xFF, 0xF0,
  0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x70, 0x70, 0x38, 0x0E,
  0x18, 0x01, 0x8E, 0x00, 0x73, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x23, 0x00, 0x1C,
  0x60, 0x0E, 0x18, 0x07, 0x07, 0x83, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xC0, 0x70, 0x30, 0x0E, 0x0C, 0x01, 0xC7,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x73, 0x00, 0x1C, 0xC0, 0x06,
  0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06, 0x18,
  0x03, 0x86, 0x03, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0x03, 0xC1, 0xC3, 0x80, 0x71, 0x80, 0x19, 0x80,
  0x0C, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x07, 0xFB, 0x03, 0xFD, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCE, 0x00, 0xE3, 0x00, 0xB1, 0xC1,
  0xD8, 0x7F, 0xD8, 0x1F, 0x8C, 0x00, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x70,
  0x03, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0,
  0x06, 0x30, 0x01, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x60, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x71, 0x80, 0x0C, 0x30, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE3, 0x00, 0x30, 0xE0, 0x0C, 0x18, 0x06, 0x07, 0x07, 0x80, 0xFF, 0xC0,
  0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x38, 0x60, 0x03, 0x03, 0x00, 0x30, 0x38,
  0x03, 0x01, 0x80, 0x70, 0x0C, 0x07, 0x00, 0x60, 0x70, 0x03, 0x07, 0x00,
  0x18, 0x70, 0x01, 0xC7, 0x00, 0x0C, 0x70, 0x00, 0x67, 0x80, 0x03, 0x7E,
  0x00, 0x1F, 0x30, 0x00, 0xF1, 0xC0, 0x0F, 0x06, 0x00, 0x70, 0x38, 0x03,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xE0, 0x70, 0x03,
  0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xB1, 0x90, 0x33, 0x19,
  0x83, 0x61, 0x98, 0x66, 0x19, 0x86, 0x61, 0x88, 0xC6, 0x18, 0xD8, 0x63,
  0x0D, 0x86, 0x30, 0xF0, 0xC3, 0x07, 0x0C, 0x30, 0x60, 0xC3, 0x04, 0x0C,
  0x30, 0x40, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01,
  0x86, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x61, 0xC0, 0x0C, 0x6C, 0x01, 0x8D, 0x80, 0x61, 0xB0, 0x0C, 0x36,
  0x01, 0x86, 0x60, 0x30, 0xCC, 0x06, 0x31, 0x80, 0xC6, 0x18, 0x30, 0xC3,
  0x06, 0x18, 0x60, 0xC3, 0x0C, 0x18, 0x60, 0xC3, 0x18, 0x18, 0x63, 0x03,
  0x18, 0x60, 0x63, 0x0C, 0x06, 0x61, 0x80, 0xCC, 0x30, 0x19, 0x8C, 0x01,
  0xB1, 0x80, 0x3C, 0x30, 0x07, 0x86, 0x00, 0xF0, 0xC0, 0x0E, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x78, 0x38, 0x38, 0x06, 0x1C, 0x00, 0xC6, 0x00,
  0x33, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xDC, 0x00, 0x36, 0x00, 0x0D,
  0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x06, 0xE0,
  0x01, 0xB8, 0x00, 0xEE, 0x00, 0x31, 0x80, 0x1C, 0x60, 0x06, 0x1C, 0x03,
  0x83, 0x83, 0xC0, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x30, 0x07, 0x06, 0x00, 0x71, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00,
  0x18, 0xC0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x01,
  0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x78, 0x38, 0x38, 0x06, 0x1C, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C,
  0xC0, 0x03, 0x30, 0x00, 0xDC, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60,
  0x00, 0xD8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00,
  0xEE, 0x00, 0x31, 0x80, 0x1C, 0x60, 0x06, 0x1C, 0x03, 0x03, 0x83, 0xC0,
  0x7F, 0xC0, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x63, 0x80, 0x1D, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x30, 0x07, 0x06, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00,
  0x18, 0xC0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x01,
  0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x70, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0xC0, 0xC0, 0x18,
  0x38, 0x03, 0x86, 0x00, 0x30, 0xC0, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0x01, 0xE0, 0xE0, 0x06, 0x1C, 0x00, 0x31, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC4, 0x00, 0x1C, 0xE0, 0x01,
  0x87, 0x00, 0x38, 0x3C, 0x0F, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x06, 0x30,
  0x01, 0x8C, 0x00, 0x63, 0x00, 0x19, 0xC0, 0x06, 0x60, 0x03, 0x98, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x38, 0x00, 0xCC, 0x00, 0x73,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x30, 0xC0,
  0x0C, 0x38, 0x07, 0x07, 0x03, 0x81, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0xC0,
  0x00, 0xF8, 0x00, 0x19, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x30, 0xC0,
  0x06, 0x18, 0x01, 0xC3, 0x00, 0x30, 0x60, 0x0E, 0x06, 0x01, 0x80, 0xC0,
  0x70, 0x18, 0x0C, 0x03, 0x03, 0x80, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x83,
  0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x01, 0x98,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x19, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x02,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x84, 0x0C, 0x0C, 0x60, 0xF0, 0x43, 0x07,
  0x86, 0x18, 0x6C, 0x30, 0xC3, 0x61, 0x86, 0x13, 0x08, 0x31, 0x98, 0xC1,
  0x8C, 0xC6, 0x0C, 0xC6, 0x30, 0x66, 0x31, 0x03, 0x20, 0x98, 0x1B, 0x04,
  0xC0, 0x98, 0x26, 0x05, 0x81, 0xA0, 0x6C, 0x0F, 0x03, 0x40, 0x78, 0x1E,
  0x03, 0xC0, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x0C,
  0x00, 0xE0, 0x18, 0x03, 0x80, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00, 0x30,
  0x60, 0x00, 0x61, 0xC0, 0x00, 0x67, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x66, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x18, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x30,
  0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x36, 0x00, 0x06, 0x70, 0x00,
  0xE3, 0x00, 0x1C, 0x38, 0x01, 0x81, 0x80, 0x30, 0x18, 0x07, 0x00, 0xC0,
  0xE0, 0x0C, 0x0C, 0x00, 0xE1, 0x80, 0x06, 0x30, 0x00, 0x67, 0x00, 0x03,
  0x60, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x01,
  0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x08,
  0x04, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x80,
  0x60, 0x30, 0x08, 0x04, 0x03, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x36, 0x00, 0x33, 0x00, 0x31, 0xC0,
  0x38, 0x60, 0x18, 0x30, 0x18, 0x0C, 0x18, 0x06, 0x1C, 0x01, 0x8C, 0x00,
  0xCC, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x47, 0x18, 0x63, 0x08, 0x60, 0x03, 0xF1, 0x87, 0xFC, 0xC7, 0x83, 0x63,
  0x00, 0xB3, 0x00, 0x33, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03,
  0x70, 0x01, 0xB0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x73, 0x80,
  0x58, 0xC0, 0x2C, 0x70, 0x6C, 0x1F, 0xE7, 0xC7, 0xE1, 0xE0, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x7C, 0x0C, 0xFF, 0x86, 0xC1, 0xC3, 0x40, 0x71,
  0xC0, 0x19, 0xC0, 0x0C, 0xE0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0x66, 0x00, 0x36, 0x00, 0x33, 0x00, 0x19, 0x80, 0x1C, 0xE0,
  0x1C, 0x68, 0x1C, 0x37, 0xFC, 0x30, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xF8,
  0x70, 0x71, 0xC0, 0x37, 0x00, 0x6C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x58, 0x00, 0xF0, 0x03,
  0x30, 0x0C, 0x70, 0x70, 0x7F, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x03, 0xF1, 0x81, 0xFF, 0x30, 0x78, 0x36, 0x0C, 0x01,
  0xC3, 0x00, 0x38, 0xE0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03,
  0x1C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x1C,
  0x38, 0x03, 0x83, 0x00, 0xB0, 0x70, 0x66, 0x07, 0xF9, 0x80, 0x7E, 0x30,
  0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x1E, 0x0E, 0x38, 0x07, 0x30, 0x03, 0x60,
  0x03, 0x60, 0x06, 0xC0, 0x0E, 0xC0, 0xFC, 0xFF, 0xF0, 0xFF, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x06, 0xC0, 0x0E, 0x60, 0x1C, 0x70, 0x38, 0x3F,
  0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x40, 0x70, 0x00,
  0xE0, 0x60, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x0E, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF8, 0xC1,
  0xFF, 0x30, 0xF0, 0x6C, 0x30, 0x07, 0x18, 0x01, 0xCE, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x06, 0x30, 0x01, 0x9C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0C,
  0x60, 0x03, 0x18, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x2C, 0x3C, 0x33, 0x07,
  0xF9, 0x80, 0x7C, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x04, 0x01,
  0xC3, 0xC0, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0xF8, 0x67, 0xF8, 0xDC, 0x39, 0xA0, 0x33, 0x80, 0x66, 0x00, 0xCC, 0x01,
  0xB8, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x76, 0x00, 0xD8,
  0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x3B, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x02, 0x06, 0x07, 0x06, 0x1C, 0x06, 0x38, 0x0C, 0x70, 0x0D, 0xC0, 0x0F,
  0x80, 0x07, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x40, 0x60, 0xE0, 0x60, 0x70,
  0x60, 0x38, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x7C, 0x03, 0x3F, 0xE0, 0x6E,
  0x1C, 0x0D, 0x01, 0x81, 0xC0, 0x38, 0x30, 0x06, 0x0E, 0x00, 0xC1, 0x80,
  0x30, 0x30, 0x0C, 0x06, 0x0F, 0x00, 0xCF, 0x80, 0x18, 0xC0, 0x07, 0x18,
  0x04, 0xC1, 0x81, 0x98, 0x30, 0x7B, 0x03, 0x1C, 0x60, 0x67, 0x0C, 0x07,
  0x83, 0x80, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x03, 0x18, 0x1C, 0x60, 0xE1, 0x8E, 0x06, 0x70, 0x1B, 0x80,
  0x7C, 0x01, 0xC0, 0x00, 0x19, 0xC3, 0xC3, 0x7C, 0xFC, 0x71, 0xF1, 0x9C,
  0x1C, 0x33, 0x83, 0x06, 0x60, 0x60, 0xCC, 0x0C, 0x19, 0x83, 0x03, 0x30,
  0x60, 0x6C, 0x0C, 0x0D, 0x81, 0x81, 0x30, 0x30, 0x66, 0x04, 0x0C, 0xC1,
  0x81, 0x98, 0x30, 0x36, 0x06, 0x06, 0xC0, 0xC1, 0x98, 0x18, 0x33, 0x06,
  0x06, 0x00, 0x18, 0xF8, 0x67, 0xF8, 0xDC, 0x39, 0xA0, 0x33, 0x80, 0x66,
  0x00, 0xCC, 0x01, 0xB8, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00,
  0x76, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x3B,
  0x00, 0x60, 0x03, 0xF0, 0x0F, 0xFC, 0x1C, 0x1E, 0x38, 0x06, 0x70, 0x03,
  0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xE0, 0x1C, 0x70, 0x78,
  0x3F, 0xF0, 0x0F, 0xC0, 0x0C, 0x3E, 0x03, 0x3F, 0xE0, 0xD8, 0x38, 0x34,
  0x07, 0x0E, 0x00, 0xC7, 0x00, 0x31, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x0C, 0xE0, 0x03, 0x30, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x38, 0xE0, 0x1C, 0x34, 0x0E, 0x1D, 0xFF, 0x06, 0x1F, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xF1, 0x87, 0xFC, 0xC7, 0x83, 0x63, 0x00, 0x73,
  0x00, 0x3B, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x70, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x73, 0x80, 0x38, 0xC0,
  0x2C, 0x70, 0x66, 0x1F, 0xE6, 0x07, 0xE3, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xFF,
  0x1F, 0xFF, 0x9F, 0xC0, 0xD8, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0x81, 0xE3, 0x00,
  0x21, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x19, 0x00, 0x0D,
  0xC0, 0x0C, 0x78, 0x1E, 0x1F, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x01, 0x03,
  0x01, 0x81, 0x83, 0xE0, 0xC3, 0x80, 0x67, 0x80, 0x67, 0x00, 0x3F, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x07, 0x30,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x60,
  0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x2C, 0xE0, 0x3C, 0x70,
  0xD8, 0x7F, 0x98, 0x1F, 0x18, 0xFC, 0x03, 0xFC, 0x07, 0x0C, 0x03, 0x0C,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18,
  0x07, 0x18, 0x06, 0x30, 0x0E, 0x30, 0x0C, 0x30, 0x1C, 0x30, 0x38, 0x30,
  0x70, 0x33, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x30, 0x30, 0xCC, 0x08, 0x33,
  0x06, 0x0C, 0xC1, 0x83, 0x20, 0x60, 0x58, 0x18, 0x16, 0x06, 0x05, 0x81,
  0x03, 0x60, 0xC0, 0xD8, 0x30, 0x34, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0,
  0xF0, 0x60, 0x6C, 0x18, 0x1B, 0x0E, 0x0C, 0xC6, 0xC7, 0x3F, 0x3F, 0x87,
  0x87, 0x80, 0x01, 0xC1, 0xE0, 0x3F, 0x1F, 0x83, 0x99, 0x86, 0x78, 0xC8,
  0x33, 0x02, 0xC1, 0x80, 0x1C, 0x0C, 0x00, 0xE0, 0x60, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x06, 0x07, 0x00,
  0x60, 0x38, 0x13, 0x02, 0xC1, 0xCC, 0x36, 0x1C, 0x63, 0x1B, 0x83, 0xF8,
  0xF8, 0x0F, 0x03, 0x80, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30,
  0x07, 0x0C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01,
  0x86, 0x00, 0xE1, 0x80, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0xC3,
  0x00, 0xB0, 0xE0, 0x3C, 0x1C, 0x36, 0x03, 0xF9, 0x80, 0x7C, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x04, 0x01, 0xC3, 0xC1, 0xE0, 0x7F, 0xF0,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xC7, 0xFF, 0x33, 0x83, 0xFC, 0xC0, 0x1E,
  0x30, 0x03, 0x0C, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x08, 0x0C, 0x06, 0x06, 0x00, 0xC7, 0x00,
  0x33, 0xF8, 0x0C, 0xFF, 0xF3, 0x30, 0xFF, 0xCC, 0x07, 0xE0, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x07, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x83,
  0x04, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0x0E, 0x00, 0x4F, 0xE0, 0x33, 0x1C, 0x0D, 0x83, 0x06, 0x40,
  0x63, 0x30, 0x1F, 0xCC, 0x01, 0xC0,
};

const GFXglyph IBMPlexMono_LightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 8, 25, 22, 7, -25 },
  { 26, 10, 10, 22, 8, -27 },
  { 39, 21, 25, 22, 1, -25 },
  { 105, 20, 33, 22, 1, -29 },
  { 188, 24, 25, 22, -1, -25 },
  { 263, 21, 25, 22, 0, -25 },
  { 329, 4, 10, 22, 11, -27 },
  { 334, 12, 32, 22, 8, -27 },
  { 382, 12, 32, 22, 2, -27 },
  { 430, 18, 18, 22, 2, -20 },
  { 471, 18, 18, 22, 2, -20 },
  { 512, 7, 10, 22, 5, -4 },
  { 521, 10, 2, 22, 6, -12 },
  { 524, 5, 4, 22, 7, -4 },
  { 527, 20, 32, 22, 1, -27 },
  { 607, 18, 25, 22, 2, -25 },
  { 664, 17, 25, 22, 2, -25 },
  { 718, 19, 25, 22, 1, -25 },
  { 778, 18, 25, 22, 1, -25 },
  { 835, 19, 25, 22, 1, -25 },
  { 895, 18, 25, 22, 2, -25 },
  { 952, 17, 25, 22, 2, -25 },
  { 1006, 17, 25, 22, 4, -25 },
  { 1060, 18, 25, 22, 2, -25 },
  { 1117, 17, 25, 22, 3, -25 },
  { 1171, 7, 19, 22, 7, -19 },
  { 1188, 9, 25, 22, 5, -19 },
  { 1217, 17, 20, 22, 3, -21 },
  { 1260, 18, 8, 22, 2, -15 },
  { 1278, 17, 20, 22, 2, -21 },
  { 1321, 15, 25, 22, 5, -25 },
  { 1368, 18, 29, 22, 2, -25 },
  { 1434, 19, 25, 22, 0, -25 },
  { 1494, 18, 25, 22, 2, -25 },
  { 1551, 18, 25, 22, 3, -25 },
  { 1608, 18, 25, 22, 2, -25 },
  { 1665, 19, 25, 22, 2, -25 },
  { 1725, 20, 25, 22, 2, -25 },
  { 1788, 17, 25, 22, 3, -25 },
  { 1842, 19, 25, 22, 2, -25 },
  { 1902, 19, 25, 22, 2, -25 },
  { 1962, 18, 25, 22, 2, -25 },
  { 2019, 21, 25, 22, 2, -25 },
  { 2085, 15, 25, 22, 3, -25 },
  { 2132, 20, 25, 22, 1, -25 },
  { 2195, 19, 25, 22, 2, -25 },
  { 2255, 18, 25, 22, 2, -25 },
  { 2312, 19, 25, 22, 2, -25 },
  { 2372, 18, 32, 22, 2, -25 },
  { 2444, 19, 25, 22, 2, -25 },
  { 2504, 20, 25, 22, 1, -25 },
  { 2567, 20, 25, 22, 3, -25 },
  { 2630, 18, 25, 22, 3, -25 },
  { 2687, 19, 25, 22, 4, -25 },
  { 2747, 21, 25, 22, 2, -25 },
  { 2813, 23, 25, 22, 0, -25 },
  { 2885, 20, 25, 22, 3, -25 },
  { 2948, 22, 25, 22, 0, -25 },
  { 3017, 15, 32, 22, 6, -27 },
  { 3077, 9, 32, 22, 7, -27 },
  { 3113, 14, 32, 22, 1, -27 },
  { 3169, 17, 14, 22, 3, -25 },
  { 3199, 17, 2, 22, 0, 4 },
  { 3204, 5, 7, 22, 8, -28 },
  { 3209, 17, 19, 22, 2, -19 },
  { 3250, 17, 27, 22, 2, -27 },
  { 3308, 15, 19, 22, 3, -19 },
  { 3344, 19, 27, 22, 2, -27 },
  { 3409, 16, 19, 22, 3, -19 },
  { 3447, 24, 34, 22, -1, -27 },
  { 3549, 18, 26, 22, 1, -19 },
  { 3608, 15, 27, 22, 3, -27 },
  { 3659, 16, 26, 22, 3, -26 },
  { 3711, 16, 34, 22, 3, -27 },
  { 3779, 19, 27, 22, 2, -27 },
  { 3844, 14, 27, 22, 4, -27 },
  { 3892, 19, 19, 22, 1, -19 },
  { 3938, 15, 19, 22, 3, -19 },
  { 3974, 16, 19, 22, 3, -19 },
  { 4012, 18, 26, 22, 1, -19 },
  { 4071, 17, 26, 22, 2, -19 },
  { 4127, 17, 19, 22, 4, -19 },
  { 4168, 17, 19, 22, 2, -19 },
  { 4209, 17, 25, 22, 3, -25 },
  { 4263, 16, 19, 22, 3, -19 },
  { 4301, 16, 19, 22, 3, -19 },
  { 4339, 18, 19, 22, 2, -19 },
  { 4382, 21, 19, 22, 0, -19 },
  { 4432, 18, 26, 22, 1, -19 },
  { 4491, 18, 19, 22, 2, -19 },
  { 4534, 17, 32, 22, 4, -27 },
  { 4602, 7, 32, 22, 8, -27 },
  { 4630, 16, 32, 22, 2, -27 },
  { 4694, 18, 7, 22, 2, -15 },
};

const GFXfont IBMPlexMono_LightItalic36pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic36pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _IBMPLEXMONO_LIGHTITALIC36PT7B_H_
