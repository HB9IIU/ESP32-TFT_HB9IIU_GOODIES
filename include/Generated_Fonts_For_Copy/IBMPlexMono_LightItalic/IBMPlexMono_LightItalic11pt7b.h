#ifndef _IBMPLEXMONO_LIGHTITALIC11PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x63, 0xFC, 0x14, 0x31, 0x99, 0x42, 0x99, 0x94, 0x28, 0x18,
  0xE5, 0x54, 0x30, 0x72, 0x69, 0x78, 0x80, 0x72, 0xAA, 0x63, 0x00, 0xCE,
  0xA9, 0x4E, 0x39, 0x24, 0x8A, 0xF2, 0x49, 0xDB, 0xE0, 0x12, 0x48, 0x88,
  0x88, 0x86, 0x44, 0x92, 0x4A, 0x50, 0x21, 0x3E, 0xC9, 0x00, 0x21, 0x3E,
  0x44, 0x00, 0xE8, 0xE0, 0xC0, 0x04, 0x10, 0x82, 0x10, 0x82, 0x10, 0x42,
  0x00, 0x7A, 0x63, 0x1A, 0xC6, 0x5C, 0x18, 0xC5, 0x04, 0x10, 0x41, 0x3F,
  0x39, 0x10, 0x41, 0x08, 0xC4, 0x3E, 0x19, 0x90, 0x4E, 0x08, 0x28, 0x9C,
  0x0C, 0x62, 0x92, 0x8B, 0xF0, 0x82, 0x7A, 0x21, 0xE8, 0x86, 0x4E, 0x13,
  0x11, 0xE8, 0xC6, 0x5E, 0x7E, 0x29, 0x04, 0x20, 0x84, 0x30, 0x7C, 0x62,
  0xEC, 0xC6, 0x3E, 0x74, 0x63, 0x17, 0x88, 0x98, 0x40, 0x30, 0x40, 0x3A,
  0x09, 0xB1, 0x06, 0x08, 0xF8, 0x3E, 0x83, 0x04, 0x36, 0x40, 0x3A, 0x62,
  0x13, 0x20, 0x08, 0x7A, 0x6F, 0x9C, 0xE6, 0xD0, 0xF0, 0x18, 0x62, 0x8A,
  0x49, 0xE4, 0xA1, 0x7C, 0x63, 0xE8, 0xC6, 0x3E, 0x32, 0x61, 0x08, 0x4A,
  0x6C, 0x74, 0x63, 0x18, 0xC6, 0x5C, 0x7C, 0x21, 0xF8, 0x42, 0x1E, 0x7E,
  0x08, 0x3E, 0x82, 0x08, 0x20, 0x32, 0x61, 0x0B, 0xC6, 0x5E, 0x45, 0x14,
  0x5F, 0x45, 0x18, 0xA2, 0x3C, 0x41, 0x04, 0x10, 0x42, 0x3E, 0x78, 0x42,
  0x21, 0x0A, 0x5C, 0xCE, 0x49, 0x28, 0xE2, 0x49, 0x26, 0x44, 0x88, 0x88,
  0x8F, 0x26, 0xD9, 0xB3, 0xA5, 0x50, 0xA1, 0x44, 0x25, 0x96, 0x55, 0x56,
  0x59, 0xA2, 0x7A, 0x63, 0x18, 0xC6, 0x5C, 0x7C, 0x63, 0x1F, 0x42, 0x10,
  0x7A, 0x63, 0x18, 0xC6, 0x5C, 0x28, 0x80, 0x7C, 0x63, 0x1F, 0x52, 0x52,
  0x39, 0x14, 0x0C, 0x0C, 0x18, 0x5E, 0xFC, 0x82, 0x08, 0x20, 0x84, 0x10,
  0x8C, 0x63, 0x18, 0xC6, 0x5E, 0x86, 0x28, 0xA4, 0x51, 0x86, 0x10, 0x86,
  0x1A, 0xBA, 0xEB, 0xAB, 0x24, 0x42, 0x48, 0xA0, 0x81, 0x05, 0x12, 0x42,
  0x86, 0x25, 0x14, 0x20, 0x84, 0x10, 0x3E, 0x88, 0x20, 0x82, 0x08, 0x20,
  0x7E, 0x74, 0x44, 0x88, 0x88, 0x8E, 0x92, 0x44, 0x92, 0x44, 0x38, 0x84,
  0x21, 0x08, 0x44, 0x27, 0x00, 0x32, 0x93, 0x10, 0xF8, 0xC0, 0x7C, 0x65,
  0x29, 0x7C, 0x44, 0x2D, 0x98, 0xC6, 0x5E, 0x74, 0x61, 0x09, 0x30, 0x08,
  0x5F, 0x18, 0xCA, 0x5E, 0x74, 0x7D, 0x09, 0xB0, 0x0E, 0x21, 0xF8, 0x81,
  0x02, 0x08, 0x50, 0xE0, 0xC0, 0x3D, 0x14, 0xA2, 0x59, 0xE8, 0x9C, 0x42,
  0x2C, 0x98, 0xCA, 0x52, 0x20, 0x38, 0x84, 0x25, 0x4C, 0x08, 0x00, 0xE1,
  0x08, 0x44, 0xA7, 0x18, 0x44, 0x2D, 0x99, 0x72, 0xB2, 0xE1, 0x08, 0x84,
  0x29, 0x6C, 0x7D, 0x59, 0x65, 0xA6, 0x90, 0xB6, 0x63, 0x29, 0x48, 0x74,
  0x63, 0x19, 0x70, 0x59, 0x94, 0x51, 0x4A, 0xE8, 0x20, 0x7C, 0x65, 0x2B,
  0x78, 0x42, 0xFC, 0x84, 0x10, 0x41, 0x00, 0x74, 0xF8, 0x29, 0x78, 0x21,
  0x3E, 0x84, 0x29, 0x6C, 0x8C, 0x65, 0x29, 0x78, 0xCA, 0x63, 0x29, 0x70,
  0xAD, 0x6B, 0x5C, 0xD8, 0x2D, 0xD9, 0x64, 0xB5, 0x60, 0x45, 0x14, 0x92,
  0x49, 0xE8, 0x9C, 0x7C, 0x4C, 0x89, 0x7C, 0x19, 0x08, 0x2E, 0x10, 0x88,
  0x43, 0x80, 0x69, 0x24, 0xA4, 0x90, 0x38, 0x21, 0x08, 0x1C, 0xC2, 0x08,
  0x33, 0x80, 0xCD, 0x64,
};

const GFXglyph IBMPlexMono_LightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 2, 3, 7, 3, -8 },
  { 4, 7, 8, 7, 0, -8 },
  { 11, 6, 10, 7, 0, -9 },
  { 19, 7, 8, 7, 0, -8 },
  { 26, 6, 8, 7, 0, -8 },
  { 32, 1, 3, 7, 3, -8 },
  { 33, 4, 10, 7, 2, -8 },
  { 38, 3, 10, 7, 1, -8 },
  { 42, 5, 5, 7, 1, -6 },
  { 46, 5, 5, 7, 1, -6 },
  { 50, 2, 3, 7, 2, -1 },
  { 51, 3, 1, 7, 2, -4 },
  { 52, 2, 1, 7, 2, -1 },
  { 53, 6, 10, 7, 0, -8 },
  { 61, 5, 8, 7, 1, -8 },
  { 66, 6, 8, 7, 0, -8 },
  { 72, 6, 8, 7, 0, -8 },
  { 78, 6, 8, 7, 0, -8 },
  { 84, 6, 8, 7, 0, -8 },
  { 90, 5, 8, 7, 1, -8 },
  { 95, 5, 8, 7, 1, -8 },
  { 100, 6, 8, 7, 1, -8 },
  { 106, 5, 8, 7, 1, -8 },
  { 111, 5, 8, 7, 1, -8 },
  { 116, 2, 6, 7, 2, -6 },
  { 118, 2, 8, 7, 2, -6 },
  { 120, 5, 6, 7, 1, -6 },
  { 124, 5, 3, 7, 1, -5 },
  { 126, 5, 6, 7, 1, -6 },
  { 130, 5, 8, 7, 1, -8 },
  { 135, 5, 9, 7, 1, -8 },
  { 141, 6, 8, 7, 0, -8 },
  { 147, 5, 8, 7, 1, -8 },
  { 152, 5, 8, 7, 1, -8 },
  { 157, 5, 8, 7, 1, -8 },
  { 162, 5, 8, 7, 1, -8 },
  { 167, 6, 8, 7, 1, -8 },
  { 173, 5, 8, 7, 1, -8 },
  { 178, 6, 8, 7, 0, -8 },
  { 184, 6, 8, 7, 0, -8 },
  { 190, 5, 8, 7, 1, -8 },
  { 195, 6, 8, 7, 1, -8 },
  { 201, 4, 8, 7, 1, -8 },
  { 205, 7, 8, 7, 0, -8 },
  { 212, 6, 8, 7, 0, -8 },
  { 218, 5, 8, 7, 1, -8 },
  { 223, 5, 8, 7, 1, -8 },
  { 228, 5, 10, 7, 1, -8 },
  { 235, 5, 8, 7, 1, -8 },
  { 240, 6, 8, 7, 0, -8 },
  { 246, 6, 8, 7, 1, -8 },
  { 252, 5, 8, 7, 1, -8 },
  { 257, 6, 8, 7, 1, -8 },
  { 263, 6, 8, 7, 1, -8 },
  { 269, 7, 8, 7, 0, -8 },
  { 276, 6, 8, 7, 1, -8 },
  { 282, 7, 8, 7, 0, -8 },
  { 289, 4, 10, 7, 2, -8 },
  { 294, 3, 10, 7, 2, -8 },
  { 298, 5, 10, 7, 0, -8 },
  { 305, 5, 4, 7, 1, -8 },
  { 308, 5, 1, 7, 0, 1 },
  { 309, 1, 2, 7, 3, -9 },
  { 310, 5, 6, 7, 1, -6 },
  { 314, 5, 8, 7, 1, -8 },
  { 319, 5, 6, 7, 1, -6 },
  { 323, 5, 8, 7, 1, -8 },
  { 328, 5, 6, 7, 1, -6 },
  { 332, 7, 10, 7, 0, -8 },
  { 341, 6, 8, 7, 0, -6 },
  { 347, 5, 8, 7, 1, -8 },
  { 352, 5, 8, 7, 1, -8 },
  { 357, 5, 11, 7, 1, -9 },
  { 364, 5, 8, 7, 1, -8 },
  { 369, 5, 8, 7, 1, -8 },
  { 374, 6, 6, 7, 0, -6 },
  { 379, 5, 6, 7, 1, -6 },
  { 383, 5, 6, 7, 1, -6 },
  { 387, 6, 8, 7, 0, -6 },
  { 393, 5, 8, 7, 1, -6 },
  { 398, 6, 6, 7, 1, -6 },
  { 403, 5, 6, 7, 1, -6 },
  { 407, 5, 8, 7, 1, -8 },
  { 412, 5, 6, 7, 1, -6 },
  { 416, 5, 6, 7, 1, -6 },
  { 420, 5, 6, 7, 1, -6 },
  { 424, 6, 6, 7, 0, -6 },
  { 429, 6, 8, 7, 0, -6 },
  { 435, 5, 6, 7, 1, -6 },
  { 439, 5, 10, 7, 1, -8 },
  { 446, 3, 10, 7, 2, -8 },
  { 450, 6, 10, 7, 0, -8 },
  { 458, 5, 3, 7, 1, -5 },
};

const GFXfont IBMPlexMono_LightItalic11pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic11pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic11pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _IBMPLEXMONO_LIGHTITALIC11PT7B_H_
