#ifndef _IBMPLEXMONO_LIGHTITALIC16PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x90, 0x1B, 0x00, 0x99, 0xAA, 0x04, 0x82, 0x40, 0x91,
  0xE7, 0x12, 0x04, 0x81, 0x23, 0x9E, 0x24, 0x09, 0x04, 0x80, 0x02, 0x02,
  0x07, 0xC6, 0x92, 0x41, 0x20, 0xE0, 0x3C, 0x09, 0x04, 0xA2, 0x49, 0x63,
  0xE0, 0x80, 0x40, 0x38, 0x51, 0x24, 0x49, 0x24, 0x3A, 0x00, 0x01, 0x70,
  0x92, 0x48, 0x92, 0x28, 0x70, 0x1E, 0x09, 0x88, 0x44, 0x21, 0x23, 0xE2,
  0x21, 0x08, 0x84, 0xC5, 0x5C, 0xC0, 0xEA, 0x0C, 0x42, 0x08, 0x41, 0x04,
  0x20, 0x82, 0x04, 0x10, 0x40, 0xC0, 0x30, 0x82, 0x10, 0x84, 0x21, 0x08,
  0x44, 0x42, 0x60, 0x08, 0x08, 0x08, 0xF7, 0x18, 0x28, 0x44, 0x84, 0x08,
  0x08, 0x08, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x2D, 0x40, 0xF0, 0xF0,
  0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x06, 0x00, 0x1E, 0x23, 0x41, 0x41, 0x81, 0x99, 0x81, 0x82,
  0x82, 0xC4, 0x78, 0x0C, 0x69, 0xA2, 0x40, 0x81, 0x02, 0x04, 0x10, 0x23,
  0xF8, 0x1E, 0x22, 0x41, 0x01, 0x02, 0x06, 0x0C, 0x10, 0x20, 0xC0, 0xFE,
  0x1E, 0x22, 0x41, 0x02, 0x02, 0x3C, 0x06, 0x02, 0x82, 0x84, 0x78, 0x01,
  0x01, 0x81, 0x41, 0x21, 0x11, 0x10, 0x88, 0x84, 0xFF, 0x81, 0x00, 0x80,
  0x3F, 0x20, 0x40, 0x40, 0x5C, 0x62, 0x02, 0x02, 0x82, 0x84, 0x78, 0x06,
  0x30, 0xC1, 0x05, 0xDC, 0x60, 0xC1, 0x83, 0x8D, 0xE0, 0xFF, 0x82, 0x84,
  0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0xC0, 0x1E, 0x21, 0x41, 0x41,
  0x42, 0x3C, 0x62, 0x82, 0x82, 0x86, 0x7C, 0x3D, 0x8E, 0x0C, 0x18, 0x30,
  0x9F, 0x04, 0x18, 0x63, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x13, 0x00, 0x00,
  0x02, 0x64, 0x80, 0x01, 0x06, 0x18, 0x20, 0xC0, 0x60, 0x10, 0x0C, 0x02,
  0xFF, 0x00, 0x00, 0xFF, 0x40, 0x60, 0x20, 0x30, 0x20, 0x86, 0x30, 0x80,
  0x3C, 0x8E, 0x08, 0x10, 0x47, 0x08, 0x10, 0x00, 0xC1, 0x80, 0x1E, 0x23,
  0x41, 0x4D, 0x53, 0x92, 0xA2, 0xA2, 0x96, 0x9A, 0x80, 0x40, 0x7C, 0x06,
  0x06, 0x0A, 0x0A, 0x12, 0x12, 0x21, 0x3F, 0x41, 0x41, 0x81, 0x3E, 0x43,
  0x41, 0x41, 0x42, 0x7C, 0x42, 0x82, 0x82, 0x82, 0xFC, 0x1E, 0x21, 0x41,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x82, 0x44, 0x38, 0x3C, 0x22, 0x41, 0x41,
  0x41, 0x41, 0x41, 0x82, 0x82, 0x84, 0xF8, 0x3F, 0x40, 0x40, 0x40, 0x40,
  0x7E, 0x40, 0x80, 0x80, 0x80, 0xFE, 0x3F, 0xA0, 0x10, 0x08, 0x04, 0x03,
  0xF1, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x1E, 0x23, 0x41, 0x40, 0x40,
  0x80, 0x8F, 0x82, 0x82, 0x46, 0x7A, 0x61, 0x41, 0x41, 0x41, 0x41, 0x7E,
  0x82, 0x82, 0x82, 0x82, 0x82, 0x3F, 0x48, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0xFE, 0x3F, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04,
  0x84, 0x84, 0x78, 0x21, 0xA1, 0x91, 0x89, 0x05, 0x03, 0x41, 0x21, 0x08,
  0x84, 0x41, 0x20, 0x80, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x83, 0xF8, 0x61, 0xB1, 0x99, 0x4A, 0xA9, 0x94, 0xCA, 0x49, 0x04, 0x82,
  0x41, 0x20, 0x80, 0x61, 0x61, 0x51, 0x51, 0x51, 0x52, 0x8A, 0x8A, 0x8A,
  0x86, 0x86, 0x1E, 0x23, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0xC4,
  0x78, 0x3E, 0x41, 0x41, 0x41, 0x41, 0x7E, 0x40, 0x80, 0x80, 0x80, 0x80,
  0x1E, 0x23, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0xC4, 0x78, 0x10,
  0x0A, 0x0C, 0x3E, 0x41, 0x41, 0x41, 0x41, 0x7E, 0x48, 0x88, 0x84, 0x84,
  0x82, 0x1F, 0x18, 0x48, 0x04, 0x03, 0x00, 0x70, 0x04, 0x02, 0x81, 0x21,
  0x8F, 0x80, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x61, 0x41, 0x41, 0x41, 0x41, 0x42, 0x82, 0x82, 0x82, 0xC4, 0x78,
  0x81, 0x82, 0x82, 0x84, 0x84, 0x48, 0x48, 0x50, 0x50, 0x60, 0x60, 0x40,
  0xA0, 0x60, 0x51, 0x29, 0x94, 0xCA, 0xA9, 0x54, 0xCA, 0x63, 0x31, 0x00,
  0x20, 0x44, 0x21, 0x10, 0x28, 0x0C, 0x03, 0x00, 0xC0, 0x48, 0x22, 0x10,
  0x48, 0x10, 0xC0, 0xA0, 0x88, 0x44, 0x42, 0x40, 0xC0, 0x60, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x3F, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80,
  0xC0, 0x20, 0x10, 0x0F, 0xF0, 0x3C, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x83, 0xC0, 0x88, 0x84, 0x44, 0x44, 0x22, 0x22, 0x11, 0x1E,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x9F, 0x00,
  0x0C, 0x14, 0x12, 0x22, 0x42, 0x81, 0xFF, 0xA4, 0x3B, 0x46, 0x82, 0x82,
  0x82, 0x86, 0x84, 0x7E, 0x20, 0x20, 0x20, 0x40, 0x5E, 0x62, 0x41, 0x41,
  0x42, 0x82, 0xC6, 0xBC, 0x3C, 0xC5, 0x04, 0x08, 0x10, 0x51, 0x3C, 0x01,
  0x01, 0x01, 0x01, 0x3E, 0x42, 0x82, 0x82, 0x82, 0x86, 0x8C, 0x74, 0x1E,
  0xC6, 0x0F, 0xE8, 0x10, 0x51, 0x3C, 0x03, 0xC1, 0x00, 0x40, 0x10, 0x3F,
  0xC1, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x82, 0x20, 0xC8, 0x1C, 0x03,
  0x00, 0x3F, 0x42, 0xC2, 0x82, 0x82, 0x82, 0x8C, 0x74, 0x04, 0x8C, 0xF8,
  0x20, 0x40, 0x81, 0x04, 0xEE, 0x50, 0xA1, 0x43, 0x06, 0x14, 0x20, 0x08,
  0x00, 0x07, 0xC1, 0x02, 0x04, 0x09, 0x26, 0x58, 0xC0, 0x02, 0x00, 0x00,
  0x03, 0xE0, 0x81, 0x02, 0x04, 0x08, 0x24, 0x44, 0x85, 0x06, 0x00, 0x20,
  0x20, 0x20, 0x40, 0x5E, 0x62, 0x42, 0x44, 0x58, 0x91, 0x8A, 0x8C, 0xF0,
  0x42, 0x08, 0x20, 0x82, 0x10, 0x45, 0x35, 0x18, 0x3B, 0xB2, 0x51, 0x29,
  0x14, 0x8A, 0x4A, 0x25, 0x12, 0x4E, 0xE5, 0x0A, 0x14, 0x30, 0x61, 0x42,
  0x3C, 0x85, 0x0C, 0x18, 0x30, 0x71, 0x3C, 0x2F, 0x18, 0x88, 0x24, 0x12,
  0x12, 0x09, 0x8C, 0xBC, 0x40, 0x20, 0x20, 0x00, 0x3F, 0x42, 0x82, 0x82,
  0x82, 0x86, 0x8C, 0x74, 0x04, 0x04, 0x04, 0xEE, 0x60, 0x81, 0x02, 0x08,
  0x10, 0x20, 0x3E, 0x85, 0x03, 0xC0, 0x60, 0x60, 0xBE, 0x10, 0x10, 0x10,
  0xFF, 0x10, 0x10, 0x20, 0x20, 0x22, 0x2C, 0x30, 0x42, 0x85, 0x0A, 0x18,
  0x30, 0xD3, 0x3A, 0xE2, 0x21, 0x21, 0x42, 0x42, 0x46, 0x4C, 0x70, 0x49,
  0x89, 0x89, 0x91, 0x91, 0x91, 0x92, 0xEC, 0x1B, 0xB6, 0x43, 0x21, 0x00,
  0x84, 0xC6, 0x54, 0xCC, 0x21, 0x21, 0x21, 0x21, 0x41, 0x43, 0x26, 0x3A,
  0x02, 0x46, 0xF8, 0x79, 0x47, 0x84, 0x08, 0x10, 0x62, 0xF2, 0x9E, 0x1E,
  0x20, 0x40, 0x81, 0x03, 0x38, 0x18, 0x10, 0x41, 0x02, 0x04, 0x0F, 0x00,
  0x32, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x3C, 0x08, 0x20, 0x41, 0x02,
  0x03, 0x88, 0x20, 0x20, 0x40, 0x81, 0x1E, 0x00, 0x71, 0x9A, 0x8E,
};

const GFXglyph IBMPlexMono_LightItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 11, 10, 3, -11 },
  { 6, 4, 4, 10, 4, -12 },
  { 8, 10, 11, 10, 0, -11 },
  { 22, 9, 15, 10, 0, -13 },
  { 39, 10, 11, 10, 0, -11 },
  { 53, 9, 11, 10, 0, -11 },
  { 66, 2, 4, 10, 5, -12 },
  { 67, 6, 14, 10, 3, -12 },
  { 78, 5, 14, 10, 1, -12 },
  { 87, 8, 8, 10, 1, -9 },
  { 95, 8, 9, 10, 1, -9 },
  { 104, 3, 4, 10, 2, -2 },
  { 106, 4, 1, 10, 3, -5 },
  { 107, 2, 2, 10, 3, -2 },
  { 108, 9, 14, 10, 0, -12 },
  { 124, 8, 11, 10, 1, -11 },
  { 135, 7, 11, 10, 1, -11 },
  { 145, 8, 11, 10, 1, -11 },
  { 156, 8, 11, 10, 1, -11 },
  { 167, 9, 11, 10, 0, -11 },
  { 180, 8, 11, 10, 1, -11 },
  { 191, 7, 11, 10, 1, -11 },
  { 201, 8, 11, 10, 2, -11 },
  { 212, 8, 11, 10, 1, -11 },
  { 223, 7, 11, 10, 2, -11 },
  { 233, 3, 9, 10, 3, -9 },
  { 237, 4, 11, 10, 2, -9 },
  { 243, 8, 9, 10, 1, -9 },
  { 252, 8, 4, 10, 1, -7 },
  { 256, 7, 9, 10, 1, -9 },
  { 264, 7, 11, 10, 2, -11 },
  { 274, 8, 13, 10, 1, -11 },
  { 287, 8, 11, 10, 0, -11 },
  { 298, 8, 11, 10, 1, -11 },
  { 309, 8, 11, 10, 1, -11 },
  { 320, 8, 11, 10, 1, -11 },
  { 331, 8, 11, 10, 1, -11 },
  { 342, 9, 11, 10, 1, -11 },
  { 355, 8, 11, 10, 1, -11 },
  { 366, 8, 11, 10, 1, -11 },
  { 377, 8, 11, 10, 1, -11 },
  { 388, 8, 11, 10, 1, -11 },
  { 399, 9, 11, 10, 1, -11 },
  { 412, 7, 11, 10, 1, -11 },
  { 422, 9, 11, 10, 1, -11 },
  { 435, 8, 11, 10, 1, -11 },
  { 446, 8, 11, 10, 1, -11 },
  { 457, 8, 11, 10, 1, -11 },
  { 468, 8, 14, 10, 1, -11 },
  { 482, 8, 11, 10, 1, -11 },
  { 493, 9, 11, 10, 0, -11 },
  { 506, 8, 11, 10, 2, -11 },
  { 517, 8, 11, 10, 1, -11 },
  { 528, 8, 11, 10, 2, -11 },
  { 539, 9, 11, 10, 1, -11 },
  { 552, 10, 11, 10, 0, -11 },
  { 566, 9, 11, 10, 1, -11 },
  { 579, 10, 11, 10, 0, -11 },
  { 593, 6, 14, 10, 3, -12 },
  { 604, 4, 14, 10, 3, -12 },
  { 611, 7, 14, 10, 0, -12 },
  { 624, 8, 6, 10, 1, -11 },
  { 630, 8, 1, 10, 0, 2 },
  { 631, 2, 3, 10, 4, -13 },
  { 632, 8, 8, 10, 1, -8 },
  { 640, 8, 12, 10, 1, -12 },
  { 652, 7, 8, 10, 1, -8 },
  { 659, 8, 12, 10, 1, -12 },
  { 671, 7, 8, 10, 1, -8 },
  { 678, 10, 15, 10, 0, -12 },
  { 697, 8, 11, 10, 1, -8 },
  { 708, 7, 12, 10, 1, -12 },
  { 719, 7, 11, 10, 1, -11 },
  { 729, 7, 15, 10, 1, -12 },
  { 743, 8, 12, 10, 1, -12 },
  { 755, 6, 12, 10, 2, -12 },
  { 764, 9, 8, 10, 0, -8 },
  { 773, 7, 8, 10, 1, -8 },
  { 780, 7, 8, 10, 1, -8 },
  { 787, 9, 11, 10, 0, -8 },
  { 800, 8, 11, 10, 1, -8 },
  { 811, 7, 8, 10, 2, -8 },
  { 818, 7, 8, 10, 1, -8 },
  { 825, 8, 11, 10, 1, -11 },
  { 836, 7, 8, 10, 1, -8 },
  { 843, 8, 8, 10, 1, -8 },
  { 851, 8, 8, 10, 1, -8 },
  { 859, 9, 8, 10, 0, -8 },
  { 868, 8, 11, 10, 0, -8 },
  { 879, 8, 8, 10, 1, -8 },
  { 887, 7, 14, 10, 2, -12 },
  { 900, 4, 14, 10, 3, -12 },
  { 907, 7, 14, 10, 1, -12 },
  { 920, 8, 3, 10, 1, -7 },
};

const GFXfont IBMPlexMono_LightItalic16pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic16pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _IBMPLEXMONO_LIGHTITALIC16PT7B_H_
