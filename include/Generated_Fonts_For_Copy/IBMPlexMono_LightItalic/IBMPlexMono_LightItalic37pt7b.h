#ifndef _IBMPLEXMONO_LIGHTITALIC37PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x60, 0xC1,
  0x02, 0x04, 0x18, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0xF1, 0xC0,
  0x61, 0xB0, 0xD8, 0x6C, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC3, 0x63, 0x00,
  0x00, 0x18, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x82, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x60, 0x3F, 0xC1,
  0xFC, 0xFF, 0x0F, 0xF0, 0x18, 0x30, 0x00, 0x60, 0x80, 0x01, 0x86, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0x83, 0x00, 0xFE, 0x0F, 0xE3, 0xF8,
  0x7F, 0x80, 0x41, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x20, 0xC0,
  0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xFF,
  0x00, 0x3F, 0xFC, 0x07, 0x89, 0xE0, 0xE1, 0x87, 0x0C, 0x18, 0x31, 0xC1,
  0x80, 0x18, 0x10, 0x01, 0x81, 0x00, 0x18, 0x30, 0x01, 0xC3, 0x00, 0x0E,
  0x30, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x67, 0x80,
  0x06, 0x1C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x40, 0xC0, 0x04, 0x0C,
  0x40, 0xC0, 0xCE, 0x0C, 0x1C, 0x70, 0xC3, 0x83, 0xCC, 0xF0, 0x1F, 0xFE,
  0x00, 0x7F, 0x80, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xF0, 0x01, 0x81, 0xFC, 0x01, 0x81, 0xC3, 0x01, 0x80, 0xC1,
  0x80, 0xC0, 0xC0, 0x40, 0xC0, 0x60, 0x20, 0xC0, 0x30, 0x30, 0xC0, 0x10,
  0x18, 0x60, 0x08, 0x0C, 0x60, 0x06, 0x0E, 0x60, 0x03, 0x0E, 0x30, 0x00,
  0xFE, 0x20, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0x9C, 0x30, 0x01, 0x8C, 0x0C, 0x01, 0x8C, 0x06, 0x00, 0xC6, 0x03,
  0x00, 0xC3, 0x01, 0x80, 0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60,
  0x60, 0x60, 0x38, 0x60, 0x60, 0x0F, 0xE0, 0x70, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xFC, 0x00, 0x1C, 0x38, 0x00, 0xC0, 0x70, 0x03, 0x00,
  0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x01, 0xC0,
  0x0C, 0x06, 0x00, 0x18, 0x38, 0x00, 0x61, 0xC0, 0x0F, 0xDE, 0x00, 0xF3,
  0xE0, 0x03, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x30, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x03, 0x02, 0xC0, 0x1E, 0x1F, 0x80, 0x58, 0x66,
  0x03, 0x33, 0x1C, 0x18, 0xDC, 0x3F, 0xC1, 0xE0, 0x3E, 0x07, 0x00, 0x33,
  0x37, 0x66, 0x66, 0x6E, 0x00, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x18, 0x1F, 0xE3, 0x1F, 0x1F,
  0xFF, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x33, 0x00, 0x0C,
  0x60, 0x03, 0x06, 0x00, 0xC0, 0xE0, 0x30, 0x0C, 0x0E, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xDF, 0xFF, 0xF8, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x0C, 0x38, 0x61,
  0x80, 0xFF, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x1E, 0x0E, 0x07, 0x00, 0xE0, 0xC0, 0x0C, 0x30, 0x01, 0xC6,
  0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0D, 0xC0, 0x01, 0xB0,
  0x00, 0x76, 0x0E, 0x0E, 0xC1, 0xE1, 0x98, 0x38, 0x33, 0x00, 0x06, 0xE0,
  0x01, 0xDC, 0x00, 0x33, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x30, 0xC0,
  0x0E, 0x1C, 0x03, 0x81, 0xC1, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x3C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x73, 0x00, 0x71, 0x80, 0x70, 0xC0,
  0xF0, 0x60, 0x70, 0x70, 0x20, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x0E, 0x0F, 0x03, 0x80, 0x70, 0xE0, 0x0E, 0x18, 0x00, 0xC6, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x3F, 0xF0, 0x0E, 0x07, 0x03, 0x00, 0x70, 0xC0, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC4, 0x00, 0x19, 0xC0,
  0x07, 0x1C, 0x01, 0xC1, 0xC0, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0x60, 0x00, 0xDC, 0x00,
  0x33, 0x00, 0x0C, 0x60, 0x03, 0x8C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x06,
  0x06, 0x01, 0x81, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0xC0,
  0x18, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x80, 0x18, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x67, 0xE0, 0x0D, 0xFF, 0x03, 0x60, 0xF0, 0x70, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x31, 0x80, 0x0E, 0x38, 0x01, 0x83, 0xC0, 0xE0, 0x3F, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x31,
  0xF8, 0x77, 0xFC, 0x6C, 0x0E, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xE0,
  0x0C, 0x70, 0x3C, 0x3F, 0xF0, 0x0F, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF6,
  0x00, 0x19, 0x80, 0x0E, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1C,
  0x0F, 0x07, 0x00, 0x61, 0xC0, 0x0E, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0,
  0x06, 0x18, 0x00, 0xC3, 0x80, 0x30, 0x38, 0x1C, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x38, 0x0E, 0x0C, 0x00, 0xE3, 0x00, 0x0C, 0xE0, 0x01, 0x98, 0x00,
  0x3B, 0x00, 0x07, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x07, 0x38, 0x01,
  0xC3, 0xC0, 0xF0, 0x3F, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xFC,
  0x3C, 0x0E, 0x30, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x70, 0x36,
  0x3F, 0xE6, 0x1F, 0x8C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x1C, 0x7C, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF1, 0xE3, 0xC7, 0x00, 0x03, 0x81, 0xF0, 0x78, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x01, 0xC0,
  0x60, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x02, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF,
  0x80, 0x10, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x18, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0xF8, 0xF0, 0x73, 0x80, 0x76, 0x00, 0x7C, 0x00,
  0xD0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x03, 0xC0,
  0x7E, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x78, 0x38, 0x18, 0x07, 0x0C,
  0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x01, 0x30, 0x3C, 0xCC, 0x1F,
  0xB3, 0x0E, 0x1C, 0xC7, 0x03, 0x61, 0x80, 0xD8, 0x60, 0x26, 0x18, 0x19,
  0x8C, 0x06, 0x63, 0x01, 0x98, 0xC0, 0x64, 0x30, 0x3B, 0x0C, 0x14, 0xC3,
  0x8F, 0x30, 0x7E, 0xC4, 0x0F, 0x31, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x00, 0x66,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xC3, 0x80, 0x18, 0x30, 0x06, 0x06,
  0x00, 0xC0, 0xC0, 0x38, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x0E,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x70, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C,
  0x60, 0x01, 0xCC, 0x00, 0x3B, 0x00, 0x03, 0x60, 0x00, 0x7C, 0x00, 0x0C,
  0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xC0, 0x38, 0x30, 0x07, 0x1C, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x63, 0x80,
  0x18, 0xE0, 0x1C, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0x00, 0x70, 0xC0, 0x0E,
  0x70, 0x01, 0x9C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x98,
  0x00, 0xEE, 0x00, 0x33, 0x00, 0x38, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x78, 0x38, 0x38, 0x06, 0x1C, 0x00, 0xC6, 0x00,
  0x33, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0xE0, 0x07, 0x18, 0x01,
  0x87, 0x00, 0xC0, 0xE0, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0x30, 0x1E, 0x06, 0x00, 0xE0, 0xC0, 0x0C, 0x18, 0x01,
  0x87, 0x00, 0x38, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03,
  0x8C, 0x00, 0x73, 0x80, 0x0E, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06,
  0x30, 0x01, 0xC6, 0x00, 0x39, 0xC0, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x30,
  0xC0, 0x0E, 0x18, 0x03, 0x83, 0x01, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0xFF, 0x83, 0xFF, 0xF8, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x70, 0x70, 0x30, 0x06, 0x18, 0x01, 0xCE, 0x00, 0x33,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x1F, 0xEC, 0x07, 0xF3, 0x02, 0x0C, 0xC0, 0x03,
  0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x07, 0x38, 0x03, 0x86,
  0x01, 0xE1, 0xE0, 0xD8, 0x3F, 0xE6, 0x03, 0xE1, 0x80, 0x0C, 0x00, 0x70,
  0xC0, 0x06, 0x0C, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06,
  0x18, 0x00, 0xE1, 0x80, 0x0C, 0x18, 0x00, 0xC3, 0x80, 0x0C, 0x30, 0x00,
  0xC3, 0x00, 0x0C, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x30, 0x01, 0x87, 0x00,
  0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x30, 0x60,
  0x03, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C,
  0x00, 0x60, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0xE0, 0x0E, 0x18, 0x03, 0x06, 0x01, 0xC1, 0xE0,
  0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x0C, 0x00, 0x38, 0x60, 0x03, 0x83,
  0x00, 0x38, 0x18, 0x03, 0x81, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x38,
  0x03, 0x03, 0x80, 0x18, 0x38, 0x00, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x73,
  0x80, 0x03, 0x3E, 0x00, 0x1B, 0xB0, 0x00, 0xF9, 0xC0, 0x07, 0x86, 0x00,
  0x78, 0x38, 0x03, 0x80, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xE0, 0x30, 0x03, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x86,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x1E, 0x01, 0xB0, 0xF0, 0x0F, 0x06, 0xC0, 0xD8, 0x66, 0x0C, 0xC3, 0x30,
  0x66, 0x18, 0x86, 0x30, 0xC6, 0x31, 0x86, 0x33, 0x18, 0x31, 0xB0, 0xC3,
  0x07, 0x86, 0x18, 0x38, 0x30, 0xC1, 0xC1, 0x86, 0x0C, 0x0C, 0x30, 0x40,
  0xC1, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x30, 0xF0, 0x06, 0x0F, 0x00, 0x61, 0xB0, 0x06, 0x1B,
  0x00, 0x61, 0x98, 0x06, 0x19, 0x80, 0x61, 0x98, 0x0C, 0x19, 0x80, 0xC3,
  0x0C, 0x0C, 0x30, 0xC0, 0xC3, 0x0C, 0x0C, 0x30, 0xE0, 0xC3, 0x06, 0x18,
  0x30, 0x61, 0x86, 0x06, 0x18, 0x60, 0x31, 0x86, 0x03, 0x18, 0x60, 0x31,
  0x86, 0x03, 0x30, 0x60, 0x1B, 0x0C, 0x01, 0xB0, 0xC0, 0x1B, 0x0C, 0x00,
  0xF0, 0xC0, 0x0F, 0x0C, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1E,
  0x0E, 0x07, 0x00, 0xE0, 0xC0, 0x0C, 0x30, 0x01, 0xC6, 0x00, 0x19, 0x80,
  0x03, 0x30, 0x00, 0x66, 0x00, 0x0D, 0xC0, 0x01, 0xB0, 0x00, 0x76, 0x00,
  0x0E, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0xE0, 0x01, 0xDC, 0x00,
  0x33, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x30, 0xC0, 0x0E, 0x1C, 0x03,
  0x81, 0xC1, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x30, 0x07, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x00, 0xC6, 0x00,
  0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x9C, 0x00,
  0x63, 0x00, 0x38, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xE0, 0x1E, 0x0E, 0x07, 0x00, 0xE0, 0xC0, 0x0C, 0x30, 0x01,
  0xC6, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0D, 0xC0, 0x01,
  0xB0, 0x00, 0x76, 0x00, 0x0E, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06,
  0xE0, 0x01, 0xDC, 0x00, 0x33, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x30,
  0xC0, 0x0E, 0x1C, 0x03, 0x81, 0xC1, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x40, 0x0E, 0x18, 0x00, 0xC7, 0x80, 0x0D, 0xC0,
  0x01, 0xF0, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x30, 0x07,
  0x06, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x9C, 0x00, 0x63, 0x00, 0x38,
  0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0x83, 0x00, 0x30, 0x30, 0x0E, 0x06, 0x01,
  0x80, 0xE0, 0x30, 0x0C, 0x06, 0x01, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x87,
  0x00, 0x30, 0xC0, 0x07, 0x18, 0x00, 0x60, 0x00, 0xFF, 0x00, 0x3F, 0xFC,
  0x07, 0x81, 0xE0, 0xE0, 0x07, 0x0C, 0x00, 0x31, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0xCE,
  0x00, 0x1C, 0x70, 0x03, 0x83, 0xC0, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x03,
  0x1C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0C,
  0x30, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x38,
  0xC0, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xE3,
  0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x38, 0x07, 0x03,
  0x81, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0xC0, 0x00, 0x6C, 0x00, 0x1D,
  0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x00, 0xC3,
  0x00, 0x38, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x30, 0x18, 0x06, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x01, 0x9C, 0x00, 0x33, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x19,
  0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00,
  0x18, 0xC0, 0x00, 0xC6, 0x0E, 0x0C, 0x30, 0x70, 0x61, 0x07, 0x83, 0x18,
  0x3C, 0x18, 0xC1, 0x61, 0x86, 0x1B, 0x0C, 0x30, 0xC8, 0x61, 0x8C, 0x43,
  0x0C, 0x62, 0x30, 0x62, 0x19, 0x83, 0x30, 0xCC, 0x19, 0x86, 0x60, 0xD8,
  0x36, 0x06, 0xC1, 0xB0, 0x2C, 0x0D, 0x83, 0x60, 0x6C, 0x1B, 0x03, 0xC0,
  0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x18, 0x07, 0x00, 0x30, 0x1C, 0x00,
  0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x63, 0x80, 0x00, 0xCE, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x76, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x0C,
  0x00, 0x38, 0x18, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x30, 0x06, 0x00, 0x70,
  0x18, 0x00, 0x60, 0x70, 0x00, 0xE1, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x3B,
  0x00, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x01, 0x83, 0x80, 0x1C, 0x0C, 0x01,
  0xC0, 0x70, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x30, 0xE0, 0x01,
  0x8E, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0xC0, 0x60, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C,
  0x02, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0x40,
  0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03,
  0x01, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0D, 0x80, 0x06,
  0x60, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x60, 0x60, 0x30, 0x18, 0x1C, 0x03,
  0x06, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x06, 0xE0, 0x01, 0xB0, 0x00, 0x38,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x4C, 0xC6, 0x63, 0x30, 0x03,
  0xF1, 0xC1, 0xFE, 0x61, 0xE0, 0xD8, 0x60, 0x0E, 0x38, 0x03, 0x8C, 0x00,
  0x66, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x58, 0x78,
  0x76, 0x0F, 0xF9, 0xF0, 0xF8, 0x78, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x7E, 0x06, 0x7F, 0xC1, 0xB8, 0x38, 0x68, 0x06, 0x1C, 0x01, 0xC6,
  0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x73, 0x00,
  0x1C, 0xC0, 0x06, 0x60, 0x01, 0x98, 0x00, 0xE7, 0x00, 0x31, 0xC0, 0x18,
  0x6C, 0x1E, 0x19, 0xFF, 0x0E, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xFC, 0x1E,
  0x0E, 0x38, 0x06, 0x30, 0x03, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x04, 0xC0, 0x06, 0xE0,
  0x0C, 0x60, 0x1C, 0x78, 0x38, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x03, 0xF0, 0xC0, 0xFF, 0x98, 0x38, 0x16, 0x0C,
  0x01, 0xC3, 0x80, 0x18, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x03, 0x1C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x71, 0xC0,
  0x0E, 0x18, 0x03, 0x83, 0x00, 0xB0, 0x78, 0x36, 0x07, 0xFC, 0xC0, 0x3E,
  0x18, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x1E, 0x07, 0x38, 0x03, 0x30, 0x03,
  0x60, 0x03, 0x60, 0x03, 0xC0, 0x0E, 0xC0, 0x7C, 0xFF, 0xF0, 0xFF, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x02, 0xC0, 0x07, 0x60, 0x0C, 0x78, 0x3C,
  0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x40, 0x30,
  0x00, 0xF0, 0x30, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x0E, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF8,
  0x60, 0x7F, 0xCC, 0x1C, 0x1B, 0x06, 0x00, 0xE1, 0xC0, 0x0C, 0x30, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0x8E, 0x00, 0x31, 0xC0, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x38, 0xE0, 0x07, 0x0C, 0x01, 0xC1, 0x80, 0x58,
  0x3C, 0x1B, 0x03, 0xFE, 0x60, 0x1F, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x10, 0x03, 0x07, 0x81, 0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0xF8, 0x19, 0xFE, 0x3B, 0x0E, 0x34, 0x07,
  0x38, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x07, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x0E, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x03, 0x06, 0x07,
  0x06, 0x0E, 0x06, 0x38, 0x06, 0x70, 0x0C, 0xE0, 0x0F, 0x80, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x40, 0x60, 0xE0, 0x60, 0x70, 0x60,
  0x38, 0x60, 0x1C, 0x60, 0x0E, 0xC0, 0x07, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x7E, 0x03, 0x9F, 0xE0, 0x66, 0x0E,
  0x0D, 0x00, 0xC1, 0xC0, 0x18, 0x38, 0x03, 0x06, 0x00, 0xE1, 0xC0, 0x18,
  0x30, 0x0E, 0x06, 0x07, 0x00, 0xCF, 0x80, 0x18, 0xC0, 0x03, 0x1C, 0x04,
  0xE1, 0x80, 0xD8, 0x38, 0x73, 0x03, 0x1C, 0x60, 0x37, 0x0C, 0x07, 0xC3,
  0x80, 0x70, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x20, 0xC1, 0xE3, 0x07, 0x06, 0x1C, 0x0C, 0xF0,
  0x1B, 0x80, 0x3E, 0x00, 0x70, 0x00, 0x19, 0xE1, 0xE1, 0xBF, 0x7F, 0x1E,
  0x34, 0x73, 0x83, 0x83, 0x38, 0x38, 0x33, 0x03, 0x03, 0x30, 0x30, 0x33,
  0x03, 0x02, 0x30, 0x20, 0x66, 0x06, 0x06, 0x60, 0x60, 0x66, 0x06, 0x06,
  0x60, 0x60, 0x66, 0x06, 0x0C, 0x60, 0x40, 0xCC, 0x0C, 0x0C, 0xC0, 0xC0,
  0xCC, 0x0C, 0x0C, 0xC0, 0xC0, 0xC0, 0x18, 0xF8, 0x39, 0xFE, 0x33, 0x0E,
  0x34, 0x07, 0x38, 0x03, 0x38, 0x03, 0x30, 0x03, 0x70, 0x03, 0x60, 0x07,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x06, 0xC0, 0x0E,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0x03, 0xF0, 0x07, 0xFE,
  0x07, 0x03, 0x87, 0x00, 0xE7, 0x00, 0x33, 0x00, 0x1B, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x76,
  0x00, 0x33, 0x00, 0x39, 0xC0, 0x38, 0x70, 0x38, 0x1F, 0xF8, 0x03, 0xF0,
  0x00, 0x0E, 0x3F, 0x01, 0x9F, 0xF0, 0x37, 0x07, 0x06, 0x80, 0x60, 0xE0,
  0x0E, 0x18, 0x00, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x1C, 0x60, 0x03, 0x8C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x8E, 0x00,
  0x61, 0xC0, 0x18, 0x36, 0x0F, 0x06, 0x7F, 0xC1, 0x87, 0xE0, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xF0, 0xC1, 0xFF, 0x30, 0xE0, 0x58, 0x70, 0x0E,
  0x38, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x38,
  0x00, 0xCE, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x07, 0x38, 0x01, 0xC6, 0x00,
  0xE1, 0x80, 0x58, 0x78, 0x36, 0x0F, 0xF9, 0x80, 0xF8, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0xFF, 0x0F, 0xFF, 0xCF, 0xF0, 0x36, 0x00, 0x0D, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0xC0, 0xE0, 0x38, 0x60, 0x07, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC4, 0x00, 0x33, 0x80, 0x1C, 0x78, 0x0E, 0x0F,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x81, 0x80, 0xE0, 0xC0,
  0xE0, 0x61, 0xE0, 0x31, 0xC0, 0x1B, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x00,
  0x38, 0x03, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x19, 0x80, 0x1C, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x9C,
  0x01, 0xCC, 0x00, 0xE6, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x58, 0x70, 0xCC,
  0x1F, 0xE6, 0x07, 0xC7, 0x00, 0xFC, 0x03, 0x7E, 0x01, 0x83, 0x00, 0x61,
  0x80, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x07, 0x18, 0x03,
  0x0C, 0x01, 0x86, 0x01, 0xC3, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0xE0, 0xC0,
  0xE0, 0x60, 0xE0, 0x31, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x00, 0x30, 0x30,
  0xC6, 0x06, 0x08, 0xC0, 0xC1, 0x98, 0x10, 0x33, 0x06, 0x06, 0x40, 0xC0,
  0xD8, 0x18, 0x1B, 0x03, 0x03, 0x60, 0x60, 0x6C, 0x18, 0x0D, 0x83, 0x01,
  0xA0, 0x60, 0x6C, 0x0C, 0x0D, 0x81, 0x81, 0xB0, 0x70, 0x66, 0x0E, 0x1C,
  0xE2, 0xC7, 0x1F, 0xCF, 0xC1, 0xE1, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x3E,
  0x3F, 0x87, 0xB1, 0x8C, 0x70, 0xD8, 0x36, 0x06, 0x81, 0x80, 0x38, 0x0C,
  0x01, 0xC0, 0x60, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x70, 0x12, 0x06, 0x81, 0x98,
  0x26, 0x38, 0xC7, 0x33, 0x87, 0xF1, 0xF8, 0x1F, 0x07, 0x00, 0x0E, 0x00,
  0xE1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01,
  0x86, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06,
  0x0C, 0x01, 0xC3, 0x00, 0x30, 0x60, 0x06, 0x0E, 0x01, 0xC0, 0xC0, 0x58,
  0x1C, 0x3B, 0x01, 0xFE, 0x60, 0x1F, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x10, 0x07, 0x07, 0x81, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0xC7, 0xFF, 0x33, 0x83, 0xFC, 0xC0, 0x1F, 0x30, 0x03, 0x8C,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x04, 0x0E, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x33, 0xF8, 0x06,
  0xFF, 0xF1, 0xB0, 0xFF, 0xEC, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x07, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x06, 0x0C, 0x18, 0x30, 0x41, 0x83,
  0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x63, 0xF0, 0x0C, 0xC7, 0x03, 0x30, 0x60, 0x66, 0x06, 0x19, 0x80, 0xE7,
  0x30, 0x0F, 0xC6, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_LightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 7, 26, 22, 8, -26 },
  { 24, 9, 10, 22, 9, -27 },
  { 36, 22, 26, 22, 1, -26 },
  { 108, 20, 34, 22, 1, -30 },
  { 193, 25, 26, 22, -1, -26 },
  { 275, 22, 26, 22, 0, -26 },
  { 347, 4, 10, 22, 11, -27 },
  { 352, 13, 33, 22, 8, -28 },
  { 406, 13, 33, 22, 2, -28 },
  { 460, 19, 18, 22, 2, -20 },
  { 503, 18, 18, 22, 2, -20 },
  { 544, 7, 10, 22, 5, -4 },
  { 553, 11, 2, 22, 6, -12 },
  { 556, 4, 4, 22, 8, -4 },
  { 558, 21, 33, 22, 1, -28 },
  { 645, 19, 26, 22, 2, -26 },
  { 707, 17, 26, 22, 2, -26 },
  { 763, 19, 26, 22, 1, -26 },
  { 825, 19, 26, 22, 1, -26 },
  { 887, 19, 26, 22, 1, -26 },
  { 949, 19, 26, 22, 2, -26 },
  { 1011, 16, 26, 22, 3, -26 },
  { 1063, 18, 26, 22, 4, -26 },
  { 1122, 19, 26, 22, 2, -26 },
  { 1184, 16, 26, 22, 4, -26 },
  { 1236, 7, 20, 22, 8, -20 },
  { 1254, 10, 26, 22, 5, -20 },
  { 1287, 18, 21, 22, 3, -22 },
  { 1335, 19, 9, 22, 2, -16 },
  { 1357, 18, 21, 22, 2, -22 },
  { 1405, 15, 26, 22, 5, -26 },
  { 1454, 18, 30, 22, 2, -26 },
  { 1522, 19, 26, 22, 0, -26 },
  { 1584, 18, 26, 22, 2, -26 },
  { 1643, 18, 26, 22, 3, -26 },
  { 1702, 19, 26, 22, 2, -26 },
  { 1764, 20, 26, 22, 2, -26 },
  { 1829, 20, 26, 22, 2, -26 },
  { 1894, 18, 26, 22, 3, -26 },
  { 1953, 20, 26, 22, 2, -26 },
  { 2018, 20, 26, 22, 2, -26 },
  { 2083, 18, 26, 22, 2, -26 },
  { 2142, 21, 26, 22, 2, -26 },
  { 2211, 15, 26, 22, 3, -26 },
  { 2260, 21, 26, 22, 1, -26 },
  { 2329, 20, 26, 22, 2, -26 },
  { 2394, 19, 26, 22, 2, -26 },
  { 2456, 19, 26, 22, 2, -26 },
  { 2518, 19, 33, 22, 2, -26 },
  { 2597, 19, 26, 22, 2, -26 },
  { 2659, 20, 26, 22, 1, -26 },
  { 2724, 20, 26, 22, 4, -26 },
  { 2789, 19, 26, 22, 3, -26 },
  { 2851, 19, 26, 22, 4, -26 },
  { 2913, 21, 26, 22, 2, -26 },
  { 2982, 23, 26, 22, 0, -26 },
  { 3057, 21, 26, 22, 3, -26 },
  { 3126, 22, 26, 22, 0, -26 },
  { 3198, 16, 33, 22, 6, -28 },
  { 3264, 9, 33, 22, 7, -28 },
  { 3302, 15, 33, 22, 1, -28 },
  { 3364, 18, 15, 22, 3, -26 },
  { 3398, 18, 2, 22, 0, 4 },
  { 3403, 4, 7, 22, 9, -29 },
  { 3407, 18, 19, 22, 2, -19 },
  { 3450, 18, 27, 22, 2, -27 },
  { 3511, 16, 19, 22, 3, -19 },
  { 3549, 19, 27, 22, 2, -27 },
  { 3614, 16, 19, 22, 3, -19 },
  { 3652, 24, 34, 22, -1, -27 },
  { 3754, 19, 26, 22, 1, -19 },
  { 3816, 16, 27, 22, 3, -27 },
  { 3870, 16, 27, 22, 3, -27 },
  { 3924, 16, 35, 22, 3, -28 },
  { 3994, 19, 27, 22, 2, -27 },
  { 4059, 15, 27, 22, 4, -27 },
  { 4110, 20, 19, 22, 1, -19 },
  { 4158, 16, 19, 22, 3, -19 },
  { 4196, 17, 19, 22, 3, -19 },
  { 4237, 19, 26, 22, 1, -19 },
  { 4299, 18, 26, 22, 2, -19 },
  { 4358, 18, 19, 22, 4, -19 },
  { 4401, 18, 19, 22, 2, -19 },
  { 4444, 17, 26, 22, 3, -26 },
  { 4500, 17, 19, 22, 3, -19 },
  { 4541, 17, 19, 22, 3, -19 },
  { 4582, 19, 19, 22, 2, -19 },
  { 4628, 21, 19, 22, 1, -19 },
  { 4678, 19, 26, 22, 1, -19 },
  { 4740, 18, 19, 22, 2, -19 },
  { 4783, 17, 33, 22, 4, -28 },
  { 4854, 7, 33, 22, 8, -28 },
  { 4883, 17, 33, 22, 2, -28 },
  { 4954, 19, 8, 22, 2, -15 },
};

const GFXfont IBMPlexMono_LightItalic37pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic37pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic37pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _IBMPLEXMONO_LIGHTITALIC37PT7B_H_
