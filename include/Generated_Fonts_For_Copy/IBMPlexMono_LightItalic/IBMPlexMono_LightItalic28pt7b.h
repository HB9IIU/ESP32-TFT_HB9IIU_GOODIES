#ifndef _IBMPLEXMONO_LIGHTITALIC28PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC6, 0x31, 0x88, 0xC6, 0x31, 0x08, 0x42, 0x00, 0x00, 0x07,
  0x39, 0xC0, 0x23, 0x62, 0x62, 0x62, 0x46, 0x46, 0xC6, 0x00, 0x42, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x10, 0x80, 0x08, 0xC0, 0x0C, 0x60, 0x04, 0x20,
  0x7E, 0x3F, 0x03, 0x18, 0x01, 0x08, 0x01, 0x8C, 0x00, 0xC6, 0x07, 0xC3,
  0xE4, 0x63, 0x00, 0x31, 0x00, 0x10, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x04,
  0x20, 0x06, 0x30, 0x00, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x1F, 0x80,
  0xCC, 0xC3, 0x18, 0xCC, 0x21, 0x18, 0x40, 0x30, 0x80, 0x61, 0x00, 0x42,
  0x00, 0xEC, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x46, 0x00, 0x84, 0x03, 0x0C,
  0x06, 0x18, 0x08, 0x24, 0x10, 0xCC, 0x21, 0x8E, 0x4E, 0x07, 0xF0, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x61, 0x8C, 0x08, 0x20, 0x82,
  0x0C, 0x10, 0xC1, 0x82, 0x10, 0x20, 0x44, 0x04, 0x19, 0x80, 0x82, 0x60,
  0x08, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x18, 0x80, 0x36, 0x18,
  0x0C, 0x83, 0x03, 0x10, 0x60, 0x46, 0x0C, 0x10, 0xC1, 0x06, 0x08, 0x20,
  0x81, 0x88, 0x60, 0x1E, 0x00, 0x01, 0xE0, 0x06, 0x18, 0x04, 0x08, 0x0C,
  0x08, 0x0C, 0x0C, 0x0C, 0x08, 0x0C, 0x08, 0x04, 0x18, 0x06, 0x10, 0x0E,
  0x60, 0x33, 0x80, 0x61, 0x80, 0x41, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0xC0,
  0x61, 0xC0, 0xA1, 0x40, 0xB2, 0x61, 0x16, 0x3E, 0x0C, 0x5F, 0xF8, 0x01,
  0xC0, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x40, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x06, 0x03, 0x00, 0x80,
  0xC0, 0xE0, 0x00, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x07,
  0x8C, 0xF3, 0xFF, 0x01, 0xE0, 0x07, 0x00, 0x36, 0x01, 0x98, 0x0C, 0x30,
  0x60, 0x41, 0x01, 0x80, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x83, 0xFF, 0xE0, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x00, 0x19, 0xCC, 0xC6, 0x23, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x30,
  0xC1, 0x81, 0x8C, 0x02, 0x20, 0x0D, 0x80, 0x36, 0x00, 0xD0, 0x03, 0xC3,
  0x0F, 0x1C, 0x3C, 0x30, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0x30,
  0x0C, 0xC0, 0x21, 0x01, 0x86, 0x0C, 0x07, 0xC0, 0x00, 0xE0, 0x1B, 0x01,
  0x98, 0x18, 0x81, 0x84, 0x10, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0xC1, 0xFF, 0xF0, 0x03, 0xF0, 0x30, 0x61, 0x80, 0xC4, 0x03,
  0x30, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x3F, 0xFE, 0x03, 0xF0, 0x30, 0x61, 0x80, 0xC4, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x1F, 0x00, 0x07, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x80, 0x13, 0x00, 0xC6,
  0x06, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x06, 0x80, 0x16, 0x00, 0xD8,
  0x06, 0x60, 0x31, 0x81, 0x84, 0x04, 0x10, 0x30, 0x41, 0x83, 0x0C, 0x0C,
  0x60, 0x31, 0x80, 0xCC, 0x02, 0x3F, 0xFF, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x0F, 0xFE, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x13, 0xE0, 0x78, 0x60, 0xC0, 0x60, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x40, 0x19, 0xC0, 0x61,
  0xC1, 0x80, 0xFC, 0x00, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x67, 0xC3, 0xC3, 0xB8, 0x0D, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x02, 0xC0, 0x32, 0x03, 0x18, 0x30, 0x3E,
  0x00, 0x7F, 0xFD, 0x00, 0x6C, 0x01, 0xB0, 0x0C, 0xC0, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x03, 0xF0, 0x0C, 0x18, 0x20, 0x10, 0xC0, 0x31, 0x00, 0x62, 0x00, 0xC4,
  0x01, 0x0C, 0x06, 0x0C, 0x10, 0x0F, 0xC0, 0x60, 0xC1, 0x80, 0xC6, 0x00,
  0xC8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x18, 0xC0, 0x30, 0xC1, 0x80,
  0xFE, 0x00, 0x0F, 0xC3, 0x06, 0x60, 0x34, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x03, 0xC0, 0x3C, 0x07, 0x60, 0xA3, 0xF6, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x39, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x73, 0x80, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x87, 0x0C, 0x30, 0x60, 0x83, 0x00, 0x00,
  0x04, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18,
  0x00, 0x60, 0x02, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x08, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x10, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x1C, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x20, 0x00, 0x1F, 0x8E, 0x19,
  0x81, 0xE0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x01, 0xC3, 0xF0, 0x70,
  0x0C, 0x01, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0xE0, 0x38,
  0x00, 0x03, 0xE0, 0x61, 0x86, 0x06, 0x20, 0x12, 0x00, 0x90, 0x05, 0x87,
  0xAC, 0x65, 0x46, 0x1A, 0x20, 0xF1, 0x07, 0x98, 0x3C, 0xC1, 0x46, 0x0A,
  0x30, 0xD1, 0x86, 0x86, 0xF4, 0x18, 0x20, 0x01, 0x80, 0x04, 0x00, 0x38,
  0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x04, 0x80, 0x19,
  0x00, 0x22, 0x00, 0xC6, 0x01, 0x0C, 0x06, 0x18, 0x08, 0x30, 0x30, 0x20,
  0x40, 0x41, 0xFF, 0x82, 0x01, 0x84, 0x03, 0x18, 0x06, 0x20, 0x0C, 0xC0,
  0x09, 0x00, 0x16, 0x00, 0x30, 0x0F, 0xF0, 0x60, 0x61, 0x80, 0xC6, 0x01,
  0x18, 0x04, 0x40, 0x31, 0x00, 0xCC, 0x02, 0x30, 0x18, 0xFF, 0x83, 0x01,
  0x08, 0x02, 0x20, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x02, 0x60, 0x19, 0x80,
  0x64, 0x03, 0x3F, 0xF0, 0x03, 0xF0, 0x18, 0x61, 0x80, 0xC4, 0x03, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x04, 0x40, 0x39, 0x80, 0x83,
  0x0E, 0x07, 0xE0, 0x1F, 0xC0, 0x40, 0xC3, 0x01, 0x8C, 0x02, 0x30, 0x08,
  0xC0, 0x32, 0x00, 0xC8, 0x03, 0x20, 0x0D, 0x80, 0x36, 0x00, 0x98, 0x06,
  0x60, 0x19, 0x00, 0x64, 0x01, 0x30, 0x0C, 0xC0, 0x23, 0x01, 0x8C, 0x0C,
  0x3F, 0xC0, 0x1F, 0xFE, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xFF, 0xF1, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xFF, 0xE1, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x30, 0x61, 0x80, 0x8C,
  0x03, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x7E, 0xC0, 0x1B, 0x00, 0x4C, 0x01, 0x30, 0x0C, 0xC0, 0x31,
  0x81, 0xC3, 0x0B, 0x07, 0xC8, 0x18, 0x02, 0x30, 0x04, 0x60, 0x18, 0xC0,
  0x31, 0x80, 0x62, 0x00, 0x8C, 0x01, 0x18, 0x02, 0x30, 0x0C, 0x60, 0x18,
  0xFF, 0xF1, 0x00, 0x66, 0x00, 0x8C, 0x01, 0x18, 0x06, 0x30, 0x0C, 0x60,
  0x18, 0x80, 0x33, 0x00, 0x46, 0x01, 0x80, 0x1F, 0xFE, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x80,
  0x46, 0x06, 0x18, 0x60, 0x7E, 0x00, 0x08, 0x03, 0x8C, 0x03, 0x06, 0x03,
  0x03, 0x03, 0x01, 0x83, 0x00, 0x83, 0x00, 0x43, 0x00, 0x63, 0x00, 0x33,
  0x00, 0x1B, 0xC0, 0x0F, 0x60, 0x07, 0x18, 0x03, 0x0C, 0x03, 0x03, 0x01,
  0x81, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x30, 0x08, 0x10, 0x06, 0x18, 0x03,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0F, 0xFF, 0x18, 0x07, 0x1C, 0x06, 0x1C,
  0x0E, 0x14, 0x0A, 0x34, 0x1E, 0x36, 0x36, 0x36, 0x36, 0x22, 0x66, 0x22,
  0x44, 0x23, 0xC4, 0x63, 0x8C, 0x61, 0x8C, 0x61, 0x0C, 0x42, 0x0C, 0x40,
  0x08, 0x40, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0x1C,
  0x02, 0x38, 0x04, 0x78, 0x18, 0xB0, 0x31, 0x20, 0x62, 0x40, 0x8C, 0xC1,
  0x19, 0x82, 0x31, 0x0C, 0x62, 0x18, 0x86, 0x31, 0x0C, 0x66, 0x08, 0x8C,
  0x19, 0x18, 0x36, 0x30, 0x2C, 0x40, 0x58, 0x80, 0xF3, 0x01, 0xC6, 0x01,
  0x80, 0x03, 0xE0, 0x30, 0xC1, 0x81, 0x8C, 0x02, 0x20, 0x0D, 0x80, 0x36,
  0x00, 0xD0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xB0, 0x06, 0xC0, 0x1B,
  0x00, 0x6C, 0x01, 0x30, 0x0C, 0xC0, 0x21, 0x01, 0x86, 0x0C, 0x07, 0xC0,
  0x1F, 0xF0, 0x40, 0x63, 0x00, 0xCC, 0x03, 0x30, 0x04, 0x80, 0x32, 0x00,
  0xC8, 0x03, 0x60, 0x19, 0x80, 0xC7, 0xFE, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03,
  0xE0, 0x30, 0xC1, 0x81, 0x8C, 0x02, 0x20, 0x0D, 0x80, 0x36, 0x00, 0xD0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C,
  0x01, 0x30, 0x0C, 0xC0, 0x21, 0x01, 0x86, 0x0C, 0x07, 0xC0, 0x06, 0x00,
  0x08, 0x40, 0x31, 0x80, 0x48, 0x00, 0xC0, 0x1F, 0xF0, 0x40, 0x63, 0x00,
  0xCC, 0x03, 0x30, 0x04, 0x80, 0x32, 0x00, 0xC8, 0x03, 0x60, 0x19, 0x80,
  0xC7, 0xFE, 0x18, 0xC0, 0x41, 0x81, 0x06, 0x0C, 0x08, 0x30, 0x30, 0xC0,
  0x43, 0x01, 0x88, 0x06, 0x20, 0x0C, 0x03, 0xF8, 0x18, 0x18, 0x60, 0x19,
  0x80, 0x23, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x80, 0x19, 0x80, 0x31, 0xC1, 0xC0, 0xFE, 0x00, 0xFF, 0xFE, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x30, 0x04,
  0xC0, 0x33, 0x00, 0xCC, 0x03, 0x20, 0x0C, 0x80, 0x26, 0x00, 0x98, 0x06,
  0x60, 0x19, 0x80, 0x64, 0x01, 0x90, 0x06, 0xC0, 0x13, 0x00, 0xCC, 0x03,
  0x30, 0x0C, 0xC0, 0x21, 0x01, 0x86, 0x0C, 0x0F, 0xC0, 0xC0, 0x07, 0x80,
  0x19, 0x00, 0x22, 0x00, 0xC4, 0x01, 0x8C, 0x06, 0x18, 0x0C, 0x30, 0x30,
  0x60, 0x60, 0x40, 0x80, 0x83, 0x01, 0x04, 0x03, 0x18, 0x06, 0x20, 0x0C,
  0xC0, 0x19, 0x00, 0x16, 0x00, 0x28, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x60,
  0x03, 0x60, 0x02, 0x60, 0x06, 0x40, 0x06, 0x40, 0x04, 0x40, 0x04, 0x43,
  0x0C, 0x43, 0x8C, 0x47, 0x88, 0x45, 0x88, 0xC5, 0x88, 0xCC, 0x98, 0xC8,
  0x98, 0xD8, 0x90, 0xD0, 0x90, 0x90, 0xB0, 0xB0, 0xB0, 0xA0, 0xA0, 0xE0,
  0xE0, 0xC0, 0xE0, 0x18, 0x01, 0xC3, 0x00, 0x60, 0x40, 0x30, 0x18, 0x18,
  0x02, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x06, 0xC0, 0x01, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x05, 0x80, 0x03, 0x60, 0x01, 0x8C, 0x00, 0xC3,
  0x00, 0x60, 0x60, 0x18, 0x18, 0x0C, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x18,
  0xC0, 0x07, 0x80, 0x19, 0x00, 0x63, 0x00, 0xC2, 0x03, 0x06, 0x0C, 0x0C,
  0x30, 0x0C, 0x40, 0x19, 0x80, 0x16, 0x00, 0x38, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE1, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFE, 0x00, 0xC0, 0x81, 0x02, 0x06,
  0x04, 0x08, 0x10, 0x20, 0x60, 0x40, 0x81, 0x03, 0x02, 0x04, 0x08, 0x18,
  0x30, 0x20, 0x40, 0x81, 0x81, 0x02, 0x07, 0xF0, 0x83, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0xFF, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x34, 0x01, 0x98, 0x0C, 0x20, 0x20, 0xC1, 0x81, 0x0C, 0x04, 0x60, 0x19,
  0x00, 0x2C, 0x00, 0xC0, 0xFF, 0xFC, 0x99, 0x22, 0x0F, 0x99, 0xC2, 0xC8,
  0x0C, 0xC0, 0x2C, 0x01, 0x60, 0x1B, 0x00, 0xD0, 0x06, 0x80, 0x24, 0x03,
  0x20, 0x19, 0x81, 0xC6, 0x16, 0x1F, 0x3C, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x7C, 0x24, 0x31, 0x40, 0xDC,
  0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x00, 0x68, 0x03, 0x40, 0x16, 0x01,
  0xB0, 0x19, 0xE1, 0x88, 0xF8, 0x00, 0x07, 0xC1, 0x87, 0x30, 0x36, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x02, 0xC0, 0x34, 0x06,
  0x30, 0xC1, 0xF0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x83, 0xE6, 0x18, 0x58, 0x80, 0xE6, 0x01, 0x10, 0x04,
  0xC0, 0x33, 0x00, 0xC8, 0x03, 0x20, 0x0C, 0x80, 0x22, 0x01, 0x8C, 0x0E,
  0x18, 0x58, 0x3E, 0x60, 0x07, 0xE0, 0xC1, 0x8C, 0x04, 0xC0, 0x36, 0x01,
  0x20, 0x1B, 0x07, 0x1F, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x0C, 0x80, 0xC3,
  0x0C, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x3F, 0xFE, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x20, 0x40, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x06,
  0x80, 0x00, 0xE0, 0x00, 0x07, 0xCC, 0x30, 0xB1, 0x01, 0xCC, 0x02, 0x20,
  0x09, 0x80, 0x26, 0x01, 0x98, 0x06, 0x40, 0x19, 0x00, 0x46, 0x03, 0x18,
  0x1C, 0x30, 0xB0, 0x7C, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x62, 0x01, 0x0C,
  0x1C, 0x0F, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x3E, 0x34, 0x33, 0x83, 0x30, 0x12, 0x01, 0x60, 0x16, 0x03,
  0x60, 0x34, 0x03, 0x40, 0x24, 0x02, 0xC0, 0x6C, 0x06, 0xC0, 0x60, 0x01,
  0x80, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x82, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01,
  0x82, 0x0C, 0x38, 0x63, 0x02, 0x20, 0x16, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x84, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x04, 0x18, 0x70, 0xC0, 0xC4, 0x03,
  0x20, 0x0D, 0x00, 0x38, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0xF8, 0x34, 0x30, 0xA0, 0x43, 0x01,
  0x18, 0x04, 0x60, 0x21, 0x83, 0x06, 0x30, 0x13, 0x00, 0x46, 0x0B, 0x08,
  0x3C, 0x31, 0x30, 0x48, 0xC0, 0xC0, 0xFE, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x81, 0x10, 0x46, 0x30, 0xCC, 0x1A, 0x03, 0x80, 0x37,
  0x1C, 0x53, 0xCC, 0xC7, 0x1B, 0x0C, 0x36, 0x18, 0x6C, 0x30, 0x90, 0x41,
  0x20, 0x82, 0x41, 0x0D, 0x86, 0x1B, 0x0C, 0x36, 0x18, 0x48, 0x20, 0x90,
  0x41, 0x00, 0x33, 0xE3, 0x43, 0x38, 0x33, 0x01, 0x20, 0x16, 0x01, 0x60,
  0x36, 0x03, 0x40, 0x34, 0x02, 0x40, 0x2C, 0x06, 0xC0, 0x6C, 0x06, 0x07,
  0xC0, 0xC3, 0x0C, 0x04, 0xC0, 0x34, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x16, 0x01, 0xB0, 0x0C, 0x80, 0xC6, 0x0C, 0x0F, 0x80, 0x19, 0xF0,
  0x68, 0x61, 0x40, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC8, 0x03,
  0x20, 0x0C, 0x80, 0x26, 0x01, 0x98, 0x0C, 0x78, 0x61, 0x1F, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x0F, 0x98, 0xC2,
  0xC8, 0x0E, 0xC0, 0x24, 0x01, 0x60, 0x1B, 0x00, 0xD0, 0x06, 0x80, 0x34,
  0x01, 0x20, 0x19, 0x81, 0xC6, 0x16, 0x1F, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0xFC, 0xFC, 0x34, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0xC1, 0x88, 0x06,
  0x40, 0x06, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x30, 0x01, 0x80,
  0x0D, 0x00, 0x6E, 0x06, 0x1F, 0xC0, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x03, 0xFF, 0xE0, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x03, 0x18, 0x60, 0xCC, 0x06,
  0xC0, 0x38, 0x00, 0x30, 0x19, 0x00, 0xC8, 0x04, 0x40, 0x26, 0x03, 0x30,
  0x19, 0x80, 0xC8, 0x06, 0x40, 0x26, 0x03, 0x30, 0x18, 0x81, 0xC6, 0x16,
  0x1E, 0x30, 0xF8, 0x10, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x01, 0x88, 0x0C,
  0xC0, 0x66, 0x02, 0x30, 0x31, 0x81, 0x08, 0x18, 0x41, 0x82, 0x30, 0x1E,
  0x00, 0x61, 0x89, 0x84, 0x34, 0x10, 0xD0, 0x43, 0x43, 0x0F, 0x0C, 0x3C,
  0x30, 0xF0, 0x83, 0x82, 0x0A, 0x08, 0x28, 0x61, 0xA2, 0x84, 0x8A, 0x23,
  0xC7, 0x00, 0x07, 0x0E, 0x1D, 0x13, 0x71, 0xA1, 0x40, 0xC1, 0x00, 0xC1,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0xC1, 0x80, 0xC2, 0x82,
  0xC2, 0xC6, 0x44, 0xDC, 0x78, 0x70, 0x18, 0x0C, 0x40, 0x31, 0x00, 0x84,
  0x02, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x88, 0x06, 0x20, 0x10, 0x80, 0xC2,
  0x03, 0x08, 0x1C, 0x30, 0xB0, 0x7C, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x62,
  0x03, 0x0C, 0x18, 0x1F, 0xC0, 0x0F, 0x84, 0x41, 0xD3, 0x01, 0xC8, 0x04,
  0x20, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x10, 0x20, 0x63, 0x01,
  0x9E, 0x02, 0x4F, 0x8B, 0x07, 0xE0, 0x01, 0xF8, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x0F, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x1F, 0x80, 0x08,
  0x42, 0x31, 0x8C, 0x42, 0x11, 0x8C, 0x62, 0x10, 0x8C, 0x63, 0x10, 0x84,
  0x63, 0x18, 0x80, 0x0F, 0xE0, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x0F,
  0x81, 0x80, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0xFE, 0x00, 0x1E, 0x06, 0x66, 0x09,
  0x84, 0x32, 0x04, 0x4C, 0x07, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 20, 17, 6, -20 },
  { 14, 8, 7, 17, 6, -21 },
  { 21, 17, 20, 17, 0, -20 },
  { 64, 15, 26, 17, 1, -23 },
  { 113, 19, 20, 17, -1, -20 },
  { 161, 16, 20, 17, 0, -20 },
  { 201, 2, 7, 17, 9, -21 },
  { 203, 10, 25, 17, 6, -21 },
  { 235, 10, 25, 17, 1, -21 },
  { 267, 14, 14, 17, 2, -15 },
  { 292, 13, 13, 17, 2, -15 },
  { 314, 5, 7, 17, 4, -3 },
  { 319, 8, 1, 17, 5, -9 },
  { 320, 3, 3, 17, 6, -3 },
  { 322, 15, 25, 17, 1, -21 },
  { 369, 14, 20, 17, 2, -20 },
  { 404, 13, 20, 17, 1, -20 },
  { 437, 14, 20, 17, 1, -20 },
  { 472, 14, 20, 17, 1, -20 },
  { 507, 14, 20, 17, 1, -20 },
  { 542, 15, 20, 17, 1, -20 },
  { 580, 13, 20, 17, 2, -20 },
  { 613, 14, 20, 17, 3, -20 },
  { 648, 15, 20, 17, 1, -20 },
  { 686, 12, 20, 17, 3, -20 },
  { 716, 5, 15, 17, 6, -15 },
  { 726, 7, 19, 17, 4, -15 },
  { 743, 14, 16, 17, 2, -17 },
  { 771, 15, 7, 17, 1, -12 },
  { 785, 14, 16, 17, 1, -17 },
  { 813, 11, 20, 17, 4, -20 },
  { 841, 13, 23, 17, 2, -20 },
  { 879, 15, 20, 17, 0, -20 },
  { 917, 14, 20, 17, 1, -20 },
  { 952, 14, 20, 17, 2, -20 },
  { 987, 14, 20, 17, 2, -20 },
  { 1022, 15, 20, 17, 2, -20 },
  { 1060, 15, 20, 17, 2, -20 },
  { 1098, 14, 20, 17, 2, -20 },
  { 1133, 15, 20, 17, 1, -20 },
  { 1171, 15, 20, 17, 1, -20 },
  { 1209, 13, 20, 17, 2, -20 },
  { 1242, 17, 20, 17, 1, -20 },
  { 1285, 12, 20, 17, 2, -20 },
  { 1315, 16, 20, 17, 1, -20 },
  { 1355, 15, 20, 17, 1, -20 },
  { 1393, 14, 20, 17, 2, -20 },
  { 1428, 14, 20, 17, 2, -20 },
  { 1463, 14, 25, 17, 2, -20 },
  { 1507, 14, 20, 17, 2, -20 },
  { 1542, 15, 20, 17, 1, -20 },
  { 1580, 15, 20, 17, 3, -20 },
  { 1618, 14, 20, 17, 2, -20 },
  { 1653, 15, 20, 17, 3, -20 },
  { 1691, 16, 20, 17, 2, -20 },
  { 1731, 18, 20, 17, 0, -20 },
  { 1776, 15, 20, 17, 3, -20 },
  { 1814, 17, 20, 17, 0, -20 },
  { 1857, 11, 25, 17, 5, -21 },
  { 1892, 7, 25, 17, 5, -21 },
  { 1914, 12, 25, 17, 0, -21 },
  { 1952, 14, 11, 17, 2, -20 },
  { 1972, 14, 1, 17, 0, 3 },
  { 1974, 3, 5, 17, 7, -22 },
  { 1976, 13, 14, 17, 2, -14 },
  { 1999, 13, 21, 17, 2, -21 },
  { 2034, 12, 14, 17, 2, -14 },
  { 2055, 14, 21, 17, 2, -21 },
  { 2092, 13, 14, 17, 2, -14 },
  { 2115, 18, 27, 17, 0, -21 },
  { 2176, 14, 20, 17, 1, -14 },
  { 2211, 12, 21, 17, 2, -21 },
  { 2243, 13, 21, 17, 2, -21 },
  { 2278, 13, 26, 17, 2, -20 },
  { 2321, 14, 21, 17, 2, -21 },
  { 2358, 11, 21, 17, 3, -21 },
  { 2387, 15, 14, 17, 1, -14 },
  { 2414, 12, 14, 17, 2, -14 },
  { 2435, 13, 14, 17, 2, -14 },
  { 2458, 14, 20, 17, 1, -14 },
  { 2493, 13, 20, 17, 2, -14 },
  { 2526, 14, 14, 17, 3, -14 },
  { 2551, 13, 14, 17, 2, -14 },
  { 2574, 13, 20, 17, 2, -20 },
  { 2607, 13, 14, 17, 2, -14 },
  { 2630, 13, 14, 17, 2, -14 },
  { 2653, 14, 14, 17, 2, -14 },
  { 2678, 16, 14, 17, 0, -14 },
  { 2706, 14, 20, 17, 1, -14 },
  { 2741, 14, 14, 17, 1, -14 },
  { 2766, 13, 25, 17, 3, -21 },
  { 2807, 5, 25, 17, 6, -21 },
  { 2823, 13, 25, 17, 1, -21 },
  { 2864, 15, 5, 17, 1, -11 },
};

const GFXfont IBMPlexMono_LightItalic28pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic28pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic28pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _IBMPLEXMONO_LIGHTITALIC28PT7B_H_
