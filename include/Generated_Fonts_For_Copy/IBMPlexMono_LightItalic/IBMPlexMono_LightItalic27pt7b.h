#ifndef _IBMPLEXMONO_LIGHTITALIC27PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC4, 0x23, 0x18, 0xC4, 0x21, 0x08, 0x80, 0x00, 0x00, 0xE7,
  0x30, 0x62, 0xCD, 0x9A, 0x34, 0x58, 0xB3, 0x00, 0x00, 0xC6, 0x00, 0x62,
  0x00, 0x21, 0x00, 0x31, 0x80, 0x18, 0x80, 0x08, 0x40, 0xFC, 0x7E, 0x04,
  0x20, 0x02, 0x10, 0x03, 0x18, 0x01, 0x08, 0x00, 0x84, 0x07, 0xC7, 0xE4,
  0x42, 0x00, 0x21, 0x00, 0x31, 0x80, 0x10, 0x80, 0x08, 0x40, 0x0C, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x3F, 0x80, 0xC9, 0xC2, 0x10,
  0xCC, 0x20, 0x18, 0x40, 0x31, 0x80, 0x63, 0x00, 0x64, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x26, 0x00, 0xC6, 0x01, 0x0C, 0x02, 0x18, 0x04, 0x32, 0x08,
  0x66, 0x11, 0x87, 0x66, 0x03, 0xF0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x07, 0x80, 0x61, 0x88, 0x18, 0x21, 0x86, 0x0C, 0x10, 0x81, 0x06, 0x20,
  0x20, 0xCC, 0x04, 0x13, 0x00, 0xC6, 0x40, 0x0F, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x01, 0x91, 0x80, 0x64, 0x10, 0x19, 0x82, 0x02, 0x30, 0x40,
  0x86, 0x08, 0x30, 0xC3, 0x04, 0x08, 0xC3, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x06, 0x30, 0x0C, 0x18, 0x0C, 0x08, 0x0C, 0x08, 0x0C, 0x18, 0x0C, 0x18,
  0x04, 0x10, 0x06, 0x20, 0x1B, 0x80, 0x63, 0x00, 0x41, 0x80, 0xC0, 0x80,
  0xC0, 0xC0, 0xC0, 0x41, 0xC0, 0xE2, 0x40, 0xA6, 0x61, 0x34, 0x3E, 0x18,
  0x6D, 0xA4, 0xB0, 0x01, 0x81, 0x01, 0x01, 0x01, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30,
  0x08, 0x04, 0x03, 0x00, 0x80, 0x60, 0x18, 0x00, 0x0C, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x00, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x08, 0x20,
  0xF9, 0x3C, 0xFF, 0x00, 0xC0, 0x0F, 0x00, 0xC8, 0x0C, 0x60, 0xC1, 0x0C,
  0x0C, 0x00, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x03,
  0xFF, 0xE0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x00,
  0x39, 0x8C, 0xC6, 0x63, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x61, 0x84, 0x04,
  0x60, 0x36, 0x00, 0xB0, 0x05, 0x00, 0x38, 0x01, 0xC3, 0x1E, 0x38, 0xF1,
  0x87, 0x00, 0x38, 0x01, 0x40, 0x1A, 0x00, 0xD8, 0x0C, 0xC0, 0x43, 0x0C,
  0x0F, 0xC0, 0x01, 0xE0, 0x1A, 0x01, 0x90, 0x31, 0x83, 0x0C, 0x10, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x3F, 0xFE, 0x03, 0xE0, 0x30,
  0xE1, 0x80, 0x8C, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x30, 0xE1, 0x80,
  0x84, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x70, 0x1E,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x20, 0x0C, 0xC0,
  0x21, 0x83, 0x03, 0xF8, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x80, 0x36,
  0x01, 0x90, 0x0C, 0x40, 0x21, 0x01, 0x8C, 0x0C, 0x30, 0x60, 0xC3, 0x02,
  0x18, 0x08, 0x60, 0x23, 0x01, 0x8F, 0xFF, 0xC0, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x33, 0xE0, 0xF0, 0xC3, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x90, 0x04, 0xC0, 0x31, 0xC1, 0x81, 0xF8,
  0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x67, 0xC5, 0x86, 0xE0, 0x3C, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x3C,
  0x02, 0xC0, 0x66, 0x0C, 0x1F, 0x00, 0x7F, 0xFA, 0x00, 0xF0, 0x0D, 0x80,
  0x68, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0x03, 0xF0, 0x30, 0x61, 0x80, 0xC4, 0x01, 0x10, 0x04, 0xC0, 0x31,
  0x00, 0xC4, 0x02, 0x0C, 0x30, 0x1F, 0x01, 0x83, 0x18, 0x06, 0x40, 0x0B,
  0x00, 0x2C, 0x01, 0xB0, 0x06, 0x40, 0x31, 0xC1, 0x81, 0xF8, 0x00, 0x0F,
  0x83, 0x06, 0x60, 0x2C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0xF6, 0x1E, 0x3E, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCE,
  0x60, 0x0C, 0x3C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3,
  0x06, 0x18, 0x30, 0xC1, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x08, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x10, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x30, 0x02, 0x00, 0x00, 0x1F, 0x8C, 0x1B, 0x01, 0xE0, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x07, 0x83, 0xC0, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x61,
  0x84, 0x04, 0x60, 0x32, 0x00, 0xB0, 0x0D, 0x87, 0x68, 0xC7, 0x44, 0x16,
  0x20, 0xB3, 0x05, 0x98, 0x28, 0x83, 0x44, 0x1A, 0x21, 0x91, 0x94, 0x87,
  0x24, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x0F, 0xC0, 0x00, 0x60, 0x03,
  0x80, 0x0B, 0x00, 0x6C, 0x01, 0x30, 0x0C, 0xC0, 0x31, 0x01, 0x84, 0x06,
  0x10, 0x30, 0x60, 0xC1, 0x82, 0x06, 0x1F, 0xF8, 0x40, 0x23, 0x00, 0x88,
  0x02, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0xC0, 0x1F, 0xF0, 0x60, 0x61, 0x80,
  0x84, 0x03, 0x10, 0x0C, 0x40, 0x33, 0x00, 0x8C, 0x06, 0x30, 0x30, 0xFF,
  0x02, 0x03, 0x08, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x40,
  0x11, 0x01, 0x8F, 0xFC, 0x00, 0x03, 0xE0, 0x61, 0xC6, 0x06, 0x60, 0x12,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x88, 0x06, 0x60, 0x61, 0x86, 0x07, 0xE0,
  0x1F, 0xC1, 0x83, 0x0C, 0x04, 0x60, 0x33, 0x01, 0x90, 0x04, 0x80, 0x2C,
  0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0x80, 0x34, 0x01, 0x60, 0x1B, 0x00,
  0xD8, 0x0C, 0xC0, 0x46, 0x0C, 0x3F, 0xC0, 0x1F, 0xFE, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x7F, 0xF0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x7F, 0xF0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x61, 0x86, 0x06,
  0x60, 0x12, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0xFD, 0x80, 0x2C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x0C, 0x40, 0xE3, 0x0D,
  0x07, 0x98, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x10, 0x80, 0x21, 0x00, 0xC6,
  0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x08, 0x7F, 0xF0, 0x80, 0x63, 0x00,
  0xC6, 0x01, 0x8C, 0x03, 0x18, 0x04, 0x20, 0x08, 0x40, 0x31, 0x80, 0x63,
  0x00, 0xC0, 0x1F, 0xFE, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x03,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x01, 0x10, 0x18, 0xC0, 0x87, 0x0C, 0x0F, 0x80, 0x18, 0x03, 0x18,
  0x06, 0x18, 0x0C, 0x18, 0x18, 0x10, 0x70, 0x10, 0xE0, 0x31, 0x80, 0x33,
  0x00, 0x37, 0x00, 0x3D, 0x80, 0x39, 0x80, 0x30, 0x80, 0x60, 0xC0, 0x60,
  0x40, 0x60, 0x60, 0x60, 0x20, 0x40, 0x30, 0x40, 0x10, 0xC0, 0x18, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03,
  0xFF, 0x80, 0x18, 0x06, 0x30, 0x1C, 0x70, 0x39, 0xE0, 0xF3, 0x41, 0x46,
  0x86, 0x89, 0x99, 0x13, 0x26, 0x22, 0xCC, 0xC5, 0x19, 0x8E, 0x23, 0x18,
  0x44, 0x20, 0x88, 0x03, 0x10, 0x06, 0x60, 0x0C, 0xC0, 0x11, 0x80, 0x22,
  0x00, 0x40, 0x1C, 0x06, 0x38, 0x0C, 0x50, 0x10, 0xB0, 0x21, 0x60, 0x46,
  0x41, 0x8C, 0x83, 0x19, 0x86, 0x23, 0x08, 0x42, 0x10, 0x86, 0x23, 0x0C,
  0xC6, 0x09, 0x8C, 0x13, 0x10, 0x34, 0x20, 0x68, 0x40, 0x51, 0x80, 0xE3,
  0x01, 0xC0, 0x07, 0xC0, 0x61, 0x84, 0x04, 0x60, 0x36, 0x00, 0xB0, 0x05,
  0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0x40,
  0x1A, 0x00, 0xD8, 0x0C, 0xC0, 0x43, 0x0C, 0x0F, 0xC0, 0x1F, 0xF8, 0x30,
  0x18, 0x60, 0x10, 0xC0, 0x31, 0x00, 0x62, 0x00, 0xCC, 0x01, 0x18, 0x06,
  0x30, 0x18, 0x7F, 0xC0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x61,
  0x84, 0x04, 0x60, 0x36, 0x00, 0xB0, 0x05, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0x40, 0x1A, 0x00, 0xD8, 0x0C, 0xC0,
  0x43, 0x0C, 0x0F, 0xC0, 0x08, 0x00, 0x61, 0x01, 0x98, 0x05, 0x80, 0x30,
  0x1F, 0xF8, 0x30, 0x18, 0x60, 0x10, 0xC0, 0x31, 0x00, 0x62, 0x00, 0xCC,
  0x01, 0x18, 0x06, 0x30, 0x18, 0x7F, 0xC0, 0x86, 0x01, 0x04, 0x02, 0x0C,
  0x0C, 0x18, 0x18, 0x10, 0x30, 0x30, 0x40, 0x20, 0x80, 0x63, 0x00, 0xC0,
  0x07, 0xF0, 0x18, 0x38, 0x40, 0x19, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x40, 0x0C, 0xC0, 0x30, 0xE0, 0xC0, 0x7E, 0x00,
  0xFF, 0xFC, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x0C,
  0xC0, 0x33, 0x00, 0x88, 0x02, 0x20, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06,
  0x60, 0x11, 0x00, 0x44, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x8C, 0x02,
  0x30, 0x18, 0xC0, 0x41, 0x83, 0x03, 0xF0, 0x00, 0xC0, 0x0F, 0x00, 0x2C,
  0x01, 0x90, 0x04, 0x40, 0x31, 0x00, 0x86, 0x06, 0x18, 0x10, 0x60, 0xC1,
  0x83, 0x02, 0x18, 0x08, 0x60, 0x23, 0x00, 0xCC, 0x03, 0x20, 0x0D, 0x80,
  0x34, 0x00, 0x70, 0x01, 0x80, 0x00, 0x60, 0x06, 0x80, 0x0D, 0x00, 0x12,
  0x00, 0x24, 0x00, 0xC8, 0x61, 0x90, 0xC2, 0x23, 0x84, 0xC5, 0x19, 0x8A,
  0x33, 0x24, 0x46, 0x4C, 0x8D, 0x9B, 0x12, 0x36, 0x2C, 0x28, 0x50, 0x50,
  0xA0, 0xE1, 0xC1, 0xC3, 0x03, 0x00, 0x18, 0x01, 0x86, 0x01, 0x83, 0x01,
  0x80, 0xC1, 0x80, 0x60, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x61, 0x80,
  0x60, 0xC0, 0x30, 0x20, 0x30, 0x18, 0x30, 0x04, 0x30, 0x03, 0x00, 0x80,
  0x0F, 0x80, 0x19, 0x00, 0x63, 0x01, 0x86, 0x06, 0x04, 0x0C, 0x0C, 0x30,
  0x08, 0xC0, 0x1B, 0x00, 0x16, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xFF,
  0xFC, 0x0F, 0xE1, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0xFE, 0x00,
  0x81, 0x81, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x02,
  0x04, 0x0C, 0x08, 0x10, 0x20, 0x60, 0x40, 0x81, 0x02, 0x06, 0x0F, 0xF0,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0xFF, 0x00,
  0x01, 0x80, 0x1E, 0x01, 0xB0, 0x08, 0x80, 0xC6, 0x0C, 0x10, 0xC0, 0xC4,
  0x02, 0x60, 0x16, 0x00, 0xE0, 0x04, 0xFF, 0xF8, 0x4C, 0x62, 0x30, 0x0F,
  0x13, 0x05, 0x60, 0x34, 0x03, 0xC0, 0x3C, 0x02, 0xC0, 0x28, 0x02, 0x80,
  0x68, 0x06, 0x80, 0x6C, 0x0E, 0x61, 0x43, 0xE7, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x8F, 0x05, 0x8C, 0x30, 0x33, 0x80,
  0x98, 0x04, 0xC0, 0x34, 0x01, 0x20, 0x09, 0x00, 0xD8, 0x06, 0xC0, 0x26,
  0x03, 0x28, 0x31, 0x1E, 0x00, 0x07, 0xC1, 0x86, 0x30, 0x36, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x04, 0xC0, 0x24, 0x04, 0x61,
  0xC1, 0xF0, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x3E, 0x46, 0x0A, 0x60, 0x32, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x02, 0x40,
  0x12, 0x00, 0x90, 0x0C, 0x80, 0x66, 0x07, 0x18, 0x50, 0x7C, 0x80, 0x07,
  0xC1, 0x86, 0x30, 0x36, 0x01, 0x40, 0x3C, 0x06, 0xC1, 0xCF, 0xE0, 0xC0,
  0x0C, 0x00, 0xC0, 0x34, 0x06, 0x60, 0xC1, 0xF0, 0x00, 0x3F, 0x80, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x3F, 0xFC, 0x21,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x10, 0x60, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xC8, 0x00, 0x34, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xC8, 0xC1, 0x4C, 0x06, 0x40, 0x36, 0x01, 0xB0, 0x0D,
  0x80, 0x48, 0x02, 0x40, 0x12, 0x01, 0x90, 0x0C, 0xC0, 0xE3, 0x0A, 0x0F,
  0x90, 0x00, 0x80, 0x0C, 0x80, 0x46, 0x0C, 0x0F, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x33, 0xC3, 0x46, 0x38, 0x33, 0x03,
  0x60, 0x36, 0x03, 0x60, 0x24, 0x02, 0x40, 0x24, 0x06, 0xC0, 0x6C, 0x06,
  0xC0, 0x48, 0x04, 0x03, 0x80, 0x38, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC1, 0x0C, 0x20, 0x8C, 0x09, 0x81, 0xB0, 0x0C, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x88, 0x10, 0x41, 0x02, 0x10, 0x13, 0x00, 0xB0, 0x06,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xCF,
  0x05, 0x8C, 0x30, 0x31, 0x81, 0x98, 0x0C, 0xC0, 0xC6, 0x0C, 0x21, 0x81,
  0x30, 0x08, 0xC1, 0xC6, 0x1E, 0x19, 0xB0, 0x59, 0x03, 0x80, 0xFE, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x11, 0x87, 0x31, 0x86, 0x40, 0x90,
  0x1C, 0x00, 0x27, 0x38, 0xE5, 0x12, 0x18, 0x58, 0x61, 0x61, 0x05, 0x04,
  0x34, 0x10, 0xD0, 0xC3, 0x43, 0x0B, 0x0C, 0x2C, 0x20, 0xA0, 0x86, 0x82,
  0x1A, 0x18, 0x60, 0x33, 0xC3, 0x46, 0x38, 0x33, 0x03, 0x60, 0x36, 0x03,
  0x60, 0x24, 0x02, 0x40, 0x24, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x48, 0x04,
  0x0F, 0xC1, 0x86, 0x20, 0x36, 0x01, 0x40, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x24, 0x04, 0x61, 0x81, 0xF0, 0x19, 0xE0, 0x58,
  0xC1, 0x81, 0x8E, 0x02, 0x30, 0x08, 0xC0, 0x32, 0x00, 0x88, 0x02, 0x20,
  0x19, 0x80, 0x66, 0x01, 0x18, 0x0C, 0x50, 0x61, 0x1E, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x93, 0x85, 0x60, 0x34,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x28, 0x02, 0x80, 0x28, 0x06, 0x80, 0x6C,
  0x0E, 0x61, 0x43, 0xE4, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0xFC, 0xF8, 0x68, 0x03, 0x80, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x07,
  0xE0, 0xC0, 0xC4, 0x02, 0x60, 0x03, 0x00, 0x08, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x10, 0x00, 0x80, 0x05, 0x80, 0x67, 0x06, 0x0F, 0xE0, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x7F, 0xFC, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0xC3, 0x08,
  0x11, 0x80, 0xB0, 0x07, 0x00, 0x30, 0x12, 0x01, 0x20, 0x36, 0x03, 0x60,
  0x36, 0x02, 0x40, 0x24, 0x02, 0x40, 0x6C, 0x06, 0xC0, 0xE4, 0x14, 0x62,
  0x43, 0xCC, 0xF8, 0x30, 0xC0, 0x84, 0x04, 0x20, 0x21, 0x01, 0x98, 0x08,
  0xC0, 0x46, 0x06, 0x30, 0x21, 0x03, 0x08, 0x30, 0x43, 0x06, 0x70, 0x1E,
  0x00, 0x30, 0x8C, 0x82, 0x12, 0x18, 0x48, 0x61, 0x61, 0x85, 0x84, 0x16,
  0x10, 0x50, 0x41, 0x43, 0x0D, 0x0C, 0x34, 0x30, 0xB0, 0xC6, 0x45, 0x31,
  0xE7, 0x80, 0x07, 0x1E, 0x19, 0x23, 0x71, 0x43, 0x01, 0xC3, 0x01, 0xC3,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC2, 0x80, 0xC2, 0x84,
  0xC2, 0x8E, 0x44, 0xD8, 0x78, 0x70, 0x18, 0x08, 0x80, 0x44, 0x06, 0x60,
  0x33, 0x01, 0x98, 0x08, 0x80, 0x44, 0x02, 0x20, 0x33, 0x01, 0x98, 0x1C,
  0x41, 0x43, 0x12, 0x0F, 0x30, 0x01, 0x80, 0x08, 0x80, 0xC6, 0x0C, 0x1F,
  0x80, 0x0F, 0x8C, 0x43, 0xF2, 0x01, 0x88, 0x0C, 0x20, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x10, 0x60, 0x43, 0x01, 0x1C, 0x06, 0x5F, 0x9B,
  0x07, 0xC0, 0x03, 0xF0, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x10, 0x03, 0x00, 0x60, 0xF8, 0x00, 0x60, 0x02,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x3F, 0x80, 0x08, 0xC6, 0x21, 0x08, 0x46, 0x31, 0x88, 0x42,
  0x31, 0x8C, 0x42, 0x10, 0x8C, 0x62, 0x10, 0x80, 0x0F, 0xC0, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x06, 0x00, 0x0F, 0x81, 0x80, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFC,
  0x00, 0x1C, 0x04, 0x88, 0x16, 0x10, 0x90, 0x66, 0xC0, 0xF0,
};

const GFXglyph IBMPlexMono_LightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 19, 16, 6, -19 },
  { 13, 7, 7, 16, 6, -20 },
  { 20, 17, 19, 16, 0, -19 },
  { 61, 15, 25, 16, 1, -22 },
  { 108, 19, 19, 16, -1, -19 },
  { 154, 16, 19, 16, 0, -19 },
  { 192, 3, 7, 16, 8, -20 },
  { 195, 9, 25, 16, 6, -21 },
  { 224, 10, 25, 16, 1, -21 },
  { 256, 13, 13, 16, 2, -15 },
  { 278, 13, 13, 16, 2, -15 },
  { 300, 5, 7, 16, 4, -3 },
  { 305, 8, 1, 16, 4, -9 },
  { 306, 3, 3, 16, 6, -3 },
  { 308, 15, 25, 16, 1, -21 },
  { 355, 13, 19, 16, 2, -19 },
  { 386, 13, 19, 16, 1, -19 },
  { 417, 14, 19, 16, 1, -19 },
  { 451, 14, 19, 16, 1, -19 },
  { 485, 14, 19, 16, 1, -19 },
  { 519, 14, 19, 16, 1, -19 },
  { 553, 12, 19, 16, 2, -19 },
  { 582, 13, 19, 16, 3, -19 },
  { 613, 14, 19, 16, 1, -19 },
  { 647, 12, 19, 16, 3, -19 },
  { 676, 5, 14, 16, 6, -14 },
  { 685, 7, 18, 16, 4, -14 },
  { 701, 13, 15, 16, 2, -16 },
  { 726, 14, 6, 16, 1, -11 },
  { 737, 13, 15, 16, 1, -16 },
  { 762, 11, 19, 16, 4, -19 },
  { 789, 13, 22, 16, 2, -19 },
  { 825, 14, 19, 16, 0, -19 },
  { 859, 14, 19, 16, 1, -19 },
  { 893, 13, 19, 16, 2, -19 },
  { 924, 13, 19, 16, 2, -19 },
  { 955, 15, 19, 16, 1, -19 },
  { 991, 15, 19, 16, 1, -19 },
  { 1027, 13, 19, 16, 2, -19 },
  { 1058, 15, 19, 16, 1, -19 },
  { 1094, 15, 19, 16, 1, -19 },
  { 1130, 13, 19, 16, 2, -19 },
  { 1161, 16, 19, 16, 1, -19 },
  { 1199, 11, 19, 16, 2, -19 },
  { 1226, 15, 19, 16, 1, -19 },
  { 1262, 15, 19, 16, 1, -19 },
  { 1298, 13, 19, 16, 2, -19 },
  { 1329, 15, 19, 16, 1, -19 },
  { 1365, 13, 24, 16, 2, -19 },
  { 1404, 15, 19, 16, 1, -19 },
  { 1440, 15, 19, 16, 1, -19 },
  { 1476, 14, 19, 16, 3, -19 },
  { 1510, 14, 19, 16, 2, -19 },
  { 1544, 14, 19, 16, 3, -19 },
  { 1578, 15, 19, 16, 2, -19 },
  { 1614, 17, 19, 16, 0, -19 },
  { 1655, 15, 19, 16, 3, -19 },
  { 1691, 16, 19, 16, 0, -19 },
  { 1729, 11, 25, 16, 5, -21 },
  { 1764, 7, 25, 16, 5, -21 },
  { 1786, 12, 25, 16, 0, -21 },
  { 1824, 13, 11, 16, 2, -19 },
  { 1842, 13, 1, 16, 0, 3 },
  { 1844, 4, 5, 16, 6, -21 },
  { 1847, 12, 14, 16, 2, -14 },
  { 1868, 13, 20, 16, 2, -20 },
  { 1901, 12, 14, 16, 2, -14 },
  { 1922, 13, 20, 16, 2, -20 },
  { 1955, 12, 14, 16, 2, -14 },
  { 1976, 17, 25, 16, 0, -20 },
  { 2030, 13, 19, 16, 1, -14 },
  { 2061, 12, 20, 16, 2, -20 },
  { 2091, 12, 21, 16, 2, -21 },
  { 2123, 12, 25, 16, 2, -20 },
  { 2161, 13, 20, 16, 2, -20 },
  { 2194, 11, 20, 16, 3, -20 },
  { 2222, 14, 14, 16, 1, -14 },
  { 2247, 12, 14, 16, 2, -14 },
  { 2268, 12, 14, 16, 2, -14 },
  { 2289, 14, 19, 16, 1, -14 },
  { 2323, 12, 19, 16, 2, -14 },
  { 2352, 13, 14, 16, 3, -14 },
  { 2375, 13, 14, 16, 1, -14 },
  { 2398, 13, 19, 16, 2, -19 },
  { 2429, 12, 14, 16, 2, -14 },
  { 2450, 13, 14, 16, 2, -14 },
  { 2473, 14, 14, 16, 1, -14 },
  { 2498, 16, 14, 16, 0, -14 },
  { 2526, 13, 19, 16, 1, -14 },
  { 2557, 14, 14, 16, 1, -14 },
  { 2582, 12, 25, 16, 3, -21 },
  { 2620, 5, 25, 16, 6, -21 },
  { 2636, 13, 25, 16, 1, -21 },
  { 2677, 14, 5, 16, 1, -11 },
};

const GFXfont IBMPlexMono_LightItalic27pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic27pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic27pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _IBMPLEXMONO_LIGHTITALIC27PT7B_H_
