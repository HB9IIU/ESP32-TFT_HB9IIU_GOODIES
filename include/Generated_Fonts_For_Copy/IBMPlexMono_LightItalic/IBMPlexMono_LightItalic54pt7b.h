#ifndef _IBMPLEXMONO_LIGHTITALIC54PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x83,
  0xF8, 0x7E, 0x0F, 0xC0, 0xF0, 0x00, 0x1C, 0x1C, 0x70, 0x73, 0x81, 0xCE,
  0x07, 0x38, 0x1C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x70, 0x39, 0xC0, 0xE7,
  0x03, 0x9C, 0x1C, 0x70, 0x73, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x0F,
  0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x60, 0x38, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xF0, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xF8, 0xE7, 0xE0,
  0x1E, 0x07, 0x0F, 0x81, 0xE0, 0x30, 0x1E, 0x0E, 0x01, 0x80, 0x70, 0xF0,
  0x0C, 0x02, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0xC0, 0x60, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xF1, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0x60, 0x3C,
  0x00, 0x03, 0x01, 0xE0, 0x00, 0x18, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x80, 0x18,
  0x07, 0x86, 0x00, 0xC0, 0x38, 0x78, 0x0E, 0x03, 0xC3, 0xE0, 0x70, 0x3C,
  0x0F, 0x83, 0x03, 0xE0, 0x3F, 0x18, 0x7E, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x07, 0xFC, 0x00, 0x0E, 0x00, 0xFF,
  0xE0, 0x00, 0xC0, 0x1E, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x70, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x38, 0x07, 0x00, 0x70, 0x03, 0x80,
  0xE0, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x03, 0x03, 0x80, 0x06, 0x00,
  0x70, 0x38, 0x00, 0x60, 0x07, 0x07, 0x00, 0x06, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0x0E, 0x0C, 0x00, 0x07, 0x83, 0xC1, 0xC0, 0x00, 0x3F, 0xFC, 0x38,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1C, 0x1F, 0xFC, 0x00, 0x03, 0x83, 0xC1,
  0xE0, 0x00, 0x38, 0x70, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x60, 0x00, 0xE0,
  0xE0, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x60, 0x01, 0xC0, 0xE0, 0x06, 0x00,
  0x38, 0x0C, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x1C, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x38, 0x00,
  0xE0, 0x3C, 0x03, 0x80, 0x0F, 0x07, 0x80, 0x70, 0x00, 0x7F, 0xF0, 0x0E,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x78, 0x03, 0x80, 0x00, 0x70, 0x03, 0xC0, 0x00, 0xF0, 0x01,
  0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xFE, 0xFC,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x78, 0x03, 0x80, 0x00, 0x70, 0x03, 0xC0,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x78, 0x06, 0xF0, 0x00, 0x78,
  0x0F, 0xF0, 0x00, 0x5C, 0x0E, 0x70, 0x00, 0xDC, 0x1C, 0x70, 0x01, 0x8E,
  0x1C, 0x78, 0x03, 0x8F, 0x38, 0x3E, 0x0F, 0x07, 0x78, 0x1F, 0xFF, 0x07,
  0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xC0, 0x39, 0xCE, 0xE7,
  0x39, 0xCE, 0x77, 0x39, 0xCE, 0x70, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x70, 0x06, 0xFE, 0x06, 0x07, 0xE7, 0xFC, 0xE3, 0xFF,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x0F,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x38, 0x01, 0x80, 0x03,
  0x80, 0x10, 0x00, 0x20, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC1, 0xE0,
  0xF8, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0xFB, 0xFF,
  0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xE0, 0x7C, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0xF0,
  0x00, 0x3C, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xFC, 0x07,
  0x80, 0x7F, 0x01, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3E, 0x03, 0xF8,
  0x07, 0x80, 0xFE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x0F, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x70, 0xF0,
  0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x3E, 0x70, 0x00, 0x1F, 0x1C, 0x00, 0x0F, 0x87, 0x00, 0x07, 0xC1, 0xC0,
  0x03, 0xE0, 0x70, 0x03, 0xF0, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x18, 0x03,
  0x80, 0x04, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x7C, 0x07, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0x40, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7C, 0x07,
  0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x08,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x1F, 0x80, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x07,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x38, 0x01, 0xC0,
  0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0xFF, 0x00, 0x0E,
  0x7F, 0xF8, 0x01, 0xDF, 0xFF, 0x80, 0x37, 0x01, 0xF8, 0x0F, 0x80, 0x0F,
  0x81, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC1, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x81,
  0xF0, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x1F, 0xC0, 0x3C, 0x7F, 0xF0, 0x39, 0xFF, 0xFC, 0x3B,
  0xC0, 0x7C, 0x77, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x78,
  0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x0F,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x1E, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x38,
  0x03, 0xE0, 0x3E, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x38,
  0x00, 0x0F, 0x9E, 0x00, 0x0D, 0xCF, 0x80, 0x0D, 0xC3, 0xF0, 0x1E, 0xE0,
  0xFF, 0xFC, 0xE0, 0x3F, 0xFC, 0x70, 0x07, 0xF8, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x7C,
  0x3F, 0x8F, 0xC3, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0xC1, 0xE0, 0x07, 0xC7, 0x80, 0x07,
  0x9E, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x40, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x07,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x07, 0x81, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x0F, 0x87,
  0x38, 0x0F, 0xF9, 0xCE, 0x07, 0xFE, 0x63, 0x81, 0xE0, 0xD8, 0xC0, 0xF0,
  0x1E, 0x70, 0x38, 0x03, 0x9C, 0x1C, 0x00, 0xE7, 0x07, 0x00, 0x39, 0xC1,
  0xC0, 0x0C, 0x70, 0xE0, 0x03, 0x38, 0x38, 0x01, 0xCE, 0x0E, 0x00, 0x73,
  0x83, 0x80, 0x1C, 0xE0, 0xE0, 0x07, 0x38, 0x38, 0x03, 0x8E, 0x0E, 0x00,
  0xE3, 0x83, 0x80, 0x78, 0xC0, 0xE0, 0x1E, 0x30, 0x3C, 0x0B, 0x8C, 0x07,
  0xDE, 0xE3, 0x01, 0xFF, 0x30, 0xC0, 0x3F, 0x8C, 0x30, 0x01, 0x04, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x07,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00,
  0x78, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x1C, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x03, 0xC0, 0x07, 0xC0, 0x70,
  0x00, 0x3C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x0F, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0F,
  0x1E, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x07,
  0x80, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x40, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x07,
  0x80, 0xF8, 0x01, 0xE0, 0x0F, 0xC0, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xC0, 0x0F, 0x80, 0x38, 0x00, 0x78, 0x07,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xF0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x0F,
  0x01, 0xC0, 0x0F, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x07, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x7F, 0xF9, 0xE0, 0x0F, 0xFF, 0x38, 0x01, 0xFF, 0xC7, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x83,
  0x80, 0x00, 0xF0, 0x70, 0x00, 0x3E, 0x0F, 0x00, 0x0D, 0x80, 0xF0, 0x03,
  0x70, 0x1F, 0x81, 0xEE, 0x01, 0xFF, 0xF9, 0xC0, 0x1F, 0xFC, 0x38, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0x38, 0xFC, 0x00, 0x00, 0x73, 0xFC, 0x00, 0x00, 0xEF, 0x38,
  0x00, 0x01, 0xFC, 0x78, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x0F, 0xC0, 0xF0,
  0x00, 0x1F, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xFC, 0x1D, 0x80, 0x07, 0xE0, 0x77, 0x00, 0x3B, 0x81,
  0xDC, 0x00, 0xEE, 0x06, 0x70, 0x07, 0x38, 0x38, 0xC0, 0x1C, 0xE0, 0xE3,
  0x80, 0xE3, 0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0x60,
  0xE1, 0xC0, 0xE1, 0xC3, 0x87, 0x07, 0x07, 0x1C, 0x1C, 0x1C, 0x1C, 0xE0,
  0x70, 0x70, 0x33, 0x83, 0x81, 0xC0, 0xFC, 0x0E, 0x07, 0x03, 0xF0, 0x38,
  0x1C, 0x07, 0x80, 0xE0, 0xE0, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x0E, 0x0E,
  0x01, 0x80, 0x70, 0x38, 0x02, 0x01, 0xC0, 0xE0, 0x10, 0x07, 0x03, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x0F, 0xC0, 0x00, 0xE0, 0x3F, 0x00, 0x03, 0x80, 0xFC, 0x00, 0x0E, 0x03,
  0xB8, 0x00, 0x38, 0x0E, 0xE0, 0x00, 0xE0, 0x3B, 0x80, 0x03, 0x81, 0xCE,
  0x00, 0x1C, 0x07, 0x1C, 0x00, 0x70, 0x1C, 0x70, 0x01, 0xC0, 0x71, 0xC0,
  0x07, 0x01, 0xC7, 0x00, 0x1C, 0x07, 0x0E, 0x00, 0x70, 0x38, 0x38, 0x03,
  0x80, 0xE0, 0xE0, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0xE0,
  0x38, 0x1C, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x1C,
  0x03, 0x81, 0xC0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x07, 0x00,
  0x70, 0x70, 0x1C, 0x01, 0xC1, 0xC0, 0xE0, 0x07, 0x0E, 0x03, 0x80, 0x0E,
  0x38, 0x0E, 0x00, 0x38, 0xE0, 0x38, 0x00, 0xE3, 0x80, 0xE0, 0x03, 0x8E,
  0x03, 0x80, 0x07, 0x38, 0x1C, 0x00, 0x1D, 0xC0, 0x70, 0x00, 0x77, 0x01,
  0xC0, 0x01, 0xDC, 0x07, 0x00, 0x03, 0xF0, 0x1C, 0x00, 0x0F, 0xC0, 0x70,
  0x00, 0x3F, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0x7C, 0x03, 0xC0, 0x07, 0x81,
  0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x0F,
  0x00, 0xF8, 0x0F, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x38, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1E, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xE0, 0x7C, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0xF0,
  0x00, 0x3C, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x0F, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x70, 0xF0,
  0x00, 0x38, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xE0, 0xF8, 0x00,
  0x3C, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x38, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1E,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x81, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3C, 0x07, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x04, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE1, 0x00, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0x7F,
  0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0x78,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x1C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x07, 0x80,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x07, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0,
  0x38, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x38, 0x03, 0xC0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x01, 0xC1, 0xC0, 0x3C, 0x03, 0x83, 0x80, 0x78, 0x07, 0x07, 0x01, 0xF0,
  0x0E, 0x0E, 0x03, 0xE0, 0x38, 0x1C, 0x06, 0xE0, 0x70, 0x38, 0x1D, 0xC0,
  0xE0, 0x70, 0x33, 0x81, 0xC0, 0xE0, 0xE7, 0x07, 0x01, 0x81, 0xCE, 0x0E,
  0x03, 0x07, 0x1C, 0x1C, 0x06, 0x0E, 0x38, 0x38, 0x1C, 0x18, 0x30, 0xE0,
  0x38, 0x70, 0x61, 0xC0, 0x70, 0xE0, 0xC3, 0x80, 0xE3, 0x81, 0x87, 0x01,
  0xC7, 0x03, 0x0C, 0x03, 0x8C, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x70, 0x0E,
  0x70, 0x1C, 0xE0, 0x1D, 0xC0, 0x39, 0x80, 0x33, 0x80, 0x77, 0x00, 0x66,
  0x00, 0xEE, 0x00, 0xDC, 0x01, 0xDC, 0x01, 0xB0, 0x03, 0xB0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x0E,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x1E, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x23, 0x8E, 0x1C, 0x70, 0xE3, 0x86,
  0x1C, 0x20, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF8, 0x70, 0x3F, 0xFF, 0x38,
  0x1F, 0x81, 0xEE, 0x07, 0x80, 0x1B, 0x83, 0xC0, 0x03, 0xE1, 0xE0, 0x00,
  0x78, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x71, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0x3C, 0x00,
  0x0F, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0x70, 0x78, 0x00, 0xDC, 0x0F,
  0x00, 0x67, 0x03, 0xE0, 0x73, 0xFC, 0x7F, 0xFC, 0x7E, 0x0F, 0xFC, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x0F, 0xC0, 0x07, 0x0F, 0xFC, 0x01, 0xC7,
  0xFF, 0x80, 0x73, 0x81, 0xF0, 0x1D, 0x80, 0x1E, 0x0E, 0xC0, 0x03, 0x83,
  0xA0, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x38,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE1, 0xD0, 0x00,
  0x78, 0x76, 0x00, 0x7C, 0x1C, 0xE0, 0x7E, 0x07, 0x3F, 0xFF, 0x01, 0xC7,
  0xFF, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x0E,
  0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x05, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x1E,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x78, 0x00, 0x70, 0x3C, 0x00, 0xF0,
  0x1F, 0x03, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x03, 0xF8, 0x1C, 0x00, 0xFF, 0xE1, 0xC0, 0x1F, 0xFF,
  0x1C, 0x07, 0xE0, 0x7B, 0xC0, 0x78, 0x01, 0xB8, 0x0F, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x70, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x7C, 0x07, 0x80, 0x0D, 0xC0, 0x3C, 0x01, 0xDC, 0x03, 0xE0, 0x79,
  0xC0, 0x1F, 0xFF, 0x1C, 0x00, 0xFF, 0xE3, 0x80, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x3E,
  0x07, 0x80, 0x0F, 0x0F, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x3E,
  0x70, 0x00, 0xFC, 0xF0, 0x1F, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x08, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C,
  0x78, 0x00, 0x38, 0x3C, 0x00, 0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x1C, 0x07, 0xFF, 0xE3,
  0x81, 0xF8, 0x1E, 0xF0, 0x7C, 0x00, 0xDC, 0x0F, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0xF0, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78,
  0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0x70, 0x00, 0x3E, 0x0E, 0x00, 0x0F, 0x81, 0xE0, 0x03, 0x70, 0x1E,
  0x00, 0xEE, 0x03, 0xE0, 0x79, 0xC0, 0x3F, 0xFE, 0x38, 0x03, 0xFF, 0x8F,
  0x00, 0x1F, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x07, 0xE0, 0x0E, 0x1F, 0xF8, 0x0E, 0x3F, 0xFC, 0x0E,
  0x70, 0x3E, 0x0E, 0xE0, 0x1E, 0x0E, 0x80, 0x0E, 0x0F, 0x80, 0x0F, 0x1D,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01, 0x80, 0x70, 0x07, 0x80, 0xE0,
  0x1E, 0x01, 0xC0, 0x78, 0x03, 0x83, 0xE0, 0x0E, 0x0F, 0x80, 0x1C, 0x3C,
  0x00, 0x39, 0xF0, 0x00, 0x77, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x20, 0x03, 0x80, 0x70, 0x03, 0x80, 0xF8, 0x03, 0x80, 0x3C, 0x07, 0x00,
  0x1E, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC7, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x03, 0xF8, 0x00, 0xE1, 0xFF, 0x80, 0x1C, 0x7F, 0xF8, 0x03,
  0x9E, 0x0F, 0x80, 0x77, 0x00, 0x70, 0x0F, 0x80, 0x0F, 0x03, 0xA0, 0x00,
  0xE0, 0x7C, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0xF8,
  0x07, 0x00, 0x7C, 0x00, 0xE0, 0x3E, 0x00, 0x1C, 0x7F, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x23, 0x81, 0xC0, 0x06,
  0x70, 0x1C, 0x01, 0xEE, 0x03, 0x80, 0x79, 0xC0, 0x38, 0x1E, 0x70, 0x07,
  0x07, 0x8E, 0x00, 0x71, 0xE1, 0xC0, 0x0E, 0x78, 0x38, 0x00, 0xFE, 0x07,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x10, 0x1C, 0x00, 0x60, 0x70, 0x07, 0xC1, 0xC0, 0x3E, 0x07,
  0x01, 0xE0, 0x1C, 0x0F, 0x00, 0xE0, 0xF8, 0x03, 0x87, 0x80, 0x0E, 0x3C,
  0x00, 0x3B, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x1C, 0xFE, 0x1F, 0xC0, 0x77, 0xF8, 0xFF, 0x81,
  0xB0, 0xF7, 0x0E, 0x0E, 0x81, 0xD8, 0x3C, 0x3C, 0x07, 0xC0, 0x70, 0xF0,
  0x1E, 0x01, 0xC3, 0x80, 0x78, 0x06, 0x0E, 0x01, 0xC0, 0x38, 0x30, 0x07,
  0x00, 0xE1, 0xC0, 0x1C, 0x03, 0x87, 0x00, 0x60, 0x0E, 0x1C, 0x03, 0x80,
  0x38, 0x70, 0x0E, 0x00, 0xE1, 0xC0, 0x38, 0x03, 0x06, 0x00, 0xE0, 0x1C,
  0x38, 0x03, 0x80, 0x70, 0xE0, 0x0C, 0x01, 0xC3, 0x80, 0x70, 0x07, 0x0E,
  0x01, 0xC0, 0x1C, 0x38, 0x07, 0x00, 0x60, 0xC0, 0x1C, 0x03, 0x87, 0x00,
  0x70, 0x0E, 0x1C, 0x01, 0x80, 0x38, 0x70, 0x0E, 0x00, 0xE1, 0xC0, 0x38,
  0x03, 0x87, 0x00, 0xE0, 0x0C, 0x18, 0x03, 0x80, 0x70, 0xE0, 0x0E, 0x01,
  0xC0, 0x00, 0x07, 0xE0, 0x0E, 0x1F, 0xF8, 0x0E, 0x3F, 0xFC, 0x0E, 0x70,
  0x3E, 0x0E, 0xE0, 0x1E, 0x0E, 0x80, 0x0E, 0x1F, 0x80, 0x0F, 0x1D, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0xFC, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3B,
  0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03,
  0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x78, 0x1C, 0x00,
  0x78, 0x0F, 0x80, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x70, 0xFF, 0xC0, 0x0E, 0x3F, 0xFC,
  0x01, 0xCE, 0x07, 0xC0, 0x7B, 0x00, 0x3C, 0x0E, 0xC0, 0x03, 0x81, 0xD0,
  0x00, 0x70, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C,
  0x3C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x3A,
  0x00, 0x0F, 0x07, 0x60, 0x07, 0xC0, 0xE7, 0x03, 0xF0, 0x1C, 0xFF, 0xFC,
  0x03, 0x8F, 0xFE, 0x00, 0xE0, 0x3F, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF8, 0x70,
  0x1F, 0xFF, 0x1C, 0x1F, 0x81, 0xEF, 0x07, 0x80, 0x1B, 0x83, 0xC0, 0x03,
  0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x1E, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xF0, 0x78,
  0x00, 0xDC, 0x0F, 0x00, 0x67, 0x03, 0xE0, 0x79, 0xC0, 0x7F, 0xFC, 0x70,
  0x0F, 0xFE, 0x38, 0x00, 0xFE, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFC, 0x01, 0xDE, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0x80, 0x7E, 0x07,
  0x80, 0x07, 0xC3, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x10, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x03, 0xF0,
  0x0F, 0xC0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x40, 0x1C, 0x00, 0x60, 0x1E, 0x00, 0xF8, 0x0E, 0x00,
  0xF8, 0x07, 0x01, 0xF0, 0x03, 0x81, 0xF0, 0x01, 0xC3, 0xE0, 0x00, 0xE3,
  0xE0, 0x00, 0x77, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0x70, 0xF0,
  0x03, 0x70, 0xF0, 0x06, 0xF0, 0x7C, 0x1C, 0xE0, 0x7F, 0xF8, 0xE0, 0x3F,
  0xF0, 0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0x7F, 0xC0, 0x03, 0xBF,
  0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x38, 0x18, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x00,
  0x0E, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x0F, 0x80, 0xE0,
  0x0F, 0x80, 0x70, 0x0F, 0x80, 0x38, 0x1F, 0x80, 0x1C, 0x7F, 0x80, 0x0F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1C, 0x01, 0x80,
  0xC1, 0xC0, 0x38, 0x1E, 0x1C, 0x03, 0x80, 0xE1, 0xC0, 0x38, 0x0E, 0x1C,
  0x03, 0x80, 0x61, 0x80, 0x38, 0x06, 0x38, 0x03, 0x00, 0x73, 0x80, 0x70,
  0x07, 0x38, 0x07, 0x00, 0x73, 0x80, 0x70, 0x07, 0x38, 0x07, 0x00, 0x73,
  0x00, 0x70, 0x07, 0x70, 0x06, 0x00, 0x67, 0x00, 0xE0, 0x06, 0x70, 0x0E,
  0x00, 0xE7, 0x00, 0xE0, 0x0E, 0x70, 0x0E, 0x00, 0xE6, 0x00, 0xE0, 0x0E,
  0x60, 0x0C, 0x01, 0xCE, 0x01, 0xC0, 0x1C, 0xE0, 0x1C, 0x01, 0xCE, 0x01,
  0xC0, 0x3C, 0xE0, 0x3C, 0x03, 0x8E, 0x02, 0xC0, 0x78, 0xE0, 0x6C, 0x0F,
  0x0F, 0x0C, 0xE1, 0xE0, 0x7F, 0xCF, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x3E,
  0x03, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xF0, 0x07,
  0xF8, 0x3F, 0xF0, 0x3F, 0x70, 0xF1, 0xE0, 0xF8, 0x71, 0x81, 0xE7, 0xC0,
  0xE6, 0x01, 0xDE, 0x01, 0xCC, 0x03, 0x90, 0x01, 0xB0, 0x07, 0x00, 0x03,
  0x60, 0x0E, 0x00, 0x06, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0xF8, 0x00,
  0x1C, 0x01, 0x70, 0x00, 0x38, 0x06, 0xE0, 0x0C, 0x70, 0x0D, 0xC0, 0x3C,
  0xE0, 0x31, 0xC1, 0xE1, 0xC0, 0xE3, 0x87, 0x83, 0xC3, 0x87, 0x3E, 0x03,
  0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0,
  0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x38,
  0x00, 0x5C, 0x07, 0x80, 0x1B, 0x80, 0xF0, 0x06, 0x70, 0x0F, 0x83, 0x9E,
  0x01, 0xFF, 0xF3, 0x80, 0x1F, 0xF8, 0x70, 0x00, 0xFE, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x08, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0x7E, 0x03,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x1C, 0x3F, 0xFF, 0x83, 0x87, 0x81,
  0xFC, 0xE1, 0xE0, 0x07, 0xFC, 0x38, 0x00, 0x1F, 0x87, 0x00, 0x01, 0xE0,
  0xC0, 0x00, 0x78, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x00, 0x60, 0x1E,
  0x00, 0x0C, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x7F, 0xC0, 0x07,
  0x1F, 0xFF, 0x80, 0x63, 0x87, 0xFF, 0x8C, 0x70, 0x0F, 0xFF, 0x8E, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x60, 0x7F, 0x00, 0x07, 0x0F, 0xF8, 0x00, 0xE1, 0xE3,
  0xC0, 0x0E, 0x38, 0x1E, 0x01, 0xC3, 0x80, 0xE0, 0x1C, 0x70, 0x07, 0x03,
  0x86, 0x00, 0x78, 0x70, 0xE0, 0x03, 0xFF, 0x0E, 0x00, 0x1F, 0xE0, 0xC0,
  0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 11, 38, 32, 11, -38 },
  { 54, 14, 14, 32, 12, -40 },
  { 79, 32, 38, 32, 1, -38 },
  { 231, 29, 49, 32, 2, -43 },
  { 409, 36, 39, 32, -1, -38 },
  { 585, 32, 39, 32, 0, -38 },
  { 741, 5, 14, 32, 17, -40 },
  { 750, 19, 48, 32, 12, -41 },
  { 864, 19, 48, 32, 3, -41 },
  { 978, 28, 27, 32, 3, -30 },
  { 1073, 26, 27, 32, 4, -30 },
  { 1161, 10, 14, 32, 8, -6 },
  { 1179, 15, 3, 32, 9, -18 },
  { 1185, 7, 6, 32, 11, -6 },
  { 1191, 30, 48, 32, 2, -41 },
  { 1371, 26, 39, 32, 4, -38 },
  { 1498, 26, 38, 32, 2, -38 },
  { 1622, 27, 38, 32, 2, -38 },
  { 1751, 27, 39, 32, 2, -38 },
  { 1883, 29, 38, 32, 1, -38 },
  { 2021, 27, 39, 32, 3, -38 },
  { 2153, 24, 39, 32, 4, -38 },
  { 2270, 26, 38, 32, 6, -38 },
  { 2394, 27, 39, 32, 3, -38 },
  { 2526, 25, 38, 32, 5, -38 },
  { 2645, 10, 29, 32, 11, -29 },
  { 2682, 13, 37, 32, 8, -29 },
  { 2743, 26, 30, 32, 5, -32 },
  { 2841, 27, 13, 32, 3, -23 },
  { 2885, 26, 30, 32, 3, -32 },
  { 2983, 23, 38, 32, 7, -38 },
  { 3093, 26, 44, 32, 4, -38 },
  { 3236, 28, 38, 32, 0, -38 },
  { 3369, 27, 38, 32, 3, -38 },
  { 3498, 27, 39, 32, 4, -38 },
  { 3630, 27, 38, 32, 3, -38 },
  { 3759, 29, 38, 32, 3, -38 },
  { 3897, 29, 38, 32, 3, -38 },
  { 4035, 27, 39, 32, 4, -38 },
  { 4167, 30, 38, 32, 2, -38 },
  { 4310, 30, 38, 32, 2, -38 },
  { 4453, 26, 39, 32, 3, -38 },
  { 4580, 31, 38, 32, 3, -38 },
  { 4728, 22, 38, 32, 5, -38 },
  { 4833, 30, 38, 32, 2, -38 },
  { 4976, 30, 38, 32, 2, -38 },
  { 5119, 26, 39, 32, 4, -38 },
  { 5246, 28, 38, 32, 3, -38 },
  { 5379, 26, 48, 32, 4, -38 },
  { 5535, 28, 38, 32, 3, -38 },
  { 5668, 29, 39, 32, 2, -38 },
  { 5810, 30, 38, 32, 5, -38 },
  { 5953, 28, 39, 32, 4, -38 },
  { 6090, 28, 38, 32, 6, -38 },
  { 6223, 31, 38, 32, 3, -38 },
  { 6371, 34, 38, 32, 0, -38 },
  { 6533, 30, 38, 32, 5, -38 },
  { 6676, 33, 38, 32, 0, -38 },
  { 6833, 23, 48, 32, 9, -41 },
  { 6971, 14, 48, 32, 10, -41 },
  { 7055, 22, 48, 32, 1, -41 },
  { 7187, 26, 21, 32, 4, -38 },
  { 7256, 26, 3, 32, 0, 6 },
  { 7266, 6, 10, 32, 13, -42 },
  { 7274, 26, 30, 32, 3, -29 },
  { 7372, 26, 41, 32, 3, -40 },
  { 7506, 24, 30, 32, 4, -29 },
  { 7596, 28, 41, 32, 3, -40 },
  { 7740, 24, 30, 32, 4, -29 },
  { 7830, 35, 51, 32, -1, -40 },
  { 8054, 27, 40, 32, 2, -29 },
  { 8189, 24, 40, 32, 4, -40 },
  { 8309, 23, 41, 32, 5, -40 },
  { 8427, 24, 51, 32, 4, -40 },
  { 8580, 27, 41, 32, 4, -40 },
  { 8719, 22, 41, 32, 6, -40 },
  { 8832, 30, 29, 32, 1, -29 },
  { 8941, 24, 29, 32, 4, -29 },
  { 9028, 25, 30, 32, 4, -29 },
  { 9122, 27, 40, 32, 2, -29 },
  { 9257, 26, 40, 32, 3, -29 },
  { 9387, 26, 28, 32, 6, -28 },
  { 9478, 26, 30, 32, 3, -29 },
  { 9576, 25, 39, 32, 4, -38 },
  { 9698, 24, 29, 32, 5, -28 },
  { 9785, 25, 28, 32, 4, -28 },
  { 9873, 28, 29, 32, 3, -28 },
  { 9975, 31, 30, 32, 1, -29 },
  { 10092, 27, 39, 32, 2, -28 },
  { 10224, 27, 30, 32, 3, -29 },
  { 10326, 25, 48, 32, 6, -41 },
  { 10476, 11, 48, 32, 11, -41 },
  { 10542, 25, 48, 32, 2, -41 },
  { 10692, 28, 11, 32, 3, -22 },
};

const GFXfont IBMPlexMono_LightItalic54pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic54pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic54pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _IBMPLEXMONO_LIGHTITALIC54PT7B_H_
