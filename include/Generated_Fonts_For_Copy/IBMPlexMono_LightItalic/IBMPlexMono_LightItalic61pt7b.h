#ifndef _IBMPLEXMONO_LIGHTITALIC61PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C, 0x0E,
  0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x78, 0x1C,
  0x78, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0xF0, 0x38,
  0xF0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xE1,
  0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0x0C, 0x7F, 0x00, 0x7E, 0x06, 0x0F, 0xC0, 0x3C, 0x07, 0x01, 0xF0, 0x3C,
  0x03, 0x80, 0x78, 0x1C, 0x01, 0xC0, 0x18, 0x1E, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x30, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x3C, 0x03, 0x00, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x07, 0xC1, 0xC0, 0x00,
  0x01, 0xF8, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0E, 0xFF,
  0x00, 0x00, 0x07, 0x0F, 0xC0, 0x00, 0x03, 0x81, 0xF0, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0xC0, 0x3C, 0x00, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x06, 0x00, 0x78, 0x00, 0x03, 0x00, 0x38, 0x30, 0x03,
  0x80, 0x3C, 0x3C, 0x01, 0xC0, 0x1E, 0x1F, 0x00, 0xE0, 0x1E, 0x07, 0xC0,
  0x70, 0x1E, 0x01, 0xF0, 0x30, 0x3F, 0x00, 0x7F, 0x18, 0x7F, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0xF8, 0x00, 0x07, 0x80, 0x1F,
  0xFE, 0x00, 0x03, 0x80, 0x1F, 0x07, 0x80, 0x03, 0x80, 0x1E, 0x01, 0xE0,
  0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x00,
  0x1C, 0x00, 0x70, 0x70, 0x00, 0x07, 0x00, 0x78, 0x78, 0x00, 0x03, 0x80,
  0x78, 0x38, 0x00, 0x01, 0xF0, 0x78, 0x38, 0x00, 0x00, 0x7F, 0xF8, 0x20,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x83, 0xFF,
  0xE0, 0x00, 0x03, 0x83, 0xE0, 0xF0, 0x00, 0x03, 0x81, 0xC0, 0x3C, 0x00,
  0x03, 0x81, 0xC0, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00,
  0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x70, 0x0F,
  0x00, 0x38, 0x00, 0x3E, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0x00, 0x38,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x00, 0x78, 0x00, 0x38, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0xFF, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xC3, 0xF8, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x06, 0xF0, 0x00, 0x1F, 0x00, 0xF7,
  0x00, 0x01, 0x70, 0x0E, 0x70, 0x00, 0x37, 0x81, 0xC7, 0x80, 0x03, 0x3C,
  0x3C, 0x78, 0x00, 0x63, 0xC3, 0x83, 0xC0, 0x0E, 0x1E, 0x78, 0x1F, 0x03,
  0xC0, 0xE7, 0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xC0, 0x3C, 0xF3, 0x8E, 0x38, 0xE7, 0x9E, 0x71, 0xC7,
  0x1C, 0xF3, 0xCE, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x01, 0x80, 0x0E,
  0x00, 0x37, 0xE0, 0x1C, 0x03, 0xEF, 0xF8, 0x38, 0x7F, 0xE7, 0xFE, 0xF7,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xE0, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x7D, 0xFF, 0xFF,
  0xFF, 0xDF, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x03, 0xDE, 0x00, 0xF0, 0x0F, 0x78, 0x07, 0xC0,
  0x3D, 0xE0, 0x3F, 0x00, 0xF7, 0x00, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x0F,
  0xF0, 0x07, 0x80, 0x3B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x9C, 0x00, 0x03, 0xF1, 0xC0,
  0x00, 0x7E, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x3E,
  0x03, 0xC0, 0x0F, 0xC0, 0x38, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x00, 0x40, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xF8,
  0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3C, 0x02, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x08,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC1, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x0F,
  0xF0, 0x00, 0x1C, 0x7F, 0xFC, 0x00, 0x39, 0xFF, 0xFC, 0x00, 0xF7, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x81, 0x00, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0x1F,
  0x00, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x7F, 0x80, 0x1E, 0x3F,
  0xFE, 0x01, 0xE7, 0xFF, 0xF8, 0x3C, 0xF0, 0x1F, 0xC3, 0xDC, 0x00, 0x7C,
  0x3B, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x03,
  0xE0, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x07,
  0xC0, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x78, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x01, 0xF8, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x05, 0xC7, 0x80, 0x00,
  0xFC, 0x3C, 0x00, 0x3B, 0xC3, 0xF8, 0x0F, 0x38, 0x1F, 0xFF, 0xE7, 0x80,
  0x7F, 0xF8, 0xF0, 0x01, 0xFE, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x81,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0x01, 0xFC, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xF1, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x7C, 0x3C, 0x78, 0x07, 0xFC, 0xE1, 0xC0, 0x3F, 0xFB, 0x87,
  0x01, 0xF0, 0x6E, 0x1C, 0x0F, 0x00, 0xF8, 0xF0, 0x38, 0x01, 0xE3, 0x81,
  0xE0, 0x07, 0x8E, 0x07, 0x00, 0x1E, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0xF0,
  0x01, 0xC7, 0x83, 0x80, 0x07, 0x1E, 0x0E, 0x00, 0x1C, 0x70, 0x38, 0x00,
  0x71, 0xC0, 0xE0, 0x03, 0xC7, 0x07, 0x80, 0x0E, 0x1C, 0x1E, 0x00, 0x38,
  0x70, 0x78, 0x00, 0xE3, 0xC1, 0xE0, 0x07, 0x8E, 0x07, 0x80, 0x1E, 0x38,
  0x1E, 0x00, 0xF8, 0xE0, 0x38, 0x03, 0xC3, 0x80, 0xF0, 0x17, 0x0E, 0x03,
  0xE1, 0xDC, 0x38, 0x07, 0xFE, 0x70, 0xE0, 0x0F, 0xF1, 0xC3, 0x80, 0x1F,
  0x88, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x38, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x70, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x0F, 0x87, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x07, 0xE0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0x03, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xF0, 0x07,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0x80, 0x03,
  0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x7F, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xD1, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0xFF, 0xF8, 0xF0, 0x03, 0xFF, 0xE3, 0x80, 0x0F, 0xFF, 0x8E, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x2E, 0x07, 0xC0, 0x01, 0xB8, 0x0F, 0x80,
  0x1D, 0xE0, 0x1F, 0x81, 0xE7, 0x00, 0x7F, 0xFF, 0x1C, 0x00, 0x7F, 0xF8,
  0x70, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x08, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x00, 0x38, 0x00,
  0x7C, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x07, 0x00, 0xF8, 0x00,
  0x00, 0x70, 0x1F, 0x00, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0xF1, 0xFC, 0x00, 0x00, 0x0E,
  0x3F, 0xC0, 0x00, 0x00, 0xE7, 0xDE, 0x00, 0x00, 0x0E, 0xF9, 0xE0, 0x00,
  0x01, 0xFF, 0x0F, 0x00, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x01, 0xFC, 0x07,
  0x00, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xEE, 0x00, 0x07, 0xF0,
  0x3B, 0x80, 0x03, 0xF8, 0x0E, 0xE0, 0x01, 0xEE, 0x03, 0x9C, 0x00, 0x73,
  0x81, 0xE7, 0x00, 0x3C, 0xE0, 0x79, 0xC0, 0x0E, 0x78, 0x1C, 0x70, 0x07,
  0x9E, 0x07, 0x0E, 0x01, 0xC7, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0,
  0x78, 0x70, 0x3C, 0x38, 0x1C, 0x1C, 0x0F, 0x07, 0x0F, 0x0F, 0x03, 0x81,
  0xC3, 0x83, 0xC0, 0xE0, 0x71, 0xC0, 0xE0, 0x38, 0x1C, 0x70, 0x38, 0x0E,
  0x03, 0xB8, 0x0E, 0x07, 0x80, 0xFE, 0x03, 0x81, 0xE0, 0x3F, 0x01, 0xE0,
  0x70, 0x0F, 0xC0, 0x78, 0x1C, 0x01, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x07,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xF0, 0x06, 0x00, 0x70, 0x3C, 0x00, 0x80,
  0x3C, 0x0E, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x03, 0x80, 0xFE, 0x00,
  0x01, 0xC0, 0x7F, 0x00, 0x00, 0xE0, 0x3B, 0x80, 0x00, 0x70, 0x1D, 0xE0,
  0x00, 0x78, 0x0E, 0xF0, 0x00, 0x3C, 0x07, 0x38, 0x00, 0x1C, 0x07, 0x9C,
  0x00, 0x0E, 0x03, 0xCF, 0x00, 0x07, 0x01, 0xC3, 0x80, 0x03, 0x80, 0xE1,
  0xC0, 0x03, 0xC0, 0x70, 0xE0, 0x01, 0xE0, 0x38, 0x78, 0x00, 0xE0, 0x3C,
  0x1C, 0x00, 0x70, 0x1E, 0x0E, 0x00, 0x38, 0x0E, 0x07, 0x80, 0x1C, 0x07,
  0x03, 0xC0, 0x1E, 0x03, 0x80, 0xE0, 0x0F, 0x01, 0xC0, 0x70, 0x07, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0xF0, 0x1C, 0x01, 0xE0, 0x78, 0x0E, 0x00, 0x70, 0x3C,
  0x0F, 0x00, 0x38, 0x1C, 0x07, 0x80, 0x1E, 0x0E, 0x03, 0x80, 0x0F, 0x07,
  0x01, 0xC0, 0x03, 0x87, 0x80, 0xE0, 0x01, 0xC3, 0xC0, 0x70, 0x00, 0xF1,
  0xE0, 0x78, 0x00, 0x38, 0xE0, 0x3C, 0x00, 0x1C, 0x70, 0x1E, 0x00, 0x0E,
  0x38, 0x0E, 0x00, 0x07, 0x9C, 0x07, 0x00, 0x01, 0xDE, 0x03, 0x80, 0x00,
  0xEF, 0x03, 0xC0, 0x00, 0x7F, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0xF0, 0x00,
  0x0F, 0xC0, 0x70, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x01,
  0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x7C,
  0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x03, 0xC0,
  0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xC0, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x03, 0xF0,
  0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x06,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0E, 0x04, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x03, 0xE0, 0x0E,
  0x0E, 0x00, 0xF8, 0x03, 0x83, 0x80, 0x3E, 0x01, 0xE0, 0xE0, 0x1F, 0x80,
  0x70, 0x38, 0x07, 0xE0, 0x1C, 0x0E, 0x03, 0xF8, 0x07, 0x03, 0x80, 0xEE,
  0x01, 0xC0, 0xE0, 0x3B, 0x80, 0xE0, 0x78, 0x1C, 0x60, 0x38, 0x1E, 0x07,
  0x1C, 0x0E, 0x07, 0x03, 0x87, 0x03, 0x81, 0xC0, 0xE1, 0xC1, 0xC0, 0x70,
  0x38, 0x70, 0x70, 0x1C, 0x1C, 0x1C, 0x1C, 0x07, 0x07, 0x07, 0x07, 0x01,
  0xC3, 0x81, 0xC3, 0x80, 0x70, 0xE0, 0x70, 0xE0, 0x1C, 0x78, 0x1C, 0x38,
  0x07, 0x1C, 0x07, 0x0E, 0x01, 0xC7, 0x01, 0xC7, 0x00, 0xF3, 0x80, 0x71,
  0xC0, 0x3C, 0xE0, 0x0C, 0x70, 0x0E, 0x78, 0x03, 0x9C, 0x03, 0x9C, 0x00,
  0xEE, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x3B, 0x80, 0x0E, 0xE0, 0x0E, 0xE0,
  0x03, 0xB8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x07,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xC8, 0x00,
  0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x80, 0x31, 0xE1, 0xE3, 0xC3, 0x87, 0x87, 0x0E, 0x0E, 0x1C, 0x10,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x07, 0x01, 0xFF, 0xFC, 0x70, 0x3F,
  0x01, 0xC7, 0x07, 0xC0, 0x06, 0xF0, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x37, 0x07, 0x80,
  0x06, 0x70, 0x7C, 0x00, 0xEF, 0x03, 0xF0, 0x3C, 0xFF, 0x1F, 0xFF, 0x87,
  0xF0, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0xFE, 0x00, 0x1C,
  0x1F, 0xFC, 0x00, 0xE1, 0xFF, 0xF8, 0x07, 0x1E, 0x07, 0xC0, 0x79, 0x80,
  0x0F, 0x03, 0xD8, 0x00, 0x3C, 0x1F, 0x80, 0x01, 0xE0, 0xE8, 0x00, 0x07,
  0x07, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0x74, 0x00, 0x0F,
  0x07, 0xB8, 0x00, 0xF8, 0x3C, 0xF0, 0x1F, 0x81, 0xE3, 0xFF, 0xF8, 0x0E,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x07, 0x83,
  0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x0E, 0xF0, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x78, 0x07, 0xE0, 0x7E, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xF8,
  0x0F, 0x00, 0x1F, 0xFE, 0x1E, 0x00, 0xFF, 0xFE, 0x38, 0x03, 0xF0, 0x1E,
  0x70, 0x0F, 0x80, 0x0C, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x07, 0xE0, 0x38, 0x00, 0x1B, 0x80, 0x78, 0x00, 0x77, 0x00, 0xF8, 0x01,
  0xCE, 0x00, 0xFC, 0x0F, 0x3C, 0x00, 0xFF, 0xFC, 0x78, 0x00, 0xFF, 0xF0,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0x3C, 0x1F,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x3F, 0xC7, 0x80, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0xF0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x00, 0x3E, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x3C, 0x01, 0xFF, 0xFC, 0x70, 0x07, 0xE0, 0x3C, 0xE0, 0x1F, 0x00, 0x19,
  0xC0, 0x78, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x0B, 0xC0, 0x78, 0x00,
  0x37, 0x00, 0xF8, 0x01, 0xCE, 0x00, 0xFC, 0x0F, 0x1C, 0x00, 0xFF, 0xFC,
  0x78, 0x00, 0xFF, 0xF0, 0xF0, 0x00, 0x7F, 0x81, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x03, 0xF8, 0x01,
  0xE1, 0xFF, 0xC0, 0x3C, 0x7F, 0xFC, 0x07, 0x1E, 0x0F, 0xC0, 0xE7, 0x00,
  0x78, 0x1D, 0x80, 0x07, 0x83, 0xA0, 0x00, 0xF0, 0xFC, 0x00, 0x1E, 0x1F,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x1C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x80,
  0x0E, 0x00, 0x18, 0x01, 0xC0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0xF8, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x1F, 0x00, 0x07, 0x07, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x1F, 0xC0, 0x01, 0xE1, 0xFF, 0xE0, 0x03, 0x87,
  0xFF, 0xE0, 0x07, 0x1E, 0x07, 0xC0, 0x0E, 0x70, 0x03, 0xC0, 0x3D, 0x80,
  0x07, 0x80, 0x7A, 0x00, 0x07, 0x00, 0xFC, 0x00, 0x0E, 0x01, 0xF0, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78,
  0x01, 0xC0, 0x03, 0xE0, 0x03, 0x80, 0x1F, 0x00, 0x0F, 0x01, 0xF8, 0x00,
  0x1E, 0x1F, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x67, 0x80, 0xF0, 0x01, 0xEF,
  0x00, 0xE0, 0x07, 0x9E, 0x01, 0xE0, 0x1E, 0x38, 0x01, 0xC0, 0x78, 0x70,
  0x03, 0xC1, 0xE0, 0xE0, 0x03, 0x8F, 0x83, 0xC0, 0x07, 0xBE, 0x07, 0x80,
  0x07, 0xF8, 0x0F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x02, 0x03, 0x80, 0x07, 0x03, 0x80, 0x0F, 0x07, 0x80, 0x3E, 0x07,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x07, 0x03, 0xE0, 0x07, 0x07, 0xC0, 0x0F,
  0x0F, 0x00, 0x0F, 0x3E, 0x00, 0x0E, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0xE7, 0xF8,
  0x3F, 0xC0, 0x7B, 0xFF, 0x1F, 0xF8, 0x1C, 0xC3, 0xCE, 0x1E, 0x07, 0x60,
  0x77, 0x03, 0x81, 0xF0, 0x1D, 0x80, 0xF0, 0x78, 0x07, 0xC0, 0x3C, 0x1E,
  0x01, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x03, 0x83, 0xC0, 0x1E, 0x00, 0xE0,
  0xE0, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x03,
  0x83, 0x80, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x00, 0x70, 0x70, 0x03, 0x80,
  0x1C, 0x1C, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0x0E,
  0x00, 0x70, 0x70, 0x07, 0x80, 0x3C, 0x3C, 0x01, 0xE0, 0x0E, 0x0E, 0x00,
  0x70, 0x03, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x38,
  0x01, 0xC0, 0x0E, 0x0E, 0x00, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x01, 0xC1,
  0xC0, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x07,
  0x07, 0x00, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0xF0, 0xFF, 0xE0, 0x1E, 0x3F, 0xFE, 0x03, 0xCF, 0x07, 0xE0, 0x73,
  0x80, 0x3C, 0x0E, 0xC0, 0x03, 0xC1, 0xD0, 0x00, 0x78, 0x7E, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0xF8, 0x03,
  0xC0, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x07, 0x78, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xC3, 0xFF,
  0x80, 0x07, 0x0F, 0xFF, 0xC0, 0x0E, 0x3C, 0x0F, 0x80, 0x1C, 0xC0, 0x07,
  0x80, 0x7B, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x0F, 0x01, 0xD0, 0x00, 0x0E,
  0x03, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x07, 0x80, 0xE8, 0x00, 0x1E, 0x03, 0xDC, 0x00, 0x7C, 0x07, 0x9E, 0x03,
  0xF0, 0x0F, 0x1F, 0xFF, 0xC0, 0x1C, 0x1F, 0xFE, 0x00, 0x38, 0x0F, 0xF0,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFF, 0xC3, 0xC0, 0x7F, 0xFF, 0x1C, 0x07, 0xE0, 0x3C, 0xE0, 0x7C,
  0x00, 0x67, 0x07, 0xC0, 0x01, 0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0xFC, 0x1C, 0x00, 0x0D, 0xC0, 0xF0, 0x00,
  0xEE, 0x07, 0xC0, 0x0E, 0x70, 0x1F, 0x81, 0xE7, 0x80, 0x7F, 0xFE, 0x3C,
  0x01, 0xFF, 0xE1, 0xE0, 0x03, 0xFC, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFE, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xD0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0x0F, 0x81,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE1,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x78, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x08, 0x01, 0xE0, 0x01,
  0xC0, 0x1C, 0x00, 0x3E, 0x01, 0xC0, 0x0F, 0x80, 0x1C, 0x01, 0xF0, 0x03,
  0xC0, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0x38, 0xFC,
  0x00, 0x03, 0x9F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x2E, 0x0E, 0x00, 0x0D, 0xC1, 0xE0, 0x03, 0x78, 0x3E, 0x00,
  0xEF, 0x03, 0xE0, 0x79, 0xE0, 0x7F, 0xFE, 0x38, 0x03, 0xFF, 0x87, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x63, 0xFF, 0x00, 0x07, 0x9F, 0xF8,
  0x00, 0x3C, 0xFF, 0xC0, 0x00, 0xE8, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78,
  0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x1C,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x03,
  0xE0, 0x03, 0x80, 0x3E, 0x00, 0x1C, 0x07, 0xE0, 0x00, 0xE1, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x70, 0x1C, 0x0E, 0x00, 0x70, 0x1E, 0x0E,
  0x00, 0x70, 0x0E, 0x0E, 0x00, 0xF0, 0x0E, 0x0E, 0x00, 0xE0, 0x0E, 0x1E,
  0x00, 0xE0, 0x0E, 0x1C, 0x00, 0xE0, 0x0E, 0x1C, 0x00, 0xE0, 0x0F, 0x1C,
  0x00, 0xE0, 0x0F, 0x1C, 0x01, 0xE0, 0x0F, 0x1C, 0x01, 0xC0, 0x0F, 0x3C,
  0x01, 0xC0, 0x0F, 0x38, 0x01, 0xC0, 0x0E, 0x38, 0x01, 0xC0, 0x0E, 0x38,
  0x01, 0xC0, 0x0E, 0x38, 0x03, 0xC0, 0x0E, 0x38, 0x03, 0x80, 0x0E, 0x78,
  0x03, 0x80, 0x0E, 0x70, 0x03, 0x80, 0x1E, 0x70, 0x03, 0x80, 0x1C, 0x70,
  0x03, 0x80, 0x1C, 0x70, 0x07, 0x80, 0x1C, 0x70, 0x07, 0x00, 0x3C, 0x70,
  0x07, 0x00, 0x38, 0xF0, 0x0F, 0x00, 0x78, 0xF0, 0x0B, 0x00, 0x70, 0xF0,
  0x1B, 0x00, 0xF0, 0xF0, 0x33, 0x81, 0xE0, 0x78, 0x73, 0xC3, 0xC0, 0x7F,
  0xE3, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFF,
  0x01, 0xF9, 0xC1, 0xE1, 0xE0, 0x7C, 0x3C, 0x70, 0x1E, 0x3F, 0x03, 0x8C,
  0x03, 0xCF, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x0E, 0x60, 0x07, 0x20, 0x01,
  0xC8, 0x00, 0xE0, 0x00, 0x1B, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x07, 0x80,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x07, 0xC0, 0x00, 0x38,
  0x00, 0xF8, 0x00, 0x07, 0x00, 0x17, 0x00, 0x00, 0xE0, 0x06, 0xE0, 0x03,
  0x1C, 0x00, 0xDC, 0x00, 0xE3, 0x80, 0x31, 0xC0, 0x7E, 0x70, 0x0E, 0x38,
  0x1F, 0x0F, 0x03, 0x87, 0x0F, 0x80, 0xF0, 0xF0, 0xF3, 0xE0, 0x1F, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x80, 0xE0,
  0x00, 0x3E, 0x03, 0x80, 0x01, 0xF0, 0x0E, 0x00, 0x0D, 0xC0, 0x3C, 0x00,
  0x67, 0x00, 0xF8, 0x03, 0xBC, 0x01, 0xF0, 0x3C, 0xF0, 0x03, 0xFF, 0xE3,
  0xC0, 0x07, 0xFF, 0x0E, 0x00, 0x07, 0xF0, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x06, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x3C, 0x0F, 0xFF, 0xF0, 0x70, 0x3C, 0x07, 0xF8,
  0xE0, 0xF0, 0x01, 0xFD, 0xC1, 0xC0, 0x00, 0x7F, 0x83, 0x80, 0x00, 0x3E,
  0x07, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xF8,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x01, 0xC0, 0xFE, 0x00, 0x03, 0xC3, 0xFF, 0xC0, 0x03, 0x87, 0x3F, 0xFC,
  0x07, 0x0E, 0x07, 0xFF, 0x8E, 0x3C, 0x00, 0xFF, 0xFC, 0x78, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x08, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x06,
  0x03, 0xFC, 0x00, 0x0F, 0x07, 0xFE, 0x00, 0x0E, 0x0F, 0x1F, 0x00, 0x1E,
  0x1E, 0x07, 0x80, 0x1C, 0x3C, 0x03, 0x80, 0x3C, 0x38, 0x03, 0xC0, 0x38,
  0x78, 0x01, 0xE0, 0x70, 0x70, 0x00, 0xF0, 0xF0, 0x70, 0x00, 0xFF, 0xE0,
  0xE0, 0x00, 0x3F, 0xC0, 0x60, 0x00, 0x1F, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 12, 43, 37, 13, -43 },
  { 66, 16, 16, 37, 14, -45 },
  { 98, 37, 43, 37, 1, -43 },
  { 297, 33, 56, 37, 2, -49 },
  { 528, 41, 44, 37, -1, -43 },
  { 754, 36, 44, 37, 0, -43 },
  { 952, 6, 16, 37, 19, -45 },
  { 964, 22, 54, 37, 13, -46 },
  { 1113, 21, 54, 37, 3, -46 },
  { 1255, 31, 30, 37, 4, -33 },
  { 1372, 29, 29, 37, 4, -33 },
  { 1478, 12, 16, 37, 9, -7 },
  { 1502, 18, 3, 37, 10, -20 },
  { 1509, 7, 7, 37, 13, -7 },
  { 1516, 34, 54, 37, 2, -46 },
  { 1746, 30, 44, 37, 4, -43 },
  { 1911, 28, 43, 37, 3, -43 },
  { 2062, 31, 43, 37, 2, -43 },
  { 2229, 31, 44, 37, 2, -43 },
  { 2400, 32, 43, 37, 1, -43 },
  { 2572, 31, 44, 37, 3, -43 },
  { 2743, 28, 44, 37, 4, -43 },
  { 2897, 29, 43, 37, 7, -43 },
  { 3053, 31, 44, 37, 3, -43 },
  { 3224, 28, 43, 37, 6, -43 },
  { 3375, 11, 33, 37, 13, -33 },
  { 3421, 15, 42, 37, 9, -33 },
  { 3500, 30, 34, 37, 5, -36 },
  { 3628, 31, 15, 37, 3, -26 },
  { 3687, 29, 34, 37, 3, -36 },
  { 3811, 26, 43, 37, 8, -43 },
  { 3951, 30, 50, 37, 4, -43 },
  { 4139, 32, 43, 37, 0, -43 },
  { 4311, 30, 43, 37, 3, -43 },
  { 4473, 30, 44, 37, 5, -43 },
  { 4638, 30, 43, 37, 4, -43 },
  { 4800, 33, 43, 37, 3, -43 },
  { 4978, 33, 43, 37, 3, -43 },
  { 5156, 30, 44, 37, 5, -43 },
  { 5321, 33, 43, 37, 3, -43 },
  { 5499, 33, 43, 37, 3, -43 },
  { 5677, 29, 44, 37, 4, -43 },
  { 5837, 36, 43, 37, 3, -43 },
  { 6031, 25, 43, 37, 5, -43 },
  { 6166, 34, 43, 37, 2, -43 },
  { 6349, 33, 43, 37, 3, -43 },
  { 6527, 30, 44, 37, 4, -43 },
  { 6692, 32, 43, 37, 3, -43 },
  { 6864, 30, 54, 37, 4, -43 },
  { 7067, 32, 43, 37, 3, -43 },
  { 7239, 33, 44, 37, 2, -43 },
  { 7421, 33, 43, 37, 6, -43 },
  { 7599, 31, 44, 37, 5, -43 },
  { 7770, 31, 43, 37, 7, -43 },
  { 7937, 34, 43, 37, 4, -43 },
  { 8120, 39, 43, 37, 0, -43 },
  { 8330, 34, 43, 37, 6, -43 },
  { 8513, 37, 43, 37, 0, -43 },
  { 8712, 25, 54, 37, 11, -46 },
  { 8881, 15, 54, 37, 12, -46 },
  { 8983, 25, 54, 37, 1, -46 },
  { 9152, 30, 24, 37, 4, -43 },
  { 9242, 30, 3, 37, 0, 7 },
  { 9254, 7, 11, 37, 14, -47 },
  { 9264, 28, 33, 37, 4, -32 },
  { 9380, 29, 46, 37, 4, -45 },
  { 9547, 26, 33, 37, 5, -32 },
  { 9655, 31, 46, 37, 4, -45 },
  { 9834, 27, 33, 37, 5, -32 },
  { 9946, 39, 58, 37, -1, -45 },
  { 10229, 31, 45, 37, 2, -32 },
  { 10404, 27, 45, 37, 4, -45 },
  { 10556, 27, 46, 37, 5, -45 },
  { 10712, 27, 58, 37, 5, -45 },
  { 10908, 31, 46, 37, 4, -45 },
  { 11087, 24, 46, 37, 7, -45 },
  { 11225, 34, 32, 37, 1, -32 },
  { 11361, 27, 32, 37, 4, -32 },
  { 11469, 28, 33, 37, 4, -32 },
  { 11585, 31, 44, 37, 2, -32 },
  { 11756, 29, 44, 37, 4, -32 },
  { 11916, 29, 31, 37, 7, -31 },
  { 12029, 29, 33, 37, 3, -32 },
  { 12149, 28, 44, 37, 5, -43 },
  { 12303, 27, 32, 37, 5, -31 },
  { 12411, 29, 32, 37, 4, -32 },
  { 12527, 32, 33, 37, 3, -32 },
  { 12659, 35, 33, 37, 1, -32 },
  { 12804, 30, 44, 37, 2, -31 },
  { 12969, 31, 33, 37, 3, -32 },
  { 13097, 28, 54, 37, 7, -46 },
  { 13286, 12, 54, 37, 13, -46 },
  { 13367, 28, 54, 37, 3, -46 },
  { 13556, 32, 12, 37, 3, -25 },
};

const GFXfont IBMPlexMono_LightItalic61pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic61pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic61pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _IBMPLEXMONO_LIGHTITALIC61PT7B_H_
