#ifndef _IBMPLEXMONO_LIGHTITALIC60PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x07, 0xC0, 0x3C, 0x0E, 0x78, 0x1C, 0xE0, 0x79, 0xC0, 0xF3,
  0x81, 0xC7, 0x03, 0x9E, 0x07, 0x3C, 0x0E, 0x70, 0x1C, 0xE0, 0x79, 0xC0,
  0xE3, 0x81, 0xCF, 0x03, 0x9E, 0x07, 0x38, 0x0E, 0x70, 0x3C, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x1C, 0xFE,
  0x00, 0x7C, 0x0E, 0x0F, 0x80, 0x7C, 0x07, 0x03, 0xE0, 0x3C, 0x03, 0x80,
  0x78, 0x3C, 0x01, 0x80, 0x30, 0x1E, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x78, 0x06, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x01, 0xF0,
  0xE0, 0x00, 0x00, 0x7F, 0x60, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0x0F, 0x80, 0x00, 0x03, 0x03, 0xE0, 0x00, 0x01, 0x80, 0xF8, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x78, 0x30, 0x03, 0x80, 0x3C,
  0x3C, 0x01, 0xC0, 0x3C, 0x1F, 0x00, 0xC0, 0x1E, 0x07, 0xC0, 0x60, 0x1E,
  0x01, 0xF0, 0x30, 0x3E, 0x00, 0x7F, 0x38, 0x7E, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00, 0x7F, 0xF8, 0x00,
  0x0E, 0x00, 0xF8, 0x3C, 0x00, 0x1C, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x00, 0x38, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x38, 0x00, 0x03,
  0xC1, 0xF0, 0x70, 0x00, 0x01, 0xFF, 0xE0, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0x07, 0xFF, 0x80, 0x00, 0x0E, 0x0F, 0x83,
  0xC0, 0x00, 0x1C, 0x1E, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x00, 0x38, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x1F, 0x00, 0x70,
  0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x07, 0xFE,
  0xFC, 0x00, 0x01, 0xE1, 0xFE, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x1F, 0xC0, 0x00, 0x7C, 0x03, 0xB8,
  0x00, 0x1F, 0x80, 0xE7, 0x00, 0x03, 0x78, 0x1C, 0xF0, 0x00, 0xC7, 0x07,
  0x1E, 0x00, 0x18, 0xF1, 0xE1, 0xE0, 0x07, 0x0E, 0x38, 0x1F, 0x03, 0xC1,
  0xEF, 0x03, 0xFF, 0xF0, 0x1F, 0xC0, 0x1F, 0xFC, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3C, 0x00, 0x39, 0xCE, 0x77, 0xBD, 0xCE, 0x73, 0xBD, 0xEE, 0x73,
  0x9C, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x38, 0x01, 0xFF, 0x01, 0xE0, 0x7F, 0xFF, 0x87, 0x0F, 0xFC, 0x7F, 0xDD,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x38, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0xFD, 0xFF, 0xFF, 0xEF, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x01, 0xE0, 0x0F, 0x78, 0x0F, 0xC0,
  0x39, 0xC0, 0x3F, 0x00, 0xEF, 0x00, 0xFC, 0x07, 0xBC, 0x03, 0xE0, 0x1E,
  0xF0, 0x07, 0x80, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7D, 0xC0, 0x00, 0x1F, 0xBC, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x83, 0x80, 0x03, 0xF0, 0x38, 0x00, 0x7C,
  0x03, 0x80, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x78,
  0x00, 0x40, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x04, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x00,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x08, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x07, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xC0,
  0x01, 0xC0, 0x07, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x1E, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0xF0, 0x00,
  0x1C, 0x7F, 0xF8, 0x00, 0x3B, 0xFF, 0xFC, 0x00, 0xEF, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x78, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x80, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x3F,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x07, 0xF0,
  0x00, 0xE3, 0xFF, 0xE0, 0x1E, 0x7F, 0xFF, 0x01, 0xDF, 0x01, 0xF8, 0x3D,
  0x80, 0x07, 0xC3, 0xB0, 0x00, 0x3C, 0x7E, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x07,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0,
  0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x00,
  0x78, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x0F, 0x78,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x37, 0x9F, 0x00,
  0x0E, 0xE1, 0xF8, 0x07, 0xBC, 0x1F, 0xFF, 0xC7, 0x00, 0xFF, 0xF1, 0xE0,
  0x07, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC1,
  0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xC8, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x0F,
  0xC3, 0x8E, 0x00, 0xFF, 0x1C, 0x70, 0x0F, 0xFC, 0xE3, 0x80, 0xF0, 0x77,
  0x1C, 0x0F, 0x00, 0xF9, 0xC0, 0x70, 0x07, 0x8E, 0x07, 0x00, 0x1C, 0x70,
  0x38, 0x00, 0xE3, 0x81, 0xC0, 0x07, 0x3C, 0x1C, 0x00, 0x39, 0xE0, 0xE0,
  0x03, 0xCE, 0x07, 0x00, 0x1C, 0x70, 0x38, 0x00, 0xE3, 0x83, 0xC0, 0x07,
  0x1C, 0x1E, 0x00, 0x38, 0xE0, 0xE0, 0x01, 0xCF, 0x07, 0x00, 0x1E, 0x70,
  0x38, 0x00, 0xE3, 0x81, 0xC0, 0x0F, 0x1C, 0x0E, 0x00, 0x78, 0xE0, 0x78,
  0x05, 0xC7, 0x01, 0xC0, 0x6E, 0x38, 0x0F, 0x06, 0xF1, 0xC0, 0x3F, 0xF7,
  0x0E, 0x01, 0xFF, 0x38, 0x70, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x03, 0xC0,
  0x0F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3C, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xF0,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x7C, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xE0, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x01,
  0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x07, 0xC0,
  0x07, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x03, 0x80, 0x03, 0xE0,
  0x0E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x40, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFC, 0x70, 0x01, 0xFF, 0xF1, 0xC0,
  0x07, 0xFF, 0xC7, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3F, 0x03,
  0xC0, 0x01, 0xB8, 0x07, 0x80, 0x0C, 0xE0, 0x1F, 0x80, 0xF3, 0x80, 0x3F,
  0xFF, 0x8E, 0x00, 0x3F, 0xF8, 0x78, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x38, 0x00, 0x00, 0xF8, 0x07, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x07, 0x0F, 0xE0,
  0x00, 0x00, 0xE3, 0xFC, 0x00, 0x00, 0x3C, 0xF3, 0x80, 0x00, 0x07, 0xBC,
  0x78, 0x00, 0x00, 0xFF, 0x07, 0x00, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x03,
  0xF0, 0x0E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0xEE, 0x00, 0x0E, 0xE0, 0x3B, 0x80, 0x07, 0xB8, 0x0E, 0xE0, 0x01, 0xDE,
  0x07, 0xBC, 0x00, 0xE7, 0x01, 0xE7, 0x00, 0x39, 0xC0, 0x71, 0xC0, 0x1C,
  0x70, 0x1C, 0x70, 0x0F, 0x1C, 0x07, 0x1E, 0x03, 0x87, 0x01, 0xC3, 0x81,
  0xC3, 0xC0, 0xF0, 0xE0, 0x70, 0xE0, 0x3C, 0x38, 0x38, 0x38, 0x0E, 0x07,
  0x1E, 0x0E, 0x03, 0x81, 0xC7, 0x03, 0x80, 0xE0, 0x73, 0x80, 0xE0, 0x38,
  0x1C, 0xE0, 0x78, 0x1E, 0x03, 0xF0, 0x1C, 0x07, 0x80, 0xFC, 0x07, 0x01,
  0xC0, 0x3E, 0x01, 0xC0, 0x70, 0x0F, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x1C,
  0x07, 0x00, 0x60, 0x0F, 0x03, 0xC0, 0x18, 0x03, 0x80, 0xF0, 0x04, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x07, 0x03, 0xF0, 0x00,
  0x0F, 0x03, 0xF8, 0x00, 0x0F, 0x03, 0xB8, 0x00, 0x0E, 0x03, 0xB8, 0x00,
  0x0E, 0x03, 0xBC, 0x00, 0x0E, 0x07, 0x9C, 0x00, 0x0E, 0x07, 0x9C, 0x00,
  0x1E, 0x07, 0x1C, 0x00, 0x1E, 0x07, 0x1E, 0x00, 0x1C, 0x07, 0x0E, 0x00,
  0x1C, 0x07, 0x0E, 0x00, 0x1C, 0x0F, 0x0E, 0x00, 0x1C, 0x0F, 0x0F, 0x00,
  0x3C, 0x0E, 0x07, 0x00, 0x3C, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x07, 0x80,
  0x38, 0x0E, 0x03, 0x80, 0x38, 0x1E, 0x03, 0x80, 0x38, 0x1E, 0x03, 0x80,
  0x78, 0x1C, 0x03, 0xC0, 0x78, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x01, 0xC0,
  0x70, 0x1C, 0x01, 0xE0, 0x70, 0x3C, 0x01, 0xE0, 0x70, 0x3C, 0x00, 0xE0,
  0xF0, 0x38, 0x00, 0xE0, 0xF0, 0x38, 0x00, 0xF0, 0xE0, 0x38, 0x00, 0x70,
  0xE0, 0x38, 0x00, 0x70, 0xE0, 0x78, 0x00, 0x70, 0xE0, 0x78, 0x00, 0x79,
  0xE0, 0x70, 0x00, 0x39, 0xE0, 0x70, 0x00, 0x39, 0xC0, 0x70, 0x00, 0x3D,
  0xC0, 0x70, 0x00, 0x1D, 0xC0, 0xF0, 0x00, 0x1D, 0xC0, 0xF0, 0x00, 0x1F,
  0xC0, 0xE0, 0x00, 0x1F, 0xC0, 0xE0, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x3C, 0x70, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xC0,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF8, 0x0E, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x70,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x01, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0xF8, 0x0E, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x04, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x78, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x0F, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x03, 0xC0,
  0x1E, 0x0E, 0x00, 0xF8, 0x07, 0x03, 0x80, 0x7E, 0x01, 0xC0, 0xE0, 0x1F,
  0x80, 0x70, 0x38, 0x0E, 0xE0, 0x3C, 0x0E, 0x03, 0xB8, 0x0E, 0x07, 0x80,
  0xEE, 0x03, 0x81, 0xE0, 0x73, 0x80, 0xE0, 0x70, 0x1C, 0xE0, 0x78, 0x1C,
  0x0E, 0x38, 0x1C, 0x07, 0x03, 0x8E, 0x07, 0x01, 0xC1, 0xE3, 0x81, 0xC0,
  0x70, 0x70, 0x60, 0xF0, 0x1C, 0x1C, 0x18, 0x38, 0x07, 0x0E, 0x07, 0x0E,
  0x01, 0xC3, 0x81, 0xC3, 0x80, 0x71, 0xC0, 0x71, 0xE0, 0x1C, 0x70, 0x1C,
  0x70, 0x07, 0x1C, 0x07, 0x1C, 0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0x73, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C,
  0x01, 0xCE, 0x00, 0xEE, 0x00, 0x77, 0x80, 0x3B, 0x80, 0x0D, 0xC0, 0x0F,
  0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x03, 0xC8, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x21, 0xE1, 0xC3, 0xC3, 0x87, 0x07, 0x0E,
  0x0E, 0x1C, 0x10, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0x01, 0xFF,
  0xF8, 0xF0, 0x3F, 0x03, 0xCE, 0x07, 0xC0, 0x0E, 0xE0, 0xF0, 0x00, 0x6E,
  0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x1C, 0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x3F, 0x07, 0x80, 0x06, 0xF0, 0x7C, 0x00, 0xCE, 0x03, 0xF0, 0x38, 0xFF,
  0x1F, 0xFF, 0x0F, 0xF0, 0xFF, 0xE0, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x01, 0xFC, 0x00, 0x70, 0x7F, 0xF0,
  0x07, 0x1F, 0xFF, 0x80, 0x73, 0xC0, 0xFC, 0x0F, 0x70, 0x03, 0xE0, 0xF6,
  0x00, 0x1E, 0x0E, 0xC0, 0x00, 0xE0, 0xE8, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x07, 0x87, 0x40, 0x00, 0xF0, 0xF6, 0x00, 0x3E, 0x0F, 0x38,
  0x0F, 0xC0, 0xE1, 0xFF, 0xF8, 0x0E, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xC0, 0xFC, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x23, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x3C, 0x00,
  0x03, 0xC7, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x07,
  0xC0, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F,
  0xC0, 0x70, 0x03, 0xFF, 0xC1, 0xC0, 0x1F, 0xFF, 0x87, 0x00, 0xFC, 0x0F,
  0x3C, 0x07, 0xC0, 0x06, 0xF0, 0x3C, 0x00, 0x0B, 0x81, 0xE0, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x5C, 0x0F,
  0x00, 0x03, 0x70, 0x1E, 0x00, 0x1B, 0xC0, 0x7C, 0x00, 0xEF, 0x00, 0xFC,
  0x0F, 0x38, 0x01, 0xFF, 0xF8, 0xE0, 0x03, 0xFF, 0x83, 0x80, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xCF,
  0x00, 0x0F, 0xE3, 0x80, 0x7F, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0C, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x7C,
  0x07, 0xC0, 0x7E, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x06, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x70,
  0x07, 0xFF, 0xE1, 0xC0, 0x3F, 0x03, 0xCF, 0x01, 0xE0, 0x01, 0xBC, 0x0F,
  0x00, 0x02, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x37, 0x01, 0xE0, 0x01, 0x9C, 0x07, 0xC0, 0x0E,
  0xF0, 0x0F, 0xC0, 0xF3, 0xC0, 0x1F, 0xFF, 0x8E, 0x00, 0x3F, 0xF8, 0x38,
  0x00, 0x3F, 0x80, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x08, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x7C, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x1F,
  0xC0, 0x0F, 0x0F, 0xFE, 0x01, 0xC3, 0xFF, 0xE0, 0x38, 0xE0, 0x7C, 0x07,
  0x30, 0x03, 0xC0, 0xEC, 0x00, 0x78, 0x3D, 0x00, 0x07, 0x07, 0xC0, 0x00,
  0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x70,
  0x00, 0x0E, 0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x70, 0xF0, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0F, 0x0E,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x80, 0x1C, 0x00,
  0x60, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x1F, 0x00, 0x38,
  0x0F, 0x80, 0x0E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE3, 0xE0, 0x00,
  0x71, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x02,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x0F, 0x00, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x00, 0xF0,
  0x38, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x81,
  0xFC, 0x00, 0x1C, 0x1F, 0xFC, 0x00, 0x70, 0xFF, 0xF8, 0x01, 0xC7, 0x01,
  0xF0, 0x07, 0x38, 0x03, 0xC0, 0x3D, 0x80, 0x07, 0x80, 0xFC, 0x00, 0x1E,
  0x03, 0xA0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x1C, 0x01, 0xC0, 0x01, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x01,
  0xF8, 0x00, 0xF0, 0x3F, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0x80, 0xE0, 0x01,
  0x9E, 0x03, 0xC0, 0x0F, 0x78, 0x07, 0x00, 0x79, 0xC0, 0x1E, 0x03, 0xC7,
  0x00, 0x38, 0x1E, 0x1C, 0x00, 0xF0, 0xF0, 0x70, 0x01, 0xC7, 0x83, 0xC0,
  0x07, 0xBC, 0x0F, 0x00, 0x0F, 0xE0, 0x38, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x04, 0x03, 0x80, 0x06, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x3E, 0x07,
  0x00, 0x78, 0x07, 0x01, 0xF0, 0x07, 0x03, 0xE0, 0x0F, 0x07, 0x80, 0x0F,
  0x1F, 0x00, 0x0E, 0x3E, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x03, 0xCF, 0xF0,
  0xFF, 0x81, 0xCF, 0xF8, 0xFF, 0xC0, 0xEE, 0x1E, 0xE1, 0xF0, 0x74, 0x07,
  0x60, 0x78, 0x3E, 0x03, 0xE0, 0x1C, 0x1E, 0x01, 0xE0, 0x0E, 0x1E, 0x00,
  0xF0, 0x07, 0x0F, 0x00, 0x78, 0x03, 0x87, 0x00, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x01, 0xE1, 0xC0, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x00, 0x70, 0xF0,
  0x07, 0x00, 0x38, 0x70, 0x03, 0x80, 0x1C, 0x38, 0x01, 0xC0, 0x0E, 0x1C,
  0x00, 0xE0, 0x0F, 0x0E, 0x00, 0x70, 0x07, 0x07, 0x00, 0x78, 0x03, 0x87,
  0x80, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x00, 0x78, 0x70, 0x03, 0x80, 0x38, 0x38, 0x03, 0xC0, 0x1C,
  0x3C, 0x01, 0xC0, 0x0E, 0x1C, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x03,
  0x87, 0x00, 0x38, 0x03, 0xC3, 0x80, 0x1C, 0x01, 0xC1, 0xC0, 0x1E, 0x00,
  0xE1, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xFC, 0x00, 0xF0, 0xFF, 0xE0,
  0x1C, 0x3F, 0xFE, 0x03, 0x8E, 0x07, 0xC0, 0x73, 0x00, 0x3C, 0x0E, 0xC0,
  0x07, 0x83, 0xD0, 0x00, 0x70, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x1C, 0x3C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1C,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x3C, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0x01, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x01, 0xF8,
  0x0F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0x07, 0xFF, 0x00, 0x1C, 0x7F, 0xFE,
  0x00, 0x73, 0xC0, 0xFC, 0x03, 0xDC, 0x00, 0xF8, 0x0F, 0x60, 0x01, 0xE0,
  0x3B, 0x00, 0x03, 0x80, 0xE8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x40, 0x00, 0xF0, 0x3D, 0x80,
  0x0F, 0x80, 0xF3, 0x80, 0xFC, 0x03, 0x87, 0xFF, 0xE0, 0x0E, 0x0F, 0xFF,
  0x00, 0x38, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFF, 0x07, 0x01, 0xFF, 0xF8, 0x70, 0x3F, 0x03, 0xCF,
  0x07, 0xC0, 0x06, 0xF0, 0xF0, 0x00, 0x2E, 0x1E, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0x70, 0xF0, 0x00, 0x37, 0x07, 0x80, 0x06, 0xF0,
  0x7C, 0x00, 0xEF, 0x03, 0xF0, 0x3C, 0xE0, 0x1F, 0xFF, 0x8E, 0x00, 0xFF,
  0xE0, 0xE0, 0x03, 0xF8, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xBF, 0xFE, 0x7F, 0xFC, 0x00, 0xE7, 0xC0, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xF0, 0x0F, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x80, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE1, 0x00, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0x71, 0xF0, 0x00, 0x07, 0x87, 0xE0, 0x00, 0xF8, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x80, 0x1C, 0x00, 0x18, 0x01, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0xF8,
  0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0x81, 0xF0, 0x00, 0x38,
  0x3E, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x39, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x38, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C,
  0x38, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x0E, 0x00, 0x0B, 0xC1,
  0xE0, 0x03, 0x70, 0x3C, 0x00, 0xCE, 0x03, 0xE0, 0x71, 0xC0, 0x7F, 0xFC,
  0x38, 0x07, 0xFF, 0x0F, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x67,
  0xFE, 0x00, 0x1E, 0xFF, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0xF0, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00,
  0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xE0, 0x0E, 0x00, 0x7C, 0x00,
  0xE0, 0x1F, 0x80, 0x0E, 0x03, 0xF0, 0x00, 0xE1, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x08, 0x1C, 0x01, 0xE0, 0x78, 0x38, 0x03, 0x80, 0x70, 0x70, 0x07, 0x00,
  0xE0, 0xE0, 0x0E, 0x01, 0xE3, 0x80, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0x03,
  0x8E, 0x00, 0xF0, 0x07, 0x1C, 0x01, 0xC0, 0x0E, 0x38, 0x03, 0x80, 0x1C,
  0x70, 0x07, 0x00, 0x39, 0xC0, 0x0E, 0x00, 0x73, 0x80, 0x1C, 0x00, 0xE7,
  0x00, 0x78, 0x01, 0xCE, 0x00, 0xE0, 0x03, 0x9C, 0x01, 0xC0, 0x07, 0x38,
  0x03, 0x80, 0x1E, 0xE0, 0x07, 0x00, 0x39, 0xC0, 0x0E, 0x00, 0x73, 0x80,
  0x3C, 0x00, 0xE7, 0x00, 0x70, 0x03, 0xCE, 0x00, 0xE0, 0x07, 0x1C, 0x01,
  0xC0, 0x0E, 0x78, 0x07, 0x80, 0x3C, 0xE0, 0x0F, 0x00, 0x71, 0xC0, 0x1E,
  0x01, 0xE3, 0xC0, 0x7C, 0x03, 0x87, 0x81, 0x9C, 0x0F, 0x07, 0x87, 0x38,
  0x7C, 0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0x80, 0x7E,
  0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xCE, 0x0E, 0x1F, 0x07, 0xC3, 0x87, 0x03, 0xC7, 0xC0,
  0x73, 0x80, 0x73, 0xE0, 0x1C, 0xC0, 0x1C, 0xE0, 0x07, 0x30, 0x07, 0x00,
  0x01, 0xD8, 0x01, 0xC0, 0x00, 0x76, 0x00, 0x70, 0x00, 0x0D, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x2E, 0x00, 0x03, 0x80, 0x1B, 0x80, 0x00, 0xE0, 0x06, 0xE0, 0x02, 0x38,
  0x01, 0x38, 0x03, 0xCE, 0x00, 0xCE, 0x01, 0xF3, 0x80, 0x73, 0xC1, 0xF0,
  0xF0, 0x38, 0x70, 0xF8, 0x1E, 0x1C, 0x1C, 0xF8, 0x07, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x78, 0x0E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x7C,
  0x07, 0x80, 0x01, 0xF0, 0x0E, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x6F, 0x00,
  0xF8, 0x03, 0x38, 0x01, 0xF0, 0x3C, 0xE0, 0x07, 0xFF, 0xE3, 0x80, 0x07,
  0xFE, 0x0E, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x06, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x3E, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x70, 0x3F, 0xFF, 0x81, 0xC1, 0xE0, 0x3F, 0x8F, 0x0F, 0x00,
  0x1F, 0xBC, 0x38, 0x00, 0x1F, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x01, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0x83, 0xF0, 0x00, 0x0E,
  0x1F, 0xFE, 0x00, 0x38, 0x73, 0xFF, 0x80, 0xE3, 0xC0, 0xFF, 0xF1, 0xCF,
  0x00, 0x7F, 0xFE, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x07, 0xF8, 0x00, 0x1C, 0x1F, 0xF8,
  0x00, 0x70, 0x78, 0xF8, 0x00, 0xE1, 0xC0, 0xF0, 0x01, 0xC7, 0x80, 0xF0,
  0x07, 0x0E, 0x00, 0xF0, 0x1E, 0x38, 0x00, 0xF0, 0x78, 0x70, 0x01, 0xF1,
  0xE0, 0xE0, 0x01, 0xFF, 0x83, 0x80, 0x01, 0xFE, 0x03, 0x00, 0x00, 0xF8,
  0x00,
};

const GFXglyph IBMPlexMono_LightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 12, 42, 36, 12, -42 },
  { 64, 15, 16, 36, 14, -44 },
  { 94, 36, 42, 36, 1, -42 },
  { 283, 33, 56, 36, 2, -49 },
  { 514, 40, 44, 36, -1, -43 },
  { 734, 35, 44, 36, 0, -43 },
  { 927, 5, 16, 36, 19, -44 },
  { 937, 21, 54, 36, 13, -46 },
  { 1079, 21, 54, 36, 3, -46 },
  { 1221, 30, 30, 36, 4, -33 },
  { 1334, 29, 29, 36, 4, -33 },
  { 1440, 11, 16, 36, 9, -7 },
  { 1462, 17, 3, 36, 10, -20 },
  { 1469, 7, 6, 36, 12, -6 },
  { 1475, 33, 54, 36, 2, -46 },
  { 1698, 30, 44, 36, 4, -43 },
  { 1863, 28, 42, 36, 3, -42 },
  { 2010, 31, 43, 36, 2, -43 },
  { 2177, 30, 44, 36, 2, -43 },
  { 2342, 32, 42, 36, 1, -42 },
  { 2510, 31, 43, 36, 3, -42 },
  { 2677, 28, 43, 36, 4, -42 },
  { 2828, 29, 42, 36, 7, -42 },
  { 2981, 31, 44, 36, 3, -43 },
  { 3152, 27, 43, 36, 6, -43 },
  { 3298, 12, 31, 36, 12, -31 },
  { 3345, 15, 40, 36, 9, -31 },
  { 3420, 29, 33, 36, 5, -35 },
  { 3540, 31, 15, 36, 3, -26 },
  { 3599, 29, 33, 36, 3, -35 },
  { 3719, 25, 43, 36, 8, -43 },
  { 3854, 29, 50, 36, 4, -43 },
  { 4036, 31, 42, 36, 0, -42 },
  { 4199, 30, 42, 36, 3, -42 },
  { 4357, 29, 44, 36, 5, -43 },
  { 4517, 30, 42, 36, 4, -42 },
  { 4675, 32, 42, 36, 3, -42 },
  { 4843, 33, 42, 36, 3, -42 },
  { 5017, 30, 44, 36, 4, -43 },
  { 5182, 32, 42, 36, 3, -42 },
  { 5350, 32, 42, 36, 3, -42 },
  { 5518, 29, 43, 36, 4, -42 },
  { 5674, 35, 42, 36, 3, -42 },
  { 5858, 25, 42, 36, 5, -42 },
  { 5990, 34, 42, 36, 2, -42 },
  { 6169, 32, 42, 36, 3, -42 },
  { 6337, 30, 44, 36, 4, -43 },
  { 6502, 32, 42, 36, 3, -42 },
  { 6670, 30, 54, 36, 4, -43 },
  { 6873, 32, 42, 36, 3, -42 },
  { 7041, 33, 44, 36, 2, -43 },
  { 7223, 33, 42, 36, 6, -42 },
  { 7397, 30, 43, 36, 5, -42 },
  { 7559, 31, 42, 36, 7, -42 },
  { 7722, 34, 42, 36, 4, -42 },
  { 7901, 38, 42, 36, 0, -42 },
  { 8101, 33, 42, 36, 6, -42 },
  { 8275, 36, 42, 36, 0, -42 },
  { 8464, 25, 54, 36, 10, -46 },
  { 8633, 15, 54, 36, 11, -46 },
  { 8735, 25, 54, 36, 1, -46 },
  { 8904, 30, 24, 36, 4, -42 },
  { 8994, 29, 3, 36, 0, 6 },
  { 9005, 7, 11, 36, 14, -46 },
  { 9015, 28, 33, 36, 4, -32 },
  { 9131, 28, 45, 36, 4, -44 },
  { 9289, 26, 33, 36, 5, -32 },
  { 9397, 30, 45, 36, 4, -44 },
  { 9566, 26, 33, 36, 5, -32 },
  { 9674, 39, 57, 36, -1, -44 },
  { 9952, 30, 45, 36, 2, -32 },
  { 10121, 27, 44, 36, 4, -44 },
  { 10270, 26, 46, 36, 5, -45 },
  { 10420, 26, 58, 36, 5, -45 },
  { 10609, 30, 45, 36, 4, -44 },
  { 10778, 24, 45, 36, 7, -44 },
  { 10913, 33, 32, 36, 1, -32 },
  { 11045, 27, 32, 36, 4, -32 },
  { 11153, 28, 33, 36, 4, -32 },
  { 11269, 30, 44, 36, 2, -32 },
  { 11434, 28, 44, 36, 4, -32 },
  { 11588, 29, 31, 36, 7, -31 },
  { 11701, 29, 33, 36, 3, -32 },
  { 11821, 28, 43, 36, 5, -42 },
  { 11972, 27, 32, 36, 5, -31 },
  { 12080, 28, 31, 36, 4, -31 },
  { 12189, 31, 32, 36, 3, -31 },
  { 12313, 34, 33, 36, 1, -32 },
  { 12454, 30, 44, 36, 2, -31 },
  { 12619, 30, 33, 36, 3, -32 },
  { 12743, 27, 54, 36, 7, -46 },
  { 12926, 12, 54, 36, 13, -46 },
  { 13007, 27, 54, 36, 3, -46 },
  { 13190, 31, 12, 36, 3, -24 },
};

const GFXfont IBMPlexMono_LightItalic60pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic60pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic60pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _IBMPLEXMONO_LIGHTITALIC60PT7B_H_
