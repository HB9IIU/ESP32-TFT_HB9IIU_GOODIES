#ifndef _IBMPLEXMONO_LIGHTITALIC6PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x6F, 0xAC, 0x5F, 0x3E, 0x80, 0xF6, 0xEE, 0xEA, 0xCF,
  0x80, 0x6A, 0xB0, 0x55, 0x60, 0x5E, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x32, 0x44, 0x88, 0xF6, 0xF0, 0x69, 0x70, 0xE5, 0x70, 0xE5, 0xF0, 0x6E,
  0xB0, 0xF8, 0xF0, 0x7A, 0xF0, 0xEA, 0x40, 0xF7, 0xF0, 0xF6, 0xA0, 0xB0,
  0x69, 0x7C, 0x88, 0xE0, 0xDA, 0xFF, 0xE6, 0x2D, 0xD0, 0xF7, 0xF0, 0xF2,
  0x70, 0xF6, 0xF0, 0xF8, 0xEE, 0xF8, 0xE8, 0xF2, 0xF0, 0xBA, 0xEA, 0x74,
  0x4E, 0x64, 0xF0, 0xBC, 0xCA, 0xAB, 0x76, 0xEA, 0x7E, 0xEE, 0xF6, 0xF0,
  0xF7, 0x40, 0xF6, 0xD6, 0xF7, 0x50, 0xF1, 0xF0, 0xF2, 0x40, 0xBA, 0xAE,
  0xFA, 0x40, 0x9E, 0xEE, 0xB4, 0x4A, 0xFA, 0x40, 0x74, 0x4E, 0x72, 0x49,
  0x80, 0xAA, 0x90, 0x69, 0x25, 0x80, 0x3C, 0xE0, 0x80, 0xF7, 0x80, 0x9E,
  0xF0, 0xF3, 0x80, 0x3E, 0xF0, 0xFB, 0x80, 0x77, 0x44, 0xC0, 0xF6, 0xF0,
  0xDE, 0xD0, 0x2B, 0x0C, 0xAC, 0x9F, 0x70, 0xAB, 0xFF, 0x80, 0xF6, 0x80,
  0xF7, 0x80, 0xF6, 0xE0, 0xF6, 0xB0, 0xF2, 0x00, 0xEF, 0x80, 0x5D, 0x70,
  0xFC, 0xF7, 0x00, 0xFF, 0x80, 0xF4, 0xE0, 0xB6, 0xF0, 0xEB, 0x80, 0x6A,
  0xB0, 0xFC, 0x4D, 0x35, 0x80, 0xE0,
};

const GFXglyph IBMPlexMono_LightItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 2, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 2, 6, 4, 0, -5 },
  { 17, 3, 3, 4, 0, -3 },
  { 19, 3, 3, 4, 0, -3 },
  { 21, 1, 2, 4, 1, -1 },
  { 22, 2, 1, 4, 1, -2 },
  { 23, 1, 1, 4, 1, -1 },
  { 24, 4, 6, 4, 0, -5 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 1, -4 },
  { 43, 3, 4, 4, 0, -4 },
  { 45, 2, 4, 4, 1, -4 },
  { 46, 1, 3, 4, 1, -3 },
  { 47, 1, 4, 4, 1, -3 },
  { 48, 2, 4, 4, 1, -4 },
  { 49, 3, 2, 4, 0, -3 },
  { 50, 3, 4, 4, 0, -4 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 3, 5, 4, 0, -4 },
  { 55, 3, 4, 4, 0, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 4, 4, 4, 0, -4 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 4, 4, 4, 0, -4 },
  { 71, 4, 4, 4, 0, -4 },
  { 73, 3, 4, 4, 0, -4 },
  { 75, 4, 4, 4, 0, -4 },
  { 77, 2, 4, 4, 1, -4 },
  { 78, 4, 4, 4, 0, -4 },
  { 80, 4, 4, 4, 0, -4 },
  { 82, 3, 4, 4, 0, -4 },
  { 84, 3, 4, 4, 0, -4 },
  { 86, 3, 5, 4, 0, -4 },
  { 88, 3, 4, 4, 0, -4 },
  { 90, 3, 4, 4, 0, -4 },
  { 92, 3, 4, 4, 1, -4 },
  { 94, 4, 4, 4, 0, -4 },
  { 96, 3, 4, 4, 1, -4 },
  { 98, 4, 4, 4, 0, -4 },
  { 100, 4, 4, 4, 0, -4 },
  { 102, 3, 4, 4, 1, -4 },
  { 104, 4, 4, 4, 0, -4 },
  { 106, 3, 6, 4, 1, -5 },
  { 109, 2, 6, 4, 1, -5 },
  { 111, 3, 6, 4, 0, -5 },
  { 114, 3, 2, 4, 0, -4 },
  { 115, 3, 1, 4, 0, 0 },
  { 116, 1, 1, 4, 1, -5 },
  { 117, 3, 3, 4, 0, -3 },
  { 119, 3, 4, 4, 0, -4 },
  { 121, 3, 3, 4, 0, -3 },
  { 123, 3, 4, 4, 0, -4 },
  { 125, 3, 3, 4, 0, -3 },
  { 127, 4, 5, 4, 0, -4 },
  { 130, 3, 4, 4, 0, -3 },
  { 132, 3, 4, 4, 0, -4 },
  { 134, 2, 4, 4, 1, -4 },
  { 135, 3, 5, 4, 0, -4 },
  { 137, 3, 4, 4, 0, -4 },
  { 139, 2, 4, 4, 1, -4 },
  { 140, 3, 3, 4, 0, -3 },
  { 142, 3, 3, 4, 0, -3 },
  { 144, 3, 3, 4, 0, -3 },
  { 146, 3, 4, 4, 0, -3 },
  { 148, 3, 4, 4, 0, -3 },
  { 150, 3, 3, 4, 1, -3 },
  { 152, 3, 3, 4, 0, -3 },
  { 154, 3, 4, 4, 0, -4 },
  { 156, 2, 3, 4, 1, -3 },
  { 157, 3, 3, 4, 0, -3 },
  { 159, 3, 3, 4, 0, -3 },
  { 161, 4, 3, 4, 0, -3 },
  { 163, 3, 4, 4, 0, -3 },
  { 165, 3, 3, 4, 0, -3 },
  { 167, 2, 6, 4, 1, -5 },
  { 169, 1, 6, 4, 1, -5 },
  { 170, 3, 6, 4, 0, -5 },
  { 173, 3, 1, 4, 0, -2 },
};

const GFXfont IBMPlexMono_LightItalic6pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic6pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _IBMPLEXMONO_LIGHTITALIC6PT7B_H_
