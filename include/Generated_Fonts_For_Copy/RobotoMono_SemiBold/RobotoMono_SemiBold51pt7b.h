#ifndef _ROBOTOMONO_SEMIBOLD51PT7B_H_
#define _ROBOTOMONO_SEMIBOLD51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold51pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F,
  0x3E, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x7C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x83,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x03, 0xC1, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3C,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0xE3, 0xF8, 0x07,
  0xF1, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x3F, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07,
  0xF7, 0xFC, 0x0F, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x3E, 0x04, 0x03, 0xC1, 0xF0, 0x78,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x3C, 0x07, 0x83, 0xE3, 0xE0, 0x3E,
  0x1F, 0x1E, 0x01, 0xF0, 0xF9, 0xF0, 0x07, 0xFF, 0x8F, 0x00, 0x3F, 0xFC,
  0xF0, 0x00, 0xFF, 0xC7, 0x80, 0x01, 0xF8, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x07,
  0x8F, 0xFC, 0x00, 0x78, 0xFF, 0xF0, 0x03, 0xCF, 0xDF, 0x80, 0x3C, 0x7C,
  0x3C, 0x01, 0xE3, 0xC1, 0xF0, 0x1E, 0x1E, 0x0F, 0x80, 0xF0, 0xF0, 0x7C,
  0x0F, 0x07, 0x83, 0xE0, 0x18, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0x1F, 0xFF, 0xC1,
  0xF8, 0xFE, 0xFE, 0x0F, 0x8F, 0xE3, 0xF8, 0x7C, 0x7E, 0x0F, 0xE7, 0xE7,
  0xF0, 0x7F, 0xBF, 0x3F, 0x81, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0x8F, 0xE0,
  0x1F, 0xFC, 0x7F, 0x00, 0xFF, 0xC3, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0x9F, 0xC0, 0x3F, 0xF0, 0x7F, 0x80, 0x10, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x00, 0x00, 0x30, 0x03, 0xC0,
  0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xC0, 0x0C, 0x60, 0x03, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xC0, 0x06, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0x00, 0xF8, 0x00, 0xE0,
  0x38, 0x0E, 0x7C, 0x1C, 0x1F, 0x7F, 0xCE, 0x3F, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3C, 0x03,
  0xE0, 0x0E, 0x00, 0xE0, 0x02, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x7E, 0x7E, 0x7C, 0xF8, 0x78, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x3F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFD, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0x00, 0xFE, 0xFE, 0x00, 0xFD,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x7E, 0xFF, 0xF1, 0xF9, 0xFF, 0xE7, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0x9F, 0xC0, 0x7F, 0x3F, 0xC1, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x1F, 0x00, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0x3F, 0xC0, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFE, 0x07, 0xF8, 0xFE, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1,
  0xFF, 0xBF, 0xF0, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x01, 0xFC, 0xFF, 0x01, 0xFE,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xE7, 0xF0, 0x01, 0xF9,
  0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3E, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x0F,
  0xC1, 0xFC, 0x03, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xF0,
  0x3E, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xC0, 0x1F, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xC7, 0xFE, 0x1E, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x81,
  0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x3F,
  0x80, 0xFE, 0xFF, 0xE0, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC3, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00,
  0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE,
  0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFC,
  0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xEF, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x01, 0xFC,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x83, 0xFF,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0x7E,
  0x03, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xDF, 0xE7, 0xF8,
  0xFC, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xF9, 0xFE, 0xFF, 0xFF, 0xF7,
  0xF9, 0xFE, 0x3F, 0x02, 0x00, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF,
  0xF3, 0xFC, 0x7E, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x87,
  0xE1, 0xF0, 0xFC, 0x1E, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xC1,
  0xF0, 0x00, 0x1E, 0x1E, 0x0F, 0xF1, 0xE3, 0xC1, 0xFF, 0x8E, 0x3C, 0x3F,
  0xF8, 0xF3, 0x87, 0xE7, 0x8F, 0x78, 0x78, 0x78, 0xF7, 0x8F, 0x87, 0x8F,
  0x78, 0xF0, 0x78, 0x77, 0x0F, 0x07, 0x87, 0xF0, 0xF0, 0x78, 0x7F, 0x1E,
  0x07, 0x0F, 0xF1, 0xE0, 0x70, 0xFF, 0x1E, 0x07, 0x0F, 0xF1, 0xE0, 0x70,
  0xFF, 0x1E, 0x0F, 0x0E, 0xF1, 0xF0, 0xF0, 0xEF, 0x1F, 0x0F, 0x1E, 0xF0,
  0xFB, 0xF3, 0xC7, 0x8F, 0xFF, 0xFC, 0x78, 0x7F, 0x7F, 0x87, 0x83, 0xE3,
  0xF0, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x01, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC3, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xCF,
  0xE0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07,
  0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0xCF, 0xE0, 0x1F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x7F,
  0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x1F, 0xFB, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFC, 0x07, 0xF8,
  0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xE0, 0x00,
  0xFD, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xCF,
  0xC0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0xE3,
  0xF8, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xE7,
  0xF0, 0x1F, 0xF3, 0xF8, 0x3F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xF8, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0,
  0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF3,
  0xFC, 0x00, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFC, 0xFE,
  0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x1F,
  0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x3F,
  0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFD, 0xFE, 0x00, 0xFF, 0x8F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xCF,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x79, 0xF7, 0xFF, 0xBE, 0xFB, 0xFF,
  0xDF, 0x7D, 0xFF, 0xEF, 0xBC, 0xFF, 0xF3, 0xFE, 0x7F, 0xF9, 0xFF, 0x3F,
  0xFC, 0xFF, 0x1F, 0xFE, 0x3F, 0x8F, 0xFF, 0x1F, 0xC7, 0xFF, 0x8F, 0xC3,
  0xFF, 0xC7, 0xE1, 0xFF, 0xE1, 0xF0, 0xFF, 0xF0, 0xF8, 0x7F, 0xF8, 0x78,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFE, 0xF8, 0x3F,
  0xFE, 0xFC, 0x3F, 0xFE, 0x7C, 0x3F, 0xFE, 0x7E, 0x3F, 0xFE, 0x3E, 0x3F,
  0xFE, 0x3F, 0x3F, 0xFE, 0x1F, 0x3F, 0xFE, 0x1F, 0xBF, 0xFE, 0x0F, 0xBF,
  0xFE, 0x0F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFC,
  0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE7,
  0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xE0,
  0x0F, 0xFB, 0xF0, 0x03, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x01, 0xFF,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x7E,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x47,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0x00, 0xFF, 0x8F, 0xC0, 0x0F, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x03, 0xF8, 0xFC,
  0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF0,
  0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE3,
  0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x03,
  0xFB, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xCF, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x07,
  0xF1, 0xFE, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7E,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x0F,
  0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x03, 0xE0, 0x7F, 0xF8, 0x3F, 0x07,
  0xE7, 0xC1, 0xF8, 0x3F, 0x3F, 0x0F, 0xE1, 0xF9, 0xF8, 0x7F, 0x0F, 0xCF,
  0xC3, 0xF8, 0x7E, 0x7E, 0x1F, 0xC3, 0xF3, 0xF1, 0xFE, 0x1F, 0x9F, 0x8F,
  0xF0, 0xF8, 0xFC, 0x7F, 0xC7, 0xC3, 0xE3, 0xFE, 0x7E, 0x1F, 0x1F, 0xF3,
  0xF0, 0xFC, 0xFF, 0x9F, 0x87, 0xE7, 0xBC, 0xFC, 0x3F, 0x7D, 0xE7, 0xE1,
  0xFB, 0xEF, 0x3F, 0x0F, 0xDF, 0x7D, 0xF0, 0x3E, 0xF3, 0xEF, 0x81, 0xF7,
  0x9F, 0xFC, 0x0F, 0xBC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x1F,
  0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01,
  0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFF, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC1,
  0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F,
  0x80, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x80,
  0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x80,
  0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0x7F,
  0x9F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80,
  0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0xBF,
  0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0xEF, 0xFC, 0x7F, 0x01, 0xFE, 0x7E, 0x00, 0xFE,
  0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFF, 0x03, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7F, 0x07, 0xFC, 0x7F,
  0x00, 0x40, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x7F, 0xC0, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFD, 0xFF, 0xE0, 0xFC, 0x7F, 0xC0, 0x00, 0x04, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7F,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x3F,
  0x7F, 0x00, 0x7F, 0x3F, 0x80, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xFE, 0x7F,
  0x07, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x7F, 0xC1, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF,
  0x3F, 0x81, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF,
  0x07, 0xFF, 0x3F, 0x03, 0xFE, 0x3F, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE1, 0xFE, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x87,
  0xF8, 0x00, 0xC1, 0xFE, 0x01, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x10, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x3F, 0x07,
  0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xC1, 0xFF, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F,
  0xC0, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xBF, 0x03, 0xFE, 0x3F, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x7F, 0x08,
  0x00, 0x7F, 0x0C, 0x00, 0xFE, 0x1E, 0x01, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x38, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE1, 0xFE,
  0x0F, 0xCF, 0xFF, 0x1F, 0xBF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7F, 0x9D, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1,
  0xFF, 0xC1, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0xEF, 0xC0, 0x1F, 0xE7, 0xE0, 0x1F, 0xE3,
  0xF0, 0x1F, 0xE1, 0xF8, 0x1F, 0xE0, 0xFC, 0x1F, 0xE0, 0x7E, 0x1F, 0xE0,
  0x3F, 0x1F, 0xE0, 0x1F, 0x9F, 0xE0, 0x0F, 0xDF, 0xE0, 0x07, 0xEF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xE7, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xE0,
  0xFF, 0x03, 0xF0, 0x3F, 0xC1, 0xF8, 0x0F, 0xF0, 0xFC, 0x03, 0xF8, 0x7E,
  0x01, 0xFE, 0x3F, 0x00, 0x7F, 0x9F, 0x80, 0x1F, 0xEF, 0xC0, 0x0F, 0xF7,
  0xE0, 0x03, 0xFC, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0xFC, 0x7F, 0x3F, 0x7F, 0xBF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xE3,
  0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x1F, 0xFC, 0x3F, 0x07, 0xFF, 0x0F,
  0xC1, 0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0xFC, 0x1F, 0xFC, 0x3F, 0x07, 0xFF,
  0x0F, 0xC1, 0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0xFC, 0x1F, 0xFC, 0x3F, 0x07,
  0xFF, 0x0F, 0xC1, 0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0xFC, 0x1F, 0xFC, 0x3F,
  0x07, 0xFF, 0x0F, 0xC1, 0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0xFC, 0x1F, 0xFC,
  0x3F, 0x07, 0xFF, 0x0F, 0xC1, 0xFF, 0xC3, 0xF0, 0x7C, 0xFC, 0x3F, 0xE1,
  0xF9, 0xFF, 0xE3, 0xF7, 0xFF, 0xE7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFC, 0x0F, 0xF1, 0xFC, 0x03,
  0xFC, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xFC, 0x0F, 0xF0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0xFD, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x03,
  0xFC, 0xFE, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFF, 0x03,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFD, 0xFF,
  0xE0, 0xFC, 0x7F, 0xC0, 0xFC, 0x04, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x3F, 0x07, 0xFF, 0x3F, 0x1F, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x81, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0x7F, 0x03, 0xFE, 0x7F, 0x00, 0x20, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xBF, 0xBF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0x80, 0x5F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x3F, 0xE3, 0xFE, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x3F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x18, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x01, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0x80, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xE0, 0x7F,
  0xDF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0x7E, 0x3F, 0xFC, 0xFC,
  0x1F, 0xE1, 0xF8, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x0F, 0x01, 0xFF, 0xC0, 0xF8, 0x3F, 0xFC, 0x1F, 0x83,
  0xFF, 0xC1, 0xF8, 0x3F, 0x7C, 0x1F, 0x83, 0xF7, 0xC1, 0xF8, 0x3E, 0x7E,
  0x1F, 0xC3, 0xE7, 0xE1, 0xFC, 0x3E, 0x7E, 0x3F, 0xC7, 0xE3, 0xE3, 0xFC,
  0x7E, 0x3E, 0x3F, 0xC7, 0xE3, 0xE3, 0xDE, 0x7C, 0x3E, 0x39, 0xE7, 0xC3,
  0xF7, 0x9E, 0x7C, 0x3F, 0x79, 0xE7, 0xC1, 0xF7, 0x9E, 0x7C, 0x1F, 0x78,
  0xFF, 0x81, 0xF7, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0xCF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x01, 0xF8,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0B, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0x3F, 0xFE, 0x01, 0xF7, 0xFF, 0xF0, 0x3E, 0xFF, 0xFF,
  0x87, 0xEF, 0xC3, 0xFF, 0xFE, 0xF8, 0x0F, 0xFF, 0xCF, 0x00, 0x7F, 0xFC,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
};

const GFXglyph RobotoMono_SemiBold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 8, 36, 31, 11, -36 },
  { 37, 15, 13, 31, 7, -38 },
  { 62, 28, 36, 31, 1, -36 },
  { 188, 25, 47, 31, 3, -42 },
  { 335, 29, 38, 31, 1, -37 },
  { 473, 29, 38, 31, 2, -37 },
  { 611, 5, 13, 31, 12, -38 },
  { 620, 13, 51, 31, 9, -40 },
  { 703, 14, 51, 31, 8, -40 },
  { 793, 25, 25, 31, 4, -36 },
  { 872, 24, 26, 31, 3, -30 },
  { 950, 8, 16, 31, 9, -6 },
  { 966, 20, 6, 31, 7, -19 },
  { 981, 9, 9, 31, 11, -8 },
  { 992, 20, 39, 31, 6, -36 },
  { 1090, 23, 38, 31, 4, -37 },
  { 1200, 16, 36, 31, 4, -36 },
  { 1272, 25, 37, 31, 2, -37 },
  { 1388, 25, 38, 31, 2, -37 },
  { 1507, 26, 36, 31, 2, -36 },
  { 1624, 24, 37, 31, 3, -36 },
  { 1735, 24, 38, 31, 3, -37 },
  { 1849, 25, 36, 31, 2, -36 },
  { 1962, 24, 38, 31, 3, -37 },
  { 2076, 24, 37, 31, 3, -37 },
  { 2187, 10, 30, 31, 11, -29 },
  { 2225, 10, 39, 31, 11, -29 },
  { 2274, 22, 23, 31, 4, -27 },
  { 2338, 23, 16, 31, 4, -24 },
  { 2384, 22, 23, 31, 4, -27 },
  { 2448, 23, 37, 31, 4, -37 },
  { 2555, 28, 36, 31, 1, -36 },
  { 2681, 29, 36, 31, 1, -36 },
  { 2812, 26, 36, 31, 3, -36 },
  { 2929, 26, 38, 31, 2, -37 },
  { 3053, 25, 36, 31, 3, -36 },
  { 3166, 24, 36, 31, 4, -36 },
  { 3274, 24, 36, 31, 4, -36 },
  { 3382, 26, 38, 31, 2, -37 },
  { 3506, 24, 36, 31, 3, -36 },
  { 3614, 21, 36, 31, 5, -36 },
  { 3709, 24, 37, 31, 3, -36 },
  { 3820, 28, 36, 31, 3, -36 },
  { 3946, 24, 36, 31, 4, -36 },
  { 4054, 25, 36, 31, 3, -36 },
  { 4167, 24, 36, 31, 3, -36 },
  { 4275, 26, 38, 31, 2, -37 },
  { 4399, 25, 36, 31, 4, -36 },
  { 4512, 28, 43, 31, 2, -37 },
  { 4663, 26, 36, 31, 4, -36 },
  { 4780, 27, 37, 31, 2, -37 },
  { 4905, 29, 36, 31, 1, -36 },
  { 5036, 24, 37, 31, 3, -36 },
  { 5147, 29, 36, 31, 1, -36 },
  { 5278, 29, 36, 31, 1, -36 },
  { 5409, 29, 36, 31, 1, -36 },
  { 5540, 29, 36, 31, 1, -36 },
  { 5671, 26, 36, 31, 2, -36 },
  { 5788, 11, 50, 31, 10, -42 },
  { 5857, 20, 39, 31, 6, -36 },
  { 5955, 11, 50, 31, 10, -42 },
  { 6024, 21, 19, 31, 5, -36 },
  { 6074, 22, 5, 31, 4, 0 },
  { 6088, 12, 7, 31, 10, -37 },
  { 6099, 24, 28, 31, 3, -27 },
  { 6183, 24, 39, 31, 4, -38 },
  { 6300, 24, 28, 31, 3, -27 },
  { 6384, 24, 39, 31, 3, -38 },
  { 6501, 25, 28, 31, 3, -27 },
  { 6589, 26, 39, 31, 3, -39 },
  { 6716, 24, 38, 31, 3, -27 },
  { 6830, 23, 38, 31, 4, -38 },
  { 6940, 22, 37, 31, 5, -37 },
  { 7042, 17, 48, 31, 5, -37 },
  { 7144, 25, 38, 31, 4, -38 },
  { 7263, 23, 38, 31, 5, -38 },
  { 7373, 26, 27, 31, 2, -27 },
  { 7461, 23, 27, 31, 4, -27 },
  { 7539, 25, 28, 31, 3, -27 },
  { 7627, 24, 37, 31, 4, -27 },
  { 7738, 24, 37, 31, 3, -27 },
  { 7849, 21, 27, 31, 7, -27 },
  { 7920, 24, 28, 31, 3, -27 },
  { 8004, 24, 35, 31, 3, -34 },
  { 8109, 23, 28, 31, 4, -27 },
  { 8190, 27, 27, 31, 2, -27 },
  { 8282, 28, 27, 31, 1, -27 },
  { 8377, 27, 27, 31, 2, -27 },
  { 8469, 29, 38, 31, 1, -27 },
  { 8607, 25, 27, 31, 3, -27 },
  { 8692, 16, 49, 31, 8, -40 },
  { 8790, 5, 46, 31, 13, -36 },
  { 8819, 17, 49, 31, 8, -40 },
  { 8924, 28, 10, 31, 1, -20 },
};

const GFXfont RobotoMono_SemiBold51pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold51pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOMONO_SEMIBOLD51PT7B_H_
