#ifndef _ROBOTOMONO_SEMIBOLD23PT7B_H_
#define _ROBOTOMONO_SEMIBOLD23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x00, 0x06, 0xFE, 0xE7, 0x8F, 0x1E,
  0x3C, 0x78, 0xC0, 0x06, 0x60, 0x33, 0x01, 0x98, 0x08, 0xC7, 0xFF, 0xBF,
  0xFC, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0xC6, 0x3F, 0xFC, 0x33, 0x01, 0x98,
  0x0C, 0xC0, 0x46, 0x06, 0x30, 0x02, 0x00, 0x20, 0x06, 0x01, 0xFC, 0x3F,
  0xE7, 0x0E, 0x70, 0x77, 0x07, 0x78, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xE8, 0x0F, 0x60, 0x77, 0x07, 0x78, 0xE3, 0xFE, 0x1F, 0xC0, 0x60, 0x06,
  0x00, 0x10, 0x03, 0xE0, 0x1B, 0x81, 0x8C, 0xCC, 0x6C, 0x37, 0x61, 0xF6,
  0x02, 0x30, 0x03, 0x00, 0x18, 0x01, 0xBC, 0x0B, 0xF0, 0xD9, 0x8C, 0xCC,
  0x26, 0x60, 0x3F, 0x00, 0xF0, 0x06, 0x00, 0xF8, 0x0F, 0xE0, 0x63, 0x07,
  0x18, 0x18, 0xC0, 0xFC, 0x07, 0xC0, 0x1C, 0x03, 0xF1, 0x9F, 0xCD, 0xCE,
  0xEE, 0x3F, 0x70, 0xF3, 0xC7, 0x8F, 0xFE, 0x3F, 0x78, 0xFF, 0xF0, 0x0C,
  0x73, 0x8C, 0x71, 0x86, 0x38, 0xE3, 0x8C, 0x30, 0xC3, 0x8E, 0x38, 0x61,
  0x87, 0x0C, 0x18, 0x70, 0xC0, 0x83, 0x06, 0x1C, 0x30, 0xE1, 0x86, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x1C, 0x63, 0x08, 0x00, 0x0E,
  0x01, 0x80, 0x30, 0x62, 0x3F, 0xFE, 0x7F, 0x03, 0x80, 0xD8, 0x33, 0x8E,
  0x38, 0x86, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x77, 0x77, 0x76, 0xC0,
  0xFF, 0xFF, 0xC0, 0x6F, 0xFF, 0x03, 0x83, 0x81, 0x81, 0xC0, 0xE0, 0x60,
  0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0,
  0x00, 0x0C, 0x0F, 0xC7, 0xFB, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x9F, 0xEF,
  0xFE, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFE, 0x3F, 0x00, 0x06,
  0x7F, 0xFF, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x07, 0xF1, 0xFF, 0x70, 0xEE, 0x0F, 0xC1, 0xC0, 0x70, 0x0E,
  0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0xFF, 0xFF,
  0xE0, 0x0E, 0x07, 0xF1, 0xFF, 0x78, 0xFE, 0x0E, 0x01, 0xC0, 0x38, 0x1E,
  0x0F, 0x81, 0xF8, 0x03, 0x80, 0x70, 0x0F, 0xC1, 0xFC, 0x7B, 0xFE, 0x3F,
  0x80, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0D, 0xC1, 0xDC, 0x39, 0xC3,
  0x1C, 0x71, 0xCE, 0x1C, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x3F, 0xE7, 0xFC, 0xC0, 0x38, 0x07, 0x00, 0xEE, 0x1F, 0xF3, 0xFF,
  0x10, 0xE0, 0x1C, 0x03, 0xC0, 0x77, 0x0E, 0xE3, 0xCF, 0xF0, 0xFC, 0x0F,
  0x83, 0xF0, 0xF0, 0x3C, 0x07, 0x00, 0xCE, 0x3F, 0xF7, 0xDF, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0x77, 0x0E, 0xF3, 0xCF, 0xF0, 0xFC, 0xFF, 0xFF, 0xFC,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x06, 0x07, 0xF1, 0xFF, 0x38,
  0xF7, 0x0E, 0xE1, 0xDC, 0x39, 0xFE, 0x1F, 0x87, 0xF9, 0xC3, 0xF0, 0x7E,
  0x0F, 0xE1, 0xDC, 0x7B, 0xFE, 0x1F, 0x80, 0x06, 0x07, 0xF1, 0xFF, 0x38,
  0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x70, 0xEF, 0xFC, 0xFF, 0x86, 0x70,
  0x1C, 0x03, 0x81, 0xE0, 0xF8, 0x1C, 0x00, 0x6F, 0xF7, 0x00, 0x00, 0x06,
  0xFF, 0x70, 0x33, 0xBE, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0xE7, 0x39, 0x8C,
  0xC0, 0x00, 0xC1, 0xF1, 0xFF, 0xF8, 0xF0, 0x3C, 0x07, 0xE0, 0x7F, 0x07,
  0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3C, 0x0F, 0xE0, 0x7E, 0x03, 0xC1, 0xF1, 0xFB, 0xF8, 0xF0, 0x30,
  0x00, 0x0C, 0x1F, 0xE7, 0xFF, 0x87, 0xE1, 0xC0, 0x70, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0xE0, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x78, 0x0C, 0x00, 0x07,
  0xC0, 0xF7, 0x8E, 0x0C, 0x67, 0x36, 0x7D, 0xB6, 0x6D, 0x33, 0x29, 0x99,
  0x4C, 0xDA, 0x66, 0xD3, 0x74, 0xDF, 0xE6, 0x24, 0x18, 0x00, 0xFF, 0x01,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xC0, 0x3B, 0x00,
  0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x61, 0xC3, 0xFF, 0x0F, 0xFC, 0x38, 0x39,
  0xC0, 0xE7, 0x03, 0xBC, 0x0F, 0xFF, 0x9F, 0xFB, 0x87, 0x70, 0x7E, 0x0F,
  0xC3, 0xB9, 0xF7, 0xF8, 0xFF, 0xDC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC7,
  0xFF, 0xF7, 0xF8, 0x06, 0x01, 0xFC, 0x3F, 0xE7, 0x0E, 0xE0, 0x7E, 0x07,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x77, 0x0E,
  0x78, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0x0F, 0xFC, 0xE1, 0xCE, 0x0E, 0xE0,
  0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xE0,
  0xEE, 0x3C, 0xFF, 0x8F, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x3F, 0xE7, 0xFC, 0xFF, 0x9C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0xFE, 0xFF, 0xDC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x06, 0x01, 0xFC, 0x3F, 0xE7, 0x0E, 0x70, 0x6E, 0x01, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x3F, 0xE3, 0xFE, 0x07, 0xE0, 0x77, 0x07, 0x78, 0xF3,
  0xFE, 0x1F, 0xC0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x0F, 0xFF, 0xFF, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xF0, 0x7E, 0x0E, 0xE3, 0xDF, 0xF0, 0xFC, 0xE0, 0xFE, 0x1C, 0xE3, 0xCE,
  0x78, 0xE7, 0x0E, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xE7, 0x0E,
  0x38, 0xE3, 0xCE, 0x1C, 0xE0, 0xEE, 0x0F, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xFB, 0xFE, 0xF7,
  0xEF, 0x7E, 0xF7, 0xEE, 0x7E, 0x67, 0xE6, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0xCF, 0xD9, 0xFB,
  0x3F, 0x77, 0xE6, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F,
  0x07, 0x06, 0x03, 0xF8, 0x7F, 0xC7, 0x0E, 0xE0, 0xEE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0E, 0x79, 0xE3,
  0xFC, 0x1F, 0x80, 0xFF, 0x9F, 0xFB, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0xFE, 0xFF, 0x9F, 0xE3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x06, 0x00, 0xFC, 0x0F, 0xF0, 0xE1, 0xCE, 0x0E, 0x70, 0x3B, 0x81,
  0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x38, 0x71,
  0xE7, 0x87, 0xF8, 0x1F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x40, 0xFF, 0x9F,
  0xFB, 0x87, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x77, 0xFE, 0xFF, 0x9F, 0xE3,
  0x9E, 0x71, 0xCE, 0x3D, 0xC3, 0xB8, 0x7F, 0x07, 0x06, 0x03, 0xFC, 0x7F,
  0xE7, 0x0F, 0x60, 0x77, 0x00, 0x70, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x01,
  0xE0, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0xF3, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xB0, 0x77, 0x0E, 0xF3, 0xCF, 0xF0, 0xFC, 0xF0, 0x3B,
  0x81, 0xDC, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0x63, 0x83, 0x9C, 0x1C,
  0xE0, 0xEE, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0xE3, 0x1D, 0x8C, 0x66, 0x73, 0x9D, 0xEE, 0x77, 0xB9, 0xDE, 0xE7, 0x7B,
  0x9D, 0xEC, 0x3D, 0xB0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3,
  0xC3, 0xCE, 0x06, 0x18, 0x70, 0x38, 0xE1, 0xC3, 0x87, 0x07, 0x38, 0x1C,
  0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0xFC, 0x07,
  0x38, 0x3C, 0xF0, 0xE1, 0xC7, 0x87, 0xBC, 0x0F, 0xF0, 0x3D, 0xC0, 0xE3,
  0x87, 0x0E, 0x1C, 0x1C, 0xE0, 0x73, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xF0,
  0xE0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x03,
  0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x80, 0xFF, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xFF, 0xE0, 0x0C,
  0x07, 0x81, 0xE0, 0xFC, 0x33, 0x0C, 0xE7, 0x1B, 0x87, 0xFF, 0xFF, 0xF0,
  0xE3, 0x8C, 0x30, 0x3F, 0x8F, 0xF9, 0xC7, 0x80, 0x70, 0x0E, 0x7F, 0xDE,
  0x3B, 0x07, 0xE0, 0xEE, 0x3D, 0xFF, 0x9F, 0x70, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3F, 0xCF, 0xFB, 0x8F, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xE1,
  0xF8, 0x7F, 0x3F, 0xFE, 0xDF, 0x00, 0x1F, 0x87, 0xF9, 0xC3, 0xB8, 0x7E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0xEF, 0x3C, 0xFF, 0x0F, 0xC0, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x7F, 0xDF, 0xFB, 0x8F, 0x70, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0xE1, 0xDE, 0x79, 0xFF, 0x1E, 0xE0, 0x1F,
  0x83, 0xFC, 0x78, 0xE7, 0x06, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x70,
  0x47, 0x8E, 0x3F, 0xE1, 0xFC, 0x01, 0xE0, 0x7F, 0x0F, 0xF0, 0xE0, 0x0E,
  0x00, 0xE0, 0xFF, 0xEF, 0xFE, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1F, 0xE7, 0xFD, 0xC3,
  0xB8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x70, 0xEF, 0x3C, 0xFF, 0x8F,
  0xF0, 0x0E, 0x41, 0xDF, 0xF1, 0xFE, 0x0F, 0x00, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3B, 0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE3, 0xFF, 0xFF, 0xC0, 0x06, 0x0F, 0x07, 0x00, 0x00, 0x7F, 0x7F, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x7E,
  0x7E, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC3, 0xB8, 0xE7,
  0x38, 0xEE, 0x1F, 0x83, 0xF0, 0x7F, 0x0E, 0x71, 0xCF, 0x38, 0xE7, 0x0E,
  0xE1, 0xE0, 0xFE, 0x1F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0xFF,
  0xFF, 0xE0, 0xDF, 0xEF, 0xFF, 0xEE, 0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6,
  0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xDF, 0xB7, 0xFE, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x1F,
  0x83, 0xFC, 0x71, 0xE7, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x06, 0x70,
  0xE7, 0x1E, 0x3F, 0xC1, 0xF8, 0xDF, 0x3F, 0xEE, 0x3F, 0x87, 0xE1, 0xF8,
  0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0xFF, 0xFB, 0xFC, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x00, 0x3F, 0xEF, 0xFD, 0xC3, 0xB8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0x70, 0xEF, 0x3C, 0xFF, 0x8F, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0xEF, 0xFF, 0xFF, 0xFE, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x00, 0x1F, 0xC7, 0xFD, 0xC3, 0xB8, 0x77, 0x80,
  0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x6E, 0x1D, 0xFF, 0x8F, 0xC0, 0x1C, 0x03,
  0x80, 0x70, 0x7F, 0xFF, 0xFE, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0xE2, 0x1F, 0xC1, 0xF8, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xF7, 0xFD, 0xF3, 0xE0, 0x76,
  0x0E, 0x70, 0xE7, 0x0E, 0x31, 0xC3, 0x9C, 0x39, 0x81, 0xB8, 0x1F, 0x80,
  0xF0, 0x0F, 0x00, 0xE0, 0xE3, 0x1B, 0x19, 0xD9, 0xCE, 0xEF, 0x77, 0x7B,
  0x3A, 0xD8, 0xD6, 0xC7, 0x96, 0x3C, 0xF1, 0xE7, 0x0E, 0x38, 0x31, 0xC0,
  0xF0, 0xF7, 0x8E, 0x39, 0xC1, 0xFC, 0x1F, 0x80, 0xF0, 0x0F, 0x01, 0xF8,
  0x3D, 0xC3, 0x9C, 0x70, 0xEF, 0x07, 0xE0, 0x7F, 0x03, 0x9C, 0x38, 0xE1,
  0xC3, 0x8E, 0x1C, 0xE0, 0x67, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x03, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x00, 0x7F, 0xE7,
  0xFE, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0x07, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x38, 0xF0, 0xF0, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0E,
  0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0xC1, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x38, 0x70, 0x78, 0xF3, 0x87, 0x0C, 0x18, 0x30, 0x61,
  0xC3, 0x8E, 0x18, 0x00, 0x3C, 0x13, 0xF0, 0xD9, 0xFF, 0x87, 0xE0, 0x0E,
  0x00,
};

const GFXglyph RobotoMono_SemiBold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 16, 14, 5, -16 },
  { 9, 7, 6, 14, 3, -17 },
  { 15, 13, 16, 14, 0, -16 },
  { 41, 12, 21, 14, 1, -19 },
  { 73, 13, 17, 14, 0, -17 },
  { 101, 13, 17, 14, 1, -17 },
  { 129, 2, 6, 14, 5, -17 },
  { 131, 6, 23, 14, 4, -18 },
  { 149, 6, 23, 14, 4, -18 },
  { 167, 11, 11, 14, 2, -16 },
  { 183, 11, 12, 14, 1, -14 },
  { 200, 4, 7, 14, 4, -3 },
  { 204, 9, 2, 14, 3, -8 },
  { 207, 4, 4, 14, 5, -4 },
  { 209, 9, 17, 14, 3, -16 },
  { 229, 10, 17, 14, 2, -17 },
  { 251, 7, 16, 14, 2, -16 },
  { 265, 11, 17, 14, 1, -17 },
  { 289, 11, 17, 14, 1, -17 },
  { 313, 12, 16, 14, 1, -16 },
  { 337, 11, 16, 14, 1, -16 },
  { 359, 11, 16, 14, 1, -16 },
  { 381, 11, 16, 14, 1, -16 },
  { 403, 11, 17, 14, 1, -17 },
  { 427, 11, 17, 14, 1, -17 },
  { 451, 4, 13, 14, 5, -13 },
  { 458, 5, 17, 14, 5, -13 },
  { 469, 10, 10, 14, 2, -12 },
  { 482, 10, 8, 14, 2, -11 },
  { 492, 10, 10, 14, 2, -12 },
  { 505, 10, 17, 14, 2, -17 },
  { 527, 13, 16, 14, 0, -16 },
  { 553, 14, 16, 14, 0, -16 },
  { 581, 11, 16, 14, 2, -16 },
  { 603, 12, 17, 14, 1, -17 },
  { 629, 12, 16, 14, 1, -16 },
  { 653, 11, 16, 14, 2, -16 },
  { 675, 11, 16, 14, 2, -16 },
  { 697, 12, 17, 14, 1, -17 },
  { 723, 11, 16, 14, 1, -16 },
  { 745, 10, 16, 14, 2, -16 },
  { 765, 11, 16, 14, 1, -16 },
  { 787, 12, 16, 14, 2, -16 },
  { 811, 10, 16, 14, 2, -16 },
  { 831, 12, 16, 14, 1, -16 },
  { 855, 11, 16, 14, 1, -16 },
  { 877, 12, 17, 14, 1, -17 },
  { 903, 11, 16, 14, 2, -16 },
  { 925, 13, 20, 14, 1, -17 },
  { 958, 11, 16, 14, 2, -16 },
  { 980, 12, 17, 14, 1, -17 },
  { 1006, 13, 16, 14, 0, -16 },
  { 1032, 11, 16, 14, 1, -16 },
  { 1054, 13, 16, 14, 0, -16 },
  { 1080, 14, 16, 14, 0, -16 },
  { 1108, 14, 16, 14, 0, -16 },
  { 1136, 14, 16, 14, 0, -16 },
  { 1164, 12, 16, 14, 1, -16 },
  { 1188, 4, 23, 14, 5, -19 },
  { 1200, 9, 17, 14, 3, -16 },
  { 1220, 5, 23, 14, 4, -19 },
  { 1235, 10, 8, 14, 2, -16 },
  { 1245, 10, 2, 14, 2, 0 },
  { 1248, 5, 4, 14, 5, -17 },
  { 1251, 11, 12, 14, 1, -12 },
  { 1268, 10, 17, 14, 2, -17 },
  { 1290, 11, 12, 14, 1, -12 },
  { 1307, 11, 17, 14, 1, -17 },
  { 1331, 12, 12, 14, 1, -12 },
  { 1349, 12, 18, 14, 1, -18 },
  { 1376, 11, 17, 14, 1, -12 },
  { 1400, 10, 17, 14, 2, -17 },
  { 1422, 10, 17, 14, 2, -17 },
  { 1444, 8, 22, 14, 2, -17 },
  { 1466, 11, 17, 14, 2, -17 },
  { 1490, 11, 17, 14, 2, -17 },
  { 1514, 12, 12, 14, 1, -12 },
  { 1532, 10, 12, 14, 2, -12 },
  { 1547, 12, 12, 14, 1, -12 },
  { 1565, 10, 17, 14, 2, -12 },
  { 1587, 11, 17, 14, 1, -12 },
  { 1611, 9, 12, 14, 3, -12 },
  { 1625, 11, 12, 14, 1, -12 },
  { 1642, 11, 15, 14, 1, -15 },
  { 1663, 10, 12, 14, 2, -12 },
  { 1678, 12, 12, 14, 1, -12 },
  { 1696, 13, 12, 14, 0, -12 },
  { 1716, 12, 12, 14, 1, -12 },
  { 1734, 13, 17, 14, 1, -12 },
  { 1762, 12, 12, 14, 1, -12 },
  { 1780, 8, 22, 14, 3, -18 },
  { 1802, 2, 21, 14, 6, -16 },
  { 1808, 7, 22, 14, 4, -18 },
  { 1828, 13, 5, 14, 0, -9 },
};

const GFXfont RobotoMono_SemiBold23pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold23pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOMONO_SEMIBOLD23PT7B_H_
