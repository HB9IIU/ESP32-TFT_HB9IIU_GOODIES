#ifndef _ROBOTOMONO_SEMIBOLD54PT7B_H_
#define _ROBOTOMONO_SEMIBOLD54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold54pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7E, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF0,
  0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x78, 0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC1, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0xFF,
  0x9F, 0xE0, 0x1F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xF9, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xE0,
  0xF8, 0x10, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF8, 0x3E,
  0x1F, 0x03, 0xE0, 0xF8, 0x78, 0x0F, 0x83, 0xE3, 0xE0, 0x3E, 0x0F, 0x8F,
  0x00, 0xFC, 0x7C, 0x78, 0x01, 0xFF, 0xF1, 0xE0, 0x03, 0xFF, 0x8F, 0x00,
  0x07, 0xFC, 0x7C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x87, 0xF8, 0x00, 0x1E,
  0x3F, 0xF0, 0x00, 0xF1, 0xFF, 0xE0, 0x07, 0xCF, 0xFF, 0xC0, 0x1E, 0x3E,
  0x1F, 0x00, 0xF8, 0xF0, 0x7C, 0x03, 0xC3, 0xC0, 0xF0, 0x1F, 0x0F, 0x03,
  0xC0, 0x78, 0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x01, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFE, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x07, 0xE1, 0xFF, 0xFC, 0x1F,
  0x8F, 0xE7, 0xF0, 0x7E, 0x7F, 0x9F, 0xE1, 0xF9, 0xFC, 0x3F, 0xC7, 0xEF,
  0xE0, 0x7F, 0xBF, 0xBF, 0x80, 0xFE, 0xFC, 0xFE, 0x03, 0xFF, 0xF3, 0xF8,
  0x07, 0xFF, 0x8F, 0xE0, 0x0F, 0xFE, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x00,
  0x7F, 0xC1, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x9F, 0xE0, 0x3F, 0xF8, 0x3F,
  0xC0, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xE0, 0x00, 0x08, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xC0, 0x03, 0x80, 0x02, 0x00, 0x40,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0,
  0x07, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x80, 0xF8, 0x04, 0x7C, 0x1E,
  0x07, 0xCF, 0xE3, 0xC3, 0xF9, 0xFF, 0xB9, 0xFF, 0x7F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF0, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0x04, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1,
  0xFE, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x3F,
  0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x87, 0xEF, 0xFF, 0xCF, 0xE7, 0xFF, 0xEF, 0xE3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF7,
  0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0xFE,
  0x1F, 0xE0, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x1F, 0x00, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x1F, 0xF0,
  0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFE, 0x03, 0xFD,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0xE0, 0xFF,
  0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE, 0x00,
  0x3F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC0,
  0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xCF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0xF0, 0x7C, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03,
  0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xC0,
  0x07, 0xE3, 0xFF, 0x01, 0xF9, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xBF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x7F, 0x8F, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFF,
  0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x1F,
  0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xF0, 0x3F,
  0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF1, 0xFF, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xFC,
  0x1F, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xBF, 0x81, 0xFF, 0x9F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1C, 0x0F,
  0xC7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0xFC, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xE3,
  0xF0, 0x20, 0x06, 0x07, 0xF0, 0xFF, 0x3F, 0xE7, 0xFE, 0xFF, 0x9F, 0xF1,
  0xFE, 0x3F, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xC0, 0x30, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF9, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x3C, 0x1F, 0x03, 0xF0, 0x78, 0x78, 0x3F, 0xF1, 0xE3,
  0xE1, 0xFF, 0xC7, 0x8F, 0x0F, 0xFF, 0x0E, 0x3C, 0x3E, 0x3C, 0x3D, 0xE1,
  0xF0, 0xF0, 0xF7, 0x87, 0x83, 0xC3, 0xDE, 0x1E, 0x0F, 0x0F, 0x78, 0xF8,
  0x3C, 0x3F, 0xE3, 0xC0, 0xF0, 0xFF, 0x0F, 0x03, 0xC3, 0xFC, 0x3C, 0x0F,
  0x0F, 0xF0, 0xF0, 0x3C, 0x3B, 0xC3, 0xC0, 0xE0, 0xEF, 0x0F, 0x07, 0x87,
  0xBC, 0x3C, 0x1E, 0x1E, 0xF8, 0xF8, 0x78, 0x71, 0xE3, 0xE3, 0xE3, 0xC7,
  0x87, 0xFF, 0xFE, 0x1E, 0x1F, 0xFF, 0xF8, 0x7C, 0x3F, 0x9F, 0xC0, 0xF0,
  0x78, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x60, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFC, 0x07, 0xFF, 0x3F, 0x80, 0x1F,
  0xE7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1,
  0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x03,
  0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC,
  0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFC,
  0x0F, 0xFC, 0x3F, 0x80, 0x7F, 0xC7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x7F,
  0x9F, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00,
  0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0x3F,
  0x80, 0x3F, 0xC7, 0xF0, 0x0F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F, 0x80,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xF7, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0,
  0x0F, 0xF1, 0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x20, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFE, 0x7F,
  0xC1, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xFE, 0x00,
  0x1F, 0xF7, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xF8, 0x7F, 0x00, 0xFF, 0x83, 0xF8, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0x83,
  0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0,
  0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0x80, 0x1F, 0xF1, 0xFE,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF8,
  0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x01,
  0xFE, 0x3F, 0x80, 0x0F, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF,
  0x7F, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xBF, 0xFE, 0xFB, 0xEF, 0xFF, 0xBE, 0xFB,
  0xFF, 0xEF, 0xFC, 0xFF, 0xFB, 0xFF, 0x3F, 0xFE, 0x7F, 0xCF, 0xFF, 0x9F,
  0xF3, 0xFF, 0xE7, 0xF8, 0xFF, 0xF8, 0xFE, 0x3F, 0xFE, 0x3F, 0x8F, 0xFF,
  0x8F, 0xC3, 0xFF, 0xE3, 0xF0, 0xFF, 0xF8, 0x7C, 0x3F, 0xFE, 0x1E, 0x0F,
  0xFF, 0x87, 0x83, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xBF, 0x07, 0xFF, 0xEF, 0xC1, 0xFF, 0xF9, 0xF0, 0x7F, 0xFE,
  0x7E, 0x1F, 0xFF, 0x8F, 0x87, 0xFF, 0xE3, 0xF1, 0xFF, 0xF8, 0xFC, 0x7F,
  0xFE, 0x1F, 0x9F, 0xFF, 0x87, 0xE7, 0xFF, 0xE0, 0xFD, 0xFF, 0xF8, 0x3F,
  0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xE3,
  0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1,
  0xFC, 0x03, 0xFF, 0x3F, 0x80, 0x1F, 0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00,
  0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x1F, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F,
  0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x01,
  0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x8F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF1, 0xFC, 0x07, 0xFF, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x01, 0xFE,
  0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF7,
  0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x7F, 0xE3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F,
  0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xEF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x3F,
  0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0xFE,
  0x01, 0xFE, 0x3F, 0xE1, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x07, 0xC0, 0xFF, 0xFC, 0x1F, 0x81, 0xFB, 0xF8, 0x3F, 0x03, 0xF7,
  0xF0, 0x7E, 0x07, 0xE7, 0xE0, 0xFE, 0x0F, 0xCF, 0xC1, 0xFC, 0x1F, 0x9F,
  0x83, 0xF8, 0x3F, 0x3F, 0x0F, 0xF0, 0xFE, 0x7E, 0x1F, 0xE1, 0xF8, 0xFC,
  0x3F, 0xC3, 0xF1, 0xFC, 0x7F, 0x87, 0xE1, 0xF8, 0xFF, 0x8F, 0xC3, 0xF1,
  0xFF, 0x1F, 0x87, 0xE3, 0xFE, 0x3F, 0x0F, 0xCF, 0xFC, 0x7E, 0x1F, 0x9F,
  0xF9, 0xFC, 0x3F, 0x3E, 0xF3, 0xF0, 0x7E, 0x7D, 0xF7, 0xE0, 0xFC, 0xFB,
  0xEF, 0xC0, 0xFD, 0xE7, 0xDF, 0x81, 0xFB, 0xCF, 0xBF, 0x03, 0xFF, 0x9F,
  0x7E, 0x07, 0xFF, 0x1E, 0xFC, 0x0F, 0xFE, 0x3D, 0xF0, 0x1F, 0xFC, 0x7F,
  0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xC3, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8,
  0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80,
  0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x03, 0xF8,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F,
  0xC0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0,
  0x0F, 0xDF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xF0, 0x3F, 0x0F, 0x81, 0xF0,
  0x7C, 0x1F, 0x83, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7E, 0x7E, 0x03, 0xF3,
  0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFE,
  0x7F, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x7F, 0xC0, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xE0, 0x03, 0xFB,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xF0, 0x07,
  0xF9, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFE, 0xFE, 0x07, 0xFE, 0x1F, 0xC0, 0x08, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE1, 0xFC, 0x07, 0xF3, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xE0, 0x3F, 0xDF,
  0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0xC0,
  0x3F, 0xDF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xF7,
  0xFF, 0xF1, 0xF9, 0xFF, 0xF0, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFC, 0x07, 0xF8, 0xFE,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0x9F, 0xE0, 0x07, 0xE3,
  0xF8, 0x03, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xE3, 0xF8, 0x1F, 0xFD, 0xFC, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xF0,
  0x3F, 0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xE0, 0x1F, 0xE7, 0xFC, 0x3F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0x7E, 0x0F, 0xFF, 0x3F, 0x01, 0xFF, 0x1F, 0x80, 0x18,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9,
  0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x04, 0x0F, 0xF0, 0x03, 0xC1, 0xFF, 0x81, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xF0, 0x08, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0xFF, 0xE7,
  0xF0, 0x7F, 0xFD, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFC, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x1F, 0xDF, 0xE0, 0x0F, 0xF3, 0xF8, 0x03, 0xFC, 0xFF, 0x83, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0x7F, 0x01, 0xFF, 0x1F, 0xC0, 0x04, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x20,
  0x00, 0xFE, 0x0C, 0x00, 0x3F, 0x87, 0x80, 0x1F, 0xE1, 0xFC, 0x3F, 0xF0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x07, 0xF1, 0xFF, 0xC3,
  0xFB, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xE0, 0x3F, 0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF9,
  0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFB, 0xFF, 0xF9,
  0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x03, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFD, 0xFC, 0x01, 0xFF, 0x3F, 0x80,
  0x7F, 0xC7, 0xF0, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x03,
  0xF8, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0xFF,
  0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xBF, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xF1, 0xFC, 0x01, 0xFF, 0x3F, 0x80, 0x1F, 0xE7, 0xF0,
  0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x1F,
  0x8F, 0xCF, 0xF3, 0xFC, 0xFD, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x87, 0xFF, 0xC1, 0xF8,
  0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF,
  0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F,
  0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F,
  0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83,
  0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC,
  0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xE0, 0x7E, 0x1F, 0xFC, 0x3F, 0x3F, 0xFF,
  0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFE, 0x03,
  0xFD, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x1F, 0xE0, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0x7E, 0x7F, 0xF8, 0x3F, 0x7F,
  0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFE,
  0x07, 0xFD, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFB, 0xFC, 0x03, 0xFD, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xDF, 0xFE, 0x0F, 0xE7, 0xFE, 0x07, 0xF0,
  0x10, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x1F,
  0x81, 0xFF, 0xCF, 0xC3, 0xFF, 0xF7, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xF7,
  0xF0, 0x01, 0xFB, 0xF8, 0x01, 0xFD, 0xFE, 0x01, 0xFE, 0x7F, 0xC1, 0xFF,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFB,
  0xF0, 0x1F, 0xF1, 0xF8, 0x01, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFC, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xF0, 0x3F, 0xE3, 0xF8, 0x03, 0xFC, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFE, 0x00,
  0xFF, 0x3F, 0xFB, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x60, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x03, 0xFD, 0xFC, 0x03, 0xFE, 0xFF, 0x03, 0xFF, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xEF, 0xE1, 0xFF, 0xE7, 0xF0, 0x7F, 0xC3,
  0xF8, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x80,
  0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xE0,
  0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x07,
  0x80, 0xFF, 0xF0, 0x1E, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0,
  0x3F, 0x7E, 0x0F, 0xC1, 0xF9, 0xF8, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0x1F,
  0x9F, 0x87, 0xF8, 0x7E, 0x7E, 0x1F, 0xE1, 0xF9, 0xF8, 0x7F, 0x87, 0xE3,
  0xE1, 0xFE, 0x1F, 0x0F, 0xC7, 0xF8, 0x7C, 0x3F, 0x3D, 0xF3, 0xF0, 0xFC,
  0xF3, 0xCF, 0xC3, 0xF3, 0xCF, 0x3F, 0x07, 0xCF, 0x3C, 0xF8, 0x1F, 0x3C,
  0xF3, 0xE0, 0x7D, 0xE3, 0xEF, 0x81, 0xFF, 0x87, 0xBE, 0x07, 0xFE, 0x1F,
  0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x03, 0xFC,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC,
  0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xCF, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0xFC, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x1E, 0x7F, 0xFE, 0x01, 0xF7,
  0xFF, 0xF8, 0x0F, 0xBF, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0xF8, 0x07, 0xFF, 0xF7, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph RobotoMono_SemiBold54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 8, 38, 32, 12, -38 },
  { 39, 16, 14, 32, 8, -41 },
  { 67, 30, 38, 32, 1, -38 },
  { 210, 26, 51, 32, 4, -45 },
  { 376, 30, 40, 32, 1, -39 },
  { 526, 30, 40, 32, 2, -39 },
  { 676, 6, 14, 32, 12, -41 },
  { 687, 15, 55, 32, 9, -43 },
  { 791, 15, 55, 32, 8, -43 },
  { 895, 27, 26, 32, 4, -38 },
  { 983, 26, 28, 32, 3, -32 },
  { 1074, 9, 16, 32, 9, -6 },
  { 1092, 22, 6, 32, 7, -20 },
  { 1109, 9, 10, 32, 12, -9 },
  { 1121, 21, 41, 32, 6, -38 },
  { 1229, 25, 40, 32, 4, -39 },
  { 1354, 16, 38, 32, 5, -38 },
  { 1430, 27, 39, 32, 2, -39 },
  { 1562, 25, 40, 32, 3, -39 },
  { 1687, 28, 38, 32, 2, -38 },
  { 1820, 26, 39, 32, 3, -38 },
  { 1947, 26, 40, 32, 3, -39 },
  { 2077, 27, 38, 32, 2, -38 },
  { 2206, 26, 40, 32, 3, -39 },
  { 2336, 25, 39, 32, 3, -39 },
  { 2458, 10, 32, 32, 12, -31 },
  { 2498, 11, 41, 32, 12, -31 },
  { 2555, 23, 25, 32, 4, -29 },
  { 2627, 25, 17, 32, 4, -25 },
  { 2681, 24, 25, 32, 4, -29 },
  { 2756, 25, 39, 32, 4, -39 },
  { 2878, 30, 38, 32, 1, -38 },
  { 3021, 31, 38, 32, 1, -38 },
  { 3169, 27, 38, 32, 4, -38 },
  { 3298, 28, 40, 32, 2, -39 },
  { 3438, 27, 38, 32, 3, -38 },
  { 3567, 25, 38, 32, 4, -38 },
  { 3686, 26, 38, 32, 4, -38 },
  { 3810, 28, 40, 32, 2, -39 },
  { 3950, 26, 38, 32, 3, -38 },
  { 4074, 22, 38, 32, 5, -38 },
  { 4179, 26, 39, 32, 3, -38 },
  { 4306, 29, 38, 32, 4, -38 },
  { 4444, 25, 38, 32, 4, -38 },
  { 4563, 26, 38, 32, 3, -38 },
  { 4687, 26, 38, 32, 3, -38 },
  { 4811, 28, 40, 32, 2, -39 },
  { 4951, 27, 38, 32, 4, -38 },
  { 5080, 30, 46, 32, 2, -39 },
  { 5253, 27, 38, 32, 4, -38 },
  { 5382, 29, 40, 32, 2, -39 },
  { 5527, 30, 38, 32, 1, -38 },
  { 5670, 26, 39, 32, 3, -38 },
  { 5797, 30, 38, 32, 1, -38 },
  { 5940, 31, 38, 32, 1, -38 },
  { 6088, 31, 38, 32, 1, -38 },
  { 6236, 31, 38, 32, 1, -38 },
  { 6384, 28, 38, 32, 2, -38 },
  { 6517, 11, 53, 32, 11, -44 },
  { 6590, 21, 41, 32, 6, -38 },
  { 6698, 11, 53, 32, 11, -44 },
  { 6771, 21, 20, 32, 6, -38 },
  { 6824, 24, 5, 32, 4, 0 },
  { 6839, 12, 7, 32, 11, -39 },
  { 6850, 26, 30, 32, 3, -29 },
  { 6948, 25, 42, 32, 4, -41 },
  { 7080, 26, 30, 32, 3, -29 },
  { 7178, 25, 42, 32, 3, -41 },
  { 7310, 27, 30, 32, 3, -29 },
  { 7412, 27, 42, 32, 3, -42 },
  { 7554, 26, 40, 32, 3, -29 },
  { 7684, 25, 41, 32, 4, -41 },
  { 7813, 23, 40, 32, 6, -40 },
  { 7928, 17, 52, 32, 6, -40 },
  { 8039, 27, 41, 32, 4, -41 },
  { 8178, 24, 41, 32, 5, -41 },
  { 8301, 28, 29, 32, 2, -29 },
  { 8403, 25, 29, 32, 4, -29 },
  { 8494, 27, 30, 32, 3, -29 },
  { 8596, 25, 40, 32, 4, -29 },
  { 8721, 25, 40, 32, 3, -29 },
  { 8846, 21, 29, 32, 8, -29 },
  { 8923, 26, 30, 32, 3, -29 },
  { 9021, 26, 36, 32, 3, -35 },
  { 9138, 25, 30, 32, 4, -29 },
  { 9232, 28, 29, 32, 2, -29 },
  { 9334, 30, 29, 32, 1, -29 },
  { 9443, 29, 29, 32, 2, -29 },
  { 9549, 31, 41, 32, 1, -29 },
  { 9708, 27, 29, 32, 3, -29 },
  { 9806, 18, 52, 32, 8, -42 },
  { 9923, 5, 49, 32, 14, -38 },
  { 9954, 17, 52, 32, 9, -42 },
  { 10065, 29, 12, 32, 1, -22 },
};

const GFXfont RobotoMono_SemiBold54pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold54pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOMONO_SEMIBOLD54PT7B_H_
