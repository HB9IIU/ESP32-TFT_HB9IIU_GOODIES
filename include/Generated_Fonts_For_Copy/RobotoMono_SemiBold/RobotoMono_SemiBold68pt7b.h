#ifndef _ROBOTOMONO_SEMIBOLD68PT7B_H_
#define _ROBOTOMONO_SEMIBOLD68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold68pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x7F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xF8,
  0xFE, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF8, 0x03, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x04, 0x00, 0x7E, 0x03,
  0xF0, 0x1E, 0x00, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0xFC,
  0x00, 0x3F, 0x87, 0xE1, 0xF0, 0x00, 0x7F, 0xFF, 0xC7, 0xE0, 0x00, 0x7F,
  0xFF, 0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x7C,
  0x00, 0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x00, 0x7E,
  0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x7F, 0xF8, 0x00, 0x03, 0xF1, 0xFF, 0xF8,
  0x00, 0x07, 0xC7, 0xFF, 0xF8, 0x00, 0x1F, 0x8F, 0xFF, 0xF8, 0x00, 0x3E,
  0x3F, 0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x0F,
  0xC0, 0x07, 0xC1, 0xF8, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0x3E,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x00, 0x30, 0x1F, 0x80,
  0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x20, 0x7F, 0xFF, 0x00, 0x7F,
  0x07, 0xFF, 0xFE, 0x01, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xF0, 0xFF, 0x9F,
  0xF8, 0x1F, 0xC7, 0xFE, 0x3F, 0xE0, 0x7F, 0x1F, 0xF0, 0xFF, 0xC3, 0xFC,
  0xFF, 0x81, 0xFF, 0x8F, 0xF3, 0xFE, 0x03, 0xFF, 0x3F, 0x8F, 0xF0, 0x07,
  0xFD, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF, 0xF8, 0xFF, 0x00, 0x3F, 0xFF, 0xC3,
  0xFC, 0x00, 0x7F, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xE0, 0x01,
  0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07,
  0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFB, 0xFF, 0x00,
  0xFF, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0xFD, 0xF8, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x01, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x20, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0xFC, 0x00,
  0xC3, 0xE0, 0x3F, 0x00, 0xF1, 0xFE, 0x0F, 0x81, 0xFC, 0x7F, 0xE1, 0xE1,
  0xFF, 0x9F, 0xFF, 0x79, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x40,
  0x01, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0x1E, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0x07, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0x60, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF9, 0xFF,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF, 0xFE, 0x3F, 0xC3,
  0xFF, 0xFD, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x87,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0,
  0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x3F, 0xE7, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF8,
  0x03, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC1,
  0xF0, 0x00, 0x3F, 0xCF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xC0, 0x0F, 0xFE, 0x01, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80,
  0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0,
  0x07, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x8F,
  0xFF, 0x80, 0xFF, 0x9F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8,
  0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xF0, 0x07, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE,
  0x7F, 0xF0, 0x1F, 0xFE, 0x3F, 0xFE, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFD, 0xFE,
  0x01, 0xFF, 0xF1, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xF7, 0xFE, 0x3F, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFE, 0x3F, 0xC0, 0x60,
  0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x7F, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF,
  0xFF, 0x3F, 0xF9, 0xFF, 0x87, 0xF8, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x0F, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFC, 0x0F,
  0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x7C,
  0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0xF8, 0x3E, 0x1F, 0x81, 0xFF, 0xF0,
  0xF8, 0x7C, 0x0F, 0xFF, 0xC3, 0xE1, 0xF0, 0x3F, 0xFF, 0x07, 0x8F, 0xC1,
  0xFC, 0x7C, 0x1E, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0xF8, 0x3F, 0x07, 0xC1,
  0xF7, 0xE1, 0xF8, 0x1F, 0x07, 0xDF, 0x07, 0xE0, 0x7C, 0x1F, 0x7C, 0x1F,
  0x01, 0xF0, 0x7D, 0xF0, 0x7C, 0x07, 0xC1, 0xF7, 0xC3, 0xF0, 0x1F, 0x07,
  0xDF, 0x0F, 0xC0, 0x7C, 0x1F, 0x7C, 0x3E, 0x01, 0xF0, 0x79, 0xF0, 0xF8,
  0x07, 0x81, 0xE7, 0xC3, 0xE0, 0x3E, 0x07, 0x9F, 0x0F, 0x80, 0xF8, 0x3E,
  0x7C, 0x3F, 0x03, 0xE0, 0xF9, 0xF0, 0xFC, 0x0F, 0x83, 0xC7, 0xC3, 0xF0,
  0x3E, 0x0F, 0x1F, 0x0F, 0xC1, 0xF8, 0x7C, 0x7C, 0x1F, 0xCF, 0xE3, 0xE1,
  0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xE1, 0xFF, 0xFF, 0xFC, 0x0F, 0x83, 0xFF,
  0x7F, 0xE0, 0x3F, 0x07, 0xF8, 0xFF, 0x00, 0xFC, 0x03, 0x80, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x80, 0x00, 0x7F, 0xC0, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFC,
  0x00, 0x3F, 0xFC, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0xBF, 0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x7F, 0xE3, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0xE3,
  0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xC0, 0x00, 0x3F,
  0xEF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x7F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xE0,
  0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC, 0xFF,
  0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xE0, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xE3, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0x80,
  0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFC,
  0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03,
  0xFD, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0x1F, 0xF8,
  0x00, 0x3F, 0xC7, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x7F,
  0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFC,
  0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0x00, 0x07,
  0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF0,
  0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x01, 0xFF,
  0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x7F, 0xE0, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x00,
  0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xF0,
  0x00, 0x0F, 0xF7, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFB, 0xFF,
  0x00, 0x0F, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xF0,
  0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x00,
  0xFF, 0xCF, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFB, 0xF1, 0xFF,
  0xFF, 0xFD, 0xF8, 0xFD, 0xFF, 0xFE, 0xFC, 0xFE, 0xFF, 0xFF, 0x7F, 0x7F,
  0x7F, 0xFF, 0x9F, 0xBF, 0x3F, 0xFF, 0xCF, 0xDF, 0x9F, 0xFF, 0xE7, 0xFF,
  0xCF, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0xF1, 0xFF, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0x87,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xFC, 0x0F, 0x81, 0xFF, 0xFE,
  0x07, 0xC0, 0xFF, 0xFF, 0x03, 0xE0, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xBF, 0x81, 0xFF, 0xFF, 0xBF, 0x81,
  0xFF, 0xFF, 0x9F, 0xC1, 0xFF, 0xFF, 0x9F, 0xC1, 0xFF, 0xFF, 0x8F, 0xE1,
  0xFF, 0xFF, 0x8F, 0xE1, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0x87, 0xF1,
  0xFF, 0xFF, 0x87, 0xF9, 0xFF, 0xFF, 0x83, 0xF9, 0xFF, 0xFF, 0x83, 0xFD,
  0xFF, 0xFF, 0x81, 0xFD, 0xFF, 0xFF, 0x81, 0xFD, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xE0,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x01,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xE3, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xFC,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0x8F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x80,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0x00,
  0x03, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0xBF, 0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xC0, 0x03, 0xFF, 0x8F, 0xF0, 0x0F,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xF0, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F,
  0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xC3, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0,
  0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0xBF,
  0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F,
  0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF,
  0x9F, 0xE0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xF0,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xE7,
  0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x07,
  0xFE, 0x3F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFE, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xFD, 0xFE,
  0x03, 0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xE0,
  0x3F, 0xCF, 0xF0, 0x3F, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0xC0, 0xFF, 0x3F,
  0xC0, 0xFF, 0x81, 0xFE, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x7F, 0x03, 0xFE,
  0x07, 0xF8, 0xFE, 0x07, 0xFC, 0x0F, 0xE1, 0xFE, 0x1F, 0xF8, 0x1F, 0xC3,
  0xFC, 0x3F, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0xE1, 0xFE, 0x1F, 0xE1, 0xFF, 0xC3, 0xFC, 0x3F, 0xC3, 0xFF, 0x87, 0xF8,
  0x3F, 0x87, 0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0xBF, 0x1F, 0xC0, 0xFE, 0x3F,
  0x7E, 0x3F, 0x81, 0xFE, 0x7E, 0xFC, 0xFF, 0x03, 0xFC, 0xFD, 0xF9, 0xFE,
  0x07, 0xF9, 0xFB, 0xF3, 0xFC, 0x0F, 0xF3, 0xF7, 0xE7, 0xF8, 0x0F, 0xEF,
  0xC7, 0xEF, 0xF0, 0x1F, 0xDF, 0x8F, 0xDF, 0xC0, 0x3F, 0xBF, 0x1F, 0xBF,
  0x80, 0x7F, 0x7E, 0x3F, 0x7F, 0x00, 0xFF, 0xFC, 0x7E, 0xFE, 0x01, 0xFF,
  0xF8, 0xFF, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFC, 0x00,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01,
  0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xBF,
  0x80, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF1, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x7F, 0xE0,
  0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0x03, 0xFE, 0x7F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFE, 0x7F, 0xF0, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFD, 0xFF, 0x07, 0xFF,
  0xF1, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x00, 0xFF, 0x8F,
  0xFE, 0x00, 0xFF, 0x9F, 0xFF, 0x80, 0xFF, 0xBF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80,
  0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0,
  0x07, 0xFC, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x7F,
  0xFF, 0xE0, 0xFF, 0x1F, 0xFF, 0x80, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x3F, 0xFC, 0x3F, 0xF8,
  0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0xC0,
  0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0,
  0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x01, 0xFF, 0x00, 0x7F,
  0xE1, 0xFF, 0x01, 0xFF, 0xF9, 0xFF, 0x07, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFF, 0x3F, 0xF0, 0x0F, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0,
  0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x80,
  0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0,
  0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x7F, 0xFC, 0x1F,
  0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x02, 0x0F, 0xFC, 0x00, 0x03, 0x03, 0xFF, 0x00,
  0x03, 0xC1, 0xFF, 0xE0, 0x07, 0xF0, 0x7F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0x01, 0xFF, 0xFC,
  0xFF, 0x03, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x3F, 0xF8, 0x07,
  0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x3F, 0xF8, 0x07,
  0xFF, 0x1F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFD,
  0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0x00, 0x07, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x04, 0x00, 0x03, 0xFE, 0x06, 0x00, 0x03,
  0xFE, 0x0F, 0x80, 0x07, 0xFE, 0x1F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x38,
  0x00, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07,
  0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFF,
  0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x0F,
  0xFE, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x0F, 0xF9,
  0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF7, 0xFE, 0x00, 0x3F, 0xF8, 0xFF,
  0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0xE3, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x03, 0xFF,
  0x3F, 0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x02, 0x00,
  0x30, 0x1F, 0xC7, 0xF8, 0x3F, 0xC3, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0x7F,
  0xFB, 0xFF, 0xCF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0x83, 0xFC,
  0x0F, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0x83, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0x83, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7F, 0x81, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0xF0,
  0x7F, 0x81, 0xFE, 0x00, 0x00, 0x70, 0x01, 0xFE, 0x07, 0xFF, 0x03, 0xFC,
  0x3F, 0xFF, 0x87, 0xF8, 0xFF, 0xFF, 0x8F, 0xF3, 0xFF, 0xFF, 0x9F, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xF8,
  0x3F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xE7, 0xFE,
  0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0x1F, 0xFF, 0x80, 0xFF, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xF8,
  0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFE,
  0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFE,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFC,
  0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xF8, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xBF, 0xFF, 0x80, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0x80, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0xFF,
  0x01, 0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x7F, 0xFF,
  0x3F, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x3F, 0xF0, 0x07, 0xFF, 0x3F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xF9, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0x00, 0x07, 0x81, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3C, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFD, 0xFE, 0xFF, 0xFF,
  0xBF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0x80, 0x1B, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xE0,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xEF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x0F,
  0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x3F, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFD, 0xFE, 0x1F, 0xFF,
  0xF3, 0xFC, 0x1F, 0xFF, 0xC7, 0xF8, 0x0F, 0xFE, 0x0F, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xF0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xDF, 0xC0, 0x3F, 0x80, 0xFF, 0x7F,
  0x01, 0xFE, 0x03, 0xF9, 0xFE, 0x07, 0xF8, 0x0F, 0xE7, 0xF8, 0x1F, 0xE0,
  0x3F, 0x9F, 0xE0, 0x7F, 0xC1, 0xFE, 0x3F, 0x81, 0xFF, 0x07, 0xF8, 0xFE,
  0x0F, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xC1,
  0xFC, 0x3F, 0xC3, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xFE, 0x1F, 0xC1, 0xFC,
  0x7E, 0xF8, 0x7F, 0x07, 0xF1, 0xF3, 0xE3, 0xF8, 0x1F, 0xC7, 0xCF, 0x8F,
  0xE0, 0x7F, 0x1F, 0x3E, 0x3F, 0x81, 0xFC, 0x7C, 0xFC, 0xFE, 0x03, 0xFB,
  0xF1, 0xF3, 0xF8, 0x0F, 0xEF, 0x87, 0xCF, 0xE0, 0x3F, 0xBE, 0x1F, 0x3F,
  0x00, 0xFE, 0xF8, 0x7D, 0xFC, 0x03, 0xFB, 0xE1, 0xFF, 0xF0, 0x07, 0xEF,
  0x83, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x08, 0x07, 0xFF, 0xF0, 0x00, 0x7E, 0x3F, 0xFF, 0xE0, 0x03,
  0xF3, 0xFF, 0xFF, 0x80, 0x1F, 0xBF, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0xFF,
  0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0xFF, 0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0xF7,
  0xE0, 0x07, 0xFF, 0xFF, 0x3F, 0x00, 0x0F, 0xFF, 0xF9, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
};

const GFXglyph RobotoMono_SemiBold68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 10, 48, 41, 15, -48 },
  { 61, 20, 17, 41, 10, -51 },
  { 104, 38, 48, 41, 1, -48 },
  { 332, 34, 63, 41, 4, -56 },
  { 600, 39, 50, 41, 1, -49 },
  { 844, 38, 50, 41, 3, -49 },
  { 1082, 7, 18, 41, 15, -51 },
  { 1098, 18, 69, 41, 12, -54 },
  { 1254, 18, 69, 41, 11, -54 },
  { 1410, 34, 33, 41, 5, -48 },
  { 1551, 34, 35, 41, 3, -40 },
  { 1700, 11, 21, 41, 12, -8 },
  { 1729, 27, 7, 41, 9, -25 },
  { 1753, 12, 12, 41, 15, -11 },
  { 1771, 26, 52, 41, 8, -48 },
  { 1940, 31, 50, 41, 5, -49 },
  { 2134, 21, 48, 41, 6, -48 },
  { 2260, 34, 49, 41, 2, -49 },
  { 2469, 33, 50, 41, 3, -49 },
  { 2676, 35, 48, 41, 2, -48 },
  { 2886, 32, 49, 41, 4, -48 },
  { 3082, 32, 50, 41, 4, -49 },
  { 3282, 33, 48, 41, 3, -48 },
  { 3480, 32, 50, 41, 4, -49 },
  { 3680, 32, 49, 41, 4, -49 },
  { 3876, 12, 40, 41, 15, -39 },
  { 3936, 13, 52, 41, 15, -39 },
  { 4021, 29, 32, 41, 5, -37 },
  { 4137, 31, 21, 41, 5, -31 },
  { 4219, 30, 32, 41, 5, -37 },
  { 4339, 30, 49, 41, 6, -49 },
  { 4523, 38, 48, 41, 1, -48 },
  { 4751, 39, 48, 41, 1, -48 },
  { 4985, 34, 48, 41, 5, -48 },
  { 5189, 35, 50, 41, 3, -49 },
  { 5408, 34, 48, 41, 4, -48 },
  { 5612, 32, 48, 41, 5, -48 },
  { 5804, 32, 48, 41, 5, -48 },
  { 5996, 34, 50, 41, 3, -49 },
  { 6209, 32, 48, 41, 4, -48 },
  { 6401, 29, 48, 41, 6, -48 },
  { 6575, 32, 49, 41, 4, -48 },
  { 6771, 36, 48, 41, 5, -48 },
  { 6987, 32, 48, 41, 5, -48 },
  { 7179, 33, 48, 41, 4, -48 },
  { 7377, 32, 48, 41, 4, -48 },
  { 7569, 35, 50, 41, 3, -49 },
  { 7788, 34, 48, 41, 5, -48 },
  { 7992, 37, 57, 41, 3, -49 },
  { 8256, 34, 48, 41, 5, -48 },
  { 8460, 35, 50, 41, 3, -49 },
  { 8679, 39, 48, 41, 1, -48 },
  { 8913, 32, 49, 41, 4, -48 },
  { 9109, 38, 48, 41, 1, -48 },
  { 9337, 39, 48, 41, 1, -48 },
  { 9571, 39, 48, 41, 1, -48 },
  { 9805, 39, 48, 41, 1, -48 },
  { 10039, 35, 48, 41, 3, -48 },
  { 10249, 15, 67, 41, 13, -56 },
  { 10375, 26, 52, 41, 8, -48 },
  { 10544, 15, 67, 41, 13, -56 },
  { 10670, 28, 25, 41, 7, -48 },
  { 10758, 30, 7, 41, 5, 0 },
  { 10785, 15, 9, 41, 14, -49 },
  { 10802, 32, 38, 41, 4, -37 },
  { 10954, 32, 52, 41, 5, -51 },
  { 11162, 32, 38, 41, 4, -37 },
  { 11314, 32, 52, 41, 4, -51 },
  { 11522, 33, 38, 41, 4, -37 },
  { 11679, 34, 53, 41, 4, -53 },
  { 11905, 32, 51, 41, 4, -37 },
  { 12109, 32, 51, 41, 5, -51 },
  { 12313, 30, 50, 41, 7, -50 },
  { 12501, 22, 65, 41, 7, -50 },
  { 12680, 34, 51, 41, 5, -51 },
  { 12897, 30, 51, 41, 7, -51 },
  { 13089, 35, 37, 41, 3, -37 },
  { 13251, 31, 37, 41, 5, -37 },
  { 13395, 33, 38, 41, 4, -37 },
  { 13552, 32, 51, 41, 5, -37 },
  { 13756, 32, 51, 41, 4, -37 },
  { 13960, 27, 37, 41, 10, -37 },
  { 14085, 33, 38, 41, 4, -37 },
  { 14242, 32, 46, 41, 4, -45 },
  { 14426, 31, 37, 41, 5, -36 },
  { 14570, 35, 36, 41, 3, -36 },
  { 14728, 38, 36, 41, 1, -36 },
  { 14899, 36, 36, 41, 3, -36 },
  { 15061, 38, 51, 41, 2, -36 },
  { 15304, 33, 36, 41, 4, -36 },
  { 15453, 23, 65, 41, 10, -53 },
  { 15640, 5, 62, 41, 18, -48 },
  { 15679, 22, 65, 41, 11, -53 },
  { 15858, 37, 14, 41, 1, -27 },
};

const GFXfont RobotoMono_SemiBold68pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold68pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _ROBOTOMONO_SEMIBOLD68PT7B_H_
