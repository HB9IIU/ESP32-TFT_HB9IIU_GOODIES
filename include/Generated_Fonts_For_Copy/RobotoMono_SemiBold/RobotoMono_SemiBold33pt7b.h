#ifndef _ROBOTOMONO_SEMIBOLD33PT7B_H_
#define _ROBOTOMONO_SEMIBOLD33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold33pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE0, 0x00,
  0x00, 0xFF, 0xFD, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xC3, 0x80, 0x03, 0x86, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38,
  0x03, 0x0E, 0x01, 0xC3, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1,
  0x87, 0x00, 0x61, 0x80, 0x38, 0x60, 0x0E, 0x38, 0x03, 0x8E, 0x0F, 0xFF,
  0xF3, 0xFF, 0xFC, 0x1C, 0x30, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0,
  0x18, 0x70, 0x06, 0x18, 0x03, 0x8E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xF0,
  0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x7C, 0x3F, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F,
  0xF8, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0x8E, 0x20, 0xC3, 0x8E, 0x30, 0xE7, 0x0E, 0x39, 0x83, 0x9C,
  0xE0, 0xFF, 0x30, 0x1F, 0x9C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x39, 0xF0, 0x0E, 0xFE, 0x07, 0x3F, 0xC1, 0x9C, 0x70,
  0xE7, 0x1C, 0x31, 0xC7, 0x04, 0x71, 0xC0, 0x1E, 0x70, 0x03, 0xF8, 0x00,
  0x7E, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xE3,
  0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC3, 0x9F, 0x78,
  0xF3, 0xCF, 0x9E, 0xF8, 0xFB, 0xDF, 0x0F, 0xF3, 0xE0, 0xFE, 0x7C, 0x0F,
  0x87, 0xC3, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0x1F, 0xFF, 0xFF,
  0xFF, 0xEE, 0xE0, 0x03, 0x07, 0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70,
  0x70, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x03,
  0x40, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x07, 0x81,
  0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC3, 0xC1, 0xC1, 0xC1, 0xE0,
  0x40, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x06, 0x1C,
  0x33, 0xCE, 0x79, 0xFF, 0xFF, 0x7F, 0xFE, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xDC, 0x01, 0xEF, 0x01, 0xE3, 0xC1, 0xE0, 0xF0, 0x70, 0x70, 0x08, 0x10,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEE, 0xF7, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B,
  0xFF, 0xFF, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E,
  0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3, 0xDF, 0xFF, 0x1F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x7C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xC3, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x03, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC3, 0xE3,
  0xC0, 0xFB, 0xC0, 0x7D, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x03, 0x80, 0x3F, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF,
  0x83, 0xFE, 0x03, 0xFC, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x1F,
  0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xEF, 0xFF, 0x8F, 0xFE, 0x0F,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0E, 0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x8F,
  0x07, 0x87, 0x83, 0x83, 0xC3, 0xC1, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFC,
  0x78, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0xF0, 0x1E, 0xF8, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0,
  0x00, 0x30, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF0, 0xC0, 0xF7, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC,
  0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x1E, 0x78, 0x1E, 0x7C, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x78, 0x3E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3C, 0x3F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xDF, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xF7,
  0xC7, 0xEF, 0xFF, 0xCF, 0xFF, 0x8F, 0xEF, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x0F, 0x80, 0x7D, 0xFF,
  0xDF, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xFF, 0x7D, 0xF0,
  0x3C, 0xFD, 0xFB, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x1E, 0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x3C, 0x30, 0x00, 0x04, 0x00,
  0x70, 0x0F, 0xC0, 0xFF, 0x0F, 0xF9, 0xFF, 0x0F, 0xF0, 0x3E, 0x00, 0xF8,
  0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80, 0x0F,
  0x80, 0x3F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x00, 0xFC,
  0x1F, 0xF3, 0xFF, 0x3F, 0xE0, 0xFE, 0x03, 0xE0, 0x0C, 0x00, 0x20, 0x00,
  0x07, 0x80, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xEF, 0x83, 0xDE, 0x07, 0xFC,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0xE0, 0xF0, 0x70, 0x0C, 0x38, 0x03, 0x9C, 0x7E, 0x66, 0x3F,
  0x9D, 0x8E, 0x67, 0xE7, 0x19, 0xF9, 0x86, 0x3C, 0x61, 0x9F, 0x38, 0xE7,
  0xCE, 0x39, 0xF3, 0x8E, 0x6C, 0xE3, 0x9B, 0x9D, 0xEE, 0xE7, 0xDF, 0x38,
  0xE7, 0x87, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x18, 0x07, 0xFE, 0x00, 0x7F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7,
  0x80, 0x3C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3E, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0xCF, 0x80, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0xF8, 0xFF, 0xF8, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9E, 0x07, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xF7,
  0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xDE, 0x0F, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xC0, 0x01, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xE0, 0xF3, 0xE0, 0x7D, 0xE0, 0x1E,
  0xF0, 0x0F, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xDE,
  0x01, 0xEF, 0x81, 0xF3, 0xE1, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x3E, 0xF1, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDE, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0x83, 0xFF,
  0xE3, 0xE0, 0xF3, 0xE0, 0x7D, 0xE0, 0x1E, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFE,
  0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDF, 0x01, 0xE7, 0x80, 0xF3, 0xF0,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xF8, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3E,
  0xFC, 0x7E, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0xF0, 0x0F, 0xFC, 0x07,
  0xCF, 0x03, 0xE3, 0xC0, 0xF8, 0xF0, 0x7C, 0x3C, 0x3E, 0x0F, 0x1F, 0x03,
  0xC7, 0xC0, 0xF3, 0xE0, 0x3D, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xCF, 0x83, 0xE3, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F,
  0x8F, 0x03, 0xE3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00, 0x7C,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFF, 0xEF,
  0xF7, 0xEF, 0xF7, 0xEF, 0xF7, 0xEF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF,
  0xF1, 0x8F, 0xF1, 0x8F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xF7, 0x1F,
  0xF7, 0x9F, 0xF3, 0x9F, 0xF3, 0xDF, 0xF1, 0xDF, 0xF1, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0xC3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3E, 0xF0, 0x0F, 0x78, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xEF, 0x81, 0xE3, 0xE3,
  0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3E, 0x1F, 0x1F, 0x03, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF9,
  0xF0, 0x3C, 0x3E, 0x3F, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x04, 0xFF, 0xF8, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9E, 0x07, 0xEF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x1F, 0x9F, 0xFF, 0x8F, 0xFF, 0x87,
  0xFF, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x7C, 0x78, 0x1E, 0x3C, 0x0F,
  0x9E, 0x03, 0xCF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3E, 0x03, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0x81, 0xF7, 0xC0, 0x7B, 0xC0, 0x3F,
  0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0x01, 0xE7, 0xC1, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x3E, 0x7C,
  0x0F, 0x9F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x7C, 0x3E, 0x1E, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0xC0,
  0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E,
  0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0xF8, 0xFF, 0x3F, 0x39, 0xCF, 0xCE,
  0x7B, 0xF7, 0x9E, 0xFD, 0xE7, 0xBF, 0x79, 0xED, 0xDE, 0x7F, 0x37, 0x9F,
  0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x8F, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x81, 0xE1, 0xE0, 0xF8, 0x07,
  0xCF, 0x81, 0xF0, 0xF0, 0x3E, 0x1F, 0x0F, 0x81, 0xE1, 0xF0, 0x3E, 0x7C,
  0x03, 0xCF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7D, 0xE0,
  0x1F, 0x3E, 0x03, 0xC3, 0xC0, 0xF8, 0x7C, 0x1E, 0x07, 0xC7, 0xC0, 0xF8,
  0xF0, 0x0F, 0xBE, 0x01, 0xF8, 0xF8, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x78,
  0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x87, 0xC1, 0xE1, 0xE0, 0x7C, 0xF8, 0x0F,
  0x3C, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x73, 0x81, 0xCF,
  0x0F, 0x1C, 0x38, 0x70, 0xE1, 0xE7, 0x03, 0xBC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF8, 0xF0, 0xF0, 0xE0, 0xE0, 0x03, 0xC0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7E, 0xFC, 0x78, 0x3E, 0xF8, 0x1E, 0x00, 0x1E, 0x01, 0xFE,
  0x1F, 0xFE, 0x7F, 0xFE, 0x7C, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E,
  0xF8, 0x7E, 0x7F, 0xFE, 0x7F, 0xFE, 0x1F, 0x9F, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xE0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF8, 0x1E, 0xFC, 0x3E, 0xFF, 0xFC, 0xF7, 0xFC, 0xF3, 0xF0, 0x03, 0xC0,
  0x1F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF7, 0xC3, 0xEF, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x81, 0xEF, 0x03,
  0xDF, 0x0F, 0x9F, 0xFE, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0x8F, 0x1F,
  0xDE, 0x7F, 0xFD, 0xFF, 0xFB, 0xE1, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF,
  0x87, 0xCF, 0xFF, 0x9F, 0xFF, 0x0F, 0xDE, 0x03, 0xC0, 0x0F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFE, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x04, 0x7E,
  0x1E, 0x3F, 0xFF, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xC0, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x1F, 0xEF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7C, 0x3F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F,
  0xDE, 0x00, 0x1E, 0x00, 0x1E, 0x30, 0x3E, 0x7C, 0xFC, 0x7F, 0xFC, 0x1F,
  0xF8, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xF0, 0xFB, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFE, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x81, 0xF0, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x7F, 0xDF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7E,
  0x7E, 0xFF, 0xBF, 0xCF, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x02, 0xF8, 0x3E,
  0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0xBF, 0x07, 0xDF, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0x7C, 0x1F, 0x1F, 0x0F,
  0x87, 0xC7, 0xC3, 0xE3, 0xE0, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F, 0x80, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x8E,
  0x7B, 0xEF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x7F, 0x8F, 0x1F, 0xC7,
  0x8F, 0xE3, 0xC7, 0xF1, 0xE3, 0xF8, 0xF1, 0xFC, 0x78, 0xFE, 0x3C, 0x7F,
  0x1E, 0x3F, 0x8F, 0x1F, 0xC7, 0x8F, 0xE3, 0xC7, 0xF1, 0xE3, 0xF8, 0xF1,
  0xC0, 0x00, 0xE0, 0xF3, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE, 0xFC, 0x1E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0xF8,
  0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0x01, 0xE0, 0xF7, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8,
  0x1E, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xFC, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFB,
  0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC3,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x81, 0xEF, 0x03, 0xDF, 0x0F, 0xBF, 0xFF, 0x3F, 0xFE, 0x1F,
  0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0xF7, 0x9F, 0xFD, 0xFF, 0xFF, 0xEF, 0xF3, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7E, 0x7E, 0x78, 0x1E, 0x78, 0x1F, 0x78, 0x00, 0x7F, 0x00,
  0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x3E, 0xF0, 0x0F, 0xF0, 0x0F,
  0x78, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF8, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC2, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFE, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xBF, 0xEF, 0x3F, 0x9E,
  0xF8, 0x07, 0xDE, 0x01, 0xE7, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x78, 0x70, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0xE1, 0xEF, 0x1E, 0x3D, 0xE3, 0xC7, 0xBC, 0x78,
  0xE7, 0x9F, 0x1C, 0x73, 0xE7, 0x8E, 0x7E, 0xF1, 0xCD, 0xDE, 0x3D, 0xBB,
  0x87, 0xF3, 0x70, 0x7E, 0x6E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x3E, 0x3E,
  0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x0E, 0x0F, 0x00, 0x7C, 0x07, 0xCF, 0x83,
  0xC1, 0xE1, 0xF0, 0x7C, 0xF8, 0x0F, 0xBC, 0x01, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F,
  0x3E, 0x07, 0xC7, 0xC3, 0xE0, 0xF0, 0xF0, 0x3E, 0xF8, 0x07, 0xC0, 0xF8,
  0x03, 0xEF, 0x00, 0xF9, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xC0, 0xF0, 0x3C,
  0x1E, 0x07, 0x87, 0xC0, 0xF8, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x1E,
  0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x3C, 0x0F, 0x83, 0xC0,
  0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3C, 0x3F, 0x87, 0xC0, 0xF8, 0x1F, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0xC0,
  0x78, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x0E,
  0x03, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x3C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x03, 0xC1, 0xF0, 0x1C, 0x03, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x1D, 0xFF,
  0x87, 0x3C, 0xFF, 0xE7, 0x0F, 0xFD, 0xC0, 0x7F, 0x00, 0x03, 0x80,
};

const GFXglyph RobotoMono_SemiBold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 5, 23, 20, 7, -23 },
  { 16, 9, 9, 20, 5, -25 },
  { 27, 18, 23, 20, 1, -23 },
  { 79, 16, 30, 20, 2, -27 },
  { 139, 18, 24, 20, 1, -24 },
  { 193, 19, 24, 20, 1, -24 },
  { 250, 4, 9, 20, 7, -25 },
  { 255, 8, 33, 20, 6, -26 },
  { 288, 9, 33, 20, 5, -26 },
  { 326, 17, 16, 20, 2, -23 },
  { 360, 16, 17, 20, 2, -19 },
  { 394, 5, 10, 20, 6, -4 },
  { 401, 14, 3, 20, 4, -12 },
  { 407, 6, 5, 20, 7, -5 },
  { 411, 13, 25, 20, 4, -23 },
  { 452, 16, 24, 20, 2, -24 },
  { 500, 10, 23, 20, 3, -23 },
  { 529, 17, 24, 20, 1, -24 },
  { 580, 15, 24, 20, 2, -24 },
  { 625, 17, 23, 20, 1, -23 },
  { 674, 16, 23, 20, 2, -23 },
  { 720, 16, 24, 20, 2, -24 },
  { 768, 17, 23, 20, 1, -23 },
  { 817, 16, 24, 20, 2, -24 },
  { 865, 15, 24, 20, 2, -24 },
  { 910, 6, 18, 20, 7, -18 },
  { 924, 7, 24, 20, 7, -18 },
  { 945, 14, 16, 20, 3, -18 },
  { 973, 15, 10, 20, 3, -15 },
  { 992, 14, 16, 20, 3, -18 },
  { 1020, 15, 24, 20, 3, -24 },
  { 1065, 18, 23, 20, 1, -23 },
  { 1117, 19, 23, 20, 1, -23 },
  { 1172, 17, 23, 20, 2, -23 },
  { 1221, 17, 24, 20, 1, -24 },
  { 1272, 16, 23, 20, 2, -23 },
  { 1318, 16, 23, 20, 2, -23 },
  { 1364, 15, 23, 20, 3, -23 },
  { 1408, 17, 24, 20, 1, -24 },
  { 1459, 16, 23, 20, 2, -23 },
  { 1505, 14, 23, 20, 3, -23 },
  { 1546, 16, 23, 20, 2, -23 },
  { 1592, 18, 23, 20, 2, -23 },
  { 1644, 15, 23, 20, 3, -23 },
  { 1688, 16, 23, 20, 2, -23 },
  { 1734, 16, 23, 20, 2, -23 },
  { 1780, 17, 24, 20, 1, -24 },
  { 1831, 16, 23, 20, 3, -23 },
  { 1877, 18, 28, 20, 1, -24 },
  { 1940, 17, 23, 20, 2, -23 },
  { 1989, 17, 24, 20, 2, -24 },
  { 2040, 18, 23, 20, 1, -23 },
  { 2092, 16, 23, 20, 2, -23 },
  { 2138, 18, 23, 20, 1, -23 },
  { 2190, 18, 23, 20, 1, -23 },
  { 2242, 19, 23, 20, 1, -23 },
  { 2297, 18, 23, 20, 1, -23 },
  { 2349, 16, 23, 20, 2, -23 },
  { 2395, 7, 32, 20, 7, -27 },
  { 2423, 13, 25, 20, 4, -23 },
  { 2464, 8, 32, 20, 6, -27 },
  { 2496, 14, 12, 20, 3, -23 },
  { 2517, 15, 3, 20, 2, 0 },
  { 2523, 7, 5, 20, 7, -24 },
  { 2528, 16, 18, 20, 2, -18 },
  { 2564, 16, 25, 20, 2, -25 },
  { 2614, 15, 18, 20, 2, -18 },
  { 2648, 15, 25, 20, 2, -25 },
  { 2695, 16, 18, 20, 2, -18 },
  { 2731, 17, 25, 20, 2, -25 },
  { 2785, 16, 25, 20, 2, -18 },
  { 2835, 16, 25, 20, 2, -25 },
  { 2885, 15, 24, 20, 3, -24 },
  { 2930, 10, 31, 20, 4, -24 },
  { 2969, 17, 25, 20, 2, -25 },
  { 3023, 15, 25, 20, 3, -25 },
  { 3070, 17, 18, 20, 1, -18 },
  { 3109, 16, 18, 20, 2, -18 },
  { 3145, 16, 18, 20, 2, -18 },
  { 3181, 16, 25, 20, 2, -18 },
  { 3231, 15, 25, 20, 2, -18 },
  { 3278, 13, 18, 20, 5, -18 },
  { 3308, 16, 18, 20, 2, -18 },
  { 3344, 16, 22, 20, 2, -22 },
  { 3388, 15, 17, 20, 3, -17 },
  { 3420, 18, 17, 20, 1, -17 },
  { 3459, 19, 17, 20, 0, -17 },
  { 3500, 18, 17, 20, 1, -17 },
  { 3539, 19, 24, 20, 1, -17 },
  { 3596, 16, 17, 20, 2, -17 },
  { 3630, 11, 32, 20, 5, -26 },
  { 3674, 2, 30, 20, 9, -23 },
  { 3682, 11, 32, 20, 5, -26 },
  { 3726, 19, 7, 20, 0, -13 },
};

const GFXfont RobotoMono_SemiBold33pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold33pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _ROBOTOMONO_SEMIBOLD33PT7B_H_
