#ifndef _ROBOTOMONO_SEMIBOLD43PT7B_H_
#define _ROBOTOMONO_SEMIBOLD43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0x00, 0x00, 0x00, 0x01, 0xCF, 0xBF, 0xFF, 0xF7,
  0x80, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3B, 0xC1,
  0xDE, 0x0E, 0xF0, 0x77, 0x83, 0xBC, 0x1C, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1C, 0x1E,
  0x00, 0x38, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xE1, 0xE0, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x78, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x1E,
  0x0E, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x81, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x70, 0x78, 0x00, 0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x87, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xDF,
  0xE3, 0xF8, 0x1F, 0x9F, 0x80, 0xFC, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0xBF,
  0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xF9, 0xFC, 0x1F, 0xCF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xF9, 0xE0, 0x00, 0xF0, 0xE0, 0xC0, 0xF0,
  0xF0, 0xE0, 0xF0, 0xF1, 0xE0, 0xF0, 0xF1, 0xC0, 0xF0, 0xF3, 0xC0, 0xF1,
  0xE3, 0x80, 0xFF, 0xE7, 0x80, 0x7F, 0xC7, 0x00, 0x3F, 0x8F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x71, 0xF8, 0x00, 0xF3, 0xFC, 0x00, 0xE7, 0xFE, 0x01,
  0xE7, 0x9F, 0x01, 0xCF, 0x0F, 0x03, 0x8F, 0x0F, 0x07, 0x8F, 0x0F, 0x07,
  0x0F, 0x0F, 0x01, 0x0F, 0x0F, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xDF, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x1F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x3E, 0x3F, 0xF8, 0x3E, 0x7E,
  0xFC, 0x3E, 0x7C, 0x7E, 0x3E, 0xFC, 0x7F, 0x3E, 0xF8, 0x3F, 0x7C, 0xF8,
  0x1F, 0xFC, 0xF8, 0x0F, 0xF8, 0xF8, 0x07, 0xF8, 0xFC, 0x07, 0xF0, 0xFE,
  0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x20, 0x0E, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x0E, 0x00,
  0x60, 0x02, 0xC0, 0x1C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0x1E, 0x03,
  0x80, 0x40, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x01, 0x81, 0xE0, 0x4F, 0x0F, 0x0F,
  0x7E, 0x71, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x0F,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x80,
  0x7C, 0x3C, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0x60, 0x38, 0x01, 0x00,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x3E, 0x7C, 0xF3, 0xE7, 0x86, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xBF, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF,
  0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xBF, 0xFB, 0xF3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x7F,
  0x0F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00,
  0x00, 0x08, 0x01, 0xC0, 0x7E, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xF0, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x03, 0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0x7E,
  0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7,
  0xFD, 0xFE, 0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF7, 0xE0, 0x1F, 0x9F, 0xC1, 0xFC,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0x3F, 0x00, 0x3C, 0x7E,
  0x00, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xE1, 0xFE, 0x18, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0x7F, 0x0F,
  0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0xFE, 0x07, 0xDF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x9F, 0xF0, 0xFE, 0xFE, 0x03, 0xF7, 0xE0, 0x0F, 0xBF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFD, 0xF0, 0x07, 0xEF,
  0x80, 0x3F, 0x7E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0xE1, 0xFC, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xBF, 0xC7, 0xE0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x7E, 0x7E, 0x0F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xFF, 0x87, 0xFF, 0xFC, 0x7E, 0x07, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7E,
  0xFE, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0xDF, 0xC7, 0xF0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x8F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xDF, 0x03, 0xF1, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x39, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x1E, 0x1F, 0x9F, 0xEF, 0xF7, 0xF9, 0xFC,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x3F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0x80,
  0x03, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xE0, 0x7F, 0x7C, 0x03, 0xF7,
  0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x3C, 0x1F, 0x1E, 0x38, 0x7F, 0x8E,
  0x78, 0xFF, 0xCE, 0x70, 0xF3, 0x8E, 0x71, 0xE3, 0x8E, 0x71, 0xC3, 0x8F,
  0xF1, 0xC3, 0x87, 0xE3, 0xC3, 0x8E, 0xE3, 0xC3, 0x8E, 0xE3, 0x83, 0x8E,
  0xE3, 0x83, 0x8E, 0xE3, 0x83, 0x8E, 0xE3, 0xC3, 0x8E, 0xE3, 0xC7, 0x9C,
  0xF3, 0xFF, 0xBC, 0xF1, 0xFF, 0xF8, 0x70, 0xF9, 0xF0, 0x78, 0x00, 0x40,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0x80, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x07, 0xC1, 0xF0, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03,
  0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7C, 0x03, 0xFB, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xEF, 0x80, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE7, 0xC0, 0x7F, 0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F,
  0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7E,
  0x00, 0xF9, 0xF8, 0x07, 0xE3, 0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7C, 0x0F, 0xE3, 0xE0,
  0x3F, 0x9F, 0x00, 0xFC, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x07,
  0xE7, 0xC0, 0x7F, 0x3E, 0x3F, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC,
  0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xDF, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF8, 0x3F, 0xC7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xF0, 0x1F, 0x9F,
  0xC1, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFB, 0xE0, 0x0F, 0xE7, 0xC0, 0x1F,
  0x8F, 0x80, 0x7F, 0x1F, 0x01, 0xFC, 0x3E, 0x07, 0xF0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x3F, 0x01, 0xF0, 0xFE, 0x03, 0xE1, 0xF8, 0x07, 0xC7, 0xE0, 0x0F,
  0x9F, 0x80, 0x1F, 0x7F, 0x00, 0x3E, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFD, 0xF8, 0x07, 0xF1, 0xF8, 0x0F, 0xE3,
  0xF0, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x07,
  0xE1, 0xF0, 0x0F, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0xCF, 0x80, 0x1F,
  0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9E, 0xFF,
  0xF9, 0xEF, 0xFF, 0x9E, 0xFF, 0xBF, 0xCF, 0xFB, 0xFC, 0xFF, 0xBF, 0xCF,
  0xFB, 0xF9, 0xFF, 0x9F, 0x9F, 0xF9, 0xF9, 0xFF, 0x9F, 0x1F, 0xF8, 0xF1,
  0xFF, 0x8F, 0x1F, 0xF8, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xBC,
  0x3F, 0xFB, 0xE3, 0xFF, 0xBE, 0x3F, 0xF9, 0xF3, 0xFF, 0x9F, 0x3F, 0xF8,
  0xF3, 0xFF, 0x8F, 0xBF, 0xF8, 0x7B, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0xFC,
  0x00, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x0F,
  0xC3, 0xF8, 0x7F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7E, 0x03, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xFC,
  0xFC, 0x00, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xC0, 0x07, 0xEF,
  0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x3E, 0x00, 0x7C, 0x7E, 0x01,
  0xF8, 0xFC, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xE0,
  0x1F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x07,
  0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0xCF,
  0x80, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x7E, 0x0F, 0x80, 0xFC,
  0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x3E,
  0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xEF,
  0xF9, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0x7D,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xF8,
  0x3F, 0xCF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xF7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3E, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xE7,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E,
  0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF,
  0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3C, 0x3C, 0xFF, 0x3C, 0x3E, 0xE7,
  0x7C, 0x3F, 0xE7, 0x7C, 0x3F, 0xE7, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xE7,
  0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x83,
  0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xFE, 0x00,
  0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x80,
  0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xE3,
  0xF0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xF7,
  0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00,
  0x7E, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC3,
  0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xF7,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3E, 0xF0, 0x1E, 0x7C,
  0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0xC7, 0xC1, 0xE3, 0xC0, 0xFB, 0xE0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x07,
  0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7E, 0x0F, 0xCF,
  0xC0, 0x7E, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xE3, 0xEF, 0xC0, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xFC, 0x1F, 0xEF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xBF, 0x1F, 0xF3, 0xF0, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0xFD, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xF9, 0xFE, 0xFE, 0x07, 0xEF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xF0, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFB, 0xFF, 0x8F, 0x8F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7F, 0x9F, 0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x03, 0xF7,
  0xE0, 0x3E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x1F, 0xCF, 0xC3, 0xFF, 0x7E, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x9F, 0xC7, 0xFD, 0xFC, 0x0F, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB,
  0xE0, 0x0F, 0xDF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x0F, 0xDF,
  0x80, 0xFE, 0x7F, 0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0x7F, 0x1F, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xC7, 0xF0, 0xFC, 0x07, 0xC7, 0xE0, 0x1F, 0x9F, 0x80,
  0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x20, 0xFC, 0x01, 0x83, 0xFC, 0x1F, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xE1, 0x81, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8,
  0xF8, 0x3F, 0xF7, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFC, 0xFF, 0x9F,
  0x81, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F,
  0xDF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0,
  0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF8, 0x0F, 0xCF, 0xE1, 0xFE,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xF7, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x40, 0x0F, 0x87, 0x00, 0xFC, 0x7E, 0x3F, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0xFD,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF8, 0xFE, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x40, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x20,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x7F, 0x7F, 0xFB,
  0xFF, 0x9F, 0xF8, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xEF, 0xC0, 0x7E, 0x3F,
  0x03, 0xF8, 0xFC, 0x1F, 0xC3, 0xF0, 0xFE, 0x0F, 0xC7, 0xF0, 0x3F, 0x3F,
  0x80, 0xFD, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x9F, 0x80, 0xFC,
  0x3F, 0x03, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x07,
  0xE3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xE1, 0xF3, 0xDF, 0xDF, 0xEF, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFD, 0xFC, 0xFF, 0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8,
  0xF8, 0x7F, 0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8,
  0x7F, 0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8, 0x7F,
  0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8, 0x7F, 0xE3,
  0xE1, 0xFF, 0x8F, 0x87, 0xC0, 0xF8, 0x7F, 0x0F, 0x9F, 0xF8, 0xFB, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0x8F, 0xEF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0x8F, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x00,
  0x7E, 0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7E,
  0x01, 0xF9, 0xF8, 0x0F, 0xC3, 0xF8, 0x7F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0xFE, 0x0F, 0xBF, 0xF0,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x1F, 0xEF, 0xE0, 0x7E, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7E, 0xFE, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFD, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0xF8, 0x7F, 0xE7, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF3, 0xF8, 0xFF, 0xBF, 0x81, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F,
  0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7E, 0x01, 0xFB,
  0xF0, 0x0F, 0xCF, 0xE1, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x7E, 0x07, 0xE7, 0xC0, 0x3F, 0x7C, 0x01, 0xF7, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x03, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x01, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x0F, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFD, 0xF1, 0xFF, 0x9F, 0x0F, 0xF1, 0xF0, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x7E, 0x7E, 0x01, 0xF8,
  0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x1F, 0x3E,
  0x00, 0x7C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x7C, 0x1E, 0xF8,
  0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0x78, 0x7E, 0x3E, 0x78, 0x7E, 0x3E, 0x7C,
  0x7E, 0x3E, 0x7C, 0xFE, 0x3C, 0x7C, 0xEE, 0x3C, 0x3C, 0xEF, 0x3C, 0x3C,
  0xEF, 0x7C, 0x3C, 0xE7, 0x7C, 0x3D, 0xE7, 0x78, 0x3F, 0xC7, 0x78, 0x3F,
  0xC7, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F,
  0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x81, 0xF8,
  0x3E, 0x01, 0xF8, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x8F,
  0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0,
  0x07, 0xC1, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xE0,
  0x03, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x01, 0xE0, 0x0F,
  0x80, 0x7F, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x03, 0xF0, 0x3F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0xC0, 0x3E, 0x00, 0x78, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xF8, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x0F,
  0xE0, 0x3F, 0x00, 0xF8, 0x02, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0,
  0x3D, 0xFF, 0xC0, 0x7F, 0xFF, 0xE1, 0xFF, 0x9F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xB8, 0x07, 0xFF, 0x30, 0x07, 0xFC, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoMono_SemiBold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 6, 31, 26, 10, -31 },
  { 25, 13, 11, 26, 6, -32 },
  { 43, 23, 31, 26, 1, -31 },
  { 133, 21, 39, 26, 3, -35 },
  { 236, 24, 31, 26, 1, -31 },
  { 329, 24, 31, 26, 2, -31 },
  { 422, 4, 11, 26, 10, -32 },
  { 428, 12, 44, 26, 7, -34 },
  { 494, 11, 44, 26, 7, -34 },
  { 555, 21, 22, 26, 3, -31 },
  { 613, 21, 22, 26, 2, -25 },
  { 671, 7, 13, 26, 8, -5 },
  { 683, 17, 5, 26, 6, -16 },
  { 694, 8, 7, 26, 9, -7 },
  { 701, 17, 34, 26, 5, -31 },
  { 774, 20, 31, 26, 3, -31 },
  { 852, 13, 31, 26, 4, -31 },
  { 903, 21, 31, 26, 2, -31 },
  { 985, 21, 31, 26, 2, -31 },
  { 1067, 23, 31, 26, 1, -31 },
  { 1157, 20, 31, 26, 3, -31 },
  { 1235, 21, 31, 26, 2, -31 },
  { 1317, 21, 31, 26, 2, -31 },
  { 1399, 20, 31, 26, 3, -31 },
  { 1477, 20, 31, 26, 2, -31 },
  { 1555, 7, 25, 26, 10, -25 },
  { 1577, 9, 33, 26, 9, -25 },
  { 1615, 19, 20, 26, 3, -23 },
  { 1663, 20, 14, 26, 3, -20 },
  { 1698, 19, 20, 26, 3, -23 },
  { 1746, 20, 31, 26, 3, -31 },
  { 1824, 24, 30, 26, 1, -30 },
  { 1914, 25, 31, 26, 1, -31 },
  { 2011, 21, 31, 26, 3, -31 },
  { 2093, 22, 31, 26, 2, -31 },
  { 2179, 21, 31, 26, 3, -31 },
  { 2261, 20, 31, 26, 3, -31 },
  { 2339, 21, 31, 26, 3, -31 },
  { 2421, 22, 31, 26, 2, -31 },
  { 2507, 20, 31, 26, 3, -31 },
  { 2585, 18, 31, 26, 4, -31 },
  { 2655, 21, 31, 26, 2, -31 },
  { 2737, 23, 31, 26, 3, -31 },
  { 2827, 20, 31, 26, 3, -31 },
  { 2905, 20, 31, 26, 3, -31 },
  { 2983, 20, 31, 26, 3, -31 },
  { 3061, 22, 31, 26, 2, -31 },
  { 3147, 21, 31, 26, 3, -31 },
  { 3229, 23, 36, 26, 2, -31 },
  { 3333, 22, 31, 26, 3, -31 },
  { 3419, 22, 31, 26, 2, -31 },
  { 3505, 24, 31, 26, 1, -31 },
  { 3598, 20, 31, 26, 3, -31 },
  { 3676, 24, 31, 26, 1, -31 },
  { 3769, 24, 31, 26, 1, -31 },
  { 3862, 24, 31, 26, 1, -31 },
  { 3955, 24, 31, 26, 1, -31 },
  { 4048, 22, 31, 26, 2, -31 },
  { 4134, 10, 42, 26, 8, -35 },
  { 4187, 17, 34, 26, 5, -31 },
  { 4260, 10, 42, 26, 8, -35 },
  { 4313, 17, 17, 26, 5, -31 },
  { 4350, 19, 4, 26, 3, 0 },
  { 4360, 9, 6, 26, 9, -31 },
  { 4367, 20, 23, 26, 3, -23 },
  { 4425, 20, 32, 26, 3, -32 },
  { 4505, 20, 23, 26, 3, -23 },
  { 4563, 21, 32, 26, 2, -32 },
  { 4647, 22, 23, 26, 2, -23 },
  { 4711, 21, 33, 26, 3, -33 },
  { 4798, 21, 32, 26, 2, -23 },
  { 4882, 20, 32, 26, 3, -32 },
  { 4962, 19, 32, 26, 4, -32 },
  { 5038, 13, 41, 26, 5, -32 },
  { 5105, 22, 32, 26, 3, -32 },
  { 5193, 19, 32, 26, 4, -32 },
  { 5269, 22, 23, 26, 2, -23 },
  { 5333, 20, 23, 26, 3, -23 },
  { 5391, 22, 23, 26, 2, -23 },
  { 5455, 20, 32, 26, 3, -23 },
  { 5535, 21, 32, 26, 2, -23 },
  { 5619, 17, 23, 26, 6, -23 },
  { 5668, 20, 23, 26, 3, -23 },
  { 5726, 20, 28, 26, 3, -28 },
  { 5796, 20, 23, 26, 3, -23 },
  { 5854, 22, 23, 26, 2, -23 },
  { 5918, 24, 23, 26, 1, -23 },
  { 5987, 23, 23, 26, 2, -23 },
  { 6054, 24, 32, 26, 1, -23 },
  { 6150, 21, 23, 26, 3, -23 },
  { 6211, 14, 42, 26, 7, -34 },
  { 6285, 4, 40, 26, 11, -31 },
  { 6305, 14, 42, 26, 7, -34 },
  { 6379, 23, 9, 26, 1, -17 },
};

const GFXfont RobotoMono_SemiBold43pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold43pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOMONO_SEMIBOLD43PT7B_H_
