#ifndef _ROBOTOMONO_SEMIBOLD39PT7B_H_
#define _ROBOTOMONO_SEMIBOLD39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0xFB, 0xFF, 0x9E, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x38,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC3, 0x80, 0x1C,
  0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC3,
  0x80, 0x1E, 0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x0F, 0x07, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x0F, 0x00, 0x38,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x3F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7E, 0x0F, 0xCF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x03, 0xFF, 0x00, 0x7B, 0xE0, 0x1F, 0x7E, 0x07, 0xE7, 0xFF, 0xFC, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x3C, 0x70, 0x40, 0xE1, 0xC3, 0xC3, 0x87, 0x0E, 0x0E, 0x1C, 0x78, 0x38,
  0x71, 0xC0, 0xF3, 0xCE, 0x03, 0xFF, 0x38, 0x07, 0xF9, 0xC0, 0x0F, 0xC7,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE1, 0xC0, 0x07, 0x9F, 0xC0, 0x1C, 0xFF, 0x80, 0xE7, 0x9E, 0x03,
  0x9C, 0x3C, 0x1C, 0x70, 0xF0, 0xF1, 0xC3, 0xC1, 0x87, 0x0F, 0x00, 0x1E,
  0x3C, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xF1, 0xE0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x1E, 0x00, 0xF1, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80,
  0x07, 0xFE, 0x1F, 0x7F, 0xF0, 0xFF, 0xE7, 0xC7, 0xBE, 0x3F, 0x3D, 0xF0,
  0xFF, 0xEF, 0x83, 0xFF, 0x7C, 0x0F, 0xF3, 0xE0, 0x7F, 0x9F, 0x81, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0x7C, 0x1F, 0xE3, 0xF0, 0xFF,
  0xFF, 0xFE, 0xEE, 0xEE, 0x00, 0x80, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0xC1,
  0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x02, 0x40, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x18, 0x02,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x81, 0xC0, 0x1C, 0x38, 0x37, 0xE7, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0x78, 0x03, 0xC7,
  0x00, 0x78, 0xF0, 0x1E, 0x0F, 0x07, 0xC1, 0xF0, 0x30, 0x18, 0x00, 0x02,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0xDF, 0x79, 0xEF, 0x18, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x1F, 0x1F,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x7D, 0xFF, 0xBE, 0x7F, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xBE,
  0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x7E, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x10, 0x07, 0x03, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xC0, 0x7C,
  0x7C, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE0, 0xFD, 0xF8, 0x0F, 0xBE, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xBE,
  0x01, 0xF7, 0xE0, 0x7E, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF,
  0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF0,
  0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x87, 0x80, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xBF,
  0x81, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0x81, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0xFB, 0xF0, 0x7E, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE7, 0xF8, 0x7D, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xBF, 0x83, 0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x0F, 0x9F, 0x01, 0xF1, 0xF0, 0x7E,
  0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xFC, 0xF8, 0x0F, 0x9F, 0x01,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x3F, 0x1F, 0x8F,
  0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7E, 0x0F,
  0xCF, 0x80, 0xF9, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xDF, 0x01, 0xFB, 0xF0, 0x7E, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC,
  0x03, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xE1,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7E, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x7D, 0xFB, 0xFF, 0xFF, 0xCF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xFB, 0xFF, 0xFF,
  0xCF, 0x80, 0x7C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x78,
  0xF3, 0xE7, 0x8E, 0x00, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00,
  0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0x1F,
  0xBF, 0x03, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0x10, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0,
  0x1F, 0x8F, 0xC0, 0xF0, 0x0E, 0x0E, 0x00, 0x38, 0xE0, 0xE1, 0xC7, 0x0F,
  0xE7, 0x70, 0xFF, 0x3B, 0x8F, 0x39, 0xDC, 0xF1, 0xCF, 0xC7, 0x0E, 0x3E,
  0x38, 0x71, 0xF1, 0xC3, 0x1F, 0x9C, 0x18, 0xFC, 0xE1, 0xC7, 0xE7, 0x0E,
  0x3F, 0x3C, 0x71, 0xB9, 0xE3, 0x9D, 0xC7, 0xFF, 0xEF, 0x3F, 0x7E, 0x38,
  0xF1, 0xE1, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x02, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x83, 0xFD, 0xF0,
  0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x03, 0xDF, 0x00, 0xFB, 0xE0,
  0x1F, 0x7C, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFE, 0xF8, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0xDF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFC, 0x7F, 0x8F, 0xC0, 0xFC, 0xFC, 0x07, 0xCF, 0xC0, 0x7E,
  0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x7C, 0xFC,
  0x0F, 0xCF, 0xC3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xFC, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x3E, 0x7C,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0xEF, 0x83, 0xFE,
  0xF8, 0x3F, 0xEF, 0x83, 0xFE, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x3F, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xBF, 0x01, 0xF3, 0xE0, 0x7E, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F,
  0xF8, 0x03, 0xFE, 0x00, 0xF8, 0x03, 0xF7, 0xC0, 0x3F, 0x3E, 0x01, 0xF9,
  0xF0, 0x1F, 0x8F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x0F,
  0xC0, 0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFE, 0xF8,
  0x07, 0xF7, 0xE0, 0x3F, 0x1F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C,
  0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3F,
  0x3E, 0x00, 0xFD, 0xF0, 0x07, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9D, 0xFF, 0x77, 0xBF, 0xEE, 0xF7, 0xFD,
  0xFC, 0xFF, 0xBF, 0x9F, 0xF3, 0xF3, 0xFE, 0x7C, 0x7F, 0xCF, 0x8F, 0xF8,
  0xF1, 0xFF, 0x1C, 0x3F, 0xE3, 0x87, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xF0, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7F, 0xEF, 0x0F, 0xFD, 0xF1, 0xFF, 0x9E, 0x3F, 0xF3,
  0xC7, 0xFE, 0x3C, 0xFF, 0xC7, 0x9F, 0xF8, 0x7B, 0xFF, 0x0F, 0x7F, 0xE1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xF0, 0x03,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0x1F, 0xC7,
  0xC0, 0x7C, 0x7C, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0xC0, 0x3E, 0x7C, 0x07, 0xC7, 0xE0, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x83, 0xFD, 0xF0, 0x0F, 0xBE,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x7F, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF,
  0xFE, 0x1F, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xF0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x9F, 0x00,
  0x7C, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF,
  0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x3E, 0x7E,
  0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x40, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF8, 0x3F, 0xCF, 0x80, 0xFC, 0xF8, 0x07,
  0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80,
  0x7C, 0xF8, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x01, 0xF7, 0xE0, 0x3F, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x01, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC,
  0x03, 0xFE, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0x9F,
  0x00, 0x7E, 0x7C, 0x01, 0xF1, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x07, 0xC1, 0xF0,
  0x1F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x3C, 0x00, 0x7D, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x78, 0x7F, 0xC1,
  0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x3E, 0x1E, 0xF8, 0xF8, 0x7B, 0xE3, 0xE1,
  0xE7, 0x8F, 0xC7, 0x9E, 0x3F, 0x3E, 0x78, 0xFC, 0xF9, 0xE7, 0xF3, 0xE7,
  0x9F, 0xCF, 0x9F, 0x7F, 0x3C, 0x7D, 0xDC, 0xF1, 0xF7, 0x7B, 0xC3, 0xDD,
  0xEF, 0x0F, 0x77, 0xBC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xF8, 0xFE,
  0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0x7E, 0x07,
  0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1,
  0xF0, 0xFC, 0x00, 0xFD, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0x80, 0xFC,
  0x3F, 0x03, 0xE0, 0x7C, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x07,
  0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0xC0, 0x3E,
  0x1F, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xF1, 0xF8, 0x07,
  0xE7, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x9F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0,
  0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E,
  0x78, 0x1E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xE3, 0xE7,
  0xC0, 0x7C, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xFC, 0x0F, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFE, 0x3E, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF9, 0xF8, 0x3E, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFE, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xDF, 0xF8,
  0xF1, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC3, 0xF0, 0xFC, 0xFC, 0x0F, 0x9F, 0x00, 0xF3, 0xE0, 0x1F, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0xFB, 0xE0, 0x1E, 0x3E, 0x07, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE,
  0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x03,
  0xE3, 0xC3, 0xFE, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0x0F, 0xDF, 0x81,
  0xF7, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF7, 0xC0, 0x3D, 0xF0, 0x1F, 0x7E,
  0x0F, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xEF, 0x07, 0xF3, 0xC0, 0x01,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF0, 0xFC, 0xFC,
  0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x04, 0x3F, 0x01, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE3, 0xE1, 0xFF, 0x7C, 0x7F, 0xFF, 0x9F,
  0xFF, 0xF3, 0xF0, 0xFE, 0xFC, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7E, 0x07, 0xE7, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFD, 0xF0, 0x7F, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x80,
  0x3E, 0x3C, 0x0F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F,
  0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0xFC, 0x3E, 0xFF, 0x8F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x00, 0x80, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF7, 0xFF, 0x3F, 0xF9, 0xFF, 0x8F, 0xF0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xF8,
  0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0, 0xF9, 0xF8, 0x0F,
  0xBF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xCF, 0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F,
  0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xF8, 0x07, 0xF0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF9, 0xE3, 0xC7, 0xDF, 0xBF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xCF, 0x8F, 0xFC, 0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8,
  0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC,
  0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7,
  0xFE, 0x3E, 0x3F, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0x80, 0xF0, 0xFC, 0x3C,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0xBE, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF0, 0xFC, 0xF8, 0x0F, 0x9F,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x7E,
  0x0F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xF1,
  0xF8, 0x3E, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFE, 0x1F, 0xBE, 0x03,
  0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0xFC,
  0x1F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFB, 0xFC, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE3, 0xC3, 0xFE, 0xF1, 0xFF, 0xFC,
  0xFF, 0xFF, 0x7F, 0x0F, 0xDF, 0x81, 0xF7, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xF7, 0xC0, 0x3D, 0xF0, 0x1F, 0x7E, 0x0F, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0x7F, 0xEF, 0x07, 0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x7F, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE,
  0x7C, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x87, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC,
  0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC,
  0xFF, 0xDF, 0x1F, 0xE7, 0xC0, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0x9F, 0x00,
  0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x83,
  0xE0, 0xF8, 0x0F, 0x07, 0xC0, 0x7C, 0x3C, 0x03, 0xE1, 0xE0, 0x0F, 0x1F,
  0x00, 0x7C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x70, 0x7F, 0xC1, 0xC1, 0xEF, 0x07, 0x87, 0xBE, 0x3E, 0x1E,
  0xF8, 0xF8, 0xF9, 0xE3, 0xE3, 0xE7, 0x8F, 0x8F, 0x1E, 0x37, 0x3C, 0x79,
  0xDC, 0xF1, 0xE7, 0x73, 0xC7, 0x9D, 0xCF, 0x0F, 0x77, 0x38, 0x3D, 0x8F,
  0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0,
  0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8,
  0x01, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xF0, 0x7C, 0x1F, 0x0F, 0x80,
  0xF9, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x00, 0xF9, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0x7C, 0x3E, 0x07, 0xE7, 0xC0,
  0x3E, 0xFC, 0x01, 0xF0, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xC0, 0x0F,
  0x9F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xC1, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xBC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x70, 0x0F, 0x80, 0xFE, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x03, 0xE0, 0xFF, 0x07, 0xE0, 0x3E, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7E, 0x01,
  0xE0, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x07, 0xE0, 0x1F, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x7E,
  0x07, 0xF0, 0x7C, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x3F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFC, 0x01, 0x1F,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xDF, 0xF8, 0x7F, 0xFB, 0x80, 0xFF,
  0x84, 0x03, 0xFC, 0x00, 0x07, 0x80,
};

const GFXglyph RobotoMono_SemiBold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 6, 28, 23, 9, -28 },
  { 22, 11, 10, 23, 6, -29 },
  { 36, 21, 28, 23, 1, -28 },
  { 110, 19, 36, 23, 3, -32 },
  { 196, 22, 28, 23, 1, -28 },
  { 273, 21, 28, 23, 2, -28 },
  { 347, 4, 10, 23, 9, -29 },
  { 352, 10, 40, 23, 7, -31 },
  { 402, 11, 40, 23, 6, -31 },
  { 457, 19, 20, 23, 3, -28 },
  { 505, 19, 20, 23, 2, -23 },
  { 553, 6, 12, 23, 7, -5 },
  { 562, 16, 4, 23, 5, -14 },
  { 570, 7, 6, 23, 8, -6 },
  { 576, 16, 30, 23, 4, -28 },
  { 636, 18, 28, 23, 3, -28 },
  { 699, 12, 28, 23, 3, -28 },
  { 741, 20, 28, 23, 1, -28 },
  { 811, 19, 28, 23, 2, -28 },
  { 878, 20, 28, 23, 1, -28 },
  { 948, 18, 28, 23, 3, -28 },
  { 1011, 19, 28, 23, 2, -28 },
  { 1078, 20, 28, 23, 1, -28 },
  { 1148, 19, 28, 23, 2, -28 },
  { 1215, 18, 28, 23, 2, -28 },
  { 1278, 7, 22, 23, 9, -22 },
  { 1298, 7, 29, 23, 9, -22 },
  { 1324, 17, 18, 23, 3, -21 },
  { 1363, 18, 12, 23, 3, -18 },
  { 1390, 17, 18, 23, 3, -21 },
  { 1429, 18, 28, 23, 3, -28 },
  { 1492, 21, 28, 23, 1, -28 },
  { 1566, 22, 28, 23, 1, -28 },
  { 1643, 19, 28, 23, 3, -28 },
  { 1710, 20, 28, 23, 2, -28 },
  { 1780, 20, 28, 23, 2, -28 },
  { 1850, 18, 28, 23, 3, -28 },
  { 1913, 18, 28, 23, 3, -28 },
  { 1976, 20, 28, 23, 2, -28 },
  { 2046, 19, 28, 23, 2, -28 },
  { 2113, 16, 28, 23, 4, -28 },
  { 2169, 19, 28, 23, 2, -28 },
  { 2236, 21, 28, 23, 3, -28 },
  { 2310, 18, 28, 23, 3, -28 },
  { 2373, 19, 28, 23, 2, -28 },
  { 2440, 19, 28, 23, 2, -28 },
  { 2507, 20, 28, 23, 2, -28 },
  { 2577, 19, 28, 23, 3, -28 },
  { 2644, 21, 33, 23, 2, -28 },
  { 2731, 20, 28, 23, 3, -28 },
  { 2801, 20, 28, 23, 2, -28 },
  { 2871, 22, 28, 23, 1, -28 },
  { 2948, 19, 28, 23, 2, -28 },
  { 3015, 22, 28, 23, 1, -28 },
  { 3092, 22, 28, 23, 1, -28 },
  { 3169, 22, 28, 23, 1, -28 },
  { 3246, 22, 28, 23, 1, -28 },
  { 3323, 20, 28, 23, 2, -28 },
  { 3393, 8, 38, 23, 8, -32 },
  { 3431, 15, 30, 23, 5, -28 },
  { 3488, 8, 38, 23, 8, -32 },
  { 3526, 16, 15, 23, 4, -28 },
  { 3556, 17, 4, 23, 3, 0 },
  { 3565, 9, 5, 23, 8, -28 },
  { 3571, 19, 21, 23, 2, -21 },
  { 3621, 18, 29, 23, 3, -29 },
  { 3687, 19, 21, 23, 2, -21 },
  { 3737, 18, 29, 23, 2, -29 },
  { 3803, 19, 21, 23, 2, -21 },
  { 3853, 20, 30, 23, 2, -30 },
  { 3928, 19, 29, 23, 2, -21 },
  { 3997, 18, 29, 23, 3, -29 },
  { 4063, 17, 29, 23, 4, -29 },
  { 4125, 13, 37, 23, 4, -29 },
  { 4186, 20, 29, 23, 3, -29 },
  { 4259, 17, 29, 23, 4, -29 },
  { 4321, 21, 21, 23, 1, -21 },
  { 4377, 18, 21, 23, 3, -21 },
  { 4425, 19, 21, 23, 2, -21 },
  { 4475, 18, 29, 23, 3, -21 },
  { 4541, 18, 29, 23, 2, -21 },
  { 4607, 15, 21, 23, 6, -21 },
  { 4647, 18, 21, 23, 3, -21 },
  { 4695, 19, 26, 23, 2, -26 },
  { 4757, 18, 21, 23, 3, -21 },
  { 4805, 21, 21, 23, 1, -21 },
  { 4861, 22, 21, 23, 1, -21 },
  { 4919, 20, 21, 23, 2, -21 },
  { 4972, 22, 29, 23, 1, -21 },
  { 5052, 19, 21, 23, 2, -21 },
  { 5102, 13, 37, 23, 6, -30 },
  { 5163, 3, 36, 23, 10, -28 },
  { 5177, 13, 37, 23, 6, -30 },
  { 5238, 21, 9, 23, 1, -16 },
};

const GFXfont RobotoMono_SemiBold39pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold39pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _ROBOTOMONO_SEMIBOLD39PT7B_H_
