#ifndef _ROBOTOMONO_SEMIBOLD44PT7B_H_
#define _ROBOTOMONO_SEMIBOLD44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xF7, 0xDF, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7,
  0x80, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0x00, 0x78, 0x78, 0x00, 0x70,
  0x78, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0xC1, 0xE0, 0x03, 0xC1,
  0xC0, 0x03, 0xC1, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x83,
  0xC0, 0x03, 0x83, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x07, 0x87, 0x80, 0x07, 0x07, 0x80, 0x07, 0x07, 0x00, 0x0F, 0x07,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xF8, 0x3F, 0x9F, 0x80, 0x7E, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFD, 0xF8,
  0x07, 0xEF, 0xE0, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x0F, 0x04, 0x07, 0x87, 0x87, 0x83, 0xC3,
  0xC3, 0x81, 0xE1, 0xE3, 0xC0, 0xF0, 0xF1, 0xC0, 0x78, 0x79, 0xE0, 0x3E,
  0x78, 0xE0, 0x0F, 0xFC, 0xF0, 0x03, 0xFC, 0x70, 0x00, 0xFC, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x3F, 0x80, 0x0F, 0x3F, 0xE0, 0x07, 0x3F,
  0xF8, 0x07, 0x9E, 0x3C, 0x03, 0x8E, 0x0E, 0x03, 0xCF, 0x07, 0x81, 0xC7,
  0x83, 0xC1, 0xE3, 0xC1, 0xE0, 0x20, 0xE0, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F,
  0x8F, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x9F, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF8, 0x1F, 0x3F, 0xFC, 0x1E, 0x7E, 0xFE, 0x3E, 0x7C, 0x7E, 0x3E, 0xFC,
  0x3F, 0x3E, 0xF8, 0x1F, 0xFE, 0xF8, 0x1F, 0xFC, 0xF8, 0x0F, 0xFC, 0xFC,
  0x07, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0x7E, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07,
  0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x20, 0x40, 0x0E,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0x01, 0xE0, 0x07, 0x03,
  0x81, 0x9F, 0x0E, 0x3E, 0x7F, 0xBB, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3E, 0xF0, 0x00,
  0xF3, 0xC0, 0x07, 0x87, 0x80, 0x3E, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC0,
  0xF0, 0x06, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xDF, 0xBE, 0x7C, 0xFB, 0xE7, 0x87, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x7F, 0x7F, 0xFF,
  0xFF, 0x7F, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xDF, 0xFD, 0xF9, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x07, 0xE3,
  0xF0, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x18, 0x07, 0xC1, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x83, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x7E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x3F,
  0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0xFE, 0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x1F,
  0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x0C, 0x00, 0xFB, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0xC1, 0xFC, 0x08, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xFC, 0x03, 0xF7, 0xF0, 0x1F, 0x9F, 0xC3, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x7C, 0x07, 0xCF, 0xF8, 0x3E, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0xFF, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7E, 0x01,
  0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0xFC, 0x7F, 0x0F, 0xE1, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF0, 0xFE, 0x7E, 0x07, 0xEF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7E,
  0x07, 0xE3, 0xF9, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E, 0x7C, 0x01,
  0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x7F, 0x03, 0xF9, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xDF, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF0, 0x70, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xF0,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x80, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x87,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x07, 0xE0, 0xF8, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x1E,
  0x1C, 0x06, 0x0E, 0x3C, 0x3F, 0x8E, 0x38, 0x7F, 0xCF, 0x78, 0xFF, 0xC7,
  0x70, 0xF1, 0xC7, 0x71, 0xE1, 0xC7, 0xF1, 0xC1, 0xC7, 0xF1, 0xC3, 0xC7,
  0xF3, 0xC3, 0xC7, 0xE3, 0xC3, 0x87, 0xE3, 0xC3, 0x87, 0xE3, 0xC3, 0x87,
  0xE3, 0xC3, 0x8E, 0xE3, 0xC3, 0x8E, 0xF3, 0xC7, 0x8E, 0xF1, 0xFF, 0xFC,
  0x71, 0xFD, 0xF8, 0x78, 0xF9, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x81, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x1F,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xFC, 0x03,
  0xE0, 0x3E, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x1F,
  0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xC0, 0x01, 0xF7, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7E, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xFC, 0x0F, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF,
  0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7C, 0xFC, 0x07, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFE, 0x0F, 0xE7, 0xF0,
  0x1F, 0x9F, 0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xE0, 0xFE, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0x83, 0xFC, 0x7C,
  0x07, 0xF3, 0xE0, 0x1F, 0xDF, 0x00, 0x7E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00,
  0x7E, 0xF8, 0x07, 0xF7, 0xC0, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFE, 0x0F, 0xE3, 0xF0, 0x1F, 0x9F,
  0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7E, 0x00,
  0x7D, 0xF8, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xF0, 0x7F, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0xE1, 0xFC, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F,
  0x80, 0xFC, 0x7F, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x1F,
  0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07,
  0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xF7, 0xFE, 0xF7, 0xBF, 0xF7, 0xFD,
  0xFF, 0xBF, 0xCF, 0xFC, 0xFE, 0x7F, 0xE7, 0xF3, 0xFF, 0x3F, 0x1F, 0xF9,
  0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x3C, 0x3F, 0xF1, 0xE1, 0xFF, 0x87, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xE0, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x1F, 0xFB, 0xC1, 0xFF, 0xBE, 0x1F, 0xFB, 0xE1, 0xFF,
  0x9F, 0x1F, 0xF9, 0xF1, 0xFF, 0x8F, 0x9F, 0xF8, 0xF9, 0xFF, 0x87, 0x9F,
  0xF8, 0x7D, 0xFF, 0x83, 0xDF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x38, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07,
  0xF0, 0xFE, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0x00, 0xFD, 0xF8,
  0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F,
  0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xFC, 0x03, 0xF0,
  0xFC, 0x0F, 0xE1, 0xFC, 0x3F, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFC, 0x0F, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0xFF, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0x87,
  0xF0, 0x7F, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0xC7, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xC0, 0xFF,
  0x1F, 0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xF9,
  0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x9F,
  0x80, 0x7F, 0x3F, 0x0F, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x1F,
  0xBF, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x9F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF8, 0x03, 0xF1, 0xFC, 0x0F,
  0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x03, 0xF3, 0xF0, 0x3F, 0x9F, 0xC3, 0xF8,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8,
  0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F,
  0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0x87,
  0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0xF8, 0x3C, 0x0F, 0xFC, 0x1F, 0x0F, 0xFE, 0x0F, 0x87, 0xDF, 0x07, 0xC3,
  0xEF, 0xC7, 0xE1, 0xF3, 0xE3, 0xF0, 0xF9, 0xF1, 0xF8, 0x7C, 0xF8, 0xFE,
  0x3E, 0x7C, 0x7F, 0x1F, 0x3E, 0x3F, 0x9F, 0x1F, 0x1F, 0xCF, 0x8F, 0x9F,
  0xE7, 0xC7, 0xCF, 0xF3, 0xE1, 0xF7, 0xB9, 0xF0, 0xFB, 0xDE, 0xF8, 0x7D,
  0xEF, 0x7C, 0x3E, 0xE7, 0xBE, 0x1F, 0xF3, 0xDE, 0x0F, 0xF9, 0xFF, 0x07,
  0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0,
  0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x7E,
  0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07,
  0xE0, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xF0,
  0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0,
  0x3F, 0x07, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xF3, 0xF0, 0x01, 0xFB, 0xF8,
  0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x3E,
  0xF8, 0x1E, 0x3C, 0x1F, 0x1F, 0x0F, 0x07, 0x87, 0x83, 0xC7, 0xC1, 0xF3,
  0xC0, 0x7B, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0,
  0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF,
  0xFE, 0x3F, 0x03, 0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0x81,
  0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBF,
  0x01, 0xFD, 0xFC, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xEF,
  0xC1, 0xFE, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE1, 0xE0, 0x3F, 0x7F, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF3, 0xFC, 0x1F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xBF,
  0x00, 0xFD, 0xFC, 0x07, 0xEF, 0xF0, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0x7F, 0xF0, 0xF8, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0x7F, 0x7E, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0x7E, 0x03, 0xF7, 0xF0, 0x7E, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x1C, 0x1F, 0x0F, 0xF9, 0xF1, 0xFF, 0xDF,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x0F, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1,
  0xFF, 0xDF, 0x07, 0xF9, 0xF0, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xDF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x02, 0x1F, 0x80, 0x38, 0xFF, 0x07, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x9F, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFE, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0x7E, 0x03, 0xF7, 0xF0, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFD, 0xF0, 0x7F, 0x9F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x10,
  0x03, 0xF3, 0x80, 0x7F, 0x3E, 0x1F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0xE0, 0x3F, 0x3F, 0xE1, 0xFB, 0xFF,
  0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFC, 0x1F, 0xDF, 0x80, 0x7E, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xF8, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x07, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0x80,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xBF, 0x01, 0xFC, 0xFC, 0x0F, 0xE3,
  0xF0, 0x7F, 0x0F, 0xC3, 0xF8, 0x3F, 0x1F, 0xC0, 0xFC, 0xFE, 0x03, 0xF7,
  0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xDF, 0x80, 0xFE, 0x3F, 0x03, 0xF0, 0xFE, 0x0F,
  0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0xCF, 0xC0,
  0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0xC1, 0xF7, 0xE7, 0xF3,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0x1F, 0x8F, 0xBE,
  0x1F, 0x1F, 0xFC, 0x3E, 0x3F, 0xF8, 0x7C, 0x7F, 0xF0, 0xF8, 0xFF, 0xE1,
  0xF1, 0xFF, 0xC3, 0xE3, 0xFF, 0x87, 0xC7, 0xFF, 0x0F, 0x8F, 0xFE, 0x1F,
  0x1F, 0xFC, 0x3E, 0x3F, 0xF8, 0x7C, 0x7F, 0xF0, 0xF8, 0xFF, 0xE1, 0xF1,
  0xFF, 0xC3, 0xE3, 0xFF, 0x87, 0xC7, 0xFF, 0x0F, 0x8F, 0xFE, 0x1F, 0x1F,
  0xFC, 0x3E, 0x3F, 0x00, 0x1C, 0x07, 0xC7, 0xFC, 0x3E, 0x7F, 0xF1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x83, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x3E,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFE, 0x0F, 0xC7, 0xE0,
  0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF,
  0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0x8F, 0xE1,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x3C, 0x07, 0xCF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x7F, 0x83, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x01, 0xF7,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF7, 0xE0, 0x1F, 0xBF,
  0x80, 0xFD, 0xFE, 0x1F, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x1F, 0x9F, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x9F, 0x1F, 0xFD, 0xF3, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0x7E, 0x03, 0xF7, 0xF0, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFD,
  0xF0, 0x7F, 0x9F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x3F, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFD, 0xFF, 0x3F, 0x01, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x3F, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x07,
  0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x30, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFE, 0x80, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0,
  0x3F, 0x7F, 0x0F, 0xF3, 0xFF, 0xFF, 0x3F, 0xFD, 0xF1, 0xFF, 0xDF, 0x0F,
  0xF1, 0xF0, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xF0,
  0x07, 0xC7, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0xC0, 0x7C, 0x0F, 0x81,
  0xF8, 0x1F, 0x03, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x01, 0xF7, 0xC0,
  0x03, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x3C, 0x1F,
  0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x7E, 0x1F, 0x78, 0x7E, 0x1F,
  0x7C, 0x7E, 0x1E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0xFF, 0x3E,
  0x7C, 0xFF, 0x3E, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3E, 0xE7, 0x3C,
  0x3F, 0xE7, 0xBC, 0x3F, 0xE7, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0x81, 0xF8,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xF8,
  0xFC, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x01,
  0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x0F,
  0xC1, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7C, 0x00,
  0xFC, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xDF, 0x80,
  0x03, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xC0, 0x10,
  0x3F, 0xF0, 0x0F, 0x7F, 0xF8, 0x1F, 0xFF, 0xFE, 0x1E, 0xF8, 0xFF, 0xFE,
  0xF0, 0x3F, 0xFE, 0xE0, 0x1F, 0xFC, 0x10, 0x07, 0xF8, 0x00, 0x01, 0xE0,
};

const GFXglyph RobotoMono_SemiBold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 6, 31, 26, 10, -31 },
  { 25, 13, 11, 26, 6, -33 },
  { 43, 24, 31, 26, 1, -31 },
  { 136, 21, 41, 26, 3, -36 },
  { 244, 25, 32, 26, 1, -32 },
  { 344, 24, 32, 26, 2, -32 },
  { 440, 4, 11, 26, 10, -33 },
  { 446, 12, 45, 26, 7, -35 },
  { 514, 12, 45, 26, 7, -35 },
  { 582, 22, 22, 26, 3, -31 },
  { 643, 22, 23, 26, 2, -26 },
  { 707, 7, 13, 26, 8, -5 },
  { 719, 17, 4, 26, 6, -16 },
  { 728, 8, 7, 26, 9, -7 },
  { 735, 17, 34, 26, 5, -31 },
  { 808, 20, 32, 26, 3, -32 },
  { 888, 13, 31, 26, 4, -31 },
  { 939, 21, 32, 26, 2, -32 },
  { 1023, 21, 32, 26, 2, -32 },
  { 1107, 23, 31, 26, 1, -31 },
  { 1197, 21, 31, 26, 3, -31 },
  { 1279, 21, 32, 26, 2, -32 },
  { 1363, 21, 31, 26, 2, -31 },
  { 1445, 20, 32, 26, 3, -32 },
  { 1525, 21, 32, 26, 2, -32 },
  { 1609, 8, 25, 26, 10, -25 },
  { 1634, 8, 33, 26, 10, -25 },
  { 1667, 19, 21, 26, 3, -24 },
  { 1717, 21, 13, 26, 3, -20 },
  { 1752, 19, 21, 26, 4, -24 },
  { 1802, 19, 32, 26, 4, -32 },
  { 1878, 24, 31, 26, 1, -31 },
  { 1971, 25, 31, 26, 1, -31 },
  { 2068, 22, 31, 26, 3, -31 },
  { 2154, 22, 32, 26, 2, -32 },
  { 2242, 21, 31, 26, 3, -31 },
  { 2324, 21, 31, 26, 3, -31 },
  { 2406, 21, 31, 26, 3, -31 },
  { 2488, 22, 32, 26, 2, -32 },
  { 2576, 20, 31, 26, 3, -31 },
  { 2654, 18, 31, 26, 4, -31 },
  { 2724, 21, 31, 26, 2, -31 },
  { 2806, 24, 31, 26, 3, -31 },
  { 2899, 21, 31, 26, 3, -31 },
  { 2981, 21, 31, 26, 3, -31 },
  { 3063, 20, 31, 26, 3, -31 },
  { 3141, 23, 32, 26, 2, -32 },
  { 3233, 22, 31, 26, 3, -31 },
  { 3319, 24, 37, 26, 2, -32 },
  { 3430, 23, 31, 26, 3, -31 },
  { 3520, 23, 32, 26, 2, -32 },
  { 3612, 25, 31, 26, 1, -31 },
  { 3709, 21, 31, 26, 3, -31 },
  { 3791, 25, 31, 26, 1, -31 },
  { 3888, 25, 31, 26, 1, -31 },
  { 3985, 25, 31, 26, 1, -31 },
  { 4082, 25, 31, 26, 1, -31 },
  { 4179, 22, 31, 26, 2, -31 },
  { 4265, 9, 43, 26, 9, -36 },
  { 4314, 17, 34, 26, 5, -31 },
  { 4387, 9, 43, 26, 9, -36 },
  { 4436, 17, 16, 26, 5, -31 },
  { 4470, 20, 4, 26, 3, 0 },
  { 4480, 10, 6, 26, 9, -32 },
  { 4488, 21, 24, 26, 3, -24 },
  { 4551, 21, 33, 26, 3, -33 },
  { 4638, 20, 24, 26, 3, -24 },
  { 4698, 20, 33, 26, 3, -33 },
  { 4781, 21, 24, 26, 3, -24 },
  { 4844, 22, 34, 26, 3, -34 },
  { 4938, 20, 33, 26, 3, -24 },
  { 5021, 21, 33, 26, 3, -33 },
  { 5108, 19, 32, 26, 5, -32 },
  { 5184, 14, 41, 26, 5, -32 },
  { 5256, 22, 33, 26, 3, -33 },
  { 5347, 20, 33, 26, 4, -33 },
  { 5430, 23, 24, 26, 2, -24 },
  { 5499, 21, 24, 26, 3, -24 },
  { 5562, 22, 24, 26, 2, -24 },
  { 5628, 21, 33, 26, 3, -24 },
  { 5715, 20, 33, 26, 3, -24 },
  { 5798, 18, 24, 26, 6, -24 },
  { 5852, 21, 24, 26, 3, -24 },
  { 5915, 21, 29, 26, 3, -29 },
  { 5992, 20, 23, 26, 3, -23 },
  { 6050, 23, 23, 26, 2, -23 },
  { 6117, 24, 23, 26, 1, -23 },
  { 6186, 23, 23, 26, 2, -23 },
  { 6253, 25, 32, 26, 1, -23 },
  { 6353, 21, 23, 26, 3, -23 },
  { 6414, 14, 42, 26, 7, -34 },
  { 6488, 4, 40, 26, 11, -31 },
  { 6508, 14, 42, 26, 7, -34 },
  { 6582, 24, 10, 26, 1, -18 },
};

const GFXfont RobotoMono_SemiBold44pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold44pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _ROBOTOMONO_SEMIBOLD44PT7B_H_
