#ifndef _ROBOTOMONO_SEMIBOLD53PT7B_H_
#define _ROBOTOMONO_SEMIBOLD53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7C, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xDE, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0x81, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xC1, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x7F, 0xE7, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x0F, 0xF3, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F,
  0xDF, 0xE0, 0x0F, 0xF3, 0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0,
  0xF0, 0x38, 0x0F, 0x83, 0xC0, 0xF0, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0x3E,
  0x1E, 0x03, 0xE0, 0xF0, 0xF0, 0x0F, 0x83, 0xC3, 0xC0, 0x3E, 0x1F, 0x1E,
  0x00, 0x7F, 0xFC, 0x78, 0x01, 0xFF, 0xE3, 0xC0, 0x03, 0xFF, 0x1F, 0x00,
  0x03, 0xF8, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x0F, 0x8F, 0xF8, 0x00, 0x3C,
  0x7F, 0xF0, 0x01, 0xF3, 0xFF, 0xE0, 0x07, 0x8F, 0x8F, 0x80, 0x3E, 0x7C,
  0x1F, 0x00, 0xF1, 0xF0, 0x7C, 0x07, 0xC7, 0xC1, 0xF0, 0x1E, 0x1F, 0x07,
  0xC0, 0xF0, 0x7C, 0x1F, 0x00, 0x41, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x01, 0xF8, 0x7F, 0xFE, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0x9F, 0xE7, 0xF0,
  0x7E, 0x7F, 0x0F, 0xE3, 0xF1, 0xF8, 0x3F, 0xCF, 0xCF, 0xE0, 0x7F, 0xFF,
  0x3F, 0x80, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0x8F,
  0xE0, 0x0F, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE7, 0xF8, 0x0F, 0xFE, 0x0F, 0xF0, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0xE0, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x18, 0x00, 0x20, 0x40, 0x00, 0xE0, 0x01, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0x00,
  0x78, 0x02, 0x78, 0x1E, 0x03, 0x9F, 0x87, 0x83, 0xE7, 0xF9, 0xE7, 0xFB,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0x80, 0x78, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x7F, 0x3F, 0x9F, 0x8F, 0xC7, 0xC7, 0xE3, 0xE3,
  0xE0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xF7,
  0xF8, 0xFC, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x01,
  0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F,
  0x7F, 0xFC, 0xFE, 0x7F, 0xFD, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7E, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xFF, 0x0F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xF0, 0x7F, 0x80,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFC, 0xFF,
  0xC7, 0xF8, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xF8, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x7F,
  0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xF0,
  0x01, 0xFD, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xCF, 0xE0,
  0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x07, 0xE0,
  0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0x80, 0x3F, 0x83, 0xF0, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x78, 0x00, 0xFD, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xCF, 0xE0, 0x1F, 0xE0, 0x20, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFD, 0xFC,
  0x00, 0xFE, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x01, 0xF9,
  0xFF, 0xC1, 0xFD, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFC, 0xFF, 0xDF, 0xF0, 0x1F, 0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x01,
  0xFD, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0xC1, 0xFF, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE1, 0xFF, 0x1F, 0xF0, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xF0,
  0x07, 0xF1, 0xF8, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0xF0, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE,
  0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0xFF, 0x7F, 0xC0, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC1, 0xFF, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0xFE, 0x01, 0xFC,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07,
  0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xF0,
  0x1F, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0x7E, 0x03, 0xFF, 0x3F, 0x00, 0x3C, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFB, 0xF8, 0x20, 0x3F, 0x1F, 0xE7,
  0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xF8, 0xFE, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0x80, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x7F, 0xE3, 0xFE, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x18, 0x1E, 0x1E, 0x07,
  0xF8, 0xF1, 0xF0, 0x7F, 0xE3, 0xCF, 0x07, 0xFF, 0x1E, 0x78, 0x7E, 0x78,
  0xF7, 0x87, 0xC3, 0xC7, 0xBC, 0x3C, 0x1E, 0x3D, 0xE1, 0xE0, 0xF0, 0xEF,
  0x1F, 0x07, 0x07, 0xF8, 0xF0, 0x38, 0x3F, 0x87, 0x83, 0xC3, 0xFC, 0x3C,
  0x1E, 0x1F, 0xE1, 0xE0, 0xF0, 0xFF, 0x0F, 0x07, 0x87, 0xF8, 0x78, 0x3C,
  0x3B, 0xC3, 0xC1, 0xE1, 0xDE, 0x1E, 0x0F, 0x1E, 0xF8, 0xF8, 0xF8, 0xE3,
  0xC7, 0xFF, 0xFF, 0x1E, 0x1F, 0xEF, 0xF0, 0xF0, 0xFF, 0x7F, 0x07, 0xC1,
  0xE1, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x18, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x03,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xCF, 0xC0, 0x0F, 0xFB, 0xF0, 0x01, 0xFE, 0xFC, 0x00, 0x3F,
  0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00,
  0x3F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x07, 0xF3, 0xF0, 0x03, 0xFC, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x3F, 0x00, 0x7F, 0xCF, 0xC0, 0x03, 0xFB, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x01, 0xFE, 0xFC, 0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xE3, 0xFF, 0x07, 0xF0, 0x0F, 0xF1, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0xBF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x1F,
  0xE0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xE3, 0xF8, 0x07,
  0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xEF, 0xE0, 0x0F, 0xF3, 0xF8, 0x07, 0xF8, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xF3, 0xFF, 0x07, 0xF8, 0x0F,
  0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0xFE, 0x01,
  0xFE, 0x7F, 0xC1, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0xFC, 0x00, 0x3F, 0xCF, 0xC0, 0x07,
  0xF8, 0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0x0F, 0xF0, 0xFC, 0x01, 0xFE, 0x0F,
  0xC0, 0x3F, 0xC0, 0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x7F, 0x80, 0xFC, 0x0F,
  0xF0, 0x0F, 0xC1, 0xFE, 0x00, 0xFC, 0x3F, 0xC0, 0x0F, 0xC3, 0xFC, 0x00,
  0xFC, 0x7F, 0x80, 0x0F, 0xCF, 0xF0, 0x00, 0xFD, 0xFE, 0x00, 0x0F, 0xDF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xDF, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x3F,
  0xC0, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x0F, 0xF0, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x07, 0xF8, 0xFC, 0x00,
  0x3F, 0xCF, 0xC0, 0x01, 0xFE, 0xFC, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xDF, 0x3E, 0xFF, 0xF7,
  0xCF, 0xBF, 0xFD, 0xF3, 0xEF, 0xFF, 0x7D, 0xF3, 0xFF, 0xCF, 0xFC, 0xFF,
  0xF3, 0xFF, 0x3F, 0xFC, 0xFF, 0xCF, 0xFF, 0x1F, 0xE3, 0xFF, 0xE7, 0xF8,
  0xFF, 0xF9, 0xFE, 0x3F, 0xFE, 0x3F, 0x0F, 0xFF, 0x8F, 0xC3, 0xFF, 0xE3,
  0xF0, 0xFF, 0xF8, 0xF8, 0x3F, 0xFE, 0x1E, 0x0F, 0xFF, 0x87, 0x83, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFB,
  0xF0, 0xFF, 0xFD, 0xF8, 0x7F, 0xFE, 0x7C, 0x3F, 0xFF, 0x3F, 0x1F, 0xFF,
  0x8F, 0x8F, 0xFF, 0xC7, 0xE7, 0xFF, 0xE1, 0xF3, 0xFF, 0xF0, 0xFD, 0xFF,
  0xF8, 0x7E, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F,
  0xC0, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xCF, 0xE0, 0x0F, 0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x01, 0xFE,
  0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7E, 0x7F, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01,
  0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF0,
  0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x10, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0xC7, 0xE0, 0x03, 0xFC, 0xFC, 0x00,
  0x3F, 0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xEF,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01,
  0xFC, 0xFC, 0x00, 0x7F, 0x9F, 0x80, 0x3F, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xFC,
  0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x0F, 0xF3, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xEF, 0xC0, 0x01, 0xFD,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0x8F,
  0xFC, 0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3,
  0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0xE0, 0x3F, 0xE1,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF8,
  0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0x3F, 0xC1, 0xFF, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0,
  0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7F, 0x3F, 0x80,
  0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0xFF, 0xF0, 0x3F, 0x03,
  0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0x3F, 0xFE, 0x0F, 0xC1, 0xFD,
  0xF8, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0x1F, 0x9F, 0x87, 0xF8, 0x7E, 0x7E,
  0x1F, 0xE1, 0xF9, 0xF8, 0x7F, 0x87, 0xE7, 0xE1, 0xFE, 0x1F, 0x9F, 0x87,
  0xF8, 0x7E, 0x3F, 0x1F, 0xE3, 0xF0, 0xFC, 0xFF, 0x8F, 0xC3, 0xF3, 0xFF,
  0x3F, 0x0F, 0xCF, 0xFC, 0xFC, 0x3F, 0x3F, 0xF3, 0xF0, 0xFC, 0xF7, 0xCF,
  0xC3, 0xF3, 0xCF, 0x3F, 0x0F, 0xCF, 0x3C, 0xFC, 0x1F, 0x7C, 0xFB, 0xE0,
  0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x03, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x03,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0x7E, 0x00, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F,
  0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x3F,
  0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xE0,
  0x0F, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0,
  0xFC, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x7E, 0x03, 0xE3,
  0xE0, 0x1F, 0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE,
  0x7F, 0xC0, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xDF, 0xC0, 0x07,
  0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x03, 0xFC, 0xFE, 0x03,
  0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xE7, 0xF0, 0x7F, 0xE3, 0xF8, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x80, 0x0F, 0xE7, 0xFC,
  0x07, 0xF7, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x7F, 0xC0, 0xFF, 0x3F, 0xC0, 0x3F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x07, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0xBF, 0xE0, 0x7F, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xC7, 0xEF, 0xFF, 0xC3, 0xF3, 0xFF, 0xC1, 0xF8, 0xFF,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x01, 0xFB, 0xF8,
  0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x06, 0x07, 0xF0, 0x3F, 0xF3, 0xF8, 0x3F, 0xFD, 0xFC, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xE0, 0xFF, 0xDF,
  0xE0, 0x1F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0xC0,
  0x3F, 0xCF, 0xF0, 0x7F, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFE, 0x7E, 0x03, 0xFC, 0x3F, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0xFE,
  0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0x83,
  0xFC, 0x00, 0xF0, 0xFF, 0x80, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xFF, 0x8F, 0xC1, 0xFF, 0xF7, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF7,
  0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFE, 0x01, 0xFE, 0x7F, 0x81, 0xFF,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7,
  0xF0, 0x1F, 0xF3, 0xF8, 0x00, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x10, 0x00,
  0x7F, 0x0C, 0x00, 0x7F, 0x0F, 0x00, 0x7F, 0x8F, 0xF1, 0xFF, 0xC7, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x40, 0x0F, 0xE3, 0xFE, 0x07, 0xF3, 0xFF, 0xC3, 0xFB, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0xFF, 0xBF, 0xC0,
  0x3F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFB, 0xF8,
  0x00, 0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE8, 0x3F, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF9, 0xFC, 0x01, 0xFE, 0x3F, 0x80,
  0x7F, 0x87, 0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x03,
  0xF8, 0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x0F, 0xE7, 0xF8, 0x01, 0xFD, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xF1, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xE7, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x10, 0x04, 0x0F, 0xCF, 0xE3, 0xF8, 0xFD, 0xFF, 0x7F,
  0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFE,
  0x3F, 0x87, 0xEF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8,
  0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF,
  0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F,
  0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F,
  0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1,
  0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87,
  0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xF0, 0x00, 0x02, 0x00, 0xFC,
  0x3F, 0xF0, 0xFC, 0x7F, 0xF8, 0xFD, 0xFF, 0xFC, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00,
  0x08, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF1, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF8,
  0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x7E, 0x3F, 0xE0, 0x3F, 0x3F, 0xFC, 0x1F, 0xBF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xF9, 0xFE,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF,
  0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xFC, 0x03,
  0xF9, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x1F, 0xDF, 0xFE, 0x0F, 0xE7, 0xFC, 0x07, 0xF0, 0x30, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x8F,
  0xC1, 0xFF, 0xE7, 0xE1, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xFB,
  0xF8, 0x01, 0xFD, 0xFE, 0x01, 0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xF0, 0x1F, 0xF3,
  0xF8, 0x01, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0x07, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xEF, 0xDF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFC, 0x06, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF, 0xC3,
  0xF8, 0x07, 0xF8, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x1F,
  0xDF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xF9, 0xFE, 0x00, 0xFE, 0x3F, 0xF3,
  0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x0C, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xBF, 0x1F, 0xFF, 0xBF, 0x1F, 0xFF, 0x3F, 0x07, 0xFC, 0x3F, 0x00,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0x81, 0xFF, 0xF0, 0x3E, 0x07, 0xEF,
  0xC0, 0xF8, 0x1F, 0xBF, 0x03, 0xF0, 0x7E, 0x7E, 0x0F, 0xC1, 0xF9, 0xF8,
  0x7F, 0x07, 0xE7, 0xE1, 0xFC, 0x1F, 0x1F, 0x87, 0xF0, 0x7C, 0x7E, 0x1F,
  0xE3, 0xF0, 0xF8, 0x7F, 0x8F, 0xC3, 0xE3, 0xDE, 0x3F, 0x0F, 0xCF, 0x78,
  0xF8, 0x3F, 0x3D, 0xE3, 0xE0, 0xFC, 0xF7, 0xCF, 0x83, 0xF3, 0xCF, 0x3E,
  0x07, 0xDE, 0x3D, 0xF8, 0x1F, 0x78, 0xF7, 0xE0, 0x7D, 0xE3, 0xDF, 0x01,
  0xF7, 0x87, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0,
  0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC1,
  0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xEF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0x8F, 0xFF, 0x80, 0x3E, 0xFF,
  0xFE, 0x01, 0xF7, 0xFF, 0xF8, 0x1F, 0x7F, 0x3F, 0xFB, 0xFB, 0xE0, 0x7F,
  0xFF, 0xDF, 0x00, 0xFF, 0xFC, 0xF0, 0x03, 0xFF, 0xE0, 0x80, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xC0,
};

const GFXglyph RobotoMono_SemiBold53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 8, 38, 32, 12, -38 },
  { 39, 15, 14, 32, 8, -40 },
  { 66, 29, 38, 32, 1, -38 },
  { 204, 26, 49, 32, 3, -44 },
  { 364, 30, 39, 32, 1, -38 },
  { 511, 30, 39, 32, 2, -38 },
  { 658, 5, 14, 32, 12, -40 },
  { 667, 14, 54, 32, 9, -42 },
  { 762, 15, 54, 32, 8, -42 },
  { 864, 26, 27, 32, 4, -38 },
  { 952, 26, 27, 32, 3, -31 },
  { 1040, 9, 16, 32, 9, -6 },
  { 1058, 21, 5, 32, 7, -19 },
  { 1072, 10, 9, 32, 11, -8 },
  { 1084, 21, 41, 32, 6, -38 },
  { 1192, 24, 39, 32, 4, -38 },
  { 1309, 16, 38, 32, 5, -38 },
  { 1385, 26, 38, 32, 2, -38 },
  { 1509, 26, 39, 32, 2, -38 },
  { 1636, 27, 38, 32, 2, -38 },
  { 1765, 25, 39, 32, 3, -38 },
  { 1887, 25, 39, 32, 3, -38 },
  { 2009, 26, 38, 32, 2, -38 },
  { 2133, 25, 39, 32, 3, -38 },
  { 2255, 25, 38, 32, 3, -38 },
  { 2374, 9, 31, 32, 12, -30 },
  { 2409, 10, 40, 32, 12, -30 },
  { 2459, 23, 25, 32, 4, -29 },
  { 2531, 24, 16, 32, 4, -24 },
  { 2579, 23, 25, 32, 4, -29 },
  { 2651, 24, 38, 32, 4, -38 },
  { 2765, 29, 37, 32, 1, -37 },
  { 2900, 30, 38, 32, 1, -38 },
  { 3043, 26, 38, 32, 4, -38 },
  { 3167, 27, 39, 32, 2, -38 },
  { 3299, 26, 38, 32, 3, -38 },
  { 3423, 25, 38, 32, 4, -38 },
  { 3542, 25, 38, 32, 4, -38 },
  { 3661, 27, 39, 32, 2, -38 },
  { 3793, 25, 38, 32, 3, -38 },
  { 3912, 22, 38, 32, 5, -38 },
  { 4017, 25, 39, 32, 3, -38 },
  { 4139, 28, 38, 32, 4, -38 },
  { 4272, 25, 38, 32, 4, -38 },
  { 4391, 26, 38, 32, 3, -38 },
  { 4515, 25, 38, 32, 3, -38 },
  { 4634, 28, 39, 32, 2, -38 },
  { 4771, 26, 38, 32, 4, -38 },
  { 4895, 29, 45, 32, 2, -38 },
  { 5059, 27, 38, 32, 4, -38 },
  { 5188, 28, 38, 32, 2, -38 },
  { 5321, 30, 38, 32, 1, -38 },
  { 5464, 25, 39, 32, 3, -38 },
  { 5586, 30, 38, 32, 1, -38 },
  { 5729, 30, 38, 32, 1, -38 },
  { 5872, 30, 38, 32, 1, -38 },
  { 6015, 30, 38, 32, 1, -38 },
  { 6158, 27, 38, 32, 2, -38 },
  { 6287, 12, 53, 32, 10, -44 },
  { 6367, 21, 41, 32, 6, -38 },
  { 6475, 12, 53, 32, 10, -44 },
  { 6555, 21, 20, 32, 6, -38 },
  { 6608, 24, 5, 32, 4, 0 },
  { 6623, 12, 7, 32, 11, -38 },
  { 6634, 25, 30, 32, 3, -29 },
  { 6728, 25, 41, 32, 4, -40 },
  { 6857, 25, 30, 32, 3, -29 },
  { 6951, 25, 41, 32, 3, -40 },
  { 7080, 26, 30, 32, 3, -29 },
  { 7178, 27, 41, 32, 3, -41 },
  { 7317, 25, 40, 32, 3, -29 },
  { 7442, 25, 40, 32, 4, -40 },
  { 7567, 23, 39, 32, 5, -39 },
  { 7680, 17, 50, 32, 6, -39 },
  { 7787, 27, 40, 32, 4, -40 },
  { 7922, 24, 40, 32, 5, -40 },
  { 8042, 28, 29, 32, 2, -29 },
  { 8144, 24, 29, 32, 4, -29 },
  { 8231, 26, 30, 32, 3, -29 },
  { 8329, 25, 40, 32, 4, -29 },
  { 8454, 25, 40, 32, 3, -29 },
  { 8579, 21, 29, 32, 8, -29 },
  { 8656, 26, 30, 32, 3, -29 },
  { 8754, 25, 36, 32, 3, -35 },
  { 8867, 24, 29, 32, 4, -28 },
  { 8954, 28, 28, 32, 2, -28 },
  { 9052, 30, 28, 32, 1, -28 },
  { 9157, 28, 28, 32, 2, -28 },
  { 9255, 30, 39, 32, 1, -28 },
  { 9402, 26, 28, 32, 3, -28 },
  { 9493, 17, 50, 32, 8, -41 },
  { 9600, 4, 49, 32, 14, -38 },
  { 9625, 17, 50, 32, 9, -41 },
  { 9732, 29, 11, 32, 1, -21 },
};

const GFXfont RobotoMono_SemiBold53pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold53pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOMONO_SEMIBOLD53PT7B_H_
