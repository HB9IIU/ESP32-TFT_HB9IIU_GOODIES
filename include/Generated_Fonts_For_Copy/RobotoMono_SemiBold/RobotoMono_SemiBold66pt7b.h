#ifndef _ROBOTOMONO_SEMIBOLD66PT7B_H_
#define _ROBOTOMONO_SEMIBOLD66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC1, 0xFC, 0xFF, 0xBF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE7, 0xF0,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x01, 0xFB,
  0xE0, 0x3F, 0x7C, 0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0xBE, 0x03, 0xF7,
  0xC0, 0x7E, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7C, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF8, 0x07,
  0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01,
  0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x80, 0x1F, 0x81, 0xF8, 0x06, 0x00, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xE0,
  0x3E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0x83, 0xF0,
  0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0x7E, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x3F,
  0x0F, 0x80, 0x0F, 0xC3, 0xF8, 0xFC, 0x00, 0x7F, 0xFF, 0x87, 0xC0, 0x01,
  0xFF, 0xFC, 0x7C, 0x00, 0x07, 0xFF, 0xC3, 0xE0, 0x00, 0x1F, 0xFC, 0x3E,
  0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0xFF, 0xE0,
  0x00, 0x1F, 0x0F, 0xFF, 0x80, 0x01, 0xF8, 0xFF, 0xFE, 0x00, 0x0F, 0x8F,
  0xFF, 0xF0, 0x00, 0xFC, 0x7F, 0x1F, 0xC0, 0x07, 0xC3, 0xF0, 0x7E, 0x00,
  0x7E, 0x3F, 0x03, 0xF0, 0x03, 0xE1, 0xF8, 0x0F, 0x80, 0x3F, 0x0F, 0xC0,
  0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0x00, 0x38,
  0x1F, 0x80, 0xF8, 0x00, 0x40, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0xFF, 0xF0,
  0x1F, 0xC3, 0xFF, 0xFF, 0x80, 0xFE, 0x3F, 0xF3, 0xFE, 0x07, 0xF1, 0xFF,
  0x0F, 0xF8, 0x7F, 0x9F, 0xF0, 0x7F, 0xE3, 0xFC, 0xFF, 0x81, 0xFF, 0x9F,
  0xC7, 0xF8, 0x07, 0xFD, 0xFE, 0x3F, 0xC0, 0x1F, 0xFF, 0xF1, 0xFE, 0x00,
  0xFF, 0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0xF8, 0x7F, 0x80, 0x0F, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xBF,
  0xF0, 0x1F, 0xFF, 0xF8, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF8, 0x00, 0x01, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x10, 0x20, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x01,
  0xF8, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x18, 0x01,
  0xF0, 0x03, 0x1F, 0x00, 0xF8, 0x07, 0x8F, 0xF0, 0x7C, 0x0F, 0xC7, 0xFE,
  0x3E, 0x3F, 0xF7, 0xFF, 0xDF, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x40, 0x01,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE7,
  0xF9, 0xFC, 0xFF, 0x3F, 0x8F, 0xC0, 0xE0, 0x08, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x03, 0xFC, 0x7F,
  0xE7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xFE, 0x3F,
  0xC0, 0x60, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0xFF, 0x1F, 0xE3, 0xFF, 0xFC, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC1,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x07, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x07, 0xFC,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x01, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0x8F, 0xF8,
  0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xF8, 0x3F,
  0xE0, 0x01, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0x80,
  0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xE0, 0x3F,
  0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC3,
  0xF0, 0x00, 0x7F, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xF0, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0xDF,
  0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x3F, 0xFE, 0x03,
  0xFC, 0xFF, 0xFF, 0x07, 0xFB, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x07,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0x80,
  0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xEF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF,
  0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xBF,
  0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xF0, 0x7F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x3F,
  0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFE, 0x7F, 0x80, 0x7F, 0xF8, 0xFE, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x04, 0x03, 0xF8, 0x7F,
  0xCF, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x3F, 0x87, 0xFC, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFE, 0x7F, 0xE3, 0xFC, 0x06, 0x00, 0x03, 0x00, 0x3F, 0x81, 0xFF,
  0x0F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xCF, 0xFE, 0x3F, 0xF8, 0x7F,
  0xC0, 0xFE, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x00, 0x70, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0x1F, 0xFE, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x07, 0xC0,
  0xF8, 0x1F, 0x01, 0xFF, 0x83, 0xC1, 0xF8, 0x1F, 0xFE, 0x1F, 0x0F, 0x81,
  0xFF, 0xF8, 0xF8, 0x7C, 0x1F, 0xFF, 0x83, 0xC7, 0xC1, 0xFC, 0x3C, 0x1E,
  0x3E, 0x0F, 0xC1, 0xE0, 0xF1, 0xF0, 0xFC, 0x1F, 0x07, 0xDF, 0x07, 0xC0,
  0xF8, 0x3E, 0xF8, 0x3E, 0x07, 0xC1, 0xF7, 0xC3, 0xF0, 0x3E, 0x0F, 0xBE,
  0x1F, 0x01, 0xF0, 0x7D, 0xF0, 0xF8, 0x0F, 0x83, 0xEF, 0x87, 0xC0, 0x7C,
  0x1E, 0x7C, 0x3E, 0x03, 0xE0, 0xF3, 0xE1, 0xF0, 0x1F, 0x07, 0x9F, 0x0F,
  0x80, 0xF0, 0x3C, 0xF8, 0x7C, 0x07, 0x83, 0xE7, 0xC3, 0xE0, 0x3C, 0x1F,
  0x3E, 0x1F, 0x03, 0xE0, 0xF1, 0xF0, 0xFC, 0x1F, 0x0F, 0x8F, 0x87, 0xE1,
  0xF8, 0x78, 0x7C, 0x3F, 0xFF, 0xFF, 0xC3, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0x83, 0xFE, 0x7F, 0xE0, 0x7C, 0x1F, 0xE3, 0xFE, 0x03, 0xF0, 0x3E, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xE0,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8,
  0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFE,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8,
  0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFF,
  0x87, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xC0,
  0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFB, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFB, 0xFE,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xE0,
  0x00, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80,
  0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0,
  0x0F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0xCF,
  0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x87,
  0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x0F,
  0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF9, 0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x8F,
  0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x07,
  0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0x7F, 0xFF, 0xFC, 0x3F,
  0x7F, 0xFF, 0xFC, 0x7F, 0x7F, 0xFF, 0xFE, 0x7E, 0x7F, 0xFF, 0x7E, 0x7E,
  0xFF, 0xFF, 0x7E, 0x7E, 0xFF, 0xFF, 0x7E, 0xFC, 0xFF, 0xFF, 0x3F, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFC, 0xFF, 0xFF, 0x3F, 0xF8, 0xFF, 0xFF, 0x1F, 0xF8,
  0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0x1F, 0xF0,
  0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xE0,
  0xFF, 0xFF, 0x07, 0xE0, 0xFF, 0xFF, 0x07, 0xE0, 0xFF, 0xFF, 0x07, 0xC0,
  0xFF, 0xFF, 0x07, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0xF9,
  0xFC, 0x1F, 0xFF, 0xF3, 0xF8, 0x3F, 0xFF, 0xE3, 0xF8, 0x7F, 0xFF, 0xC7,
  0xF0, 0xFF, 0xFF, 0x87, 0xF1, 0xFF, 0xFF, 0x0F, 0xE3, 0xFF, 0xFE, 0x1F,
  0xE7, 0xFF, 0xFC, 0x1F, 0xCF, 0xFF, 0xF8, 0x3F, 0x9F, 0xFF, 0xF0, 0x3F,
  0xBF, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x0F,
  0xF9, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF8,
  0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE3,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0x80,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0xC7,
  0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x03,
  0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x3F, 0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x01,
  0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF8, 0x01,
  0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x07, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF8,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0,
  0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE,
  0x07, 0xF9, 0xFE, 0x07, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xE0, 0x7F, 0x9F,
  0xE0, 0x7F, 0x81, 0xFE, 0x7F, 0x83, 0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0xF8,
  0x1F, 0xC3, 0xF8, 0x3F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xC1, 0xFC, 0x3F,
  0x83, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xF0,
  0xFF, 0x0F, 0xF1, 0xFF, 0xC3, 0xFC, 0x3F, 0xC7, 0xFF, 0x0F, 0xF0, 0xFF,
  0x1F, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0xF8, 0xFE, 0x07, 0xF1, 0xFF, 0xE3,
  0xF8, 0x1F, 0xC7, 0xDF, 0x8F, 0xE0, 0x7F, 0x3F, 0x7E, 0x7F, 0x81, 0xFC,
  0xFC, 0xF9, 0xFE, 0x07, 0xFB, 0xF3, 0xF7, 0xF8, 0x1F, 0xEF, 0xCF, 0xDF,
  0xC0, 0x3F, 0xBF, 0x3F, 0x7F, 0x00, 0xFE, 0xF8, 0xFD, 0xFC, 0x03, 0xFB,
  0xE3, 0xF7, 0xF0, 0x0F, 0xFF, 0x87, 0xDF, 0xC0, 0x3F, 0xFE, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF,
  0x87, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F,
  0xEF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0xFD, 0xFF,
  0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0x80,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x7E, 0x00,
  0x0F, 0xCF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC3,
  0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xF0, 0x1F, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x0F,
  0xF9, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xEF, 0xF8,
  0x01, 0xFF, 0xDF, 0xFC, 0x0F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xF7, 0xFC, 0x3F, 0xFF,
  0xCF, 0xF8, 0x1F, 0xFE, 0x0F, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x30, 0x00, 0x7F, 0x87, 0xFE, 0x00,
  0xFF, 0x3F, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0x3F,
  0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFD, 0xFE,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07,
  0xFD, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x7F, 0xE7, 0xFF, 0xC3, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xBF, 0xFF, 0xE0, 0xFF, 0x3F, 0xFF, 0x01, 0xFC, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x03, 0xFF,
  0x87, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0x00, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0x01, 0xFF, 0xF3, 0xFE, 0x0F, 0xFF,
  0xF7, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x03,
  0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xBF,
  0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0x80, 0x3F, 0xF9, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0xFF, 0x03, 0xFF,
  0xF1, 0xFE, 0x01, 0xFF, 0xC3, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0,
  0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x7F, 0xE0,
  0x00, 0x78, 0x3F, 0xF8, 0x00, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xFF, 0xC3, 0xFC, 0x07, 0xFF, 0xE7, 0xF8, 0x3F, 0xFF, 0xEF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFE, 0x1F, 0xFF, 0x3F, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFD,
  0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00,
  0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0x00,
  0x7F, 0xE7, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xE7,
  0xF8, 0x07, 0xFF, 0x0F, 0xF0, 0x00, 0x60, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x82, 0x00, 0x01, 0xFE, 0x06, 0x00, 0x07, 0xFC,
  0x1F, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x06, 0x00, 0x3F, 0xC1, 0xFF, 0xC0, 0xFF,
  0x0F, 0xFF, 0x83, 0xFC, 0xFF, 0xFF, 0x8F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF1, 0xFF, 0xEF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x0F, 0xFC,
  0x7F, 0x80, 0x0F, 0xFC, 0x3F, 0xC0, 0x0F, 0xFC, 0x1F, 0xE0, 0x0F, 0xFC,
  0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x0F, 0xFC,
  0x01, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0x8F, 0xFE,
  0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x0F, 0xF7, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xE0, 0x07, 0xFE,
  0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF8, 0x1F,
  0xE0, 0x07, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0xE3,
  0xFC, 0x00, 0x3F, 0xF1, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x03, 0xFF,
  0x7F, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x04, 0x00, 0x20, 0x3F, 0x8F, 0xF0, 0xFF, 0x0F, 0xE7, 0xFE,
  0x7F, 0xE3, 0xFB, 0xFF, 0xBF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0xF3, 0xFF, 0xFF,
  0x07, 0xF8, 0x3F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF,
  0xF8, 0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xF0,
  0x3F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF8, 0x1F,
  0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFF,
  0x81, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF,
  0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x03,
  0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x81, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0x00,
  0x20, 0x03, 0xF8, 0x1F, 0xFC, 0x0F, 0xE1, 0xFF, 0xFC, 0x3F, 0xCF, 0xFF,
  0xF8, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x01, 0xFE, 0x1F, 0xF8, 0x03, 0xFC, 0xFF, 0xFC, 0x07, 0xFB, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F,
  0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xCF, 0xFC,
  0x01, 0xFF, 0x9F, 0xFE, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFE, 0xFF, 0xFF, 0x03, 0xFC, 0xFF,
  0xFC, 0x07, 0xF8, 0x7F, 0xF0, 0x0F, 0xF0, 0x0C, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0xFF, 0xC3, 0xFC, 0x0F, 0xFF, 0xE7, 0xF8, 0x3F, 0xFF, 0xEF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFE, 0x1F, 0xFF, 0x3F, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0xFF,
  0xE7, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xEF, 0xF8,
  0x07, 0xFF, 0x1F, 0xF0, 0x00, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x3F, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0xFF, 0x3F, 0xFF, 0xBF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFE, 0x00, 0x2F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F,
  0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0x3F, 0xFF, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x7F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF,
  0xF3, 0xFC, 0x1F, 0xFF, 0x8F, 0xF0, 0x3F, 0xF8, 0x3F, 0xC0, 0x0F, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x01,
  0xFE, 0xFE, 0x03, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xC0, 0x7F, 0x3F, 0x80,
  0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF8, 0x1F, 0xCF, 0xF0, 0x7F, 0xC0, 0xFE,
  0x3F, 0x83, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF,
  0x83, 0xF8, 0x7F, 0x07, 0xFE, 0x1F, 0xC3, 0xF8, 0x7D, 0xF0, 0xFE, 0x1F,
  0xC3, 0xEF, 0x87, 0xF0, 0x7F, 0x1F, 0x7C, 0x3F, 0x03, 0xF8, 0xFB, 0xE3,
  0xF8, 0x1F, 0xC7, 0xDF, 0x9F, 0xC0, 0xFE, 0x7C, 0x7C, 0xFE, 0x07, 0xF3,
  0xE3, 0xE7, 0xF0, 0x1F, 0x9F, 0x1F, 0x3F, 0x80, 0xFC, 0xF8, 0xF9, 0xF8,
  0x07, 0xF7, 0xC7, 0xEF, 0xC0, 0x3F, 0xFC, 0x1F, 0x7E, 0x01, 0xFF, 0xE0,
  0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xDF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF4,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xD0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x38, 0x1F, 0xFF, 0xC0, 0x03,
  0xF3, 0xFF, 0xFE, 0x00, 0x3F, 0x3F, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xFF,
  0xC0, 0x7F, 0x7F, 0xFF, 0xFF, 0x1F, 0xEF, 0xF0, 0x3F, 0xFF, 0xFE, 0xFE,
  0x01, 0xFF, 0xFF, 0xEF, 0xC0, 0x07, 0xFF, 0xFC, 0xFC, 0x00, 0x3F, 0xFF,
  0x81, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0x00,
};

const GFXglyph RobotoMono_SemiBold66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 10, 47, 40, 15, -47 },
  { 60, 19, 17, 40, 10, -50 },
  { 101, 36, 47, 40, 1, -47 },
  { 313, 32, 61, 40, 4, -54 },
  { 557, 37, 49, 40, 1, -48 },
  { 784, 37, 49, 40, 3, -48 },
  { 1011, 7, 18, 40, 15, -50 },
  { 1027, 18, 67, 40, 11, -52 },
  { 1178, 18, 67, 40, 10, -52 },
  { 1329, 33, 33, 40, 5, -47 },
  { 1466, 32, 34, 40, 3, -39 },
  { 1602, 10, 21, 40, 12, -8 },
  { 1629, 26, 7, 40, 9, -24 },
  { 1652, 12, 12, 40, 14, -11 },
  { 1670, 26, 51, 40, 7, -47 },
  { 1836, 30, 49, 40, 5, -48 },
  { 2020, 20, 47, 40, 6, -47 },
  { 2138, 33, 48, 40, 2, -48 },
  { 2336, 32, 49, 40, 3, -48 },
  { 2532, 34, 47, 40, 2, -47 },
  { 2732, 31, 48, 40, 4, -47 },
  { 2918, 31, 48, 40, 4, -47 },
  { 3104, 32, 47, 40, 3, -47 },
  { 3292, 31, 49, 40, 4, -48 },
  { 3482, 31, 48, 40, 3, -48 },
  { 3668, 12, 39, 40, 15, -38 },
  { 3727, 14, 51, 40, 14, -38 },
  { 3817, 28, 31, 40, 5, -36 },
  { 3926, 30, 20, 40, 5, -30 },
  { 4001, 29, 31, 40, 5, -36 },
  { 4114, 30, 48, 40, 5, -48 },
  { 4294, 37, 47, 40, 1, -47 },
  { 4512, 38, 47, 40, 1, -47 },
  { 4736, 34, 47, 40, 4, -47 },
  { 4936, 34, 49, 40, 3, -48 },
  { 5145, 33, 47, 40, 4, -47 },
  { 5339, 31, 47, 40, 5, -47 },
  { 5522, 31, 47, 40, 5, -47 },
  { 5705, 33, 49, 40, 3, -48 },
  { 5908, 31, 47, 40, 4, -47 },
  { 6091, 27, 47, 40, 6, -47 },
  { 6250, 32, 48, 40, 3, -47 },
  { 6442, 36, 47, 40, 4, -47 },
  { 6654, 31, 47, 40, 5, -47 },
  { 6837, 32, 47, 40, 4, -47 },
  { 7025, 31, 47, 40, 4, -47 },
  { 7208, 34, 49, 40, 3, -48 },
  { 7417, 32, 47, 40, 5, -47 },
  { 7605, 36, 56, 40, 3, -48 },
  { 7857, 33, 47, 40, 5, -47 },
  { 8051, 34, 49, 40, 3, -48 },
  { 8260, 37, 47, 40, 1, -47 },
  { 8478, 31, 48, 40, 4, -47 },
  { 8664, 37, 47, 40, 1, -47 },
  { 8882, 38, 47, 40, 1, -47 },
  { 9106, 38, 47, 40, 1, -47 },
  { 9330, 38, 47, 40, 1, -47 },
  { 9554, 34, 47, 40, 3, -47 },
  { 9754, 14, 65, 40, 13, -54 },
  { 9868, 25, 51, 40, 8, -47 },
  { 10028, 14, 65, 40, 13, -54 },
  { 10142, 27, 25, 40, 7, -47 },
  { 10227, 29, 7, 40, 5, 0 },
  { 10253, 15, 9, 40, 13, -48 },
  { 10270, 31, 37, 40, 4, -36 },
  { 10414, 31, 51, 40, 5, -50 },
  { 10612, 31, 37, 40, 4, -36 },
  { 10756, 31, 51, 40, 4, -50 },
  { 10954, 32, 37, 40, 4, -36 },
  { 11102, 33, 51, 40, 4, -51 },
  { 11313, 31, 50, 40, 4, -36 },
  { 11507, 30, 50, 40, 5, -50 },
  { 11695, 28, 48, 40, 7, -48 },
  { 11863, 21, 62, 40, 7, -48 },
  { 12026, 33, 50, 40, 5, -50 },
  { 12233, 30, 50, 40, 6, -50 },
  { 12421, 34, 36, 40, 3, -36 },
  { 12574, 30, 36, 40, 5, -36 },
  { 12709, 33, 37, 40, 3, -36 },
  { 12862, 31, 49, 40, 5, -36 },
  { 13052, 31, 49, 40, 4, -36 },
  { 13242, 26, 36, 40, 10, -36 },
  { 13359, 32, 37, 40, 4, -36 },
  { 13507, 31, 44, 40, 4, -43 },
  { 13678, 30, 36, 40, 5, -35 },
  { 13813, 35, 35, 40, 2, -35 },
  { 13967, 37, 35, 40, 1, -35 },
  { 14129, 35, 35, 40, 3, -35 },
  { 14283, 37, 49, 40, 2, -35 },
  { 14510, 32, 35, 40, 4, -35 },
  { 14650, 22, 63, 40, 10, -51 },
  { 14824, 6, 60, 40, 17, -47 },
  { 14869, 21, 63, 40, 11, -51 },
  { 15035, 36, 14, 40, 1, -26 },
};

const GFXfont RobotoMono_SemiBold66pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold66pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _ROBOTOMONO_SEMIBOLD66PT7B_H_
