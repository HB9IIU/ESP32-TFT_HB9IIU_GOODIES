#ifndef _ROBOTOMONO_SEMIBOLD69PT7B_H_
#define _ROBOTOMONO_SEMIBOLD69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold69pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xF9, 0xFF,
  0x3F, 0xFF, 0xFE, 0xFF, 0xDF, 0xF3, 0xFE, 0x3F, 0x80, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F,
  0xE0, 0x01, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFF, 0xDF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x0C, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xE0,
  0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x1F,
  0x00, 0x3F, 0x81, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0xF8, 0x00, 0x7F,
  0xBF, 0xC3, 0xF0, 0x00, 0x7F, 0xFF, 0x8F, 0xC0, 0x00, 0xFF, 0xFE, 0x1F,
  0x00, 0x00, 0xFF, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0xE0, 0xF8, 0x00, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0xF8,
  0x00, 0x01, 0xF0, 0xFF, 0xF8, 0x00, 0x07, 0xE3, 0xFF, 0xF8, 0x00, 0x0F,
  0x8F, 0xFF, 0xF8, 0x00, 0x3F, 0x1F, 0xEF, 0xF0, 0x00, 0x7C, 0x3F, 0x07,
  0xF0, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x00, 0x60, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x83, 0xFF,
  0xFE, 0x00, 0xFE, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0xDF, 0xF0, 0x1F,
  0xE3, 0xFE, 0x7F, 0xE0, 0x7F, 0x9F, 0xF8, 0xFF, 0xC1, 0xFE, 0x7F, 0xC1,
  0xFF, 0x87, 0xF3, 0xFE, 0x03, 0xFF, 0x3F, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF,
  0x3F, 0xE0, 0x1F, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xE3, 0xFE, 0x00,
  0x7F, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xF0,
  0xFF, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x08, 0x40,
  0x00, 0x18, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x0C, 0x00, 0x7C, 0x00, 0x43, 0xC0, 0x1F,
  0x00, 0x78, 0xFC, 0x07, 0xC0, 0x7E, 0x7F, 0xE1, 0xF0, 0xFF, 0x9F, 0xFE,
  0x7C, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x7F, 0x8F, 0xF1, 0xFC, 0x7F,
  0x8F, 0xE3, 0xF8, 0x1E, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x83, 0xFC, 0x7F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x3F, 0xC0,
  0x60, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8,
  0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE,
  0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFE,
  0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x87, 0xF9, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE,
  0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xFC, 0x03,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF0, 0x07,
  0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0xC3,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFC,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0x80,
  0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF3,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xE0, 0x03, 0xFF, 0x80,
  0x20, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x03,
  0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x30,
  0x00, 0x3F, 0xC3, 0xFF, 0x80, 0x1F, 0xE3, 0xFF, 0xF0, 0x1F, 0xF7, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0,
  0x03, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFE,
  0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x8F, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE,
  0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x7F,
  0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF,
  0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC,
  0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0,
  0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80,
  0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0,
  0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFD, 0xFE, 0x01, 0xFF, 0xF1, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0x7F, 0xF1, 0xFF, 0x87, 0xF8, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x1F, 0xF1, 0xFF, 0xCF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF7, 0xFF, 0x1F, 0xF8, 0x7F, 0x80, 0x60, 0x07, 0xC0, 0x7F, 0xC3, 0xFF,
  0x8F, 0xFE, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0x7F,
  0xE0, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x03, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x0F, 0xF8, 0x3E, 0x0F, 0x80, 0xFF, 0xF0, 0xF8, 0x7E, 0x07,
  0xFF, 0xE1, 0xF1, 0xF0, 0x3F, 0xFF, 0x87, 0xC7, 0xC1, 0xFF, 0xFE, 0x1F,
  0x3F, 0x07, 0xE0, 0xF8, 0x7C, 0xF8, 0x3F, 0x03, 0xE1, 0xF3, 0xE0, 0xFC,
  0x0F, 0x07, 0xDF, 0x83, 0xE0, 0x7C, 0x0F, 0x7C, 0x1F, 0x81, 0xF0, 0x3D,
  0xF0, 0x7C, 0x07, 0xC0, 0xF7, 0xC1, 0xF0, 0x1F, 0x03, 0xDF, 0x07, 0xC0,
  0x7C, 0x1F, 0x7C, 0x3F, 0x01, 0xF0, 0x7D, 0xF0, 0xFC, 0x07, 0xC1, 0xF7,
  0xC3, 0xF0, 0x1F, 0x07, 0xDF, 0x0F, 0xC0, 0x7C, 0x1F, 0x7C, 0x3F, 0x01,
  0xF0, 0x79, 0xF0, 0xFC, 0x07, 0xC1, 0xE7, 0xC3, 0xF0, 0x3E, 0x0F, 0x9F,
  0x0F, 0xC0, 0xF8, 0x3E, 0x7C, 0x1F, 0x87, 0xF1, 0xF1, 0xF0, 0x7F, 0xFF,
  0xCF, 0xC7, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0x83, 0xFF, 0xFF, 0xF0, 0x3E,
  0x07, 0xFC, 0xFF, 0xC0, 0xFC, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x04, 0x00,
  0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x01, 0xFF, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFC, 0x00, 0x7F, 0xFC, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xC0, 0x00, 0x7F,
  0xEF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00,
  0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x7F, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xC0, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xBF, 0xC0, 0x03, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xFC, 0x1F, 0xFC,
  0x01, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xE0, 0x03,
  0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x1F,
  0xFC, 0x3F, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0xFF, 0xFC, 0x1F, 0xFC, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x07, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x07, 0xFE,
  0x7F, 0xC0, 0x07, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFC,
  0x00, 0x07, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x03, 0xFF, 0x83, 0xFE, 0x00,
  0x1F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFC, 0x07,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x07, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFD, 0xFF, 0xC0,
  0x03, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF,
  0xE1, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xC0,
  0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFE,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xBF, 0xFF, 0xDF, 0x87, 0xEF, 0xFF, 0xF7, 0xE3, 0xFB,
  0xFF, 0xFD, 0xFC, 0xFC, 0xFF, 0xFF, 0x7F, 0x3F, 0x3F, 0xFF, 0xCF, 0xDF,
  0xCF, 0xFF, 0xF3, 0xF7, 0xF3, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xF0, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0x3F,
  0xFF, 0xE1, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xFE, 0x0F, 0x81,
  0xFF, 0xFF, 0x83, 0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xF3, 0xF8, 0x1F,
  0xFF, 0xF9, 0xFC, 0x0F, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0x83,
  0xFF, 0xFF, 0x1F, 0xE1, 0xFF, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0xC3, 0xFC,
  0x7F, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0x9F, 0xFF, 0xF8, 0x1F,
  0xCF, 0xFF, 0xFC, 0x0F, 0xE7, 0xFF, 0xFE, 0x03, 0xFB, 0xFF, 0xFF, 0x01,
  0xFD, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0xBF,
  0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x7F, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03,
  0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xF0,
  0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF9,
  0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF,
  0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x07, 0xFC,
  0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0xDF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0xFE, 0x01, 0xFE,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0x81, 0xFF, 0x03,
  0xFC, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x3F,
  0xC1, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF,
  0x83, 0xFC, 0x3F, 0xC3, 0xFF, 0x83, 0xFC, 0x3F, 0xC3, 0xFF, 0x83, 0xFC,
  0x3F, 0xC3, 0xFF, 0x83, 0xF8, 0x3F, 0xC3, 0xFF, 0xC7, 0xF8, 0x1F, 0xC3,
  0xFF, 0xC7, 0xF8, 0x1F, 0xC3, 0xFF, 0xC7, 0xF8, 0x1F, 0xE3, 0xFF, 0xC7,
  0xF8, 0x1F, 0xE7, 0xEF, 0xC7, 0xF8, 0x1F, 0xE7, 0xEF, 0xC7, 0xF8, 0x1F,
  0xE7, 0xEF, 0xC7, 0xF0, 0x1F, 0xE7, 0xE7, 0xE7, 0xF0, 0x1F, 0xE7, 0xE7,
  0xE7, 0xF0, 0x0F, 0xE7, 0xE7, 0xEF, 0xF0, 0x0F, 0xEF, 0xC7, 0xEF, 0xF0,
  0x0F, 0xFF, 0xC7, 0xEF, 0xF0, 0x0F, 0xFF, 0xC7, 0xEF, 0xF0, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF, 0xC3, 0xFF,
  0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x07,
  0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFF, 0x00,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00,
  0x7F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x3F,
  0x9F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0xFC,
  0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xE3, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0x3F, 0xE0, 0x1F, 0xFE, 0x0F, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x8F, 0xFF, 0x80,
  0xFF, 0xBF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xFC,
  0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFE,
  0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xF0, 0xFF, 0x3F, 0xFF, 0xE0,
  0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFE,
  0x3F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF,
  0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF8, 0x07, 0xFE,
  0x1F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0xFD, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFC, 0x1F, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF,
  0x3F, 0xE0, 0x03, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0x7F, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0xF0, 0xFF,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x81, 0xFF,
  0x80, 0x00, 0x70, 0x3F, 0xF0, 0x00, 0x3E, 0x07, 0xFF, 0x00, 0x3F, 0xC1,
  0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x3F, 0xC0, 0xFF,
  0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0x1F, 0xFF, 0x3F,
  0xF0, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x3F, 0xF9, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0x9F, 0xF0, 0x07, 0xFF, 0x0F, 0xF8, 0x00,
  0x38, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x02,
  0x00, 0x01, 0xFF, 0x03, 0x00, 0x01, 0xFF, 0x83, 0xE0, 0x01, 0xFF, 0x81,
  0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF,
  0xF8, 0xFF, 0xBF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x04, 0xFF, 0x80, 0x07,
  0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x80,
  0x1F, 0xF0, 0xFF, 0xE0, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xCF, 0xFE,
  0x00, 0x0F, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF,
  0x87, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0xF3, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0,
  0xFE, 0x0F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFE, 0x7F, 0xF3, 0xFF, 0x8F, 0xEF,
  0xFF, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xE3, 0xFE, 0xFF, 0x07, 0xFC,
  0x1F, 0xEF, 0xF0, 0x3F, 0x81, 0xFE, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0x80, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0xFF,
  0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0x03, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0x80, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0xFF,
  0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0x03, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0x80, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0xFF,
  0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0x03, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0x80, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0,
  0x07, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x0F,
  0xFF, 0x80, 0xFF, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8,
  0x3F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xBF,
  0xFF, 0xE0, 0xFF, 0x9F, 0xFF, 0x80, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0x80,
  0x78, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC,
  0x0F, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xC0,
  0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0,
  0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xF0,
  0x03, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFD, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0x00, 0x07,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x07, 0xFC, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x08, 0x00, 0xFF, 0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0,
  0x07, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF,
  0xF8, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xFD, 0xFC, 0x03, 0xF8, 0x07, 0xF3, 0xFC,
  0x07, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xE0,
  0x7F, 0x9F, 0xE0, 0x7F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x81, 0xFC, 0x3F,
  0x81, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0xFC, 0x3F, 0xC3, 0xFC, 0x3E, 0xF8, 0x7F, 0x03,
  0xF8, 0x7D, 0xF0, 0xFE, 0x07, 0xF0, 0xFB, 0xE1, 0xFC, 0x0F, 0xE3, 0xF7,
  0xE3, 0xF8, 0x1F, 0xC7, 0xCF, 0xC7, 0xF0, 0x3F, 0x8F, 0x8F, 0x8F, 0xE0,
  0x3F, 0x9F, 0x1F, 0x3F, 0x80, 0x7F, 0x3E, 0x3E, 0x7F, 0x00, 0xFE, 0xFC,
  0x7E, 0xFE, 0x01, 0xFD, 0xF0, 0xFD, 0xFC, 0x03, 0xFB, 0xE0, 0xFB, 0xF8,
  0x07, 0xF7, 0xC1, 0xF7, 0xE0, 0x07, 0xEF, 0x83, 0xEF, 0xC0, 0x0F, 0xFF,
  0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0E, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0x3F, 0xFF, 0xF0, 0x01, 0xFC, 0xFF, 0xFF, 0xE0,
  0x07, 0xF7, 0xFF, 0xFF, 0xE0, 0x3F, 0x9F, 0xFF, 0xFF, 0xE3, 0xFE, 0x7F,
  0x03, 0xFF, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xFF, 0xCF, 0xC0, 0x07, 0xFF,
  0xFF, 0x3F, 0x00, 0x0F, 0xFF, 0xF8, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
};

const GFXglyph RobotoMono_SemiBold69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 11, 49, 41, 15, -49 },
  { 69, 20, 18, 41, 10, -52 },
  { 114, 37, 49, 41, 2, -49 },
  { 341, 33, 64, 41, 5, -57 },
  { 605, 39, 51, 41, 1, -50 },
  { 854, 38, 51, 41, 3, -50 },
  { 1097, 6, 18, 41, 16, -52 },
  { 1111, 18, 71, 41, 12, -55 },
  { 1271, 18, 71, 41, 11, -55 },
  { 1431, 34, 34, 41, 5, -49 },
  { 1576, 34, 36, 41, 3, -41 },
  { 1729, 11, 21, 41, 12, -8 },
  { 1758, 28, 7, 41, 9, -25 },
  { 1783, 12, 12, 41, 15, -11 },
  { 1801, 27, 53, 41, 8, -49 },
  { 1980, 32, 51, 41, 5, -50 },
  { 2184, 21, 49, 41, 6, -49 },
  { 2313, 35, 50, 41, 2, -50 },
  { 2532, 33, 51, 41, 3, -50 },
  { 2743, 36, 49, 41, 2, -49 },
  { 2964, 33, 50, 41, 4, -49 },
  { 3171, 33, 50, 41, 4, -49 },
  { 3378, 34, 49, 41, 3, -49 },
  { 3587, 33, 51, 41, 4, -50 },
  { 3798, 32, 50, 41, 4, -50 },
  { 3998, 13, 40, 41, 15, -39 },
  { 4063, 14, 52, 41, 15, -39 },
  { 4154, 30, 32, 41, 5, -37 },
  { 4274, 32, 22, 41, 5, -32 },
  { 4362, 30, 32, 41, 6, -37 },
  { 4482, 31, 50, 41, 6, -50 },
  { 4676, 38, 49, 41, 1, -49 },
  { 4909, 40, 49, 41, 1, -49 },
  { 5154, 34, 49, 41, 5, -49 },
  { 5363, 35, 51, 41, 3, -50 },
  { 5587, 34, 49, 41, 4, -49 },
  { 5796, 33, 49, 41, 5, -49 },
  { 5999, 33, 49, 41, 5, -49 },
  { 6202, 35, 51, 41, 3, -50 },
  { 6426, 33, 49, 41, 4, -49 },
  { 6629, 29, 49, 41, 6, -49 },
  { 6807, 33, 50, 41, 4, -49 },
  { 7014, 37, 49, 41, 5, -49 },
  { 7241, 32, 49, 41, 5, -49 },
  { 7437, 34, 49, 41, 4, -49 },
  { 7646, 33, 49, 41, 4, -49 },
  { 7849, 35, 51, 41, 3, -50 },
  { 8073, 34, 49, 41, 5, -49 },
  { 8282, 38, 59, 41, 3, -50 },
  { 8563, 35, 49, 41, 5, -49 },
  { 8778, 36, 51, 41, 3, -50 },
  { 9008, 39, 49, 41, 1, -49 },
  { 9247, 33, 50, 41, 4, -49 },
  { 9454, 39, 49, 41, 1, -49 },
  { 9693, 40, 49, 41, 1, -49 },
  { 9938, 40, 49, 41, 1, -49 },
  { 10183, 40, 49, 41, 1, -49 },
  { 10428, 35, 49, 41, 3, -49 },
  { 10643, 14, 68, 41, 14, -57 },
  { 10762, 27, 53, 41, 8, -49 },
  { 10941, 14, 68, 41, 14, -57 },
  { 11060, 28, 26, 41, 7, -49 },
  { 11151, 31, 7, 41, 5, 0 },
  { 11179, 16, 10, 41, 14, -50 },
  { 11199, 33, 38, 41, 4, -37 },
  { 11356, 32, 53, 41, 5, -52 },
  { 11568, 32, 38, 41, 4, -37 },
  { 11720, 32, 53, 41, 4, -52 },
  { 11932, 34, 38, 41, 4, -37 },
  { 12094, 35, 53, 41, 4, -53 },
  { 12326, 33, 51, 41, 4, -37 },
  { 12537, 32, 52, 41, 5, -52 },
  { 12745, 30, 51, 41, 7, -51 },
  { 12937, 23, 66, 41, 7, -51 },
  { 13127, 35, 52, 41, 5, -52 },
  { 13355, 31, 52, 41, 7, -52 },
  { 13557, 36, 37, 41, 3, -37 },
  { 13724, 32, 37, 41, 5, -37 },
  { 13872, 34, 38, 41, 4, -37 },
  { 14034, 32, 51, 41, 5, -37 },
  { 14238, 32, 51, 41, 4, -37 },
  { 14442, 27, 37, 41, 10, -37 },
  { 14567, 33, 38, 41, 4, -37 },
  { 14724, 33, 46, 41, 4, -45 },
  { 14914, 32, 37, 41, 5, -36 },
  { 15062, 36, 36, 41, 3, -36 },
  { 15224, 39, 36, 41, 1, -36 },
  { 15400, 37, 36, 41, 3, -36 },
  { 15567, 39, 51, 41, 2, -36 },
  { 15816, 34, 36, 41, 4, -36 },
  { 15969, 22, 66, 41, 11, -54 },
  { 16151, 6, 63, 41, 18, -49 },
  { 16199, 23, 66, 41, 11, -54 },
  { 16389, 38, 15, 41, 1, -28 },
};

const GFXfont RobotoMono_SemiBold69pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold69pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _ROBOTOMONO_SEMIBOLD69PT7B_H_
