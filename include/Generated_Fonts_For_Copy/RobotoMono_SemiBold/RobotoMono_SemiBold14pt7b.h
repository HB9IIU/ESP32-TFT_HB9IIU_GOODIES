#ifndef _ROBOTOMONO_SEMIBOLD14PT7B_H_
#define _ROBOTOMONO_SEMIBOLD14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0x99, 0x99, 0x12, 0x12, 0x16, 0x7F, 0x34, 0x24,
  0xFE, 0x2C, 0x28, 0x68, 0x10, 0x21, 0xF3, 0x6C, 0x78, 0x1C, 0x0E, 0x07,
  0x8F, 0x3B, 0xE1, 0x00, 0x70, 0xD6, 0x94, 0x74, 0x08, 0x18, 0x17, 0x2D,
  0x2D, 0x07, 0x78, 0xD3, 0x22, 0xC7, 0x1E, 0x77, 0xCF, 0xCD, 0xFC, 0xFA,
  0x12, 0x64, 0x4C, 0xCC, 0xC4, 0x46, 0x21, 0x84, 0x62, 0x33, 0x33, 0x33,
  0x26, 0x48, 0x10, 0x23, 0x5B, 0xE3, 0x8D, 0x91, 0x00, 0x30, 0x63, 0xFF,
  0xF3, 0x06, 0x0C, 0x00, 0x6D, 0xAC, 0xF8, 0xF8, 0x18, 0x8C, 0x62, 0x31,
  0x88, 0xC6, 0x20, 0x7B, 0xBC, 0x73, 0xDF, 0x9C, 0x71, 0xCD, 0xE0, 0x1F,
  0xF6, 0x31, 0x8C, 0x63, 0x18, 0xC0, 0x3C, 0xCD, 0x1C, 0x30, 0x61, 0x86,
  0x18, 0x60, 0xFC, 0x7B, 0x3C, 0xC3, 0x38, 0xF0, 0xE1, 0xCD, 0xE0, 0x0C,
  0x0C, 0x1C, 0x34, 0x24, 0x64, 0x7F, 0xFF, 0x04, 0x04, 0x7C, 0xFB, 0x06,
  0x8F, 0xC1, 0x81, 0xE2, 0xCC, 0xF0, 0x39, 0xCC, 0x36, 0xFF, 0x3C, 0x71,
  0xCD, 0xE0, 0xFF, 0xF0, 0xC2, 0x18, 0x63, 0x0C, 0x61, 0x80, 0x7B, 0x3C,
  0xF3, 0x79, 0xFC, 0x71, 0xCD, 0xE0, 0x7B, 0x3C, 0xF1, 0xCF, 0xF7, 0xC3,
  0x39, 0xC0, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x12, 0x5A, 0x00, 0x04, 0x37,
  0xB0, 0xF0, 0x70, 0x40, 0xFE, 0x03, 0xFF, 0xF0, 0x83, 0x87, 0x83, 0x3F,
  0xC8, 0x00, 0x7F, 0xBC, 0x43, 0x0C, 0x63, 0x00, 0x30, 0xC0, 0x1C, 0x22,
  0x4D, 0x55, 0xB5, 0xA5, 0xB5, 0x5E, 0x40, 0x3C, 0x18, 0x1C, 0x1C, 0x34,
  0x36, 0x26, 0x7E, 0x7F, 0x63, 0xC3, 0xF9, 0xFB, 0x1E, 0x3F, 0xDF, 0xB1,
  0xE3, 0xCF, 0xF8, 0x79, 0xDB, 0x1C, 0x08, 0x10, 0x20, 0x63, 0xCC, 0xF0,
  0xF1, 0xFB, 0x36, 0x3C, 0x78, 0xF1, 0xE6, 0xDD, 0xF0, 0xFF, 0xFF, 0x06,
  0x0F, 0xDF, 0xB0, 0x60, 0xC1, 0xFC, 0xFF, 0xFF, 0x06, 0x0F, 0xDF, 0xB0,
  0x60, 0xC1, 0x80, 0x79, 0xDB, 0x1C, 0x08, 0x13, 0xE1, 0xE3, 0xEE, 0xF8,
  0xC7, 0x1C, 0x71, 0xFF, 0xFC, 0x71, 0xC7, 0x10, 0xFF, 0xF3, 0x0C, 0x30,
  0xC3, 0x0C, 0x33, 0xF0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x71, 0xCD, 0xE0,
  0xC6, 0xCC, 0xD8, 0xD8, 0xF0, 0xF8, 0xD8, 0xCC, 0xCE, 0xC7, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFC, 0xCF, 0xDF, 0xBD, 0xFF, 0x7E,
  0xF5, 0xE3, 0xC7, 0x8C, 0xC7, 0x1E, 0x79, 0xF7, 0x5D, 0xF3, 0xCF, 0x30,
  0x79, 0xDB, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xCC, 0xF0, 0xF9, 0xFB, 0x1E,
  0x3C, 0x7F, 0xB0, 0x60, 0xC1, 0x80, 0x79, 0xDB, 0x1C, 0x38, 0x70, 0xE1,
  0xE3, 0xCC, 0xF8, 0x18, 0x10, 0xF9, 0xFB, 0x1E, 0x3C, 0xDF, 0x36, 0x66,
  0xCD, 0x8C, 0x7D, 0xDF, 0x1E, 0x07, 0x87, 0x81, 0xC3, 0xCE, 0xF8, 0xFF,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE2, 0xCC, 0xF0, 0xC3, 0x63, 0x62, 0x66, 0x26, 0x34,
  0x3C, 0x1C, 0x1C, 0x18, 0xD9, 0xDB, 0x5B, 0x5B, 0x5F, 0x7E, 0x76, 0x76,
  0x66, 0x26, 0xE3, 0x66, 0x36, 0x3C, 0x1C, 0x1C, 0x3C, 0x36, 0x66, 0xE3,
  0xC3, 0x63, 0x66, 0x36, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xF8,
  0x30, 0xC1, 0x06, 0x18, 0x20, 0xC1, 0xFC, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D,
  0xC0, 0x86, 0x30, 0x86, 0x10, 0xC6, 0x10, 0xC6, 0xFD, 0xB6, 0xDB, 0x6D,
  0xB7, 0xC0, 0x30, 0xE2, 0x9A, 0xCC, 0xFC, 0xCC, 0x13, 0xFC, 0xC7, 0xFF,
  0x3C, 0xDD, 0xC1, 0x83, 0x06, 0x8F, 0xD9, 0xB1, 0xE3, 0xC5, 0x9B, 0xE0,
  0x11, 0xFC, 0xF0, 0xC3, 0x0C, 0xDE, 0x04, 0x10, 0x49, 0x7F, 0x3C, 0x71,
  0xC7, 0x37, 0x40, 0x10, 0xFB, 0x16, 0x3F, 0xF8, 0x39, 0xBE, 0x1E, 0x7C,
  0xC1, 0x8F, 0xC6, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x21, 0xFC, 0x71, 0xC7,
  0x1C, 0xDF, 0x07, 0xF7, 0x80, 0xC1, 0x83, 0x06, 0x8F, 0xD8, 0xB1, 0xE3,
  0xC7, 0x8F, 0x18, 0x38, 0x20, 0x07, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC,
  0x18, 0xC0, 0xF1, 0x8C, 0x63, 0x18, 0xC7, 0x7F, 0x00, 0xC1, 0x83, 0x06,
  0x1C, 0xDB, 0x3C, 0x78, 0xD9, 0x9B, 0x18, 0xF1, 0xE0, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x23, 0xF8, 0x25, 0xFE, 0xDD, 0xBB, 0x76, 0xED, 0xDB,
  0x11, 0xFB, 0x16, 0x3C, 0x78, 0xF1, 0xE3, 0x10, 0xFB, 0x36, 0x3C, 0x78,
  0xF3, 0x3C, 0x11, 0xFB, 0x36, 0x3C, 0x78, 0xB3, 0x7C, 0xC1, 0x83, 0x00,
  0x21, 0xFC, 0xF1, 0xC7, 0x1C, 0xDD, 0x04, 0x10, 0x40, 0x0F, 0xEE, 0x30,
  0xC3, 0x0C, 0x30, 0x10, 0xFB, 0x1F, 0x03, 0xC0, 0xF1, 0x3E, 0x20, 0x8F,
  0xC8, 0x20, 0x82, 0x0D, 0x3C, 0xC7, 0x1C, 0x71, 0xC7, 0x37, 0x40, 0xC7,
  0x99, 0x33, 0x47, 0x87, 0x0C, 0x00, 0xDB, 0x5B, 0x5B, 0x5E, 0x56, 0x66,
  0x26, 0xCE, 0xD8, 0xE1, 0xC7, 0x8D, 0xB1, 0x80, 0xE3, 0x62, 0x26, 0x36,
  0x1C, 0x1C, 0x18, 0x18, 0x70, 0x70, 0xFE, 0x18, 0x61, 0x86, 0x18, 0x3F,
  0x80, 0x19, 0x8C, 0x63, 0x13, 0x0C, 0x21, 0x8C, 0x61, 0x80, 0xFF, 0xF8,
  0xC3, 0x18, 0xC6, 0x10, 0xE6, 0x23, 0x18, 0xCC, 0x00, 0x20, 0x7B, 0x8E,
};

const GFXglyph RobotoMono_SemiBold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 2, -11 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 7, 13, 8, 1, -12 },
  { 28, 8, 10, 8, 0, -10 },
  { 38, 7, 10, 8, 1, -10 },
  { 47, 2, 4, 8, 3, -11 },
  { 48, 4, 14, 8, 2, -11 },
  { 55, 4, 14, 8, 2, -11 },
  { 62, 7, 7, 8, 1, -10 },
  { 69, 7, 7, 8, 1, -8 },
  { 76, 3, 5, 8, 2, -2 },
  { 78, 5, 1, 8, 2, -5 },
  { 79, 3, 2, 8, 3, -2 },
  { 80, 5, 11, 8, 2, -10 },
  { 87, 6, 10, 8, 1, -10 },
  { 95, 5, 10, 8, 1, -10 },
  { 102, 7, 10, 8, 0, -10 },
  { 111, 6, 10, 8, 1, -10 },
  { 119, 8, 10, 8, 0, -10 },
  { 129, 7, 10, 8, 1, -10 },
  { 138, 6, 10, 8, 1, -10 },
  { 146, 6, 10, 8, 1, -10 },
  { 154, 6, 10, 8, 1, -10 },
  { 162, 6, 10, 8, 1, -10 },
  { 170, 3, 8, 8, 3, -8 },
  { 173, 3, 11, 8, 3, -8 },
  { 178, 6, 7, 8, 1, -8 },
  { 184, 7, 4, 8, 1, -6 },
  { 188, 6, 7, 8, 1, -8 },
  { 194, 6, 10, 8, 1, -10 },
  { 202, 8, 10, 8, 0, -10 },
  { 212, 8, 10, 8, 0, -10 },
  { 222, 7, 10, 8, 1, -10 },
  { 231, 7, 10, 8, 1, -10 },
  { 240, 7, 10, 8, 1, -10 },
  { 249, 7, 10, 8, 1, -10 },
  { 258, 7, 10, 8, 1, -10 },
  { 267, 7, 10, 8, 1, -10 },
  { 276, 6, 10, 8, 1, -10 },
  { 284, 6, 10, 8, 1, -10 },
  { 292, 6, 10, 8, 1, -10 },
  { 300, 8, 10, 8, 1, -10 },
  { 310, 7, 10, 8, 1, -10 },
  { 319, 7, 10, 8, 1, -10 },
  { 328, 6, 10, 8, 1, -10 },
  { 336, 7, 10, 8, 1, -10 },
  { 345, 7, 10, 8, 1, -10 },
  { 354, 7, 12, 8, 1, -10 },
  { 365, 7, 10, 8, 1, -10 },
  { 374, 7, 10, 8, 1, -10 },
  { 383, 8, 10, 8, 0, -10 },
  { 393, 7, 10, 8, 1, -10 },
  { 402, 8, 10, 8, 0, -10 },
  { 412, 8, 10, 8, 0, -10 },
  { 422, 8, 10, 8, 0, -10 },
  { 432, 8, 10, 8, 0, -10 },
  { 442, 7, 10, 8, 1, -10 },
  { 451, 3, 14, 8, 3, -12 },
  { 457, 5, 11, 8, 2, -10 },
  { 464, 3, 14, 8, 3, -12 },
  { 470, 6, 5, 8, 1, -10 },
  { 474, 6, 1, 8, 1, 0 },
  { 475, 3, 2, 8, 3, -10 },
  { 476, 6, 8, 8, 1, -8 },
  { 482, 7, 11, 8, 1, -11 },
  { 492, 6, 8, 8, 1, -8 },
  { 498, 6, 11, 8, 1, -11 },
  { 507, 7, 8, 8, 1, -8 },
  { 514, 7, 11, 8, 1, -11 },
  { 524, 6, 11, 8, 1, -8 },
  { 533, 7, 11, 8, 1, -11 },
  { 543, 7, 10, 8, 1, -10 },
  { 552, 5, 13, 8, 1, -10 },
  { 561, 7, 11, 8, 1, -11 },
  { 571, 7, 11, 8, 1, -11 },
  { 581, 7, 8, 8, 1, -8 },
  { 588, 7, 8, 8, 1, -8 },
  { 595, 7, 8, 8, 1, -8 },
  { 602, 7, 11, 8, 1, -8 },
  { 612, 6, 11, 8, 1, -8 },
  { 621, 6, 8, 8, 2, -8 },
  { 627, 7, 8, 8, 1, -8 },
  { 634, 6, 9, 8, 1, -9 },
  { 641, 6, 7, 8, 1, -7 },
  { 647, 7, 7, 8, 1, -7 },
  { 654, 8, 7, 8, 0, -7 },
  { 661, 7, 7, 8, 1, -7 },
  { 668, 8, 10, 8, 0, -7 },
  { 678, 7, 7, 8, 1, -7 },
  { 685, 5, 13, 8, 2, -11 },
  { 694, 1, 13, 8, 4, -10 },
  { 696, 5, 13, 8, 2, -11 },
  { 705, 8, 3, 8, 0, -6 },
};

const GFXfont RobotoMono_SemiBold14pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold14pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOMONO_SEMIBOLD14PT7B_H_
