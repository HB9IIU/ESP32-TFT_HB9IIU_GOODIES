#ifndef _ROBOTOMONO_SEMIBOLD49PT7B_H_
#define _ROBOTOMONO_SEMIBOLD49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x0F, 0xBF, 0xFF, 0xFF, 0xFD, 0xF0, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x1F, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x3C, 0x1E, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x3F, 0xC1, 0xFE, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F,
  0x7F, 0x80, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xF8,
  0x78, 0x10, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x87,
  0x80, 0xF0, 0x78, 0x78, 0x0F, 0x07, 0x8F, 0x00, 0xF8, 0xF8, 0xF0, 0x07,
  0xFF, 0x9E, 0x00, 0x7F, 0xF1, 0xE0, 0x03, 0xFE, 0x3C, 0x00, 0x0F, 0x83,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x03,
  0xC7, 0xF8, 0x00, 0x79, 0xFF, 0xC0, 0x07, 0x9F, 0xFE, 0x00, 0xF3, 0xE3,
  0xE0, 0x0E, 0x3C, 0x1E, 0x01, 0xE3, 0xC1, 0xE0, 0x3C, 0x3C, 0x1F, 0x03,
  0xC3, 0xC1, 0xF0, 0x18, 0x3C, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3F,
  0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x7C, 0x00,
  0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x1F, 0x0F, 0xFF, 0x03, 0xE3, 0xFF, 0xF0, 0x7C, 0xFE,
  0x7F, 0x0F, 0x9F, 0x87, 0xF3, 0xF7, 0xF0, 0xFE, 0x7E, 0xFC, 0x0F, 0xEF,
  0xDF, 0x80, 0xFF, 0xF3, 0xF0, 0x0F, 0xFE, 0x7E, 0x01, 0xFF, 0x8F, 0xE0,
  0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xF7, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFB, 0xF8, 0x1F, 0xFC, 0x3F, 0x80, 0x10,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x00, 0x00,
  0x10, 0x01, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0x80, 0x40, 0x07, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x1E, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x60, 0x3C, 0x06, 0x7C, 0x3C, 0x3E, 0xFF, 0x3C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x03, 0xE7,
  0x80, 0x07, 0xC7, 0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x83, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E,
  0x7E, 0x7E, 0x7C, 0x7C, 0xF8, 0xF8, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x3F, 0x9F, 0xEF,
  0xFF, 0xFB, 0xFD, 0xFE, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x3F, 0x7F, 0xFC, 0xFC, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07,
  0xE7, 0xF0, 0x0F, 0xC7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8, 0x1F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0x83, 0xFC,
  0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F, 0x80, 0xFE, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xDF, 0xC0,
  0x03, 0xF7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x7C, 0x7F, 0x00, 0x3F, 0x1F,
  0xC0, 0x0F, 0x87, 0xF0, 0x07, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xF8,
  0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0x80, 0x7F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFE, 0x07, 0xF8, 0x38, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xE0, 0x3F, 0x8F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC3, 0xF8,
  0x1F, 0x9F, 0xFC, 0x3F, 0x7F, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0x07, 0xFB, 0xF8, 0x07, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xC7, 0xF0,
  0x3F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x9F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7,
  0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xFB, 0xFE, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xF0,
  0x1F, 0xCF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xEF, 0xE0, 0x3F, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0x1F,
  0x80, 0x7E, 0x7F, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x03, 0xFD, 0xFE, 0x1F,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0x3F,
  0x00, 0x70, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xFB,
  0xFD, 0xFF, 0xFF, 0xFF, 0xDF, 0xCF, 0xC0, 0x1E, 0x1F, 0x9F, 0xEF, 0xF7,
  0xFB, 0xFD, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x3E, 0x3E, 0x1F, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x03, 0xF0, 0x0F,
  0x80, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x0F, 0xE3,
  0xC7, 0x83, 0xFE, 0x38, 0xF0, 0xFF, 0xC7, 0xBC, 0x3E, 0x38, 0xF7, 0x87,
  0x8F, 0x1E, 0xF1, 0xE1, 0xE3, 0xDC, 0x3C, 0x3C, 0x3F, 0x8F, 0x07, 0x87,
  0xF1, 0xE0, 0xF0, 0xFE, 0x3C, 0x1E, 0x3F, 0xC7, 0x83, 0xC7, 0xF8, 0xF0,
  0x70, 0xEF, 0x1E, 0x0E, 0x1D, 0xE3, 0xC1, 0xC3, 0xBC, 0x78, 0x78, 0xF7,
  0x8F, 0x8F, 0x1C, 0x70, 0xFF, 0xFF, 0x8F, 0x1F, 0xFF, 0xE1, 0xE1, 0xF9,
  0xF8, 0x3E, 0x08, 0x0C, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x08, 0x00, 0x7F, 0x8F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x01,
  0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7,
  0xF0, 0x3F, 0xF3, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x07,
  0xF7, 0xF0, 0x07, 0xF3, 0xF8, 0x0F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xC0, 0xFF, 0xCF, 0xE0,
  0x07, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0xF7, 0xF0, 0x0F, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE1, 0xFE, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xE0,
  0x07, 0xF3, 0xF0, 0x07, 0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0xF8, 0xFC, 0x03, 0xFC,
  0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE,
  0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xFC, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFE, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x7F,
  0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0,
  0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xFE, 0x01, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0,
  0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0x7F,
  0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE7, 0xBF, 0xFF, 0xEF, 0xBF, 0xFD, 0xEF, 0xBF, 0xFD, 0xFF, 0xBF,
  0xFD, 0xFF, 0x3F, 0xFC, 0xFF, 0x3F, 0xFC, 0xFF, 0x3F, 0xFC, 0xFE, 0x3F,
  0xFC, 0xFE, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F,
  0xFC, 0x3C, 0x3F, 0xFC, 0x38, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xDF, 0x07, 0xFF, 0xBE, 0x0F, 0xFF, 0x3E, 0x1F, 0xFE, 0x7C,
  0x3F, 0xFC, 0xFC, 0x7F, 0xF8, 0xF8, 0xFF, 0xF1, 0xF9, 0xFF, 0xE1, 0xF3,
  0xFF, 0xC3, 0xF7, 0xFF, 0x83, 0xEF, 0xFF, 0x07, 0xDF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1,
  0xFE, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xE0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFC, 0x07, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x03,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7E,
  0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x81, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x02, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0xF3, 0xF8, 0x03, 0xFD,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F,
  0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01,
  0xFD, 0xFC, 0x01, 0xFC, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3,
  0xF8, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF9, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7F,
  0x00, 0x1F, 0x8F, 0xE0, 0x1F, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xF0, 0x0F,
  0xCF, 0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xE7, 0xF0, 0x01, 0xFC, 0x7E,
  0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F,
  0x83, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x03, 0xFF, 0xC1, 0xF0, 0x3F,
  0xFC, 0x1F, 0x03, 0xEF, 0xC1, 0xF8, 0x3E, 0xFC, 0x1F, 0x87, 0xE7, 0xC1,
  0xF8, 0x7E, 0x7C, 0x3F, 0x87, 0xE7, 0xC3, 0xF8, 0x7E, 0x7E, 0x3F, 0x87,
  0xE7, 0xE3, 0xF8, 0x7C, 0x7E, 0x3F, 0xC7, 0xC7, 0xE3, 0xFC, 0x7C, 0x7E,
  0x3F, 0xC7, 0xC3, 0xE7, 0xFC, 0xFC, 0x3E, 0x7F, 0xCF, 0xC3, 0xE7, 0xBC,
  0xFC, 0x3F, 0x7B, 0xEF, 0xC3, 0xF7, 0xBE, 0xF8, 0x3F, 0x79, 0xEF, 0x83,
  0xF7, 0x9E, 0xF8, 0x1F, 0xF9, 0xEF, 0x81, 0xFF, 0x1F, 0xF8, 0x1F, 0xF1,
  0xFF, 0x81, 0xFF, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFF, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F,
  0x9F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x01, 0xFC,
  0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x81,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x9F, 0x80,
  0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0,
  0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x07,
  0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF,
  0x8F, 0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x9F, 0xE0, 0x3F, 0x3F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xF8,
  0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F, 0xDF, 0xFB,
  0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFE, 0xFE, 0x1F, 0xF0,
  0xFC, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE7, 0xFC, 0x0F,
  0xDF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF,
  0x03, 0xF9, 0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xEF, 0xC0,
  0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0xBF, 0x80, 0x7F, 0x7F, 0x81, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE3, 0xEF, 0xFF, 0x87, 0xCF, 0xFE, 0x0F, 0x8F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF8, 0x07, 0xF7, 0xF8, 0x1F,
  0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0xE7, 0xF0, 0xFF, 0xEF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0x81, 0xFE, 0xFE, 0x01, 0xFD, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF,
  0xC0, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFB, 0xF0, 0x3F, 0xC7, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x81, 0xFC, 0x7F,
  0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x08, 0x7F, 0x00, 0x18, 0x3F, 0x80, 0x3C, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xC3, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x7E, 0x1F, 0xFE, 0xFC, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xDF, 0xC0,
  0x3F, 0xBF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF8, 0x07, 0xF7, 0xF8, 0x1F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x0F, 0xFF, 0x7E, 0x07, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x80, 0x0F, 0xE3, 0x00, 0x3F, 0x8F, 0x80, 0xFF, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0xE0, 0xFC, 0xFF,
  0xE3, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x01, 0xFE, 0xFC, 0x03, 0xFC, 0xFC, 0x07, 0xF8, 0xFC, 0x0F, 0xF0, 0xFC,
  0x1F, 0xE0, 0xFC, 0x3F, 0xC0, 0xFC, 0x7F, 0x80, 0xFC, 0x7F, 0x00, 0xFC,
  0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE,
  0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x07, 0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0xFC, 0x7E, 0x7D, 0xFE, 0xFF, 0xBE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0xFF, 0xF0, 0xF8, 0x3F, 0xF8, 0x7C, 0x1F,
  0xFC, 0x3E, 0x0F, 0xFE, 0x1F, 0x07, 0xFF, 0x0F, 0x83, 0xFF, 0x87, 0xC1,
  0xFF, 0xC3, 0xE0, 0xFF, 0xE1, 0xF0, 0x7F, 0xF0, 0xF8, 0x3F, 0xF8, 0x7C,
  0x1F, 0xFC, 0x3E, 0x0F, 0xFE, 0x1F, 0x07, 0xFF, 0x0F, 0x83, 0xFF, 0x87,
  0xC1, 0xFF, 0xC3, 0xE0, 0xFF, 0xE1, 0xF0, 0x7F, 0xF0, 0xF8, 0x3F, 0xF8,
  0x7C, 0x1F, 0xFC, 0x3E, 0x0F, 0xFE, 0x1F, 0x07, 0xC0, 0xF8, 0x7F, 0xC3,
  0xE3, 0xFF, 0x8F, 0x9F, 0xFF, 0x3E, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFC,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x7F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x01, 0xFC,
  0x3F, 0xEF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xF8, 0xFF, 0x81, 0xF3, 0xFF, 0x83,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xE0, 0xFF, 0x3F,
  0x00, 0x7F, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07,
  0xF7, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF0, 0xFD, 0xFF, 0xC1, 0xF9, 0xFF, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x7E, 0x1F, 0xFE, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xDF, 0xC0, 0x3F, 0xBF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF8, 0x07, 0xF7,
  0xF8, 0x1F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F,
  0xFF, 0x7E, 0x07, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFE, 0xFC, 0xFF, 0xEF, 0xDF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xE3, 0xFC, 0x3F, 0xCF, 0xE0, 0x1F, 0xDF, 0x80, 0x1F, 0xBF,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xEF, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xBF, 0x1F, 0xFC, 0xFC, 0x3F, 0xE3, 0xF0, 0x08, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0x8F, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x1F, 0x03, 0xFF, 0x83, 0xE0, 0x7F, 0xF0, 0x7C, 0x1F, 0xFE, 0x0F,
  0x83, 0xF7, 0xC1, 0xF0, 0x7E, 0xF8, 0x7F, 0x0F, 0x9F, 0x0F, 0xE1, 0xF3,
  0xE1, 0xFC, 0x3E, 0x7E, 0x3F, 0x87, 0xCF, 0xC7, 0x71, 0xF8, 0xF9, 0xEF,
  0x3E, 0x1F, 0x3D, 0xE7, 0xC3, 0xE7, 0xBC, 0xF8, 0x7C, 0xF7, 0x9F, 0x0F,
  0x9C, 0x73, 0xE0, 0xFF, 0x8F, 0x78, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F,
  0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xCF, 0xC0, 0x0F, 0xE3, 0xF8,
  0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x7F, 0x00,
  0x3F, 0xBF, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7E,
  0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC1, 0xF8,
  0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0xFF,
  0xC0, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xBF, 0xFE,
  0x01, 0xE7, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0x9F, 0xBE, 0x0F, 0xFF, 0xF7,
  0x80, 0x7F, 0xFC, 0xF0, 0x07, 0xFF, 0x02, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xE0, 0x00,
};

const GFXglyph RobotoMono_SemiBold49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 7, 35, 29, 11, -35 },
  { 32, 14, 13, 29, 7, -37 },
  { 55, 27, 35, 29, 1, -35 },
  { 174, 24, 45, 29, 3, -40 },
  { 309, 28, 35, 29, 1, -35 },
  { 432, 27, 36, 29, 2, -35 },
  { 554, 5, 13, 29, 11, -37 },
  { 563, 13, 50, 29, 8, -39 },
  { 645, 13, 50, 29, 8, -39 },
  { 727, 24, 25, 29, 4, -35 },
  { 802, 24, 26, 29, 2, -29 },
  { 880, 8, 15, 29, 9, -6 },
  { 895, 20, 5, 29, 6, -18 },
  { 908, 9, 8, 29, 10, -8 },
  { 917, 20, 38, 29, 5, -35 },
  { 1012, 23, 36, 29, 3, -35 },
  { 1116, 15, 35, 29, 4, -35 },
  { 1182, 24, 35, 29, 2, -35 },
  { 1287, 24, 35, 29, 2, -35 },
  { 1392, 26, 35, 29, 1, -35 },
  { 1506, 23, 35, 29, 3, -35 },
  { 1607, 23, 35, 29, 3, -35 },
  { 1708, 24, 35, 29, 2, -35 },
  { 1813, 23, 35, 29, 3, -35 },
  { 1914, 23, 35, 29, 3, -35 },
  { 2015, 9, 28, 29, 11, -28 },
  { 2047, 9, 37, 29, 11, -28 },
  { 2089, 21, 22, 29, 4, -26 },
  { 2147, 22, 16, 29, 4, -23 },
  { 2191, 21, 22, 29, 4, -26 },
  { 2249, 22, 35, 29, 4, -35 },
  { 2346, 27, 35, 29, 1, -35 },
  { 2465, 28, 35, 29, 1, -35 },
  { 2588, 25, 35, 29, 3, -35 },
  { 2698, 25, 36, 29, 2, -35 },
  { 2811, 24, 35, 29, 3, -35 },
  { 2916, 23, 35, 29, 4, -35 },
  { 3017, 23, 35, 29, 4, -35 },
  { 3118, 25, 35, 29, 2, -35 },
  { 3228, 23, 35, 29, 3, -35 },
  { 3329, 20, 35, 29, 5, -35 },
  { 3417, 23, 35, 29, 3, -35 },
  { 3518, 27, 35, 29, 3, -35 },
  { 3637, 23, 35, 29, 4, -35 },
  { 3738, 24, 35, 29, 3, -35 },
  { 3843, 23, 35, 29, 3, -35 },
  { 3944, 25, 35, 29, 2, -35 },
  { 4054, 24, 35, 29, 4, -35 },
  { 4159, 27, 41, 29, 2, -35 },
  { 4298, 25, 35, 29, 3, -35 },
  { 4408, 26, 35, 29, 2, -35 },
  { 4522, 28, 35, 29, 1, -35 },
  { 4645, 23, 35, 29, 3, -35 },
  { 4746, 27, 35, 29, 1, -35 },
  { 4865, 28, 35, 29, 1, -35 },
  { 4988, 28, 35, 29, 1, -35 },
  { 5111, 28, 35, 29, 1, -35 },
  { 5234, 25, 35, 29, 2, -35 },
  { 5344, 10, 48, 29, 10, -40 },
  { 5404, 19, 38, 29, 6, -35 },
  { 5495, 10, 48, 29, 10, -40 },
  { 5555, 20, 19, 29, 5, -35 },
  { 5603, 21, 5, 29, 4, 0 },
  { 5617, 11, 6, 29, 10, -35 },
  { 5626, 23, 26, 29, 3, -26 },
  { 5701, 23, 37, 29, 4, -37 },
  { 5808, 23, 27, 29, 3, -26 },
  { 5886, 23, 37, 29, 3, -37 },
  { 5993, 24, 26, 29, 3, -26 },
  { 6071, 24, 38, 29, 3, -38 },
  { 6185, 23, 36, 29, 3, -26 },
  { 6289, 22, 37, 29, 4, -37 },
  { 6391, 21, 36, 29, 5, -36 },
  { 6486, 16, 46, 29, 5, -36 },
  { 6578, 24, 37, 29, 4, -37 },
  { 6689, 22, 37, 29, 5, -37 },
  { 6791, 25, 26, 29, 2, -26 },
  { 6873, 22, 26, 29, 4, -26 },
  { 6945, 24, 27, 29, 3, -26 },
  { 7026, 23, 36, 29, 4, -26 },
  { 7130, 23, 36, 29, 3, -26 },
  { 7234, 20, 26, 29, 7, -26 },
  { 7299, 23, 27, 29, 3, -26 },
  { 7377, 23, 33, 29, 3, -32 },
  { 7472, 22, 27, 29, 4, -26 },
  { 7547, 26, 26, 29, 2, -26 },
  { 7632, 27, 26, 29, 1, -26 },
  { 7720, 26, 26, 29, 2, -26 },
  { 7805, 28, 36, 29, 1, -26 },
  { 7931, 24, 26, 29, 3, -26 },
  { 8009, 16, 47, 29, 7, -38 },
  { 8103, 4, 45, 29, 13, -35 },
  { 8126, 16, 47, 29, 8, -38 },
  { 8220, 27, 11, 29, 1, -20 },
};

const GFXfont RobotoMono_SemiBold49pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold49pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _ROBOTOMONO_SEMIBOLD49PT7B_H_
