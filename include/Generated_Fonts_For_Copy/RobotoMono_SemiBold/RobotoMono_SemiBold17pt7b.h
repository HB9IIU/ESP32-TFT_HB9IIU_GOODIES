#ifndef _ROBOTOMONO_SEMIBOLD17PT7B_H_
#define _ROBOTOMONO_SEMIBOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x0F, 0xCE, 0x73, 0x9C, 0x80, 0x09, 0x02, 0x41, 0x91,
  0xFF, 0x7F, 0xC4, 0x81, 0x23, 0xFE, 0xFF, 0x8D, 0x82, 0x60, 0x90, 0x08,
  0x08, 0x3E, 0x7F, 0x63, 0x63, 0x70, 0x3C, 0x1E, 0x03, 0xC3, 0xE3, 0x7F,
  0x3E, 0x08, 0x08, 0x70, 0x36, 0x4D, 0xB3, 0x68, 0x76, 0x01, 0x00, 0xC0,
  0x2E, 0x16, 0xCD, 0xB0, 0x6C, 0x0E, 0x3C, 0x3F, 0x19, 0x8C, 0x87, 0xC1,
  0xC1, 0xE7, 0xBB, 0xCF, 0x63, 0xBF, 0xCF, 0xF0, 0xFA, 0x80, 0x13, 0x66,
  0xCC, 0xCC, 0xCC, 0xCC, 0x46, 0x23, 0x10, 0x8C, 0x62, 0x33, 0x33, 0x33,
  0x33, 0x36, 0x4C, 0x80, 0x08, 0x04, 0x12, 0x5F, 0xF1, 0xC0, 0xA0, 0xD8,
  0xC6, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x6D, 0xEC,
  0xFF, 0xFC, 0xDF, 0x00, 0x0E, 0x18, 0x30, 0xC1, 0x83, 0x0C, 0x18, 0x60,
  0xC1, 0x86, 0x0C, 0x00, 0x3E, 0x7E, 0xE3, 0xC3, 0xC7, 0xCF, 0xF3, 0xE3,
  0xC3, 0xE3, 0x7E, 0x3C, 0x0D, 0xFF, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x7C, 0xFE, 0xC7, 0xC7, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xFF,
  0xFF, 0x7E, 0xFE, 0xC3, 0x03, 0x06, 0x3E, 0x3E, 0x03, 0x03, 0xC3, 0xFE,
  0x7C, 0x0E, 0x0E, 0x1E, 0x36, 0x36, 0x66, 0xC6, 0xC6, 0xFF, 0x06, 0x06,
  0x06, 0x7F, 0x7F, 0x60, 0x60, 0x7C, 0xFE, 0x03, 0x03, 0x03, 0xC3, 0x7E,
  0x3E, 0x1C, 0x3C, 0x60, 0xE0, 0xDC, 0xFE, 0xC3, 0xC3, 0xC3, 0xE3, 0x7E,
  0x3C, 0xFF, 0xFF, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0x70, 0x7E, 0x7E, 0xE3, 0xC3, 0x66, 0x3E, 0x7E, 0xC3, 0xC3, 0xC3, 0xFF,
  0x7E, 0x7C, 0x7E, 0xC7, 0xC3, 0xC3, 0xC3, 0x7F, 0x7B, 0x06, 0x06, 0x3C,
  0x38, 0xDF, 0x80, 0x06, 0xFC, 0x5F, 0x80, 0x00, 0xFF, 0x6C, 0x03, 0x0F,
  0x7C, 0xE0, 0xF0, 0x3E, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0xF0, 0x3E, 0x07, 0x0F, 0x7C, 0xE0, 0x80, 0x3E, 0x7F, 0xE3, 0x03, 0x07,
  0x0E, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x1F, 0x0C, 0x66, 0x09, 0x3B,
  0x5A, 0x74, 0x9D, 0x2F, 0x4A, 0x5F, 0x90, 0x06, 0x20, 0x78, 0x0C, 0x03,
  0x81, 0xE0, 0x78, 0x1B, 0x0C, 0xC3, 0x30, 0xFE, 0x7F, 0x98, 0x66, 0x1F,
  0x83, 0xFE, 0x7F, 0xB0, 0xD8, 0x6C, 0x37, 0xF3, 0xFD, 0x87, 0xC3, 0xE1,
  0xFF, 0xDF, 0xC0, 0x3E, 0x7F, 0xC3, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC3,
  0xC3, 0x7F, 0x3E, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC7, 0xFE, 0xFC, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x3E, 0x7F, 0xE3, 0xC0, 0xC0, 0xC0, 0xCF, 0xCF, 0xC3,
  0xE3, 0x7F, 0x3E, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xFF, 0xFC, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x63,
  0xFF, 0xF0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xC3, 0xC3,
  0xFE, 0x7C, 0xC3, 0xE3, 0xB1, 0x99, 0x8D, 0xC7, 0xC3, 0xF1, 0xD8, 0xC6,
  0x63, 0xB0, 0xD8, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0xDB, 0xDB, 0xDB,
  0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB, 0xCF,
  0xCF, 0xC7, 0xC7, 0xC3, 0x3C, 0x7E, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x7E, 0x3C, 0xFE, 0x7F, 0xB0, 0xD8, 0x7C, 0x3E, 0x3B, 0xF9,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x3E, 0x3F, 0xB0, 0xD8, 0x6C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0x61, 0x9F, 0x87, 0xE0, 0x38, 0x08, 0xFE, 0x7F,
  0xB0, 0xD8, 0x6C, 0x36, 0x3B, 0xF9, 0x9C, 0xC6, 0x63, 0xB0, 0xD8, 0x70,
  0x3E, 0x3B, 0xB0, 0xD8, 0x1E, 0x03, 0xE0, 0x7C, 0x06, 0xC3, 0xE1, 0xDF,
  0xC7, 0xC0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xE3, 0x7E, 0x3C, 0xE1, 0xD8, 0x66, 0x19, 0xC6, 0x33, 0x0C,
  0xC3, 0x30, 0x7C, 0x1E, 0x07, 0x80, 0xE0, 0x30, 0xCC, 0xD3, 0x36, 0xCD,
  0xB2, 0x6F, 0x9F, 0xE7, 0xF9, 0xEE, 0x73, 0x8C, 0xE3, 0x38, 0xCC, 0xE1,
  0xDC, 0x63, 0x30, 0xEC, 0x1E, 0x03, 0x80, 0xE0, 0x78, 0x3B, 0x0C, 0xE7,
  0x1B, 0x87, 0xE1, 0xD8, 0x63, 0x18, 0xCC, 0x1B, 0x07, 0x81, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0x06, 0x0E, 0x0C, 0x1C, 0x18,
  0x30, 0x70, 0x60, 0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCF, 0xF0, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30,
  0x60, 0xE0, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x30,
  0x71, 0xE3, 0x44, 0xD8, 0xC0, 0xFF, 0xFF, 0xE3, 0x7C, 0x7E, 0xC3, 0x03,
  0x7F, 0xC3, 0xC3, 0xFF, 0x7B, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xFF, 0xE3,
  0xC3, 0xC3, 0xC3, 0xE3, 0xFF, 0xDE, 0x3E, 0x7F, 0xE3, 0xC0, 0xC0, 0xC0,
  0xE3, 0x7F, 0x3E, 0x03, 0x03, 0x03, 0x03, 0x3B, 0x7F, 0xE3, 0xC3, 0xC3,
  0xC3, 0xE3, 0x7F, 0x3B, 0x3E, 0x7F, 0xE3, 0xC3, 0xFF, 0xC0, 0xE1, 0x7F,
  0x3E, 0x0F, 0x8F, 0x86, 0x07, 0x0F, 0xF7, 0xF8, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x80, 0x3F, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F,
  0x3F, 0x03, 0x47, 0xFE, 0x10, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xFF, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x38, 0x20, 0x07, 0xCF, 0x87, 0x0E,
  0x1C, 0x38, 0x73, 0xFF, 0xF0, 0x18, 0xC0, 0xF7, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x9F, 0xDC, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x76, 0x73, 0x71, 0xB0,
  0xF8, 0x76, 0x33, 0x98, 0xEC, 0x38, 0xF9, 0xF0, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE7, 0xFF, 0xE0, 0xFF, 0xFF, 0xD9, 0xD9, 0xD9, 0xD9,
  0xD9, 0xD9, 0xD9, 0xDE, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x3C, 0x7E, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7E, 0x3C, 0xDE, 0xFF, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xDE, 0xC0, 0xC0, 0xC0, 0x3B, 0x7F, 0xE3,
  0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3B, 0x03, 0x03, 0x03, 0xCF, 0xFF, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x3E, 0x77, 0xC3, 0x70, 0x3E, 0x07, 0xC3,
  0x67, 0x3E, 0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3F,
  0x1F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x7B, 0xC3, 0xE1,
  0x98, 0xCC, 0xC6, 0x61, 0xA0, 0xF0, 0x38, 0x18, 0x00, 0xCC, 0xD3, 0x36,
  0xC9, 0xB6, 0x7F, 0x9E, 0xE7, 0x38, 0xCC, 0x33, 0x00, 0xE3, 0xB3, 0x8D,
  0x87, 0x81, 0xC1, 0xE0, 0xD8, 0xCE, 0xC3, 0x80, 0xE0, 0xD8, 0x63, 0x18,
  0xCE, 0x3B, 0x06, 0xC1, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0x80, 0xE0, 0x60,
  0x00, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x70, 0xFF, 0xFF, 0x19, 0x8C,
  0x63, 0x19, 0x98, 0xE3, 0x0C, 0x63, 0x18, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC3, 0x18, 0xC6, 0x30, 0xC7, 0x3B, 0x18, 0xC6, 0x33, 0x98, 0x30, 0x1F,
  0x3C, 0xF8, 0x0C,
};

const GFXglyph RobotoMono_SemiBold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 5, 5, 10, 2, -13 },
  { 8, 10, 12, 10, 0, -12 },
  { 23, 8, 16, 10, 1, -14 },
  { 39, 10, 12, 10, 0, -12 },
  { 54, 9, 12, 10, 1, -12 },
  { 68, 2, 5, 10, 4, -13 },
  { 70, 4, 17, 10, 3, -13 },
  { 79, 4, 17, 10, 3, -13 },
  { 88, 9, 8, 10, 1, -12 },
  { 97, 8, 9, 10, 1, -10 },
  { 106, 3, 5, 10, 3, -2 },
  { 108, 7, 2, 10, 2, -6 },
  { 110, 3, 3, 10, 4, -3 },
  { 112, 7, 13, 10, 2, -12 },
  { 124, 8, 12, 10, 1, -12 },
  { 136, 6, 12, 10, 1, -12 },
  { 145, 8, 12, 10, 1, -12 },
  { 157, 8, 12, 10, 1, -12 },
  { 169, 8, 12, 10, 1, -12 },
  { 181, 8, 12, 10, 1, -12 },
  { 193, 8, 12, 10, 1, -12 },
  { 205, 8, 12, 10, 1, -12 },
  { 217, 8, 12, 10, 1, -12 },
  { 229, 8, 12, 10, 1, -12 },
  { 241, 3, 10, 10, 4, -10 },
  { 245, 3, 13, 10, 4, -10 },
  { 250, 8, 8, 10, 1, -9 },
  { 258, 8, 5, 10, 1, -8 },
  { 263, 8, 8, 10, 1, -9 },
  { 271, 8, 12, 10, 1, -12 },
  { 283, 10, 12, 10, 0, -12 },
  { 298, 10, 12, 10, 0, -12 },
  { 313, 9, 12, 10, 1, -12 },
  { 327, 8, 12, 10, 1, -12 },
  { 339, 8, 12, 10, 1, -12 },
  { 351, 8, 12, 10, 1, -12 },
  { 363, 8, 12, 10, 1, -12 },
  { 375, 8, 12, 10, 1, -12 },
  { 387, 8, 12, 10, 1, -12 },
  { 399, 7, 12, 10, 2, -12 },
  { 410, 8, 12, 10, 1, -12 },
  { 422, 9, 12, 10, 1, -12 },
  { 436, 8, 12, 10, 1, -12 },
  { 448, 8, 12, 10, 1, -12 },
  { 460, 8, 12, 10, 1, -12 },
  { 472, 8, 12, 10, 1, -12 },
  { 484, 9, 12, 10, 1, -12 },
  { 498, 9, 14, 10, 1, -12 },
  { 514, 9, 12, 10, 1, -12 },
  { 528, 9, 12, 10, 1, -12 },
  { 542, 10, 12, 10, 0, -12 },
  { 557, 8, 12, 10, 1, -12 },
  { 569, 10, 12, 10, 0, -12 },
  { 584, 10, 12, 10, 0, -12 },
  { 599, 10, 12, 10, 0, -12 },
  { 614, 10, 12, 10, 0, -12 },
  { 629, 8, 12, 10, 1, -12 },
  { 641, 4, 17, 10, 3, -14 },
  { 650, 7, 13, 10, 2, -12 },
  { 662, 4, 17, 10, 3, -14 },
  { 671, 7, 6, 10, 2, -12 },
  { 677, 8, 2, 10, 1, 0 },
  { 679, 4, 2, 10, 3, -12 },
  { 680, 8, 9, 10, 1, -9 },
  { 689, 8, 13, 10, 1, -13 },
  { 702, 8, 9, 10, 1, -9 },
  { 711, 8, 13, 10, 1, -13 },
  { 724, 8, 9, 10, 1, -9 },
  { 733, 9, 13, 10, 1, -13 },
  { 748, 8, 13, 10, 1, -9 },
  { 761, 8, 13, 10, 1, -13 },
  { 774, 7, 12, 10, 2, -12 },
  { 785, 5, 16, 10, 2, -12 },
  { 795, 9, 13, 10, 1, -13 },
  { 810, 7, 13, 10, 2, -13 },
  { 822, 8, 9, 10, 1, -9 },
  { 831, 8, 9, 10, 1, -9 },
  { 840, 8, 9, 10, 1, -9 },
  { 849, 8, 12, 10, 1, -9 },
  { 861, 8, 12, 10, 1, -9 },
  { 873, 7, 9, 10, 2, -9 },
  { 881, 8, 9, 10, 1, -9 },
  { 890, 8, 11, 10, 1, -11 },
  { 901, 8, 9, 10, 1, -9 },
  { 910, 9, 9, 10, 1, -9 },
  { 921, 10, 9, 10, 0, -9 },
  { 933, 9, 9, 10, 1, -9 },
  { 944, 10, 13, 10, 0, -9 },
  { 961, 8, 9, 10, 1, -9 },
  { 970, 5, 16, 10, 3, -13 },
  { 980, 2, 15, 10, 4, -12 },
  { 984, 5, 16, 10, 3, -13 },
  { 994, 10, 4, 10, 0, -7 },
};

const GFXfont RobotoMono_SemiBold17pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold17pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOMONO_SEMIBOLD17PT7B_H_
