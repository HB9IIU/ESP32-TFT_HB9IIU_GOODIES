#ifndef _ROBOTOMONO_SEMIBOLD9PT7B_H_
#define _ROBOTOMONO_SEMIBOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB6, 0x80, 0x3B, 0xD5, 0xF5, 0x28, 0x4B, 0x9E, 0x39, 0xF4,
  0xF7, 0x88, 0x75, 0x8C, 0x72, 0x98, 0xDD, 0xBC, 0xE0, 0x6A, 0xAA, 0x40,
  0x88, 0x92, 0x4A, 0x80, 0x4F, 0x6B, 0x27, 0xFE, 0x40, 0xE0, 0xF0, 0xC0,
  0x32, 0x44, 0x48, 0x80, 0xE9, 0xF9, 0x9E, 0xFD, 0xB6, 0xC0, 0x74, 0xC4,
  0x44, 0x7C, 0x74, 0x4C, 0x3C, 0xB8, 0x31, 0x94, 0xAF, 0x88, 0xF8, 0xE1,
  0x9E, 0x72, 0x1D, 0x94, 0xB8, 0xF8, 0x84, 0x42, 0x20, 0xE9, 0xEB, 0x9E,
  0x76, 0x56, 0xD1, 0x30, 0xC0, 0xC0, 0xC0, 0xA8, 0x1E, 0xC3, 0xF0, 0xF0,
  0x8E, 0x3C, 0xF1, 0x24, 0x04, 0x7D, 0xF7, 0xBB, 0x38, 0x31, 0x94, 0xB7,
  0xE4, 0xF9, 0xE9, 0x9F, 0x7E, 0x71, 0x84, 0xB8, 0xE9, 0x99, 0xBE, 0xF8,
  0xE8, 0x8F, 0xF8, 0xF8, 0x88, 0x7E, 0x71, 0xB4, 0xBC, 0x99, 0xF9, 0x99,
  0xF4, 0x44, 0x4F, 0x08, 0x42, 0x1C, 0xB8, 0xBA, 0xCA, 0xB9, 0x88, 0x88,
  0x8F, 0xBF, 0xDD, 0x99, 0x9D, 0xDD, 0xBB, 0x7E, 0x73, 0x94, 0xB8, 0xF9,
  0x9E, 0x88, 0x7E, 0x73, 0x94, 0xB8, 0x20, 0xF9, 0xBE, 0xA9, 0x7A, 0x1C,
  0x3C, 0xBC, 0xF9, 0x08, 0x42, 0x10, 0x99, 0x99, 0x9E, 0xCA, 0xD4, 0xA3,
  0x10, 0xAD, 0x5E, 0xB5, 0xA8, 0xDB, 0x8C, 0x65, 0x64, 0xCA, 0x8C, 0x42,
  0x10, 0xF8, 0x88, 0x44, 0x7C, 0xEA, 0xAB, 0x84, 0x44, 0x22, 0x30, 0xD5,
  0x57, 0x66, 0xB0, 0xF0, 0x90, 0xEB, 0xFB, 0xF0, 0x88, 0xE9, 0x99, 0xE0,
  0x69, 0x89, 0xE0, 0x11, 0xDB, 0x99, 0xF0, 0x69, 0xF8, 0xF0, 0x74, 0xF4,
  0x44, 0x40, 0xF9, 0x99, 0xFB, 0xE0, 0x88, 0xE9, 0x99, 0x90, 0x64, 0xC4,
  0x44, 0xF0, 0x27, 0x92, 0x49, 0xC0, 0x88, 0xBE, 0xCA, 0xB0, 0xC4, 0x44,
  0x44, 0xF0, 0xFD, 0x6B, 0x5A, 0x80, 0xE9, 0x99, 0x90, 0x72, 0x72, 0x97,
  0x00, 0xEB, 0x99, 0xE8, 0x80, 0xDB, 0x99, 0xF1, 0x10, 0xBC, 0x88, 0x80,
  0xE9, 0xE9, 0xE0, 0x4F, 0x44, 0x47, 0x99, 0x99, 0xF0, 0xCA, 0xD4, 0x62,
  0x00, 0xAD, 0x5A, 0xB5, 0x00, 0xCB, 0x8C, 0xEC, 0x80, 0xCA, 0x54, 0x62,
  0x11, 0x00, 0xF2, 0x4C, 0xF0, 0x25, 0xAC, 0xD9, 0x20, 0xFF, 0xC9, 0x22,
  0x92, 0x80, 0x45, 0xC0,
};

const GFXglyph RobotoMono_SemiBold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 5, 1, -7 },
  { 12, 5, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 3, 5, 2, -7 },
  { 21, 2, 9, 5, 2, -7 },
  { 24, 3, 9, 5, 1, -7 },
  { 28, 4, 4, 5, 1, -6 },
  { 30, 5, 4, 5, 0, -5 },
  { 33, 1, 3, 5, 2, -1 },
  { 34, 4, 1, 5, 1, -3 },
  { 35, 2, 1, 5, 2, -1 },
  { 36, 4, 7, 5, 1, -6 },
  { 40, 4, 6, 5, 1, -6 },
  { 43, 3, 6, 5, 1, -6 },
  { 46, 5, 6, 5, 0, -6 },
  { 50, 5, 6, 5, 0, -6 },
  { 54, 5, 6, 5, 0, -6 },
  { 58, 4, 6, 5, 1, -6 },
  { 61, 5, 6, 5, 0, -6 },
  { 65, 5, 6, 5, 0, -6 },
  { 69, 4, 6, 5, 1, -6 },
  { 72, 5, 6, 5, 0, -6 },
  { 76, 2, 5, 5, 2, -5 },
  { 78, 2, 7, 5, 2, -5 },
  { 80, 4, 4, 5, 1, -5 },
  { 82, 4, 3, 5, 1, -4 },
  { 84, 4, 4, 5, 1, -5 },
  { 86, 4, 6, 5, 1, -6 },
  { 89, 5, 6, 5, 0, -6 },
  { 93, 5, 6, 5, 0, -6 },
  { 97, 4, 6, 5, 1, -6 },
  { 100, 5, 6, 5, 0, -6 },
  { 104, 4, 6, 5, 1, -6 },
  { 107, 4, 6, 5, 1, -6 },
  { 110, 4, 6, 5, 1, -6 },
  { 113, 5, 6, 5, 0, -6 },
  { 117, 4, 6, 5, 1, -6 },
  { 120, 4, 6, 5, 1, -6 },
  { 123, 5, 6, 5, 0, -6 },
  { 127, 4, 6, 5, 1, -6 },
  { 130, 4, 6, 5, 1, -6 },
  { 133, 4, 6, 5, 1, -6 },
  { 136, 4, 6, 5, 1, -6 },
  { 139, 5, 6, 5, 0, -6 },
  { 143, 4, 6, 5, 1, -6 },
  { 146, 5, 7, 5, 0, -6 },
  { 151, 4, 6, 5, 1, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 5, 6, 5, 0, -6 },
  { 162, 4, 6, 5, 1, -6 },
  { 165, 5, 6, 5, 0, -6 },
  { 169, 5, 6, 5, 0, -6 },
  { 173, 5, 6, 5, 0, -6 },
  { 177, 5, 6, 5, 0, -6 },
  { 181, 5, 6, 5, 0, -6 },
  { 185, 2, 8, 5, 2, -7 },
  { 187, 4, 7, 5, 1, -6 },
  { 191, 2, 8, 5, 2, -7 },
  { 193, 4, 3, 5, 1, -6 },
  { 195, 4, 1, 5, 1, 0 },
  { 196, 2, 2, 5, 2, -7 },
  { 197, 4, 5, 5, 1, -5 },
  { 200, 4, 7, 5, 1, -7 },
  { 204, 4, 5, 5, 1, -5 },
  { 207, 4, 7, 5, 1, -7 },
  { 211, 4, 5, 5, 1, -5 },
  { 214, 4, 7, 5, 1, -7 },
  { 218, 4, 7, 5, 1, -5 },
  { 222, 4, 7, 5, 1, -7 },
  { 226, 4, 7, 5, 1, -7 },
  { 230, 3, 9, 5, 1, -7 },
  { 234, 4, 7, 5, 1, -7 },
  { 238, 4, 7, 5, 1, -7 },
  { 242, 5, 5, 5, 0, -5 },
  { 246, 4, 5, 5, 1, -5 },
  { 249, 5, 5, 5, 0, -5 },
  { 253, 4, 7, 5, 1, -5 },
  { 257, 4, 7, 5, 1, -5 },
  { 261, 4, 5, 5, 1, -5 },
  { 264, 4, 5, 5, 1, -5 },
  { 267, 4, 6, 5, 1, -6 },
  { 270, 4, 5, 5, 1, -5 },
  { 273, 5, 5, 5, 0, -5 },
  { 277, 5, 5, 5, 0, -5 },
  { 281, 5, 5, 5, 0, -5 },
  { 285, 5, 7, 5, 0, -5 },
  { 290, 4, 5, 5, 1, -5 },
  { 293, 3, 9, 5, 1, -7 },
  { 297, 1, 8, 5, 2, -6 },
  { 298, 3, 9, 5, 1, -7 },
  { 302, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoMono_SemiBold9pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold9pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOMONO_SEMIBOLD9PT7B_H_
