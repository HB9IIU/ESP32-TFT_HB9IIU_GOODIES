#ifndef _ROBOTOMONO_SEMIBOLD34PT7B_H_
#define _ROBOTOMONO_SEMIBOLD34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x00,
  0x00, 0x4F, 0x7F, 0xFE, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x86, 0xE1, 0x80, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x60, 0x0E,
  0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x30, 0xE1, 0xFF, 0xFF, 0x7F, 0xFF,
  0xC1, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x70, 0x0E, 0x1C, 0x03, 0x86, 0x0F,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x83, 0x0E, 0x01, 0xC3, 0x80, 0x70,
  0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7C, 0x3E, 0x7C, 0x0F, 0x3C, 0x07, 0xDE, 0x03, 0xEF, 0x80, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0xF0,
  0x1F, 0x7E, 0x1F, 0x1F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x08, 0x00, 0x0F, 0xC0, 0x03, 0xFC,
  0x00, 0x73, 0xC0, 0x0E, 0x38, 0xE1, 0xC7, 0x1C, 0x38, 0xE7, 0x07, 0x1C,
  0xE0, 0xFF, 0xB8, 0x0F, 0xE7, 0x00, 0xF9, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0xFC, 0x03, 0xBF, 0xC0, 0xE7,
  0x38, 0x1D, 0xC3, 0x87, 0x38, 0x70, 0xE7, 0x0E, 0x08, 0xE1, 0xC0, 0x0E,
  0x70, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x3F,
  0xE0, 0x0F, 0xFE, 0x01, 0xE3, 0xC0, 0x3C, 0x38, 0x07, 0x87, 0x00, 0xF1,
  0xE0, 0x1E, 0x3C, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x83, 0xCF, 0xF8, 0x7B, 0xEF, 0x8F, 0x78, 0xF9, 0xDF, 0x0F,
  0xFB, 0xE1, 0xFF, 0x7C, 0x1F, 0xC7, 0x81, 0xF8, 0xF8, 0x7F, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x0F, 0xF3, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x01,
  0xC1, 0xE1, 0xE1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0x80, 0x40, 0x40, 0x18, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x38, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x18, 0x04, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x81, 0x81, 0xF1, 0x87, 0xFD, 0xBF,
  0xFF, 0xFF, 0x1F, 0xF8, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0xF0, 0x1E, 0x70,
  0x3C, 0x38, 0x7C, 0x3C, 0x18, 0x18, 0x08, 0x10, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7D, 0xF7, 0xDF, 0x7D,
  0xE7, 0x9E, 0xF3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x7C, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x80, 0x0F,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1F, 0x78,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF9, 0xEF, 0xFF,
  0xCF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78,
  0x1F, 0x7C, 0x1E, 0x3E, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00,
  0xC0, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC7, 0xC3, 0xF3, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x01,
  0x00, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0xFC, 0x3E, 0xF8, 0x1E, 0xF0,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x07, 0xFC, 0x07,
  0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x03, 0xCF, 0x80,
  0xE3, 0xE0, 0x78, 0xF8, 0x3C, 0x3E, 0x0E, 0x0F, 0x87, 0x83, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x79,
  0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x18, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7C,
  0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x01, 0xF8, 0x07, 0xF8, 0x0F,
  0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF9,
  0xF0, 0xF7, 0xFC, 0xFF, 0xFE, 0xFE, 0xFE, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x1E, 0x7E,
  0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x80,
  0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1F,
  0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x3E, 0x3E, 0x3F, 0xFC, 0x0F, 0xF0,
  0x3F, 0xFC, 0x7E, 0x7E, 0x78, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0,
  0x01, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x7C, 0xF8, 0x3E,
  0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x7E, 0x7F, 0x7F, 0xFF, 0x3F, 0xFE, 0x0F, 0xDE, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0,
  0x1F, 0x00, 0xFB, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xBF, 0xFF, 0xFF, 0x80, 0x3C, 0xFD, 0xFB, 0xF3, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x1E, 0x38, 0xF0, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFB,
  0xFF, 0x0F, 0xE0, 0x3C, 0x00, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x01, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0x00, 0xFE, 0x0F, 0xF8, 0xFF, 0xC7,
  0xFC, 0x0F, 0xE0, 0x1E, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xEF, 0xC3, 0xFE, 0x07, 0xFC, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x70, 0x0E, 0x38, 0x01, 0x8C, 0x3E, 0x77, 0x1F, 0xCD, 0x8F,
  0xF3, 0xE3, 0x1C, 0xF9, 0xC6, 0x3E, 0x71, 0x8F, 0x18, 0x63, 0xC6, 0x18,
  0xF3, 0x86, 0x3C, 0xE1, 0x8F, 0x9C, 0xE6, 0xE7, 0xFF, 0xB9, 0xFF, 0xC6,
  0x18, 0xE1, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x86, 0x01, 0xFF, 0x80, 0x1F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x3C, 0x1E, 0x07, 0x83,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x3C, 0x03,
  0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xBE, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0x0F, 0xEF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x7C, 0x0F, 0xBF, 0xFF, 0x9F, 0xFF, 0x0F,
  0xFF, 0xE7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF,
  0xE0, 0x00, 0x40, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3E, 0x1F,
  0x8F, 0x01, 0xE7, 0xC0, 0x7D, 0xE0, 0x1F, 0x78, 0x03, 0xFE, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF7, 0x80, 0x7D, 0xF0, 0x1F, 0x3C, 0x0F,
  0x8F, 0xC7, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0x3F, 0xCF, 0x83, 0xE7, 0xC0, 0xFB, 0xE0,
  0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x7C, 0x07,
  0xBE, 0x07, 0xDF, 0x07, 0xCF, 0x9F, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0x80, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x40, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0x1F,
  0x8F, 0x01, 0xE7, 0xC0, 0x79, 0xE0, 0x1F, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x1F, 0xFF, 0x87, 0xFD, 0xE1,
  0xFF, 0x78, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x7D, 0xF0, 0x1F, 0x3E, 0x07,
  0xCF, 0xC3, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0x7C, 0x7E, 0x7F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xF0, 0xF8, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x7C, 0x7C,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xBE, 0x07, 0xE7, 0xC0, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0,
  0x3F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF9,
  0xDF, 0xFE, 0xEF, 0xF7, 0x77, 0xFB, 0xF3, 0xFD, 0xF9, 0xFE, 0x7C, 0xFF,
  0x3C, 0x7F, 0x9E, 0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xF7, 0x0F, 0xF7, 0x8F, 0xF3, 0x8F, 0xF3,
  0xCF, 0xF1, 0xCF, 0xF1, 0xEF, 0xF1, 0xEF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0x00, 0x40, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3E, 0x1F,
  0x0F, 0x03, 0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0x78, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x79, 0xF0, 0x1E, 0x3C, 0x0F,
  0x8F, 0xCF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xFE, 0xF0, 0x7E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xE1, 0xF0, 0x78, 0x1F,
  0x1F, 0x01, 0xE3, 0xC0, 0x3E, 0x78, 0x07, 0xCF, 0x00, 0x7B, 0xE0, 0x0F,
  0x7C, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x1E,
  0xF8, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1F, 0x3E, 0x03, 0xC3, 0xC0, 0xF8,
  0x7E, 0x3E, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x18, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xE1, 0xFC, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x1E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xE1, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x0F,
  0x83, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x1F, 0x00, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xC1, 0xF3,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFB, 0xF0, 0xFC,
  0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7E, 0x3E, 0x3F, 0xFE,
  0x1F, 0xFC, 0x0F, 0xF0, 0xF8, 0x03, 0xFF, 0x00, 0x7B, 0xE0, 0x1F, 0x3C,
  0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x1F, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x3E,
  0x0F, 0x03, 0xC3, 0xE0, 0x78, 0x78, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x1E,
  0x7C, 0x03, 0xCF, 0x00, 0x7D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0xF0, 0xE1, 0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0xF8, 0xF0, 0xEF, 0x1F,
  0x3D, 0xE3, 0xE7, 0xBC, 0x7C, 0xF3, 0x9F, 0x9E, 0x7B, 0xF3, 0xCF, 0x7E,
  0x79, 0xEF, 0xCF, 0x3D, 0xDD, 0xC7, 0xBB, 0xF8, 0xF7, 0x7F, 0x0F, 0xCF,
  0xE1, 0xF9, 0xFC, 0x3F, 0x3F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x8F,
  0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0x78, 0xF8, 0x03,
  0xEF, 0x80, 0xF9, 0xF0, 0x3E, 0x1F, 0x07, 0xC1, 0xE1, 0xF0, 0x3E, 0x3E,
  0x03, 0xCF, 0x80, 0x7D, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3D, 0xE0,
  0x0F, 0xBE, 0x03, 0xE3, 0xC0, 0x7C, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0xF8, 0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x79,
  0xF0, 0x1F, 0x3E, 0x03, 0xC3, 0xC0, 0xF8, 0x7C, 0x1E, 0x07, 0x87, 0xC0,
  0xF8, 0xF0, 0x0F, 0x3E, 0x01, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xFE,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFF, 0xFF, 0xFE,
  0x07, 0x00, 0x7C, 0x03, 0xE0, 0x3F, 0x81, 0xDC, 0x0E, 0xE0, 0xE7, 0x87,
  0x1C, 0x78, 0xF3, 0x87, 0xBC, 0x1D, 0xE0, 0xFE, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0xF0, 0x3F,
  0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0xF8, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x07,
  0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF8,
  0x1E, 0xF8, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x1F, 0xCF, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF7, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xE3, 0xEF, 0x03, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x07, 0xFF, 0x1F, 0x7F, 0xFE, 0xFF, 0xF9, 0xCF, 0xE0, 0x07, 0xF0,
  0x1F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x0F,
  0x78, 0x1F, 0x7E, 0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x0F, 0xCF, 0x3F, 0xEF, 0x3F, 0xFF, 0x7E, 0x3F, 0x78, 0x1F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7E, 0x3F, 0x3F, 0xFF, 0x3F, 0xEF,
  0x0F, 0xCF, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xC7, 0xC7, 0xC1,
  0xF7, 0xC0, 0x7B, 0xE0, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x31, 0xF8, 0x7C, 0x7F, 0xFE,
  0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7E, 0x10, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x0F, 0xCF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7E, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xCF, 0x00, 0x0F, 0x00, 0x1F, 0x30, 0x1E, 0x3C, 0x7E, 0x7F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF8, 0xFB, 0xFE, 0xFF,
  0xFE, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x07, 0x00, 0x1E, 0x00, 0xF8,
  0x01, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x78, 0x0F, 0x81, 0xE0, 0x18, 0x00, 0x00,
  0x03, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE8, 0xFD, 0xFF, 0x3F, 0xC7, 0xF0, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0xBE, 0x0F, 0x8F, 0x87, 0xC3,
  0xE3, 0xE0, 0xF9, 0xF8, 0x3E, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xF3, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F,
  0x0F, 0x83, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0xBE, 0x03, 0xF0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF7,
  0xCF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xDF, 0xF1, 0xE3, 0xFC, 0x78,
  0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F,
  0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1,
  0xE3, 0xFC, 0x78, 0xF0, 0xF1, 0xF8, 0xFB, 0xFE, 0xFF, 0xFE, 0xFE, 0x3F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xCF,
  0xC7, 0x81, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xEF, 0x80, 0xF3, 0xC0, 0xF9, 0xF8, 0xF8,
  0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0xFB, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFE, 0x7E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xCF, 0x3F,
  0xEF, 0x3F, 0xFF, 0x7E, 0x3F, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78,
  0x1F, 0x7E, 0x3F, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0xCF, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF1,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C,
  0x1F, 0x78, 0x0F, 0x78, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0x7C, 0x1F, 0x7F,
  0xFE, 0x3F, 0xFE, 0x0F, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC1, 0x07, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x07, 0xFE, 0x1F, 0xBF, 0xFF, 0x7F, 0xDE, 0x7F, 0x3C, 0xF8,
  0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x00, 0xF3, 0xC0,
  0x1E, 0xF0, 0x07, 0xB8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0xF0, 0xE1, 0xFE, 0x3C, 0x3B, 0xC7, 0x8F, 0x78,
  0xF1, 0xEF, 0x1E, 0x3C, 0xE3, 0xE7, 0x9C, 0xFC, 0xE3, 0x9F, 0x9C, 0x7B,
  0xB3, 0x8F, 0x66, 0xF1, 0xEC, 0xFE, 0x1F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7E,
  0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x1E, 0x1F, 0x03, 0xC3, 0xC0, 0xF8,
  0x0F, 0x9E, 0x03, 0xC7, 0xC1, 0xF0, 0xF8, 0xF8, 0x1F, 0x7C, 0x03, 0xDF,
  0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xE0, 0x1F, 0x7C, 0x07, 0x8F, 0x03, 0xE3, 0xE1, 0xF0, 0x7C, 0x78,
  0x0F, 0xBE, 0x03, 0xF0, 0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x1F, 0x3E,
  0x03, 0xE3, 0xC0, 0x78, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF8, 0xF8, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x3C, 0x0F, 0x81,
  0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x07, 0x87, 0xF0, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0xF8, 0x0F, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0x07, 0x00, 0xF8, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x7F, 0x01, 0xF0, 0x3F, 0x07, 0xC0, 0xF0, 0x0F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0xFC, 0x07, 0x80, 0x60, 0x00, 0x08, 0x00, 0x1F, 0xC0, 0x77,
  0xFC, 0x1F, 0xFF, 0x8F, 0xE1, 0xFF, 0xF8, 0x3F, 0xE4, 0x07, 0xF0, 0x00,
  0x30,
};

const GFXglyph RobotoMono_SemiBold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 5, 24, 20, 8, -24 },
  { 16, 10, 9, 20, 5, -26 },
  { 28, 18, 24, 20, 1, -24 },
  { 82, 17, 32, 20, 2, -28 },
  { 150, 19, 25, 20, 1, -25 },
  { 210, 19, 25, 20, 1, -25 },
  { 270, 3, 9, 20, 8, -26 },
  { 274, 9, 35, 20, 6, -27 },
  { 314, 10, 35, 20, 5, -27 },
  { 358, 16, 17, 20, 3, -24 },
  { 392, 16, 18, 20, 2, -20 },
  { 428, 6, 10, 20, 6, -4 },
  { 436, 14, 3, 20, 4, -12 },
  { 442, 6, 5, 20, 7, -5 },
  { 446, 13, 26, 20, 4, -24 },
  { 489, 16, 25, 20, 2, -25 },
  { 539, 10, 24, 20, 3, -24 },
  { 569, 17, 25, 20, 1, -25 },
  { 623, 16, 25, 20, 2, -25 },
  { 673, 18, 24, 20, 1, -24 },
  { 727, 16, 24, 20, 2, -24 },
  { 775, 16, 24, 20, 2, -24 },
  { 823, 17, 24, 20, 1, -24 },
  { 874, 16, 25, 20, 2, -25 },
  { 924, 16, 25, 20, 2, -25 },
  { 974, 6, 19, 20, 8, -19 },
  { 989, 7, 25, 20, 7, -19 },
  { 1011, 14, 15, 20, 3, -18 },
  { 1038, 15, 11, 20, 3, -16 },
  { 1059, 15, 15, 20, 3, -18 },
  { 1088, 15, 25, 20, 3, -25 },
  { 1135, 18, 24, 20, 1, -24 },
  { 1189, 19, 24, 20, 1, -24 },
  { 1246, 17, 24, 20, 2, -24 },
  { 1297, 18, 25, 20, 1, -25 },
  { 1354, 17, 24, 20, 2, -24 },
  { 1405, 16, 24, 20, 3, -24 },
  { 1453, 16, 24, 20, 3, -24 },
  { 1501, 18, 25, 20, 1, -25 },
  { 1558, 16, 24, 20, 2, -24 },
  { 1606, 14, 24, 20, 3, -24 },
  { 1648, 16, 24, 20, 2, -24 },
  { 1696, 19, 24, 20, 2, -24 },
  { 1753, 15, 24, 20, 3, -24 },
  { 1798, 17, 24, 20, 2, -24 },
  { 1849, 16, 24, 20, 2, -24 },
  { 1897, 18, 25, 20, 1, -25 },
  { 1954, 16, 24, 20, 3, -24 },
  { 2002, 19, 29, 20, 1, -25 },
  { 2071, 18, 24, 20, 2, -24 },
  { 2125, 17, 25, 20, 2, -25 },
  { 2179, 19, 24, 20, 1, -24 },
  { 2236, 16, 24, 20, 2, -24 },
  { 2284, 19, 24, 20, 1, -24 },
  { 2341, 19, 24, 20, 1, -24 },
  { 2398, 19, 24, 20, 1, -24 },
  { 2455, 19, 24, 20, 1, -24 },
  { 2512, 17, 24, 20, 2, -24 },
  { 2563, 7, 33, 20, 7, -28 },
  { 2592, 13, 26, 20, 4, -24 },
  { 2635, 7, 33, 20, 7, -28 },
  { 2664, 13, 13, 20, 4, -24 },
  { 2686, 16, 3, 20, 2, 0 },
  { 2692, 8, 5, 20, 7, -25 },
  { 2697, 16, 18, 20, 2, -18 },
  { 2733, 15, 26, 20, 3, -26 },
  { 2782, 16, 18, 20, 2, -18 },
  { 2818, 16, 26, 20, 2, -26 },
  { 2870, 17, 18, 20, 2, -18 },
  { 2909, 17, 26, 20, 2, -26 },
  { 2965, 16, 25, 20, 2, -18 },
  { 3015, 16, 26, 20, 2, -26 },
  { 3067, 14, 25, 20, 4, -25 },
  { 3111, 11, 32, 20, 4, -25 },
  { 3155, 18, 26, 20, 2, -26 },
  { 3214, 15, 26, 20, 3, -26 },
  { 3263, 18, 18, 20, 1, -18 },
  { 3304, 16, 18, 20, 2, -18 },
  { 3340, 17, 18, 20, 2, -18 },
  { 3379, 16, 25, 20, 2, -18 },
  { 3429, 16, 25, 20, 2, -18 },
  { 3479, 13, 18, 20, 5, -18 },
  { 3509, 16, 18, 20, 2, -18 },
  { 3545, 16, 22, 20, 2, -22 },
  { 3589, 15, 18, 20, 3, -18 },
  { 3623, 18, 18, 20, 1, -18 },
  { 3664, 19, 18, 20, 1, -18 },
  { 3707, 18, 18, 20, 2, -18 },
  { 3748, 19, 25, 20, 1, -18 },
  { 3808, 17, 18, 20, 2, -18 },
  { 3847, 11, 33, 20, 5, -27 },
  { 3893, 3, 31, 20, 9, -24 },
  { 3905, 12, 33, 20, 5, -27 },
  { 3955, 18, 8, 20, 1, -14 },
};

const GFXfont RobotoMono_SemiBold34pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold34pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOMONO_SEMIBOLD34PT7B_H_
