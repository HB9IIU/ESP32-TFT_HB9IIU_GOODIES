#ifndef _ROBOTOMONO_SEMIBOLD18PT7B_H_
#define _ROBOTOMONO_SEMIBOLD18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xED, 0xB6, 0xC0, 0x7E, 0x9C, 0xE7, 0x39, 0x80, 0x0D, 0x82,
  0x60, 0x98, 0x64, 0x7F, 0xC6, 0x41, 0x30, 0x4C, 0xFF, 0xCC, 0x83, 0x20,
  0xD8, 0x26, 0x00, 0x0C, 0x06, 0x07, 0x8F, 0xE6, 0x3B, 0x0D, 0x80, 0xF0,
  0x3E, 0x07, 0x80, 0xF8, 0x3E, 0x3B, 0xF8, 0xF8, 0x10, 0x08, 0x00, 0x70,
  0x36, 0x0C, 0x9B, 0x2C, 0x7A, 0x0D, 0x80, 0x40, 0x30, 0x0B, 0xC6, 0x93,
  0x24, 0x09, 0x03, 0xC0, 0x3C, 0x1F, 0x86, 0x61, 0x98, 0x6E, 0x0F, 0x03,
  0x81, 0xF6, 0xCD, 0xB3, 0xEC, 0x73, 0xFE, 0x7D, 0xC0, 0xFF, 0xC0, 0x19,
  0x8C, 0xC6, 0x63, 0x18, 0xC6, 0x31, 0x84, 0x31, 0x86, 0x18, 0x40, 0x86,
  0x18, 0x63, 0x18, 0xC3, 0x18, 0xC6, 0x63, 0x18, 0x8C, 0xC4, 0x00, 0x0C,
  0x06, 0x03, 0x0D, 0x3F, 0xF8, 0xE0, 0x58, 0xE6, 0x22, 0x00, 0x18, 0x0C,
  0x06, 0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x6D, 0xBC,
  0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x1C, 0x30, 0x61, 0x83, 0x06, 0x18, 0x30,
  0x61, 0x83, 0x06, 0x18, 0x00, 0x3C, 0x3F, 0x98, 0xDC, 0x6E, 0x3F, 0x3F,
  0xFF, 0xE7, 0xE3, 0xF1, 0x98, 0xCF, 0xE3, 0xE0, 0x0B, 0xFF, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x80, 0x3C, 0x3F, 0x31, 0xD8, 0x60, 0x30, 0x38,
  0x38, 0x18, 0x18, 0x18, 0x18, 0x1F, 0xFF, 0xF8, 0x3C, 0x7F, 0xE3, 0xC3,
  0x03, 0x07, 0x1E, 0x07, 0x03, 0x03, 0xC3, 0xFF, 0x7E, 0x06, 0x07, 0x03,
  0x83, 0xC3, 0x61, 0xB1, 0x99, 0x8C, 0xFF, 0xFF, 0xC1, 0x80, 0xC0, 0x60,
  0x7F, 0x3F, 0x98, 0x0C, 0x06, 0x03, 0xF1, 0x9C, 0x06, 0x03, 0xE1, 0xF8,
  0xCF, 0xE3, 0xE0, 0x0E, 0x1F, 0x1C, 0x0C, 0x0E, 0x86, 0xF3, 0x9D, 0x86,
  0xC3, 0xE1, 0xF8, 0xCF, 0xE3, 0xE0, 0xFF, 0xFF, 0xC0, 0xC0, 0x60, 0x60,
  0x30, 0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x00, 0x3C, 0x3F, 0x98,
  0xDC, 0x6E, 0x33, 0xB8, 0xF8, 0xEE, 0xE3, 0x61, 0xF8, 0xCF, 0xE3, 0xE0,
  0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3B, 0x03, 0x06, 0x3E,
  0x38, 0x7F, 0x80, 0x03, 0xFC, 0x6F, 0x60, 0x00, 0x00, 0x66, 0x6E, 0xC0,
  0x01, 0x07, 0x1F, 0x78, 0xE0, 0x7C, 0x1F, 0x07, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x80, 0xE0, 0xFC, 0x1F, 0x03, 0x1F, 0xFC, 0xE0, 0x80,
  0x3E, 0x3F, 0x98, 0xD0, 0x70, 0x30, 0x38, 0x38, 0x18, 0x1C, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x0E, 0x07, 0xE2, 0x0D, 0xBD, 0x4B, 0x56, 0xDD, 0x37,
  0x49, 0xDA, 0x57, 0xE6, 0x00, 0xC4, 0x1F, 0x00, 0x0E, 0x01, 0xC0, 0x38,
  0x0F, 0x81, 0xB0, 0x36, 0x0E, 0xE1, 0x8C, 0x3F, 0x8F, 0xF9, 0x83, 0x30,
  0x6E, 0x0E, 0xFE, 0x7F, 0xB8, 0xFC, 0x3E, 0x1F, 0x3B, 0xF9, 0xC7, 0xE1,
  0xF0, 0xF8, 0xFF, 0xFF, 0xE0, 0x3E, 0x3F, 0xB8, 0xF8, 0x3C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0xF8, 0xEF, 0xE3, 0xE0, 0xF8, 0x7F, 0x31, 0xD8,
  0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF1, 0xDF, 0xCF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0xFB, 0xFD, 0xC0, 0xE0, 0x70, 0x38, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x00, 0x3E, 0x3F, 0xB8, 0xF8, 0x3C, 0x06, 0x03,
  0x3F, 0x9F, 0xC1, 0xE0, 0xF8, 0x6F, 0xF3, 0xF0, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3F, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x38, 0xFF,
  0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE7, 0xFF, 0xE0, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xE1, 0xF8, 0xCF,
  0xE3, 0xE0, 0xE1, 0xF8, 0xEE, 0x73, 0x98, 0xEC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xEE, 0x39, 0xCE, 0x33, 0x8E, 0xE1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xF8, 0xE3, 0xF1,
  0xFD, 0xFE, 0xFD, 0x5E, 0xEF, 0x77, 0xB3, 0xC9, 0xE0, 0xF0, 0x78, 0x3C,
  0x18, 0xE3, 0xF1, 0xF8, 0xFE, 0x7F, 0x3E, 0xDF, 0x6F, 0x9F, 0xCF, 0xE3,
  0xF1, 0xF8, 0x7C, 0x38, 0x3C, 0x3F, 0xB8, 0xD8, 0x7C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE1, 0xF8, 0xCF, 0xE3, 0xE0, 0xFE, 0x7F, 0xB8, 0xFC, 0x3E,
  0x1F, 0x0F, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x3C, 0x1F,
  0xCE, 0x33, 0x0E, 0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0x6E, 0x39,
  0xFC, 0x3F, 0x00, 0xF0, 0x18, 0xFC, 0x7F, 0xB8, 0xFC, 0x3E, 0x1F, 0x1F,
  0xFD, 0xFC, 0xE6, 0x73, 0xB8, 0xDC, 0x7E, 0x18, 0x3E, 0x3F, 0xB8, 0xF8,
  0x3E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xE0, 0xF8, 0x6F, 0xF3, 0xF0, 0xFF,
  0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x00, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xF1, 0xF8, 0xCF, 0xE3, 0xE0, 0xE0, 0xD8, 0x36, 0x1D, 0xC6,
  0x31, 0x8C, 0xE3, 0xB8, 0x6C, 0x1B, 0x07, 0xC1, 0xE0, 0x38, 0x0E, 0x00,
  0xC4, 0xFD, 0x99, 0xBB, 0x37, 0x66, 0xEC, 0xDD, 0x9A, 0xB3, 0xD6, 0x7B,
  0x87, 0x70, 0xEE, 0x19, 0xC3, 0x18, 0xE0, 0xEE, 0x38, 0xC6, 0x1D, 0xC1,
  0xB0, 0x3E, 0x03, 0x80, 0x70, 0x1B, 0x07, 0x70, 0xC6, 0x38, 0xEE, 0x0E,
  0xE0, 0xEC, 0x19, 0xC6, 0x18, 0xC3, 0xB8, 0x36, 0x07, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0xE0,
  0x60, 0x70, 0x70, 0x30, 0x38, 0x18, 0x1F, 0xFF, 0xF8, 0xFF, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xFC, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18,
  0x30, 0x30, 0x60, 0xE0, 0xC0, 0xFD, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0xFC,
  0x10, 0x70, 0xA3, 0x66, 0xC8, 0xF1, 0x80, 0xFF, 0xFF, 0xC7, 0x1C, 0x3F,
  0x38, 0xC0, 0x63, 0xF3, 0xFB, 0x0D, 0x86, 0xFF, 0x3F, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0xC7, 0xFB, 0x8D, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x6F,
  0xF6, 0xF0, 0x1C, 0x3F, 0x98, 0xDC, 0x7C, 0x06, 0x03, 0x03, 0xC6, 0x7F,
  0x1F, 0x00, 0x03, 0x03, 0x03, 0x03, 0x1B, 0x7F, 0x63, 0xE3, 0xC3, 0xC3,
  0xC3, 0xE3, 0x7F, 0x3F, 0x1C, 0x1F, 0x98, 0xDC, 0x3F, 0xFF, 0xFF, 0x01,
  0xC2, 0x7F, 0x9F, 0x00, 0x07, 0x8F, 0xC6, 0x03, 0x0F, 0xF7, 0xF8, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x1B, 0xBF, 0xD8, 0xFC,
  0x7C, 0x3E, 0x1F, 0x0F, 0xC7, 0x7F, 0x9F, 0xC0, 0xC8, 0x67, 0xF0, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xE7, 0xFB, 0x8D, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1C, 0x18, 0x38, 0x00, 0xF8, 0xF8, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0xFF, 0x1C, 0x70, 0x1F, 0x7C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xBE, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x3F,
  0x3B, 0xB9, 0xF8, 0xF8, 0x7E, 0x3B, 0x9C, 0xEE, 0x37, 0x1C, 0xF8, 0xF8,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0xDB, 0x7F, 0xF6, 0x7B, 0x3D, 0x9E, 0xCF, 0x67, 0xB3, 0xD9, 0xEC, 0xC0,
  0xCE, 0x6F, 0xB8, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0,
  0x1C, 0x3F, 0x18, 0xDC, 0x7C, 0x1E, 0x0F, 0x0F, 0xC6, 0x7F, 0x1F, 0x00,
  0xCC, 0x7F, 0xB9, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC6, 0xFF, 0x7F, 0x38,
  0x1C, 0x0E, 0x07, 0x00, 0x1B, 0x7F, 0x63, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3,
  0x7F, 0x3F, 0x03, 0x03, 0x03, 0x03, 0xCF, 0xFF, 0xF6, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x80, 0x1C, 0x3F, 0x98, 0xFC, 0x07, 0x81, 0xF8, 0x0F, 0x87,
  0x77, 0x1F, 0x00, 0x38, 0x1C, 0x3F, 0xDF, 0xE3, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x07, 0xC3, 0xF0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0x7F, 0x9F, 0xC0, 0xC1, 0xE1, 0xF8, 0xCC, 0x66, 0x71, 0xB0,
  0xD8, 0x68, 0x1C, 0x0E, 0x00, 0xC4, 0xF3, 0x36, 0xCD, 0xBB, 0x6E, 0xDA,
  0xA7, 0xA8, 0xEE, 0x33, 0x8C, 0x60, 0xC1, 0xB1, 0xDD, 0xC7, 0xC1, 0xC0,
  0xE0, 0xF8, 0x6E, 0x63, 0x70, 0xC0, 0xE0, 0xEC, 0x19, 0xC7, 0x18, 0xC3,
  0x98, 0x36, 0x06, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80,
  0xE0, 0x00, 0xFF, 0xFF, 0xC1, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xC0, 0x08, 0x73, 0x0C, 0x30, 0xC3, 0x18, 0xC1, 0x83, 0x0C, 0x30,
  0xC3, 0x06, 0x1C, 0xFF, 0xFF, 0x80, 0xC1, 0x86, 0x18, 0x71, 0xC3, 0x0C,
  0x1C, 0xE3, 0x1C, 0x71, 0x86, 0x18, 0xC0, 0x78, 0x5F, 0x3C, 0x7C, 0x0C,
};

const GFXglyph RobotoMono_SemiBold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 5, 5, 11, 3, -14 },
  { 10, 10, 13, 11, 0, -13 },
  { 27, 9, 17, 11, 1, -15 },
  { 47, 10, 13, 11, 0, -13 },
  { 64, 10, 13, 11, 1, -13 },
  { 81, 2, 5, 11, 4, -14 },
  { 83, 5, 18, 11, 3, -14 },
  { 95, 5, 18, 11, 3, -14 },
  { 107, 9, 9, 11, 1, -13 },
  { 118, 9, 10, 11, 1, -11 },
  { 130, 3, 5, 11, 3, -2 },
  { 132, 8, 2, 11, 2, -7 },
  { 134, 3, 3, 11, 4, -3 },
  { 136, 7, 14, 11, 2, -13 },
  { 149, 9, 13, 11, 1, -13 },
  { 164, 5, 13, 11, 2, -13 },
  { 173, 9, 13, 11, 1, -13 },
  { 188, 8, 13, 11, 1, -13 },
  { 201, 9, 13, 11, 1, -13 },
  { 216, 9, 13, 11, 1, -13 },
  { 231, 9, 13, 11, 1, -13 },
  { 246, 9, 13, 11, 1, -13 },
  { 261, 9, 13, 11, 1, -13 },
  { 276, 8, 13, 11, 1, -13 },
  { 289, 3, 10, 11, 4, -10 },
  { 293, 4, 13, 11, 4, -10 },
  { 300, 8, 9, 11, 1, -10 },
  { 309, 9, 5, 11, 1, -8 },
  { 315, 8, 9, 11, 1, -10 },
  { 324, 9, 13, 11, 1, -13 },
  { 339, 10, 13, 11, 0, -13 },
  { 356, 11, 13, 11, 0, -13 },
  { 374, 9, 13, 11, 1, -13 },
  { 389, 9, 13, 11, 1, -13 },
  { 404, 9, 13, 11, 1, -13 },
  { 419, 9, 13, 11, 1, -13 },
  { 434, 9, 13, 11, 1, -13 },
  { 449, 9, 13, 11, 1, -13 },
  { 464, 9, 13, 11, 1, -13 },
  { 479, 7, 13, 11, 2, -13 },
  { 491, 9, 13, 11, 1, -13 },
  { 506, 10, 13, 11, 1, -13 },
  { 523, 9, 13, 11, 1, -13 },
  { 538, 9, 13, 11, 1, -13 },
  { 553, 9, 13, 11, 1, -13 },
  { 568, 9, 13, 11, 1, -13 },
  { 583, 9, 13, 11, 1, -13 },
  { 598, 10, 15, 11, 1, -13 },
  { 617, 9, 13, 11, 1, -13 },
  { 632, 9, 13, 11, 1, -13 },
  { 647, 10, 13, 11, 0, -13 },
  { 664, 9, 13, 11, 1, -13 },
  { 679, 10, 13, 11, 0, -13 },
  { 696, 11, 13, 11, 0, -13 },
  { 714, 11, 13, 11, 0, -13 },
  { 732, 11, 13, 11, 0, -13 },
  { 750, 9, 13, 11, 1, -13 },
  { 765, 3, 18, 11, 4, -15 },
  { 772, 7, 14, 11, 2, -13 },
  { 785, 3, 18, 11, 4, -15 },
  { 792, 7, 7, 11, 2, -13 },
  { 799, 8, 2, 11, 1, 0 },
  { 801, 4, 2, 11, 4, -13 },
  { 802, 9, 10, 11, 1, -10 },
  { 814, 9, 14, 11, 1, -14 },
  { 830, 9, 10, 11, 1, -10 },
  { 842, 8, 14, 11, 1, -14 },
  { 856, 9, 10, 11, 1, -10 },
  { 868, 9, 14, 11, 1, -14 },
  { 884, 9, 14, 11, 1, -10 },
  { 900, 9, 14, 11, 1, -14 },
  { 916, 8, 13, 11, 2, -13 },
  { 929, 6, 17, 11, 2, -13 },
  { 942, 9, 14, 11, 1, -14 },
  { 958, 8, 14, 11, 2, -14 },
  { 972, 9, 10, 11, 1, -10 },
  { 984, 9, 10, 11, 1, -10 },
  { 996, 9, 10, 11, 1, -10 },
  { 1008, 9, 14, 11, 1, -10 },
  { 1024, 8, 14, 11, 1, -10 },
  { 1038, 7, 10, 11, 3, -10 },
  { 1047, 9, 10, 11, 1, -10 },
  { 1059, 9, 12, 11, 1, -12 },
  { 1073, 9, 10, 11, 1, -10 },
  { 1085, 9, 10, 11, 1, -10 },
  { 1097, 10, 10, 11, 0, -10 },
  { 1110, 9, 10, 11, 1, -10 },
  { 1122, 11, 14, 11, 0, -10 },
  { 1142, 9, 10, 11, 1, -10 },
  { 1154, 6, 17, 11, 3, -14 },
  { 1167, 1, 17, 11, 5, -13 },
  { 1170, 6, 17, 11, 3, -14 },
  { 1183, 10, 4, 11, 0, -7 },
};

const GFXfont RobotoMono_SemiBold18pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold18pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _ROBOTOMONO_SEMIBOLD18PT7B_H_
