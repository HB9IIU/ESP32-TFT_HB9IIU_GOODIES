#ifndef _ROBOTOMONO_SEMIBOLD26PT7B_H_
#define _ROBOTOMONO_SEMIBOLD26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x0E, 0xFE, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0x80, 0x06, 0x30, 0x19, 0xC0, 0xE6, 0x03, 0x18,
  0x0C, 0x61, 0xFF, 0xF7, 0xFF, 0xC7, 0x38, 0x18, 0xC0, 0x63, 0x01, 0x8C,
  0x3F, 0xFE, 0xFF, 0xF8, 0xE6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xCE,
  0x00, 0x06, 0x00, 0x60, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x8F, 0xF0, 0x7F,
  0x07, 0xF0, 0x07, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0xFE,
  0x07, 0xE0, 0x7F, 0x07, 0xF9, 0xF7, 0xFE, 0x1F, 0xC0, 0x60, 0x06, 0x00,
  0x60, 0x1C, 0x00, 0xFC, 0x01, 0x98, 0x07, 0x39, 0x8E, 0x73, 0x0C, 0xEC,
  0x1F, 0x98, 0x1E, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x19, 0xC0,
  0x67, 0xC0, 0xDD, 0xC3, 0x31, 0x86, 0x63, 0x04, 0xC6, 0x01, 0xFC, 0x01,
  0xF0, 0x07, 0x00, 0x3F, 0x80, 0xFF, 0x01, 0xC7, 0x03, 0x8E, 0x07, 0x1C,
  0x0E, 0x70, 0x1F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xFC, 0x73, 0xFC, 0xEF,
  0x3D, 0xDC, 0x3F, 0xB8, 0x7E, 0x78, 0x7C, 0x79, 0xF8, 0xFF, 0xF0, 0xFE,
  0xF8, 0xFF, 0xFC, 0x02, 0x0C, 0x38, 0xE1, 0x87, 0x0C, 0x38, 0x70, 0xE1,
  0x83, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xE1, 0xC3, 0x83, 0x07, 0x06, 0x0E,
  0x0E, 0x0C, 0x08, 0x81, 0x83, 0x83, 0x83, 0x87, 0x07, 0x0E, 0x0C, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x0E, 0x38,
  0x71, 0xC2, 0x00, 0x07, 0x00, 0x38, 0x01, 0x80, 0x8C, 0x2F, 0x6F, 0x7F,
  0xFC, 0x3E, 0x01, 0xE0, 0x1D, 0x81, 0xCE, 0x1E, 0x38, 0x61, 0x80, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x77, 0x77, 0x7E,
  0xEC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0x06, 0x03, 0xFC, 0x7F, 0xE7,
  0x1E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE3, 0xFE, 0x77, 0xFC, 0x7F,
  0x87, 0xF0, 0x7E, 0x0F, 0xE0, 0xFF, 0x0E, 0x7B, 0xE3, 0xFC, 0x1F, 0x80,
  0x07, 0x1F, 0xFF, 0xFF, 0xC7, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x01, 0xFE, 0x1F, 0xF8, 0xE1,
  0xEF, 0x07, 0x70, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0x01, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3F,
  0xC1, 0xFE, 0x0E, 0x7D, 0xF1, 0xFF, 0x07, 0xF0, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0xEE, 0x07, 0x70, 0x73, 0x83, 0x9C, 0x38, 0xE3, 0x87,
  0x1C, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x7F, 0xE7, 0xFE, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xEF,
  0x8F, 0xFC, 0xFB, 0xE2, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x7E, 0x0F, 0xE0,
  0xFF, 0xBE, 0x7F, 0xC1, 0xF8, 0x00, 0xC0, 0x3E, 0x03, 0xF0, 0x3E, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0xF8, 0x7F, 0xE7, 0xEF, 0xBC, 0x1F, 0xE0,
  0xFF, 0x03, 0xB8, 0x1D, 0xC1, 0xEF, 0x0E, 0x3D, 0xF1, 0xFF, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xEF, 0x1E,
  0xE0, 0xEE, 0x0E, 0xE0, 0xEF, 0x1E, 0x7F, 0xC3, 0xF8, 0x7F, 0xCF, 0x0E,
  0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xFB, 0xE7, 0xFE, 0x3F, 0x80, 0x07,
  0x00, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x78, 0x3B, 0xC1, 0xFE, 0x0F,
  0x70, 0x7B, 0xC3, 0xDF, 0xFC, 0x7F, 0xE1, 0xF7, 0x00, 0x38, 0x03, 0xC0,
  0x3C, 0x1F, 0xC0, 0xFC, 0x07, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x39, 0xCE,
  0x77, 0x38, 0x80, 0x00, 0x20, 0x1C, 0x1F, 0x8F, 0xEF, 0xF1, 0xF0, 0x3E,
  0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x03, 0xF0,
  0x3F, 0xC0, 0xFE, 0x03, 0xC0, 0x78, 0x7F, 0x7F, 0x9F, 0x83, 0xC0, 0x40,
  0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xEF, 0x0F, 0xF0, 0xF0, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0xE0, 0x7F, 0xC3, 0x03, 0x98,
  0x46, 0x67, 0xCB, 0x3B, 0x3C, 0xCC, 0xF3, 0x33, 0xD8, 0xCF, 0x63, 0x3D,
  0x8C, 0xB7, 0x36, 0xCF, 0xFB, 0x39, 0xCE, 0x00, 0x1C, 0x10, 0x3F, 0xC0,
  0x7E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x38, 0x70, 0x70, 0xE0, 0xFF,
  0xC3, 0xFF, 0xC7, 0xFF, 0x8E, 0x07, 0x3C, 0x0F, 0x70, 0x0F, 0xE0, 0x1C,
  0xFF, 0xC7, 0xFF, 0x38, 0x7D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0xDF,
  0xFC, 0xFF, 0xC7, 0xFF, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xDF, 0xFE, 0xFF, 0xE7, 0xFC, 0x00, 0x07, 0x00, 0xFF, 0x0F, 0xFC, 0xF0,
  0xF7, 0x03, 0xF8, 0x1F, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x1D, 0xC0, 0xEF, 0x0F, 0x7D, 0xF1, 0xFF, 0x83,
  0xF0, 0xFF, 0x0F, 0xFC, 0xE3, 0xEE, 0x0E, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE1, 0xEF,
  0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00,
  0xFF, 0x0F, 0xFC, 0xF0, 0xF7, 0x03, 0xB8, 0x1F, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x7F, 0xC3, 0xFF, 0x03, 0xF8, 0x1D, 0xC0, 0xEF, 0x07,
  0x3E, 0xF9, 0xFF, 0xC3, 0xF8, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFC, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xF8, 0x3D, 0xC1, 0xCF, 0xBE, 0x3F,
  0xE0, 0xFE, 0x00, 0xE0, 0x7F, 0x83, 0xCE, 0x1E, 0x38, 0x70, 0xE3, 0xC3,
  0x9E, 0x0E, 0xF0, 0x3B, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3C, 0xF0,
  0xE3, 0xC3, 0x87, 0x8E, 0x0F, 0x38, 0x3C, 0xE0, 0x7B, 0x80, 0xF0, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x1F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0xBF, 0xFF,
  0x7E, 0xF7, 0xEF, 0x7E, 0xE7, 0xEE, 0x7E, 0x67, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x87, 0xF8,
  0x7F, 0xC7, 0xFC, 0x7E, 0xEF, 0xEE, 0xFE, 0x6F, 0xE7, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0x07, 0x00, 0x7F, 0x83,
  0xFF, 0x1E, 0x3C, 0x70, 0x7B, 0xC0, 0xEF, 0x03, 0xB8, 0x0E, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0E, 0xF0, 0x3B, 0xC0, 0xE7, 0x03, 0x9E, 0x1E,
  0x3F, 0xF0, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x38, 0x3D, 0xC0,
  0xEE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xFF, 0xF7, 0xFF, 0x3F, 0xE1,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x3C, 0x70, 0x7B, 0xC0, 0xEF, 0x03,
  0xB8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0xE7, 0x03, 0x9E, 0x1E, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x60, 0xFF, 0xC7, 0xFF, 0x38, 0x7D, 0xC0, 0xEE, 0x07, 0x70,
  0x3B, 0x81, 0xDC, 0x1E, 0xFF, 0xE7, 0xFE, 0x3F, 0xE1, 0xC7, 0x8E, 0x1C,
  0x70, 0xF3, 0x83, 0x9C, 0x1E, 0xE0, 0x77, 0x03, 0xC0, 0x03, 0x80, 0x7F,
  0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0, 0xF7, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x3B, 0xC0, 0xFF, 0x03, 0xDC,
  0x0F, 0x7E, 0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xF0, 0xF7, 0xBE, 0x7F, 0xC1, 0xF8, 0xF0, 0x1E, 0xF0, 0x39,
  0xE0, 0x71, 0xC1, 0xE3, 0x83, 0xC7, 0x87, 0x07, 0x0E, 0x0E, 0x3C, 0x1E,
  0x70, 0x1C, 0xE0, 0x3B, 0xC0, 0x77, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0xF3, 0x8E, 0xE7, 0x1D, 0xCF, 0x3B,
  0x9E, 0x77, 0x3C, 0xEE, 0x79, 0x9C, 0xF7, 0x1B, 0xEE, 0x3F, 0xDC, 0x7D,
  0xF8, 0xFB, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E, 0x0E, 0x3C,
  0x1C, 0x78, 0x38, 0x70, 0xF0, 0x3D, 0xE1, 0xE7, 0x87, 0x8F, 0x3C, 0x1C,
  0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x3F, 0x00, 0xFC, 0x07,
  0xF8, 0x1C, 0xE0, 0xF3, 0xC3, 0x87, 0x1E, 0x1E, 0xF0, 0x3F, 0xC0, 0xF0,
  0xF8, 0x1E, 0xF0, 0x38, 0xE0, 0xF1, 0xE1, 0xC1, 0xC3, 0x83, 0xCE, 0x03,
  0x9C, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xFC, 0xE0,
  0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0xFF, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0xFC,
  0x33, 0x1C, 0xE7, 0x3B, 0x86, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF1, 0xE3, 0x87, 0x1F, 0x07, 0xFC, 0xFF, 0xEE, 0x0E, 0x00, 0xE0, 0x0E,
  0x3F, 0xEF, 0xFE, 0xE0, 0xEE, 0x0E, 0xE0, 0xEF, 0x3E, 0xFF, 0xF7, 0xEF,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8F, 0xFC,
  0xFF, 0xEF, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0xFF, 0xBE, 0xFF, 0xEE, 0xFC, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x0E,
  0xE0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0xF0, 0xF7, 0x9E,
  0x7F, 0xC1, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x3D, 0xE7, 0xFF, 0x3F, 0xFB, 0xC3, 0xDC, 0x1E, 0xE0, 0xF7, 0x07,
  0xF8, 0x3D, 0xC1, 0xEE, 0x0F, 0x78, 0x7B, 0xEF, 0xCF, 0xFE, 0x3E, 0x70,
  0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xF7, 0x03, 0xB8, 0x1D, 0xFF, 0xFF,
  0xFF, 0x70, 0x03, 0x80, 0x1E, 0x04, 0x7D, 0xF1, 0xFF, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x83, 0xFC, 0x1C, 0x01, 0xE0, 0x0F, 0x03, 0xFF, 0xDF, 0xFE,
  0xFF, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x77, 0xFF, 0x7F,
  0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFF, 0xFF, 0x7F, 0xF3, 0xFF, 0x00, 0xF4, 0x0F, 0x71, 0xEF, 0xFC, 0x3F,
  0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8E,
  0xFE, 0xFF, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x0E, 0x03, 0xC0, 0x38, 0x00,
  0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x0F,
  0x0F, 0x02, 0x00, 0x7F, 0x7F, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x1F, 0xFE, 0xFC, 0x60, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xDC, 0x3C,
  0xE3, 0xC7, 0x3C, 0x3B, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xDE, 0x1C,
  0x78, 0xE3, 0xC7, 0x0F, 0x38, 0x3D, 0xC0, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xEE, 0x73, 0xFF, 0xEF, 0xFF, 0xB9, 0xCF, 0xE7, 0x3F, 0x9C, 0xFE, 0x73,
  0xF9, 0xCF, 0xE7, 0x3F, 0x9C, 0xFE, 0x73, 0xF9, 0xCF, 0xE7, 0x3F, 0x9C,
  0xF0, 0xE7, 0xCE, 0xFE, 0xFF, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x0F, 0x80,
  0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3B, 0x81, 0xDE, 0x1E, 0xFB, 0xE3, 0xFE, 0x07, 0xE0, 0xE7, 0x8F, 0xFC,
  0xFF, 0xEF, 0x0E, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0xFF, 0xBE, 0xFF, 0xCE, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x00, 0x1E, 0x77, 0xF7, 0x7F, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x9F, 0x7F, 0xF3, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xE7, 0xFB, 0xFF, 0xFF, 0xE1,
  0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x00, 0x1F, 0x87, 0xFE, 0x7B, 0xEE, 0x0F, 0xE0, 0x0F, 0x80, 0x7F, 0x81,
  0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x0F, 0x7F, 0xE3, 0xFC, 0x1C, 0x01,
  0xC0, 0x1C, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0x70, 0xFF, 0x07, 0xF0,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0xFF, 0xBF, 0x7F, 0x73, 0xE7, 0xE0, 0x3B, 0xC0,
  0xE7, 0x07, 0x9C, 0x1C, 0x38, 0x70, 0xE3, 0xC3, 0x8E, 0x07, 0x38, 0x1C,
  0xC0, 0x37, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xE1, 0x8E,
  0xE7, 0x1D, 0xCE, 0x3B, 0x9C, 0x67, 0x3D, 0xCE, 0x7B, 0x8D, 0xB7, 0x1B,
  0x6E, 0x3E, 0xD8, 0x7C, 0xF0, 0xF9, 0xE1, 0xE3, 0xC1, 0xC7, 0x83, 0x87,
  0x00, 0xF0, 0x3D, 0xE1, 0xE3, 0x87, 0x07, 0x3C, 0x1F, 0xE0, 0x3F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x7F, 0x81, 0xCF, 0x0F, 0x1C, 0x78, 0x7B,
  0xC0, 0xF0, 0xE0, 0x1F, 0xC0, 0xF7, 0x03, 0x9E, 0x0E, 0x38, 0x78, 0xE1,
  0xC3, 0xCF, 0x07, 0x38, 0x1E, 0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x01, 0xF8, 0x07, 0xC0, 0x08,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x0F,
  0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0xF0, 0xF0, 0x78,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0E, 0x0F, 0x07, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x78, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x0E, 0x07, 0x81, 0xF0, 0x78, 0xF8, 0x70, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC1, 0xE0, 0x80, 0x00, 0x3E, 0x0E,
  0xFE, 0x1D, 0xDF, 0xF7, 0x0F, 0xE0, 0x0F, 0x80,
};

const GFXglyph RobotoMono_SemiBold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 18, 16, 6, -18 },
  { 10, 7, 7, 16, 4, -20 },
  { 17, 14, 18, 16, 1, -18 },
  { 49, 12, 24, 16, 2, -21 },
  { 85, 15, 19, 16, 0, -19 },
  { 121, 15, 19, 16, 1, -19 },
  { 157, 2, 7, 16, 6, -20 },
  { 159, 7, 27, 16, 4, -21 },
  { 183, 7, 27, 16, 4, -21 },
  { 207, 13, 12, 16, 2, -18 },
  { 227, 13, 13, 16, 1, -15 },
  { 249, 4, 8, 16, 5, -3 },
  { 253, 11, 2, 16, 3, -9 },
  { 256, 4, 4, 16, 6, -4 },
  { 258, 10, 20, 16, 3, -18 },
  { 283, 12, 19, 16, 2, -19 },
  { 312, 8, 18, 16, 2, -18 },
  { 330, 13, 19, 16, 1, -19 },
  { 361, 13, 19, 16, 1, -19 },
  { 392, 13, 18, 16, 1, -18 },
  { 422, 12, 18, 16, 2, -18 },
  { 449, 13, 19, 16, 1, -19 },
  { 480, 13, 18, 16, 1, -18 },
  { 510, 12, 19, 16, 2, -19 },
  { 539, 13, 19, 16, 1, -19 },
  { 570, 4, 15, 16, 6, -15 },
  { 578, 5, 20, 16, 6, -15 },
  { 591, 11, 12, 16, 2, -14 },
  { 608, 12, 8, 16, 2, -12 },
  { 620, 11, 12, 16, 2, -14 },
  { 637, 12, 19, 16, 2, -19 },
  { 666, 14, 18, 16, 1, -18 },
  { 698, 15, 18, 16, 0, -18 },
  { 732, 13, 18, 16, 2, -18 },
  { 762, 13, 19, 16, 1, -19 },
  { 793, 12, 18, 16, 2, -18 },
  { 820, 12, 18, 16, 2, -18 },
  { 847, 12, 18, 16, 2, -18 },
  { 874, 13, 19, 16, 1, -19 },
  { 905, 12, 18, 16, 2, -18 },
  { 932, 11, 18, 16, 2, -18 },
  { 957, 13, 18, 16, 1, -18 },
  { 987, 14, 18, 16, 2, -18 },
  { 1019, 12, 18, 16, 2, -18 },
  { 1046, 12, 18, 16, 2, -18 },
  { 1073, 12, 18, 16, 2, -18 },
  { 1100, 14, 19, 16, 1, -19 },
  { 1134, 13, 18, 16, 2, -18 },
  { 1164, 14, 22, 16, 1, -19 },
  { 1203, 13, 18, 16, 2, -18 },
  { 1233, 14, 19, 16, 1, -19 },
  { 1267, 15, 18, 16, 0, -18 },
  { 1301, 12, 18, 16, 2, -18 },
  { 1328, 15, 18, 16, 0, -18 },
  { 1362, 15, 18, 16, 0, -18 },
  { 1396, 14, 18, 16, 1, -18 },
  { 1428, 15, 18, 16, 0, -18 },
  { 1462, 13, 18, 16, 1, -18 },
  { 1492, 6, 25, 16, 5, -21 },
  { 1511, 10, 20, 16, 3, -18 },
  { 1536, 6, 25, 16, 5, -21 },
  { 1555, 10, 9, 16, 3, -18 },
  { 1567, 12, 3, 16, 2, 0 },
  { 1572, 6, 4, 16, 5, -19 },
  { 1575, 12, 14, 16, 2, -14 },
  { 1596, 12, 20, 16, 2, -20 },
  { 1626, 12, 14, 16, 2, -14 },
  { 1647, 13, 20, 16, 1, -20 },
  { 1680, 13, 14, 16, 1, -14 },
  { 1703, 13, 20, 16, 2, -20 },
  { 1736, 12, 19, 16, 2, -14 },
  { 1765, 12, 20, 16, 2, -20 },
  { 1795, 11, 19, 16, 3, -19 },
  { 1822, 8, 25, 16, 3, -19 },
  { 1847, 13, 20, 16, 2, -20 },
  { 1880, 11, 20, 16, 3, -20 },
  { 1908, 14, 14, 16, 1, -14 },
  { 1933, 12, 14, 16, 2, -14 },
  { 1954, 13, 14, 16, 1, -14 },
  { 1977, 12, 19, 16, 2, -14 },
  { 2006, 12, 19, 16, 2, -14 },
  { 2035, 10, 14, 16, 4, -14 },
  { 2053, 12, 14, 16, 2, -14 },
  { 2074, 12, 17, 16, 2, -17 },
  { 2100, 12, 14, 16, 2, -14 },
  { 2121, 14, 14, 16, 1, -14 },
  { 2146, 15, 14, 16, 0, -14 },
  { 2173, 14, 14, 16, 1, -14 },
  { 2198, 14, 20, 16, 1, -14 },
  { 2233, 12, 14, 16, 2, -14 },
  { 2254, 8, 25, 16, 4, -20 },
  { 2279, 2, 23, 16, 7, -18 },
  { 2285, 9, 25, 16, 4, -20 },
  { 2314, 15, 5, 16, 0, -10 },
};

const GFXfont RobotoMono_SemiBold26pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold26pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOMONO_SEMIBOLD26PT7B_H_
