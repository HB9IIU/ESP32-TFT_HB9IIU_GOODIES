#ifndef _ROBOTOMONO_SEMIBOLD30PT7B_H_
#define _ROBOTOMONO_SEMIBOLD30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0xFF, 0xF0,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x03, 0x1C, 0x07,
  0x1C, 0x07, 0x18, 0x07, 0x18, 0x06, 0x18, 0x06, 0x38, 0x7F, 0xFF, 0x7F,
  0xFF, 0x0E, 0x30, 0x0E, 0x30, 0x0C, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0xFF,
  0xFE, 0xFF, 0xFE, 0x18, 0x60, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38,
  0xC0, 0x38, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x01, 0xFF,
  0x07, 0xFF, 0x1F, 0xFF, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x39, 0xE0, 0x0B,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00,
  0x7B, 0xC0, 0x77, 0x80, 0xFF, 0x01, 0xCF, 0x07, 0x9F, 0xFF, 0x1F, 0xFC,
  0x1F, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xC7, 0x10, 0xC7, 0x18, 0xC7, 0x30, 0xC7, 0x70, 0xFE, 0x60,
  0x7E, 0xE0, 0x38, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x3E,
  0x07, 0x7F, 0x06, 0xE7, 0x0C, 0xE3, 0x1C, 0xE3, 0x08, 0xE3, 0x00, 0xE3,
  0x00, 0x7F, 0x00, 0x3E, 0x01, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xDE,
  0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xC0, 0x79, 0xE0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x73, 0xDE, 0x39, 0xE7, 0x9D,
  0xE1, 0xFE, 0xF0, 0xFE, 0x78, 0x3F, 0x3E, 0x1F, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFE, 0x7C, 0xFF, 0xFF, 0xF6, 0x01, 0x07, 0x0F, 0x0E, 0x1C, 0x3C,
  0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x0F, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E,
  0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E,
  0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0xC0, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x06, 0x18, 0xCF, 0xB7, 0xFF, 0xFF, 0x87, 0xF8, 0x07,
  0xC0, 0x0D, 0xC0, 0x3B, 0x80, 0xE3, 0x83, 0xC7, 0x83, 0x06, 0x00, 0x08,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x39, 0xCE, 0x77, 0xBD, 0xDC, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x31, 0xEF, 0xDF, 0x78, 0x00, 0xF0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF,
  0x1F, 0xFE, 0x78, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3,
  0xFF, 0x3F, 0xFD, 0xEF, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0,
  0x3D, 0xC0, 0xE7, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x03, 0x87,
  0xDF, 0xFF, 0xFF, 0xFE, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x03, 0x00,
  0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xC0, 0x01, 0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7,
  0x83, 0xCF, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x01, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3D, 0xE0, 0xF3, 0xFF, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xDE, 0x07,
  0x3C, 0x1E, 0x78, 0x38, 0xF0, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x3F, 0xF8, 0xFF, 0xE7, 0xFF, 0x9E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1D, 0xF0, 0x7F, 0xF1, 0xFF, 0xE7, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xE7, 0xFF, 0x8F,
  0xFC, 0x1F, 0xE0, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0x80, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3D, 0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0x87, 0xBC, 0x0F,
  0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE1, 0xE7, 0xFF,
  0x8F, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x7F, 0x83,
  0xFF, 0x1F, 0xFE, 0xF8, 0x7B, 0xC0, 0xEF, 0x03, 0xFC, 0x0E, 0x78, 0x79,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xFB, 0xE1, 0xEF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x07,
  0x00, 0x7F, 0x03, 0xFF, 0x1F, 0x7C, 0xF0, 0x7B, 0xC1, 0xEE, 0x03, 0xB8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xFE, 0x3F, 0x7F, 0xFC, 0xFF, 0xE1,
  0xF3, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x07, 0xF8, 0x1F, 0x80,
  0x78, 0x00, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xFF,
  0xF0, 0x73, 0xEF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x9E, 0x79, 0xC7, 0x3C, 0xE3, 0x84, 0x00, 0x00, 0x08, 0x03, 0xC0, 0x7E,
  0x1F, 0xF3, 0xFE, 0x7F, 0x83, 0xE0, 0x1F, 0x80, 0x7F, 0x80, 0xFF, 0x81,
  0xFE, 0x01, 0xF0, 0x03, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xC0, 0x3F, 0x07, 0xF8, 0xFF, 0x8F, 0xF0, 0x3F, 0x00, 0xE0, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x78, 0x3F, 0xC0, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x1C, 0x1C, 0x38, 0x0E,
  0x70, 0xC6, 0x63, 0xF3, 0x67, 0xB3, 0xE6, 0x33, 0xCE, 0x33, 0xCC, 0x33,
  0xCC, 0x73, 0xCC, 0x73, 0xCC, 0x63, 0xCE, 0x66, 0xCF, 0xFE, 0xE7, 0xBC,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x20, 0x1F, 0xF0, 0x0F, 0xE0, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3D,
  0xC0, 0x1E, 0xE0, 0x0E, 0x78, 0x0F, 0x1C, 0x07, 0x8E, 0x03, 0x87, 0x83,
  0xC3, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0x78, 0x0E, 0x3C, 0x07,
  0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0x78, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF,
  0xF7, 0x81, 0xEF, 0x01, 0xDE, 0x03, 0xFC, 0x07, 0x78, 0x1E, 0xF0, 0xFD,
  0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xEF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xCF, 0xFE, 0x00, 0x01,
  0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x7C, 0x1E, 0x78, 0x1E, 0x78,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x3C,
  0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0xC7, 0x87, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xBC, 0x0F, 0x78,
  0x1E, 0xF0, 0x79, 0xE1, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x7C, 0x1E, 0x78,
  0x1E, 0x78, 0x0F, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x3C, 0x1F, 0x3F, 0xFF, 0x1F, 0xFC, 0x07, 0xF8, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC1, 0xE7, 0xFF, 0x9F, 0xFC, 0x1F, 0xC0, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0,
  0x7C, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF7, 0xC0, 0xF7,
  0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xF9, 0xE0, 0xF0,
  0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0,
  0x1F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3,
  0xFE, 0xED, 0xFB, 0xF7, 0xEF, 0xDF, 0x9E, 0x7E, 0x79, 0xF9, 0xE7, 0xE3,
  0x1F, 0x8C, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1C, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0x3F, 0xDC, 0xFF, 0x7B, 0xFC, 0xEF,
  0xF3, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x3C, 0x03, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E,
  0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0,
  0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x81, 0xEF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFE,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFF,
  0x87, 0xC3, 0xE3, 0xC0, 0xF1, 0xE0, 0x39, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D,
  0xE0, 0x1E, 0x78, 0x1E, 0x3C, 0x0F, 0x0F, 0x0F, 0x87, 0xFF, 0x81, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0x00,
  0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x81, 0xEF, 0x03, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x3D, 0xE0, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE,
  0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0x7B, 0xC0, 0xF7,
  0x80, 0xFF, 0x01, 0xE0, 0x00, 0x80, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7E,
  0x7C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D,
  0xE1, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0xE3, 0xC7, 0xF1, 0xE3, 0xB8, 0xF1, 0xDE, 0x78, 0xEF, 0x3C, 0x77,
  0x9E, 0x7B, 0xCF, 0xBC, 0xEF, 0xDE, 0x77, 0xEE, 0x3B, 0xF7, 0x1D, 0xFB,
  0x8E, 0xCD, 0xC7, 0xE6, 0xE3, 0xF3, 0xF0, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E,
  0x7C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC0, 0xF8, 0x0F,
  0xBC, 0x0F, 0x9F, 0x07, 0x87, 0x87, 0x81, 0xE3, 0xC0, 0xF3, 0xC0, 0x3D,
  0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x79, 0xE0, 0x3C, 0xF8, 0x3C, 0x3C, 0x1E, 0x1F,
  0x1E, 0x07, 0x9F, 0x03, 0xEF, 0x00, 0xF8, 0xF0, 0x0F, 0xFC, 0x07, 0x9E,
  0x07, 0x8F, 0x03, 0xC3, 0xC3, 0xC1, 0xE1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0,
  0x0F, 0x70, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xF0, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0xFF, 0xFF, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0xF0, 0x0F, 0x81,
  0xF8, 0x1D, 0xC3, 0x9C, 0x39, 0xC3, 0x8E, 0x70, 0xE7, 0x07, 0xE0, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0, 0xF0, 0xF0, 0x1F, 0xC0,
  0xFF, 0xC7, 0xFF, 0xBC, 0x1E, 0xF0, 0x38, 0x00, 0xE0, 0x3F, 0x8F, 0xFE,
  0x7F, 0xFB, 0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x7B, 0xFF, 0xE7, 0xFF,
  0xCF, 0xCF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3D, 0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0x87, 0xBC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE,
  0x1F, 0xFF, 0xFB, 0xFF, 0xCF, 0x7E, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF,
  0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x0F, 0x78, 0x79, 0xFF, 0xE3, 0xFF, 0x03, 0xF8, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC7,
  0xEF, 0x3F, 0xFD, 0xFF, 0xF7, 0x87, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x1F, 0x7F, 0xFC,
  0xFF, 0xF1, 0xFB, 0xC0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C,
  0x02, 0x78, 0x19, 0xFF, 0xF3, 0xFF, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xFC,
  0x1F, 0xF8, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x1F, 0xBC, 0xFF, 0xF7, 0xFF, 0xDE, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0x78, 0x7D, 0xFF, 0xF3, 0xFF, 0xC7, 0xEF, 0x00, 0x3C, 0x80, 0xF3,
  0x07, 0x9F, 0xFE, 0x7F, 0xF0, 0x7F, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xF8, 0xF7, 0xFB, 0xFF,
  0xEF, 0x87, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0,
  0x07, 0x00, 0x3C, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x1F,
  0xF0, 0xFF, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0x80, 0xF0, 0x7C, 0x0E, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x7F, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0xBF, 0xEF, 0xF3, 0xF8, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x1E, 0xF0, 0x79, 0xE1, 0xE3, 0xC7, 0x87, 0x9E, 0x0F, 0x7C, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF3, 0xC3, 0xC7, 0xC7, 0x87,
  0xCF, 0x07, 0x9E, 0x07, 0xBC, 0x0F, 0x80, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE7, 0xBC, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xE3, 0xDF, 0xEF, 0xFF, 0xBE, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x0F, 0xC0, 0xFF,
  0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xF8, 0x79, 0xFF, 0xE3, 0xFF, 0x07,
  0xF8, 0xF7, 0xE3, 0xFF, 0xCF, 0xFF, 0xBE, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7B,
  0xFF, 0xEF, 0xFF, 0x3D, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x1F, 0xBC, 0xFF, 0xF7, 0xFF, 0xDE, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0x78, 0x7D, 0xFF, 0xF3, 0xFF, 0xC7, 0xEF, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF,
  0x9E, 0x0F, 0xF0, 0x3D, 0xC0, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07,
  0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xFB, 0xF3, 0xFF, 0x87, 0xF8, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x83,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x7D, 0xFF, 0xF3, 0xFF,
  0xC7, 0xEF, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1C,
  0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0xC3,
  0xB8, 0xE1, 0xDC, 0x78, 0xEE, 0x3C, 0xF7, 0x9E, 0x7B, 0xCF, 0x38, 0xEF,
  0x9C, 0x76, 0xEE, 0x3B, 0x77, 0x1D, 0x9B, 0x8E, 0xCF, 0x83, 0xE7, 0xC1,
  0xE3, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x38, 0x78, 0x0F, 0x7C, 0x1E,
  0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x3C, 0x3C, 0x3E,
  0x7C, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0x9E, 0x03, 0xCF, 0x03,
  0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x0E, 0x78, 0x07,
  0xBC, 0x03, 0xDC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x83, 0xC3, 0xC1, 0xC0,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x8F, 0xC7, 0x83, 0xC0,
  0xF8, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0E, 0x07,
  0x81, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x3C,
  0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xC0,
  0x78, 0x0F, 0x81, 0xF0, 0x7C, 0x3E, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0x80, 0x1E, 0x00, 0x1F,
  0xC1, 0xDF, 0xF0, 0xEE, 0x7F, 0xEE, 0x0F, 0xF1, 0x03, 0xF0,
};

const GFXglyph RobotoMono_SemiBold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 21, 18, 7, -21 },
  { 12, 9, 8, 18, 4, -23 },
  { 21, 16, 21, 18, 1, -21 },
  { 63, 15, 28, 18, 2, -25 },
  { 116, 16, 22, 18, 1, -22 },
  { 160, 17, 22, 18, 1, -22 },
  { 207, 3, 8, 18, 7, -23 },
  { 210, 8, 31, 18, 5, -24 },
  { 241, 8, 31, 18, 5, -24 },
  { 272, 15, 15, 18, 2, -21 },
  { 301, 14, 16, 18, 2, -18 },
  { 329, 5, 9, 18, 5, -3 },
  { 335, 12, 3, 18, 4, -11 },
  { 340, 6, 5, 18, 6, -5 },
  { 344, 12, 23, 18, 3, -21 },
  { 379, 14, 22, 18, 2, -22 },
  { 418, 9, 21, 18, 3, -21 },
  { 442, 15, 22, 18, 1, -22 },
  { 484, 15, 22, 18, 1, -22 },
  { 526, 15, 21, 18, 1, -21 },
  { 566, 14, 21, 18, 2, -21 },
  { 603, 14, 21, 18, 2, -21 },
  { 640, 15, 21, 18, 1, -21 },
  { 680, 14, 22, 18, 2, -22 },
  { 719, 14, 22, 18, 2, -22 },
  { 758, 5, 17, 18, 7, -17 },
  { 769, 6, 23, 18, 7, -17 },
  { 787, 13, 14, 18, 2, -16 },
  { 810, 14, 10, 18, 2, -14 },
  { 828, 14, 14, 18, 2, -16 },
  { 853, 14, 22, 18, 2, -22 },
  { 892, 16, 21, 18, 1, -21 },
  { 934, 17, 21, 18, 1, -21 },
  { 979, 15, 21, 18, 2, -21 },
  { 1019, 16, 22, 18, 1, -22 },
  { 1063, 15, 21, 18, 2, -21 },
  { 1103, 14, 21, 18, 2, -21 },
  { 1140, 14, 21, 18, 2, -21 },
  { 1177, 16, 22, 18, 1, -22 },
  { 1221, 14, 21, 18, 2, -21 },
  { 1258, 12, 21, 18, 3, -21 },
  { 1290, 14, 21, 18, 2, -21 },
  { 1327, 16, 21, 18, 2, -21 },
  { 1369, 14, 21, 18, 2, -21 },
  { 1406, 14, 21, 18, 2, -21 },
  { 1443, 14, 21, 18, 2, -21 },
  { 1480, 16, 22, 18, 1, -22 },
  { 1524, 15, 21, 18, 2, -21 },
  { 1564, 17, 26, 18, 1, -22 },
  { 1620, 15, 21, 18, 2, -21 },
  { 1660, 16, 22, 18, 1, -22 },
  { 1704, 16, 21, 18, 1, -21 },
  { 1746, 14, 21, 18, 2, -21 },
  { 1783, 16, 21, 18, 1, -21 },
  { 1825, 17, 21, 18, 1, -21 },
  { 1870, 17, 21, 18, 1, -21 },
  { 1915, 17, 21, 18, 1, -21 },
  { 1960, 16, 21, 18, 1, -21 },
  { 2002, 6, 30, 18, 6, -25 },
  { 2025, 12, 23, 18, 3, -21 },
  { 2060, 6, 30, 18, 6, -25 },
  { 2083, 12, 11, 18, 3, -21 },
  { 2100, 14, 3, 18, 2, 0 },
  { 2106, 7, 4, 18, 6, -22 },
  { 2110, 14, 16, 18, 2, -16 },
  { 2138, 14, 23, 18, 2, -23 },
  { 2179, 14, 16, 18, 2, -16 },
  { 2207, 14, 23, 18, 2, -23 },
  { 2248, 14, 16, 18, 2, -16 },
  { 2276, 15, 23, 18, 2, -23 },
  { 2320, 14, 22, 18, 2, -16 },
  { 2359, 14, 23, 18, 2, -23 },
  { 2400, 13, 22, 18, 3, -22 },
  { 2436, 10, 28, 18, 3, -22 },
  { 2471, 15, 23, 18, 2, -23 },
  { 2515, 13, 23, 18, 3, -23 },
  { 2553, 16, 16, 18, 1, -16 },
  { 2585, 14, 16, 18, 2, -16 },
  { 2613, 14, 16, 18, 2, -16 },
  { 2641, 14, 22, 18, 2, -16 },
  { 2680, 14, 22, 18, 2, -16 },
  { 2719, 12, 16, 18, 4, -16 },
  { 2743, 14, 16, 18, 2, -16 },
  { 2771, 14, 20, 18, 2, -20 },
  { 2806, 14, 16, 18, 2, -16 },
  { 2834, 16, 16, 18, 1, -16 },
  { 2866, 17, 16, 18, 0, -16 },
  { 2900, 16, 16, 18, 1, -16 },
  { 2932, 17, 22, 18, 1, -16 },
  { 2979, 14, 16, 18, 2, -16 },
  { 3007, 9, 28, 18, 5, -23 },
  { 3039, 2, 27, 18, 8, -21 },
  { 3046, 10, 28, 18, 5, -23 },
  { 3081, 17, 6, 18, 0, -12 },
};

const GFXfont RobotoMono_SemiBold30pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold30pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOMONO_SEMIBOLD30PT7B_H_
