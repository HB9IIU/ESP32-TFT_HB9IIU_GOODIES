#ifndef _ROBOTOMONO_SEMIBOLD10PT7B_H_
#define _ROBOTOMONO_SEMIBOLD10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xCC, 0xB6, 0x80, 0x28, 0xA7, 0xCC, 0xF9, 0x45, 0x00, 0x27,
  0xA5, 0x97, 0x0A, 0x7E, 0x20, 0xE2, 0xA7, 0x08, 0x3D, 0x51, 0xC0, 0x71,
  0x67, 0x18, 0x57, 0x67, 0xC0, 0xE0, 0x5A, 0xAA, 0xD0, 0xA5, 0x55, 0xA0,
  0x25, 0x5C, 0xCD, 0x00, 0x31, 0xBE, 0x63, 0x00, 0xE0, 0xF0, 0x70, 0x12,
  0x22, 0x44, 0x48, 0xF9, 0x9F, 0x99, 0xF0, 0x7C, 0x92, 0x48, 0x7E, 0x42,
  0x23, 0x33, 0xE0, 0x7A, 0x42, 0x60, 0xE5, 0xE0, 0x19, 0xCE, 0xBF, 0x8C,
  0x60, 0xF8, 0xE9, 0x19, 0xF0, 0x68, 0xE9, 0x99, 0xF0, 0xF8, 0x46, 0x23,
  0x11, 0x80, 0xF9, 0x9E, 0x99, 0xF0, 0xE9, 0x9B, 0x53, 0x60, 0x70, 0x70,
  0x70, 0x16, 0x3C, 0xE3, 0xF0, 0xFF, 0xC3, 0x7C, 0xF9, 0x12, 0x60, 0x60,
  0x39, 0x5B, 0x6D, 0xB6, 0x27, 0x00, 0x30, 0xC3, 0x1A, 0x79, 0x2C, 0xC0,
  0xF4, 0xE5, 0xE9, 0xCF, 0xC0, 0x79, 0x3C, 0x30, 0xC5, 0x27, 0x80, 0xE4,
  0xA7, 0x39, 0x4B, 0x80, 0xF8, 0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80,
  0x79, 0x2C, 0x77, 0xCD, 0x37, 0x80, 0x99, 0x9F, 0x99, 0x90, 0xF6, 0x66,
  0x66, 0xF0, 0x11, 0x11, 0x19, 0xF0, 0x9D, 0xB9, 0xCA, 0x4A, 0x60, 0x88,
  0x88, 0x88, 0xF0, 0x9F, 0xFF, 0xD9, 0x90, 0x9D, 0xDF, 0xBB, 0x90, 0x79,
  0x2C, 0xF3, 0xCD, 0x27, 0x80, 0xF4, 0xE7, 0xE8, 0x42, 0x00, 0x79, 0x2C,
  0xF3, 0xCD, 0x27, 0x83, 0xF4, 0xE7, 0xEB, 0x4A, 0x60, 0x79, 0x34, 0x0E,
  0x8D, 0x37, 0x80, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x99, 0x99, 0x99,
  0xF0, 0xCD, 0x24, 0x9E, 0x30, 0xC3, 0x00, 0xB7, 0xD7, 0xDE, 0x79, 0xE4,
  0x80, 0xCD, 0xA3, 0x0C, 0x31, 0x2C, 0xC0, 0xCD, 0x27, 0x8C, 0x30, 0xC3,
  0x00, 0xF8, 0x21, 0x0C, 0x21, 0x0F, 0xC0, 0xEA, 0xAA, 0xB0, 0xC4, 0x46,
  0x22, 0x31, 0xD5, 0x55, 0x70, 0x66, 0x59, 0xF0, 0xC0, 0xF1, 0xF9, 0xF0,
  0x88, 0x8F, 0x99, 0x9F, 0xF9, 0x89, 0xF0, 0x11, 0x1F, 0x99, 0x9F, 0xF9,
  0xF9, 0xF0, 0x3B, 0x11, 0xE4, 0x21, 0x08, 0xF9, 0x99, 0xF9, 0xF0, 0x88,
  0x8F, 0x99, 0x99, 0x60, 0xE2, 0x22, 0xF0, 0x23, 0x92, 0x49, 0xE0, 0x84,
  0x21, 0x6E, 0x72, 0xD3, 0xEE, 0x22, 0x22, 0x2F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF9, 0x99, 0x90, 0xF9, 0x99, 0xF0, 0xF9, 0x99, 0xF8, 0x80, 0xF9, 0x99,
  0xF1, 0x10, 0xFC, 0xCC, 0xC0, 0xF8, 0x79, 0xF0, 0x44, 0xF4, 0x44, 0x70,
  0x99, 0x99, 0xF0, 0xCD, 0x27, 0x8C, 0x30, 0xB7, 0xE7, 0x9E, 0x48, 0x4C,
  0xC3, 0x1E, 0xCC, 0xCD, 0x23, 0x8C, 0x30, 0x86, 0x00, 0xF1, 0x19, 0x8F,
  0x80, 0x29, 0x2D, 0x92, 0x44, 0xFF, 0x80, 0x93, 0x66, 0xB6, 0x90, 0x66,
  0x60,
};

const GFXglyph RobotoMono_SemiBold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 1, -8 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 5, 9, 6, 1, -8 },
  { 17, 6, 7, 6, 0, -7 },
  { 23, 6, 7, 6, 0, -7 },
  { 29, 1, 3, 6, 2, -8 },
  { 30, 2, 10, 6, 2, -8 },
  { 33, 2, 10, 6, 2, -8 },
  { 36, 5, 5, 6, 1, -7 },
  { 40, 5, 5, 6, 0, -6 },
  { 44, 1, 3, 6, 2, -1 },
  { 45, 4, 1, 6, 1, -4 },
  { 46, 2, 2, 6, 2, -2 },
  { 47, 4, 8, 6, 1, -7 },
  { 51, 4, 7, 6, 1, -7 },
  { 55, 3, 7, 6, 1, -7 },
  { 58, 5, 7, 6, 0, -7 },
  { 63, 5, 7, 6, 0, -7 },
  { 68, 5, 7, 6, 0, -7 },
  { 73, 4, 7, 6, 1, -7 },
  { 77, 4, 7, 6, 1, -7 },
  { 81, 5, 7, 6, 0, -7 },
  { 86, 4, 7, 6, 1, -7 },
  { 90, 4, 7, 6, 1, -7 },
  { 94, 2, 6, 6, 2, -6 },
  { 96, 2, 8, 6, 2, -6 },
  { 98, 4, 4, 6, 1, -5 },
  { 100, 4, 4, 6, 1, -5 },
  { 102, 4, 4, 6, 1, -5 },
  { 104, 4, 7, 6, 1, -7 },
  { 108, 6, 7, 6, 0, -7 },
  { 114, 6, 7, 6, 0, -7 },
  { 120, 5, 7, 6, 1, -7 },
  { 125, 6, 7, 6, 0, -7 },
  { 131, 5, 7, 6, 1, -7 },
  { 136, 4, 7, 6, 1, -7 },
  { 140, 4, 7, 6, 1, -7 },
  { 144, 6, 7, 6, 0, -7 },
  { 150, 4, 7, 6, 1, -7 },
  { 154, 4, 7, 6, 1, -7 },
  { 158, 4, 7, 6, 1, -7 },
  { 162, 5, 7, 6, 1, -7 },
  { 167, 4, 7, 6, 1, -7 },
  { 171, 4, 7, 6, 1, -7 },
  { 175, 4, 7, 6, 1, -7 },
  { 179, 6, 7, 6, 0, -7 },
  { 185, 5, 7, 6, 1, -7 },
  { 190, 6, 8, 6, 0, -7 },
  { 196, 5, 7, 6, 1, -7 },
  { 201, 6, 7, 6, 0, -7 },
  { 207, 6, 7, 6, 0, -7 },
  { 213, 4, 7, 6, 1, -7 },
  { 217, 6, 7, 6, 0, -7 },
  { 223, 6, 7, 6, 0, -7 },
  { 229, 6, 7, 6, 0, -7 },
  { 235, 6, 7, 6, 0, -7 },
  { 241, 6, 7, 6, 0, -7 },
  { 247, 2, 10, 6, 2, -8 },
  { 250, 4, 8, 6, 1, -7 },
  { 254, 2, 10, 6, 2, -8 },
  { 257, 4, 4, 6, 1, -7 },
  { 259, 4, 1, 6, 1, 0 },
  { 260, 2, 1, 6, 2, -7 },
  { 261, 4, 5, 6, 1, -5 },
  { 264, 4, 8, 6, 1, -8 },
  { 268, 4, 5, 6, 1, -5 },
  { 271, 4, 8, 6, 1, -8 },
  { 275, 4, 5, 6, 1, -5 },
  { 278, 5, 8, 6, 1, -8 },
  { 283, 4, 7, 6, 1, -5 },
  { 287, 4, 8, 6, 1, -8 },
  { 291, 4, 7, 6, 1, -7 },
  { 295, 3, 9, 6, 1, -7 },
  { 299, 5, 8, 6, 1, -8 },
  { 304, 4, 8, 6, 1, -8 },
  { 308, 6, 5, 6, 0, -5 },
  { 312, 4, 5, 6, 1, -5 },
  { 315, 4, 5, 6, 1, -5 },
  { 318, 4, 7, 6, 1, -5 },
  { 322, 4, 7, 6, 1, -5 },
  { 326, 4, 5, 6, 1, -5 },
  { 329, 4, 5, 6, 1, -5 },
  { 332, 4, 7, 6, 1, -7 },
  { 336, 4, 5, 6, 1, -5 },
  { 339, 6, 5, 6, 0, -5 },
  { 343, 6, 5, 6, 0, -5 },
  { 347, 6, 5, 6, 0, -5 },
  { 351, 6, 7, 6, 0, -5 },
  { 357, 5, 5, 6, 1, -5 },
  { 361, 3, 10, 6, 2, -8 },
  { 365, 1, 9, 6, 3, -7 },
  { 367, 3, 10, 6, 2, -8 },
  { 371, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_SemiBold10pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold10pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOMONO_SEMIBOLD10PT7B_H_
