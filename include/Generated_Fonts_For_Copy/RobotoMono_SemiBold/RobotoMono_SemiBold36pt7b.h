#ifndef _ROBOTOMONO_SEMIBOLD36PT7B_H_
#define _ROBOTOMONO_SEMIBOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x78,
  0x00, 0x00, 0x3B, 0xFF, 0xFB, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE,
  0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x38, 0x70,
  0x07, 0x0E, 0x00, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0x87, 0x00,
  0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0x1E, 0x00, 0xE3, 0x80, 0x38, 0x70, 0x07,
  0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xFE, 0x3E, 0x0F, 0x8F, 0x01, 0xE7, 0xC0, 0x7D, 0xF0, 0x1F,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x01, 0xF7, 0xF3, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0E, 0x38, 0x40,
  0xE3, 0xC7, 0x0E, 0x3C, 0x70, 0xE3, 0xCE, 0x0E, 0x38, 0xC0, 0xF7, 0x9C,
  0x07, 0xFB, 0x80, 0x3F, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x78, 0x01, 0xDF, 0xE0, 0x39, 0xFE, 0x03,
  0x3C, 0xF0, 0x73, 0x87, 0x0E, 0x38, 0x70, 0xE3, 0x87, 0x02, 0x38, 0x70,
  0x03, 0xCF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78,
  0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xFB, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC3, 0xC7, 0xFE,
  0x1E, 0x7C, 0xF8, 0xF3, 0xC3, 0xEF, 0x3E, 0x0F, 0xF9, 0xF0, 0x7F, 0xCF,
  0x81, 0xFC, 0x3E, 0x07, 0xE1, 0xF8, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF, 0xEE, 0xE0, 0x00, 0x80, 0x60,
  0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0E, 0x00, 0x80, 0x80, 0x60, 0x38, 0x1E,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x1C,
  0x0C, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x02, 0x0E, 0x07, 0xC7, 0x1F, 0xFB, 0xBF, 0xFF, 0xFF, 0x8F, 0xFF, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x77, 0x00, 0x73, 0xC0, 0x78, 0xF0, 0x78, 0x3C,
  0x3C, 0x1E, 0x04, 0x04, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xDE, 0x7B, 0xC2, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x73, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0xE3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3E, 0xF0, 0x1F, 0x78,
  0x07, 0xBC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x8F, 0x7F, 0xDF, 0x3F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xEF, 0x01,
  0xF7, 0xC0, 0xFB, 0xE0, 0xF8, 0xFC, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x20, 0x1C, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E,
  0x1F, 0x9F, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xC1, 0xF7,
  0xC0, 0x7B, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFD,
  0xF8, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xDF, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x07,
  0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x3E, 0x0F, 0x07, 0xC3, 0xC0, 0xF8, 0x78,
  0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x78, 0x1F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xFF, 0xF1, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xE0, 0x7D, 0xFC, 0xFC,
  0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x38, 0x00, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0xFC, 0x3E, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xE0,
  0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xF7, 0x80, 0xFB, 0xE0, 0xF8, 0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xC1,
  0xF3, 0xE0, 0x79, 0xE0, 0x3E, 0xF0, 0x1F, 0x78, 0x0F, 0x3E, 0x07, 0x8F,
  0x87, 0xC7, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0xF8, 0x3E,
  0x78, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xE0,
  0x7D, 0xF8, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC3, 0xF3, 0xC0, 0xFB, 0xE0,
  0x3D, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFB, 0xE1, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xEF, 0x01, 0xC7,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x38, 0xFB, 0xF7, 0xFF, 0xCF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x7D, 0xFB, 0xFF, 0xE7,
  0xC0, 0x38, 0xF9, 0xFB, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x79, 0xE3,
  0xC1, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xCF,
  0xFC, 0x3F, 0xC0, 0x7E, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0x00, 0x3F, 0x01, 0xFF, 0x0F, 0xFC, 0x7F, 0xF0, 0xFF, 0x80, 0xFE, 0x00,
  0xF0, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x7F,
  0xF0, 0x0F, 0x87, 0x81, 0xE0, 0x1C, 0x38, 0x00, 0xC3, 0x87, 0xCE, 0x71,
  0xFE, 0x67, 0x1F, 0xE6, 0x63, 0x8C, 0x6E, 0x38, 0xC7, 0xE7, 0x0C, 0x7E,
  0x70, 0xC6, 0xE7, 0x0C, 0x6E, 0x71, 0xC6, 0xE7, 0x1C, 0x6E, 0x71, 0xCE,
  0xE7, 0x3C, 0xCE, 0x7F, 0xFC, 0xE3, 0xEF, 0x87, 0x08, 0x20, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0xBC, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xDE, 0x00, 0x79, 0xE0,
  0x07, 0x9E, 0x00, 0xF9, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F,
  0x81, 0xF0, 0x78, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0x81, 0xF9, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x00, 0xF3, 0xE0, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7B, 0xE0,
  0x0F, 0xFC, 0x01, 0xEF, 0x80, 0x7D, 0xF0, 0x1F, 0xBF, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xF0, 0x7C, 0x7C, 0x07, 0x9F, 0x00, 0xFB, 0xE0,
  0x1F, 0x78, 0x03, 0xEF, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x0F, 0x8F, 0xE7,
  0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x7F, 0x3E, 0x07, 0xCF, 0x80, 0xFB,
  0xE0, 0x3E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x1F, 0xBE, 0x0F, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFF, 0xF9, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x0F, 0x9F, 0x01,
  0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x01,
  0xF3, 0xF9, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xF9, 0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC,
  0x07, 0xF8, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x80,
  0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8,
  0xF8, 0x0F, 0x9F, 0x80, 0xFB, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFE, 0x7C, 0x0F, 0xC7, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x0F,
  0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xBF, 0xDC, 0xEF, 0xF7, 0x7B,
  0xFD, 0xDE, 0xFF, 0x7F, 0x3F, 0xCF, 0xDF, 0xF3, 0xF7, 0xFC, 0xF9, 0xFF,
  0x1E, 0x7F, 0xE7, 0x9F, 0xF9, 0xC7, 0xFE, 0x71, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xF0, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFE, 0xE1, 0xFF, 0x78, 0xFF, 0xBC, 0x7F, 0xCF, 0x3F, 0xE7, 0x9F, 0xF1,
  0xEF, 0xF8, 0xF7, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF0, 0xF8, 0x78,
  0x0F, 0x9F, 0x00, 0xF3, 0xE0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0x7D, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0x78, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0,
  0x7C, 0x7C, 0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x03, 0xF7,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x03, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF0, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xE1, 0xF8, 0xF8, 0x1F, 0x3E,
  0x01, 0xE7, 0xC0, 0x3E, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x0F, 0x78,
  0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0,
  0x03, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xF8, 0xF8,
  0x1F, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x81, 0xF9, 0xF0, 0x1F, 0xBE,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C,
  0x07, 0xCF, 0x87, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xF8,
  0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7C, 0x03,
  0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7C, 0x0F, 0xDE, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x01,
  0xF7, 0xF1, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xF7, 0x80, 0xFB,
  0xE0, 0xFD, 0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7,
  0xC0, 0x7C, 0x3C, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0x83, 0xE0, 0xF8,
  0x1E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x9F,
  0x00, 0xF9, 0xE0, 0x07, 0x9E, 0x00, 0x7B, 0xE0, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF1, 0xFF, 0x1F, 0x1E, 0xF9, 0xF1, 0xE7, 0x9F, 0x9E,
  0x79, 0xF9, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xE7, 0xBF, 0x9E, 0x7B, 0xBB,
  0xC7, 0xBB, 0xFC, 0x3B, 0x9F, 0xC3, 0xF9, 0xFC, 0x3F, 0x9F, 0xC3, 0xF9,
  0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xFC, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0xF8, 0x01, 0xF7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0xF8,
  0x1F, 0x0F, 0x80, 0xF9, 0xF0, 0x07, 0x9F, 0x00, 0x7F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFE, 0x00, 0x7D, 0xE0, 0x0F, 0x9F, 0x01, 0xF8, 0xF8, 0x1F,
  0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x0F,
  0x00, 0xF9, 0xF0, 0x07, 0x9E, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xCE, 0x0F, 0x3C, 0x3C, 0xF0, 0xE1,
  0xC7, 0x87, 0x9E, 0x0E, 0xF0, 0x3F, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x1E, 0x0F, 0x0F, 0x0F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0x87, 0xE7, 0x81, 0xF3, 0xC0, 0x78, 0x00, 0x3E,
  0x01, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xDF, 0x83, 0xEF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF8, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7,
  0xF3, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF3, 0xF8, 0x7F, 0xFE, 0x3F,
  0xFF, 0x9F, 0xCF, 0xCF, 0x81, 0xF7, 0x80, 0xFB, 0xC0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xEF, 0x00, 0xF7, 0x80,
  0xFB, 0xE0, 0x7D, 0xFC, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3C, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xE7, 0xE7, 0xC0, 0xFB, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x3D, 0xF0, 0x3E, 0x7E, 0x7E, 0x3F, 0xFF,
  0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0xEF,
  0x8F, 0xFF, 0xCF, 0xFF, 0xEF, 0xE7, 0xF7, 0xC0, 0xFB, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFB, 0xC0, 0x7D, 0xF0, 0x3E, 0xFE, 0x7F, 0x3F, 0xFF, 0x8F, 0xFB,
  0xC3, 0xF9, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFC, 0xFC,
  0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x47, 0xE0,
  0x30, 0xFE, 0x7E, 0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x1F,
  0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xE7, 0x8F, 0xFB, 0xCF, 0xFF, 0xEF, 0xE7, 0xF7, 0xC0, 0xFB,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xF0, 0x3E, 0xFE, 0x7F, 0x3F,
  0xFF, 0x8F, 0xFB, 0xC3, 0xF9, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x80, 0x7C,
  0xF0, 0xFC, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFC, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF3, 0xF8, 0xF7, 0xFE, 0xFF, 0xFE, 0xFE, 0x7F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x08, 0x00,
  0x00, 0x03, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xFF, 0xF7, 0xFC,
  0xFF, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0xBC,
  0x0F, 0x8F, 0x07, 0xC3, 0xC3, 0xF0, 0xF1, 0xF8, 0x3C, 0xFC, 0x0F, 0x7E,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xF7, 0xC0,
  0xF8, 0xF8, 0x3C, 0x3F, 0x0F, 0x07, 0xC3, 0xC0, 0xF8, 0xF0, 0x3F, 0x3C,
  0x07, 0xEF, 0x00, 0xFC, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xEF,
  0xDE, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFD, 0xFF, 0x8F, 0x1F, 0xF1, 0xE3,
  0xFE, 0x3C, 0x7F, 0xC7, 0x8F, 0xF8, 0xF1, 0xFF, 0x1E, 0x3F, 0xE3, 0xC7,
  0xFC, 0x78, 0xFF, 0x8F, 0x1F, 0xF1, 0xE3, 0xFE, 0x3C, 0x7F, 0xC7, 0x8F,
  0xF8, 0xF1, 0xFF, 0x1E, 0x3F, 0xE3, 0xC7, 0x80, 0xF3, 0xF8, 0xF7, 0xFE,
  0xFF, 0xFE, 0xFE, 0x7F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x07, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFC, 0xFC, 0x7C, 0x0F, 0xBE, 0x03, 0xEF,
  0x80, 0x7B, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xBE, 0x03, 0xE7, 0xC0, 0xF9, 0xFC, 0xFC, 0x3F, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0x80, 0xF3, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE,
  0xFE, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xF3, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xE7, 0x8F,
  0xFB, 0xCF, 0xFF, 0xEF, 0xE7, 0xF7, 0xC0, 0xFB, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFB, 0xC0, 0x7D, 0xF0, 0x3E, 0xFE, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3,
  0xFB, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0xFF, 0xF7, 0xFB, 0xFF, 0xF7, 0xFF,
  0xEF, 0xF0, 0x5F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF,
  0xC3, 0xF7, 0xC0, 0xFB, 0xC0, 0x3D, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF8, 0x1F, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFE, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x38, 0x1F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFE, 0x7F, 0x7F, 0xFF, 0x3F,
  0xEF, 0x1F, 0xCF, 0xF8, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0x1E, 0x03,
  0xE3, 0xE0, 0x78, 0x7C, 0x0F, 0x07, 0x83, 0xE0, 0xF8, 0x78, 0x0F, 0x0F,
  0x01, 0xE3, 0xE0, 0x3E, 0x78, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0xE0, 0xFF, 0x0E, 0x1F, 0xF0, 0xF1, 0xEF, 0x1F, 0x1E, 0xF1,
  0xF1, 0xE7, 0x1F, 0x1E, 0x79, 0xF1, 0xE7, 0x9B, 0x9C, 0x7B, 0xB9, 0xC7,
  0xBB, 0xBC, 0x7B, 0xBB, 0xC3, 0xB9, 0xBC, 0x3B, 0x1F, 0x83, 0xF1, 0xF8,
  0x3F, 0x1F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x1E, 0x0F,
  0x00, 0xF8, 0x07, 0xCF, 0x81, 0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0x81, 0xF3,
  0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3E, 0x7C, 0x07, 0xC7,
  0xC1, 0xF0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xFB, 0xE0, 0x1F, 0x80, 0xF8,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE3, 0xC0, 0x3E, 0x3E, 0x03, 0xC3,
  0xE0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF8, 0xF0,
  0x07, 0x9F, 0x00, 0x7D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x70, 0x1F, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x0F, 0xF0, 0xFC, 0x0F, 0xC0, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xFF, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0xF8,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0x3F, 0x00, 0x8F,
  0xF8, 0x1F, 0xFF, 0x87, 0xFD, 0xFF, 0xFE, 0x0F, 0xFD, 0xC0, 0xFF, 0x80,
  0x07, 0xE0,
};

const GFXglyph RobotoMono_SemiBold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 5, 26, 22, 8, -26 },
  { 18, 11, 9, 22, 5, -27 },
  { 31, 19, 26, 22, 1, -26 },
  { 93, 18, 34, 22, 2, -30 },
  { 170, 20, 26, 22, 1, -26 },
  { 235, 21, 26, 22, 1, -26 },
  { 304, 4, 9, 22, 8, -27 },
  { 309, 10, 37, 22, 6, -29 },
  { 356, 9, 37, 22, 6, -29 },
  { 398, 17, 18, 22, 3, -26 },
  { 437, 17, 18, 22, 2, -21 },
  { 476, 6, 11, 22, 6, -4 },
  { 485, 14, 4, 22, 5, -13 },
  { 492, 6, 6, 22, 8, -6 },
  { 497, 14, 28, 22, 4, -26 },
  { 546, 17, 26, 22, 2, -26 },
  { 602, 11, 26, 22, 3, -26 },
  { 638, 18, 26, 22, 1, -26 },
  { 697, 17, 26, 22, 2, -26 },
  { 753, 19, 26, 22, 1, -26 },
  { 815, 17, 26, 22, 2, -26 },
  { 871, 17, 26, 22, 2, -26 },
  { 927, 18, 26, 22, 1, -26 },
  { 986, 17, 26, 22, 2, -26 },
  { 1042, 17, 26, 22, 2, -26 },
  { 1098, 7, 21, 22, 8, -21 },
  { 1117, 7, 28, 22, 8, -21 },
  { 1142, 15, 16, 22, 3, -19 },
  { 1172, 16, 12, 22, 3, -17 },
  { 1196, 16, 16, 22, 3, -19 },
  { 1228, 16, 26, 22, 3, -26 },
  { 1280, 20, 25, 22, 1, -25 },
  { 1343, 20, 26, 22, 1, -26 },
  { 1408, 19, 26, 22, 2, -26 },
  { 1470, 19, 26, 22, 1, -26 },
  { 1532, 18, 26, 22, 2, -26 },
  { 1591, 17, 26, 22, 3, -26 },
  { 1647, 17, 26, 22, 3, -26 },
  { 1703, 18, 26, 22, 2, -26 },
  { 1762, 17, 26, 22, 2, -26 },
  { 1818, 15, 26, 22, 3, -26 },
  { 1867, 17, 26, 22, 2, -26 },
  { 1923, 20, 26, 22, 2, -26 },
  { 1988, 17, 26, 22, 3, -26 },
  { 2044, 18, 26, 22, 2, -26 },
  { 2103, 17, 26, 22, 2, -26 },
  { 2159, 19, 26, 22, 1, -26 },
  { 2221, 17, 26, 22, 3, -26 },
  { 2277, 19, 30, 22, 2, -26 },
  { 2349, 19, 26, 22, 2, -26 },
  { 2411, 18, 26, 22, 2, -26 },
  { 2470, 20, 26, 22, 1, -26 },
  { 2535, 17, 26, 22, 2, -26 },
  { 2591, 20, 26, 22, 1, -26 },
  { 2656, 20, 26, 22, 1, -26 },
  { 2721, 20, 26, 22, 1, -26 },
  { 2786, 20, 26, 22, 1, -26 },
  { 2851, 18, 26, 22, 2, -26 },
  { 2910, 8, 36, 22, 7, -30 },
  { 2946, 14, 28, 22, 4, -26 },
  { 2995, 8, 36, 22, 7, -30 },
  { 3031, 14, 14, 22, 4, -26 },
  { 3056, 16, 4, 22, 3, 0 },
  { 3064, 8, 5, 22, 7, -26 },
  { 3069, 17, 19, 22, 2, -19 },
  { 3110, 17, 27, 22, 3, -27 },
  { 3168, 17, 19, 22, 2, -19 },
  { 3209, 17, 27, 22, 2, -27 },
  { 3267, 18, 19, 22, 2, -19 },
  { 3310, 18, 28, 22, 2, -28 },
  { 3373, 17, 26, 22, 2, -19 },
  { 3429, 16, 27, 22, 3, -27 },
  { 3483, 15, 26, 22, 4, -26 },
  { 3532, 11, 34, 22, 4, -26 },
  { 3579, 18, 27, 22, 3, -27 },
  { 3640, 16, 27, 22, 4, -27 },
  { 3694, 19, 19, 22, 1, -19 },
  { 3740, 16, 19, 22, 3, -19 },
  { 3778, 18, 19, 22, 2, -19 },
  { 3821, 16, 26, 22, 3, -19 },
  { 3873, 17, 26, 22, 2, -19 },
  { 3929, 15, 19, 22, 5, -19 },
  { 3965, 17, 19, 22, 2, -19 },
  { 4006, 17, 24, 22, 2, -24 },
  { 4057, 16, 19, 22, 3, -19 },
  { 4095, 19, 19, 22, 1, -19 },
  { 4141, 20, 19, 22, 1, -19 },
  { 4189, 19, 19, 22, 2, -19 },
  { 4235, 20, 27, 22, 1, -19 },
  { 4303, 18, 19, 22, 2, -19 },
  { 4346, 12, 34, 22, 5, -28 },
  { 4397, 3, 33, 22, 9, -26 },
  { 4410, 12, 34, 22, 6, -28 },
  { 4461, 19, 7, 22, 1, -14 },
};

const GFXfont RobotoMono_SemiBold36pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold36pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOMONO_SEMIBOLD36PT7B_H_
