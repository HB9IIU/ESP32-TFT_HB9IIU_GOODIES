#ifndef _ROBOTOMONO_SEMIBOLD41PT7B_H_
#define _ROBOTOMONO_SEMIBOLD41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold41pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x78, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0,
  0xEE, 0x0E, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E,
  0x00, 0x38, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x1C, 0x00,
  0x70, 0x70, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0xF0,
  0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x00, 0x1E, 0x1C, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF8, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E,
  0x00, 0x38, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE0,
  0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3F, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03,
  0xE7, 0xE0, 0x7E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x04,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x1E,
  0x08, 0x1C, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xF1, 0xC0, 0xE1, 0xE3,
  0x81, 0xE3, 0xCE, 0x03, 0xFF, 0x3C, 0x03, 0xFE, 0x70, 0x03, 0xF1, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x8F, 0xC0, 0x07, 0x3F, 0xE0, 0x1C, 0xFF, 0xC0,
  0x79, 0xE3, 0xC0, 0xE3, 0x87, 0x83, 0xC7, 0x0F, 0x07, 0x0E, 0x1E, 0x06,
  0x1C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x60, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xE1, 0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xF0, 0x7C, 0xFF, 0xF0, 0xF9, 0xF3, 0xF1, 0xF7, 0xE3, 0xE3, 0xCF,
  0x87, 0xEF, 0x9F, 0x07, 0xFF, 0x3E, 0x07, 0xFE, 0x7C, 0x07, 0xF8, 0xF8,
  0x0F, 0xE1, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x81, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x40, 0x18, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07,
  0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xC0, 0x08, 0x40, 0x06, 0x00,
  0x70, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x70, 0x06, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x04, 0x07, 0x02, 0x70, 0x70, 0xE7, 0xE7, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07,
  0x9E, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0x7C, 0x0E, 0x07, 0x80,
  0x40, 0x20, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9E, 0x7C, 0xF9, 0xE7, 0x82, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0xFE, 0x3E, 0xFF, 0xCF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xE0, 0x3E,
  0x7C, 0x07, 0xCF, 0xC1, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0x30, 0x1F, 0x07, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x00,
  0x70, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7E, 0x7C, 0x01, 0xF7, 0xE0,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xE0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x03, 0xE7, 0xE0, 0x7E, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x1E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x3E, 0x00,
  0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x1F,
  0x03, 0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF7, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F,
  0x07, 0xF0, 0x40, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3E, 0xFE,
  0x0F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0xFE, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x0F,
  0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xE0, 0x3E, 0x3F,
  0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0x7E, 0x03, 0xE3, 0xE0, 0x7E, 0x3F, 0x0F, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF0, 0xFC, 0x7E, 0x07,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0,
  0x3F, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xDF, 0x00, 0xFB, 0xF0, 0x3F, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F,
  0xFF, 0x87, 0xFD, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0x80, 0x00, 0x18, 0x7E, 0xFE, 0xFF, 0xFE, 0x7E, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0xFE,
  0xFF, 0xFE, 0x7E, 0x7C, 0x08, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x01,
  0xF0, 0x03, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x01,
  0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0x9F,
  0x01, 0xFF, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0x78, 0x78,
  0x00, 0xE3, 0xC1, 0xE3, 0x8E, 0x1F, 0xE7, 0x78, 0xFF, 0x9D, 0xC7, 0x8E,
  0x77, 0x1C, 0x39, 0xFC, 0xF0, 0xC7, 0xE3, 0x87, 0x0F, 0x8E, 0x1C, 0x7E,
  0x38, 0x71, 0xF8, 0xE1, 0xC7, 0xE3, 0x87, 0x1F, 0x8E, 0x1C, 0x7E, 0x38,
  0x71, 0xB8, 0xF3, 0xCE, 0xF3, 0xFF, 0xF1, 0xC7, 0xEF, 0xC7, 0x0E, 0x1C,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x04, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0x9E,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0x00, 0x7E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x03, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x07, 0xEF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x83, 0xF9, 0xF8, 0x0F,
  0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0x80, 0x3E, 0x7E, 0x03, 0xF1,
  0xF8, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF8,
  0x7F, 0x8F, 0x81, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x81,
  0xFC, 0xF8, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x83, 0xF9,
  0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7E,
  0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x01, 0xFF, 0x80, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xE7,
  0xC0, 0x7E, 0x7E, 0x0F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0,
  0x07, 0xFC, 0x00, 0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0xCF, 0x80, 0x7E, 0x3E,
  0x03, 0xF8, 0xF8, 0x0F, 0xC3, 0xE0, 0x7E, 0x0F, 0x83, 0xF0, 0x3E, 0x1F,
  0xC0, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0x9F, 0x80, 0x3E, 0xFE, 0x00,
  0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xFC, 0x03, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3F,
  0x83, 0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xE3,
  0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xF8, 0x01, 0xFC, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xEF, 0xF7, 0x3D, 0xFE, 0xF7, 0xBF, 0xDE, 0xE7, 0xF9, 0xFC,
  0xFF, 0x3F, 0x9F, 0xE7, 0xF3, 0xFC, 0xFC, 0x7F, 0x8F, 0x8F, 0xF1, 0xF1,
  0xFE, 0x3C, 0x3F, 0xC3, 0x87, 0xF8, 0x70, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFD, 0xE1, 0xFF, 0xBE, 0x3F,
  0xF3, 0xC7, 0xFE, 0x78, 0xFF, 0xCF, 0x9F, 0xF8, 0xF3, 0xFF, 0x1F, 0x7F,
  0xE1, 0xEF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x7E, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7E, 0xFC,
  0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB,
  0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7E, 0x03, 0xE1, 0xF8, 0x7F, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFC, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xE0,
  0x07, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0xC0,
  0x1F, 0x1F, 0x00, 0x7C, 0x7E, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x02, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x80, 0xFE,
  0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x01, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x1F, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F,
  0x01, 0xF8, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x3E, 0x00, 0xFD, 0xF0, 0x07,
  0xEF, 0x80, 0x1F, 0x80, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x81, 0xF9, 0xF8, 0x07, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xF8, 0x1F,
  0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3E, 0x7E, 0x0F, 0xCF, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x8F, 0xC0,
  0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x3E, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0xFC,
  0x03, 0xE1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00,
  0x1F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x78, 0x3F, 0xF0,
  0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87, 0xC3, 0xDF, 0x0F,
  0x87, 0x9E, 0x3F, 0x1F, 0x3C, 0x7E, 0x3E, 0x7C, 0xFE, 0x7C, 0xF9, 0xFC,
  0xF9, 0xF3, 0xF9, 0xF3, 0xE7, 0xF3, 0xC7, 0xDE, 0xE7, 0x87, 0xBD, 0xCF,
  0x0F, 0x7B, 0xDE, 0x1E, 0xF7, 0xFC, 0x3D, 0xCF, 0xF8, 0x7F, 0x9F, 0xF0,
  0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07,
  0xE1, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0x80, 0xFC, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xFE, 0x00, 0x7E, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xC0, 0x07, 0xDF,
  0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xBE, 0x00, 0x3F, 0x7E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xFC, 0x03,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0xF8,
  0x00, 0xF9, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0x78, 0x1E, 0x3C, 0x0F, 0x1E,
  0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7E, 0x0F, 0xE7, 0xC0, 0x7E, 0x7C, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xE7, 0xC0,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFB, 0xE0, 0xFF, 0x3F, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x1F, 0x83, 0xEF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFE, 0x3F, 0xBF, 0x01, 0xF7, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x80,
  0xFB, 0xF8, 0x3F, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xF7, 0xFE, 0x3E, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0x8F, 0xE7, 0xE0, 0x3E, 0x7E, 0x03, 0xF7, 0xC0, 0x1F, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x7E, 0x03, 0xE3, 0xF0, 0x7E, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x3F, 0x0F, 0xFB, 0xF1,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xF8, 0xFF, 0x7E, 0x07, 0xF7, 0xC0, 0x3F,
  0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0,
  0x3F, 0x3F, 0x07, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xDF, 0x07,
  0xF1, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x3F, 0x87, 0xE3, 0xE0, 0x3E, 0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x43, 0xF8, 0x1E, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x07, 0x80,
  0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0xFF, 0xDF, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x3F, 0x8F, 0xF7, 0xE0, 0x3F, 0x7E, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x03, 0xF3,
  0xF0, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFD, 0xF0, 0x7F, 0x9F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x08, 0x03, 0xE1, 0xC0, 0x7E, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x0F, 0xC3, 0xE7,
  0xFC, 0x7D, 0xFF, 0xCF, 0xFF, 0xFD, 0xFE, 0x3F, 0xBF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xF8, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x03,
  0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE7, 0xFF, 0x1F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x3E, 0x03, 0xF1, 0xF0,
  0x3F, 0x0F, 0x83, 0xF8, 0x7C, 0x3F, 0x83, 0xE3, 0xF8, 0x1F, 0x1F, 0x80,
  0xF9, 0xF8, 0x07, 0xDF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0x8F, 0xC0, 0xF8, 0x3F, 0x07,
  0xC1, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0x80, 0xFE, 0x7C, 0x03,
  0xFB, 0xE0, 0x0F, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF3, 0xE3, 0xC7, 0xBF, 0xBF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x9F, 0x9F, 0xF8, 0x7C, 0x7F, 0xC3, 0xE3, 0xFE, 0x1F, 0x1F, 0xF0,
  0xF8, 0xFF, 0x87, 0xC7, 0xFC, 0x3E, 0x3F, 0xE1, 0xF1, 0xFF, 0x0F, 0x8F,
  0xF8, 0x7C, 0x7F, 0xC3, 0xE3, 0xFE, 0x1F, 0x1F, 0xF0, 0xF8, 0xFF, 0x87,
  0xC7, 0xFC, 0x3E, 0x3F, 0xE1, 0xF1, 0xFF, 0x0F, 0x8F, 0xF8, 0x7C, 0x7C,
  0xF8, 0x7E, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xEF, 0xF0, 0xFD,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0x8F, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xF7, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xE3,
  0xF0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0xF8, 0xFC, 0x1F, 0x7F, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xE1, 0xFD,
  0xF8, 0x1F, 0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xDF, 0xC1, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF,
  0xBF, 0xF1, 0xF3, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF1, 0xF0, 0xFF, 0xDF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0x8F,
  0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C,
  0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF3, 0xF0, 0x7F, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF9, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03,
  0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xC0, 0xFD, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFD, 0xFE, 0x7F, 0x3F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x07, 0xEF, 0xC1, 0xFD, 0xFF, 0xFF, 0x9F, 0xFD, 0xF3, 0xFF, 0xBE, 0x1F,
  0xC7, 0xC0, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0,
  0x03, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0xF0, 0x78, 0x3F, 0xF0, 0xF0, 0x7B, 0xE1, 0xE0, 0xF7, 0xC3, 0xE1, 0xEF,
  0x87, 0xC7, 0xCF, 0x1F, 0x8F, 0x9E, 0x3F, 0x1F, 0x3C, 0x7E, 0x3C, 0x78,
  0xFE, 0x78, 0xF9, 0xFC, 0xF0, 0xF7, 0xB9, 0xE1, 0xEE, 0x77, 0xC3, 0xDC,
  0xEF, 0x07, 0xB9, 0xFE, 0x0F, 0x71, 0xFC, 0x1F, 0xE3, 0xF8, 0x1F, 0x87,
  0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E,
  0x01, 0xE0, 0x7C, 0x00, 0xFC, 0x00, 0xF9, 0xF8, 0x07, 0xC3, 0xE0, 0x3F,
  0x0F, 0xC1, 0xF8, 0x1F, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xFD, 0xF8, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xE0,
  0x0F, 0x8F, 0xC0, 0x7E, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0x80, 0xFC, 0x7E,
  0x01, 0xFB, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF8,
  0x01, 0xF3, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xE0, 0x1F, 0x07, 0xC0,
  0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xFC, 0x03,
  0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFE,
  0x03, 0xF0, 0x3F, 0x83, 0xFC, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x0F, 0xC0, 0x7C, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0x80, 0xF7, 0xFF, 0x03, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0xFB, 0x80,
  0xFF, 0xEE, 0x01, 0xFF, 0x00, 0x03, 0xF8,
};

const GFXglyph RobotoMono_SemiBold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 6, 29, 25, 9, -29 },
  { 23, 12, 11, 25, 6, -31 },
  { 40, 22, 29, 25, 1, -29 },
  { 120, 20, 38, 25, 3, -34 },
  { 215, 23, 30, 25, 1, -30 },
  { 302, 23, 30, 25, 2, -30 },
  { 389, 4, 11, 25, 9, -31 },
  { 395, 11, 42, 25, 7, -33 },
  { 453, 12, 42, 25, 6, -33 },
  { 516, 20, 20, 25, 3, -29 },
  { 566, 20, 21, 25, 2, -24 },
  { 619, 7, 13, 25, 7, -5 },
  { 631, 17, 4, 25, 5, -15 },
  { 640, 7, 7, 25, 9, -7 },
  { 647, 16, 32, 25, 5, -29 },
  { 711, 19, 30, 25, 3, -30 },
  { 783, 12, 29, 25, 4, -29 },
  { 827, 21, 30, 25, 1, -30 },
  { 906, 20, 30, 25, 2, -30 },
  { 981, 21, 29, 25, 1, -29 },
  { 1058, 19, 29, 25, 3, -29 },
  { 1127, 20, 29, 25, 2, -29 },
  { 1200, 20, 29, 25, 2, -29 },
  { 1273, 20, 30, 25, 2, -30 },
  { 1348, 19, 30, 25, 2, -30 },
  { 1420, 8, 24, 25, 9, -24 },
  { 1444, 8, 32, 25, 9, -24 },
  { 1476, 18, 19, 25, 3, -22 },
  { 1519, 19, 13, 25, 3, -19 },
  { 1550, 18, 19, 25, 3, -22 },
  { 1593, 19, 30, 25, 3, -30 },
  { 1665, 22, 29, 25, 1, -29 },
  { 1745, 23, 29, 25, 1, -29 },
  { 1829, 20, 29, 25, 3, -29 },
  { 1902, 21, 30, 25, 2, -30 },
  { 1981, 20, 29, 25, 3, -29 },
  { 2054, 19, 29, 25, 3, -29 },
  { 2123, 19, 29, 25, 3, -29 },
  { 2192, 21, 30, 25, 2, -30 },
  { 2271, 19, 29, 25, 3, -29 },
  { 2340, 17, 29, 25, 4, -29 },
  { 2402, 20, 29, 25, 2, -29 },
  { 2475, 22, 29, 25, 3, -29 },
  { 2555, 19, 29, 25, 3, -29 },
  { 2624, 19, 29, 25, 3, -29 },
  { 2693, 19, 29, 25, 3, -29 },
  { 2762, 21, 30, 25, 2, -30 },
  { 2841, 20, 29, 25, 3, -29 },
  { 2914, 22, 35, 25, 2, -30 },
  { 3011, 21, 29, 25, 3, -29 },
  { 3088, 21, 30, 25, 2, -30 },
  { 3167, 23, 29, 25, 1, -29 },
  { 3251, 19, 29, 25, 3, -29 },
  { 3320, 23, 29, 25, 1, -29 },
  { 3404, 23, 29, 25, 1, -29 },
  { 3488, 23, 29, 25, 1, -29 },
  { 3572, 23, 29, 25, 1, -29 },
  { 3656, 21, 29, 25, 2, -29 },
  { 3733, 9, 41, 25, 8, -34 },
  { 3780, 16, 32, 25, 5, -29 },
  { 3844, 9, 41, 25, 8, -34 },
  { 3891, 17, 15, 25, 4, -29 },
  { 3923, 18, 4, 25, 3, 0 },
  { 3932, 10, 6, 25, 8, -30 },
  { 3940, 20, 22, 25, 2, -22 },
  { 3995, 19, 31, 25, 3, -31 },
  { 4069, 20, 22, 25, 2, -22 },
  { 4124, 20, 31, 25, 2, -31 },
  { 4202, 20, 22, 25, 2, -22 },
  { 4257, 20, 32, 25, 3, -32 },
  { 4337, 20, 31, 25, 2, -22 },
  { 4415, 19, 31, 25, 3, -31 },
  { 4489, 18, 30, 25, 4, -30 },
  { 4557, 14, 39, 25, 4, -30 },
  { 4626, 21, 31, 25, 3, -31 },
  { 4708, 18, 31, 25, 4, -31 },
  { 4778, 21, 22, 25, 2, -22 },
  { 4836, 19, 22, 25, 3, -22 },
  { 4889, 20, 22, 25, 2, -22 },
  { 4944, 19, 30, 25, 3, -22 },
  { 5016, 20, 30, 25, 2, -22 },
  { 5091, 16, 22, 25, 6, -22 },
  { 5135, 19, 22, 25, 3, -22 },
  { 5188, 19, 27, 25, 3, -27 },
  { 5253, 19, 22, 25, 3, -22 },
  { 5306, 21, 22, 25, 2, -22 },
  { 5364, 23, 22, 25, 1, -22 },
  { 5428, 22, 22, 25, 2, -22 },
  { 5489, 23, 31, 25, 1, -22 },
  { 5579, 20, 22, 25, 3, -22 },
  { 5634, 14, 39, 25, 6, -32 },
  { 5703, 3, 37, 25, 11, -29 },
  { 5717, 13, 39, 25, 7, -32 },
  { 5781, 22, 8, 25, 1, -16 },
};

const GFXfont RobotoMono_SemiBold41pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold41pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOMONO_SEMIBOLD41PT7B_H_
