#ifndef _ROBOTOMONO_SEMIBOLD19PT7B_H_
#define _ROBOTOMONO_SEMIBOLD19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xDB, 0x60, 0x2F, 0xC0, 0xDE, 0xE7, 0x39, 0x80, 0x0C,
  0x81, 0x90, 0x32, 0x04, 0xC7, 0xFE, 0xFF, 0xC6, 0x40, 0xC8, 0x13, 0x1F,
  0xF8, 0x4C, 0x19, 0x03, 0x20, 0x6C, 0x00, 0x0C, 0x06, 0x03, 0x87, 0xE7,
  0x3B, 0x0D, 0x86, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3E, 0x1F, 0x0D, 0xFE,
  0x7E, 0x0C, 0x06, 0x00, 0x30, 0x0F, 0x03, 0x32, 0x66, 0xCC, 0xB0, 0xF4,
  0x01, 0x80, 0x20, 0x0D, 0xC1, 0x7C, 0x6D, 0x89, 0x30, 0x36, 0x03, 0x80,
  0x1C, 0x0F, 0x87, 0x61, 0x8C, 0x66, 0x1F, 0x83, 0x81, 0xE3, 0xFC, 0xF3,
  0xBC, 0x7B, 0x0E, 0xFF, 0x9F, 0x70, 0xFF, 0xC0, 0x08, 0xCC, 0x66, 0x31,
  0x98, 0xC6, 0x31, 0x8E, 0x31, 0x8C, 0x30, 0xC2, 0x86, 0x18, 0x63, 0x1C,
  0x63, 0x18, 0xC6, 0x31, 0x9C, 0xC6, 0x67, 0x30, 0x0C, 0x03, 0x00, 0xC1,
  0x32, 0xFF, 0xC7, 0x81, 0xE0, 0x4C, 0x73, 0x88, 0x40, 0x1C, 0x0E, 0x07,
  0x03, 0x8F, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x6D, 0xBE, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0, 0x1C, 0x1F, 0x9C, 0xCC, 0x7E,
  0x1F, 0x1F, 0x9F, 0xFB, 0xF1, 0xF0, 0xF8, 0x6C, 0x77, 0xF1, 0xF0, 0x04,
  0x7F, 0xFF, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x1C, 0x3F,
  0xB9, 0xD8, 0x7C, 0x38, 0x18, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0F,
  0xFF, 0xFC, 0x1C, 0x3F, 0xB8, 0xDC, 0x70, 0x38, 0x18, 0x7C, 0x3E, 0x03,
  0x80, 0xF0, 0x7C, 0x77, 0xF1, 0xF0, 0x07, 0x03, 0x83, 0xC3, 0xE1, 0xF1,
  0xB8, 0xDC, 0xCE, 0xC7, 0x7F, 0xFF, 0xE0, 0xE0, 0x70, 0x38, 0x7F, 0xBF,
  0xDF, 0xEC, 0x06, 0x03, 0xF1, 0xFC, 0xC7, 0x01, 0x80, 0xF8, 0x7C, 0x77,
  0xF1, 0xF0, 0x02, 0x0F, 0x0F, 0x0E, 0x06, 0x07, 0xF3, 0xFD, 0xC7, 0xC1,
  0xE0, 0xF8, 0x6C, 0x77, 0xF1, 0xF0, 0xFF, 0xFF, 0xC0, 0x60, 0x60, 0x30,
  0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x80, 0x1C, 0x3F,
  0x9C, 0xFC, 0x7E, 0x3B, 0x18, 0xFC, 0x7E, 0x63, 0xF0, 0xF8, 0x7C, 0x77,
  0xF1, 0xF0, 0x1C, 0x3F, 0x1D, 0xDC, 0x7C, 0x3E, 0x0F, 0x8E, 0xEF, 0x7F,
  0x8D, 0xC0, 0xC0, 0xE3, 0xE1, 0xC0, 0x6F, 0x60, 0x00, 0x00, 0x6F, 0x60,
  0x77, 0x70, 0x00, 0x00, 0x06, 0x66, 0x6C, 0x40, 0x01, 0x83, 0xCF, 0xDF,
  0x0F, 0x03, 0xF0, 0x3E, 0x07, 0x00, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x80, 0xF0, 0x7C, 0x0F, 0x0F, 0x3E, 0xF8, 0xC0, 0x80, 0x3C,
  0xFE, 0xE7, 0xC3, 0x03, 0x07, 0x0E, 0x1C, 0x18, 0x18, 0x00, 0x10, 0x38,
  0x18, 0x1F, 0x86, 0x18, 0x89, 0x37, 0xB4, 0x96, 0xB2, 0x76, 0x5E, 0xCB,
  0x5B, 0x49, 0xB9, 0x80, 0x18, 0x81, 0xF0, 0x06, 0x01, 0xC0, 0x3C, 0x07,
  0x81, 0xF0, 0x37, 0x06, 0x61, 0xCC, 0x31, 0xC7, 0xF8, 0xFF, 0x38, 0x66,
  0x0F, 0xC0, 0xC0, 0xF8, 0x3F, 0xCE, 0x7B, 0x86, 0xE1, 0xF8, 0x6F, 0xF3,
  0xFE, 0xE1, 0xB8, 0x7E, 0x1F, 0x87, 0xFF, 0xBF, 0xC0, 0x1C, 0x0F, 0xC7,
  0x3B, 0x86, 0xC1, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x1F, 0x86,
  0x7F, 0x8F, 0x80, 0xF0, 0x3F, 0x8E, 0xF3, 0x8E, 0xE1, 0xB8, 0x6E, 0x1F,
  0x87, 0xE1, 0xF8, 0x6E, 0x3B, 0x8E, 0xFF, 0x3F, 0x00, 0xFF, 0xFF, 0xF8,
  0x1C, 0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x00, 0x1C, 0x1F, 0x9C, 0xFC, 0x3C, 0x06, 0x03,
  0x01, 0x8F, 0xC7, 0xE0, 0xF8, 0x6C, 0x37, 0xF9, 0xF8, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0xFF, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0C, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xF0, 0x7C, 0x77, 0xF1, 0xF0, 0xE1, 0xDC, 0x3B, 0x8E, 0x73,
  0x8E, 0xE1, 0xD8, 0x3F, 0x07, 0xE0, 0xFE, 0x1C, 0xE3, 0x8C, 0x71, 0xCE,
  0x1D, 0xC3, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFC, 0xE3, 0xF1, 0xFC, 0xFE, 0xFD,
  0x7E, 0xFF, 0x77, 0xBB, 0xCD, 0xE4, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0xE1,
  0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0xCF, 0xE7, 0xDB, 0xED, 0xF3, 0xF9, 0xFC,
  0x7E, 0x3F, 0x1C, 0x1C, 0x0F, 0xC7, 0x7B, 0x86, 0xC1, 0xB0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x6E, 0x1B, 0x8E, 0x7F, 0x0F, 0x80, 0xF8, 0x3F, 0xCE,
  0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1B, 0xFE, 0xFE, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x00, 0x1C, 0x0F, 0xC7, 0x3B, 0x86, 0xC1, 0xB0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7E, 0x1B, 0x8E, 0x7F, 0x0F, 0xE0, 0x1C, 0x03, 0xF8,
  0x3F, 0xCE, 0x7B, 0x86, 0xE1, 0xF8, 0x6E, 0x3B, 0xFC, 0xFE, 0x39, 0xCE,
  0x33, 0x8E, 0xE1, 0xB8, 0x70, 0x1C, 0x1F, 0xC7, 0x3B, 0x87, 0xE0, 0x1C,
  0x07, 0xC0, 0x7C, 0x03, 0x80, 0x7C, 0x1F, 0x87, 0x7F, 0x8F, 0xC0, 0xFF,
  0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x6C, 0x77, 0xF1, 0xF0, 0xE0,
  0xEC, 0x1D, 0xC3, 0x38, 0x63, 0x1C, 0x63, 0x0E, 0x60, 0xDC, 0x1B, 0x83,
  0x60, 0x7C, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0xE6, 0x7C, 0xCD, 0x99, 0xB7,
  0x36, 0xEE, 0xDD, 0x9B, 0xF3, 0x5E, 0x6B, 0xC7, 0x78, 0xE7, 0x1C, 0xE3,
  0x9C, 0x63, 0x00, 0xE0, 0xEE, 0x1C, 0xC7, 0x1C, 0xC1, 0xB8, 0x3E, 0x03,
  0xC0, 0x70, 0x0F, 0x03, 0xF0, 0xE6, 0x1C, 0xE7, 0x0D, 0xE1, 0xC0, 0xE0,
  0x6C, 0x1D, 0xC3, 0x18, 0xE3, 0x98, 0x37, 0x07, 0xC0, 0x78, 0x0E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0xBF, 0xE0, 0x38, 0x0C,
  0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xFF, 0xFF,
  0xF0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC0,
  0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0E,
  0x06, 0x07, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x7F, 0xF0,
  0x18, 0x18, 0x3C, 0x3C, 0x6C, 0x66, 0xC6, 0xC3, 0xFF, 0xFF, 0xC0, 0xE6,
  0x30, 0x3E, 0x3F, 0xB8, 0xE0, 0x73, 0xFB, 0x9F, 0x8F, 0xC7, 0xFF, 0xBE,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xF7, 0xFB, 0x8F, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x7F, 0xF7, 0xF8, 0x3E, 0x3F, 0x98, 0xFC, 0x3E, 0x07, 0x03,
  0x80, 0xC7, 0x7F, 0x1F, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x33, 0xDB, 0xFF,
  0x8F, 0xC3, 0xC1, 0xE0, 0xF8, 0x7C, 0x77, 0xF9, 0xEC, 0x3E, 0x3F, 0xD8,
  0x7C, 0x3F, 0xFF, 0xFF, 0x80, 0xC2, 0x7F, 0x9F, 0x80, 0x03, 0x83, 0xF1,
  0xC4, 0x60, 0x18, 0x3F, 0xEF, 0xF8, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x3D, 0xBF, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x86,
  0xC7, 0x7F, 0x9E, 0xC0, 0x68, 0x77, 0xF1, 0xF0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0xF7, 0xFF, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0C,
  0x18, 0x18, 0x10, 0x00, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0x0C, 0x70, 0x80, 0x7D, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC7, 0xFB, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xB9, 0xCE,
  0xE3, 0xF0, 0xFC, 0x3F, 0x8E, 0x63, 0x9C, 0xE3, 0xB8, 0x70, 0xF8, 0xF8,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0xFB, 0xBF, 0xEC, 0xDF, 0x37, 0xCD, 0xF3, 0x7C, 0xDF, 0x37, 0xCD, 0xF3,
  0x70, 0xEF, 0x7F, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xC0, 0x3E, 0x3F, 0xB8, 0xFC, 0x3C, 0x1E, 0x0F, 0x87, 0xC7, 0x7F, 0x1F,
  0x00, 0xFF, 0x7F, 0xB8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xFF, 0x7F,
  0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3D, 0xBF, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F,
  0x87, 0xC7, 0x7F, 0x9E, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0xDF, 0xFF, 0x86,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x3F, 0x3F, 0xD8, 0x6C, 0x07, 0xE0,
  0xFC, 0x0F, 0xC3, 0x7F, 0x9F, 0x80, 0x18, 0x0C, 0x3F, 0xFF, 0xF1, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xE1, 0xF0, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x86, 0xC7, 0x7F, 0x9E, 0xC0, 0xC1, 0xF8, 0x66, 0x39,
  0x8C, 0x73, 0x0D, 0xC3, 0x60, 0x78, 0x1C, 0x07, 0x00, 0xE6, 0x6C, 0xCD,
  0xBB, 0xB7, 0x66, 0xAC, 0xD7, 0x8A, 0xF1, 0xDE, 0x39, 0x86, 0x30, 0xE1,
  0xDC, 0xE3, 0x70, 0xF8, 0x1E, 0x07, 0x83, 0xE0, 0xCC, 0x73, 0xB8, 0x70,
  0xC1, 0xF8, 0x76, 0x19, 0xCE, 0x33, 0x0D, 0xC3, 0xE0, 0x78, 0x1E, 0x03,
  0x01, 0xC0, 0x60, 0x78, 0x1C, 0x00, 0xFF, 0xFF, 0xC1, 0xC0, 0xC0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xC0, 0x0C, 0x71, 0x8E, 0x30, 0xC3, 0x0C,
  0xF3, 0x87, 0x0C, 0x30, 0xC3, 0x0E, 0x18, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC3, 0x87, 0x0C, 0x30, 0xC3, 0x0C, 0x1C, 0x73, 0x8C, 0x30, 0xC3,
  0x0C, 0x63, 0x80, 0x30, 0x0F, 0x8F, 0xBF, 0x63, 0xE0,
};

const GFXglyph RobotoMono_SemiBold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 5, 5, 11, 3, -14 },
  { 11, 11, 14, 11, 0, -14 },
  { 31, 9, 18, 11, 1, -16 },
  { 52, 11, 14, 11, 0, -14 },
  { 72, 10, 14, 11, 1, -14 },
  { 90, 2, 5, 11, 4, -14 },
  { 92, 5, 19, 11, 3, -15 },
  { 104, 5, 19, 11, 3, -15 },
  { 116, 10, 10, 11, 1, -14 },
  { 129, 9, 10, 11, 1, -11 },
  { 141, 3, 6, 11, 3, -2 },
  { 144, 8, 2, 11, 2, -7 },
  { 146, 3, 3, 11, 4, -3 },
  { 148, 8, 15, 11, 2, -14 },
  { 163, 9, 14, 11, 1, -14 },
  { 179, 6, 14, 11, 2, -14 },
  { 190, 9, 14, 11, 1, -14 },
  { 206, 9, 14, 11, 1, -14 },
  { 222, 9, 14, 11, 1, -14 },
  { 238, 9, 14, 11, 1, -14 },
  { 254, 9, 14, 11, 1, -14 },
  { 270, 9, 14, 11, 1, -14 },
  { 286, 9, 14, 11, 1, -14 },
  { 302, 9, 14, 11, 1, -14 },
  { 318, 4, 11, 11, 4, -11 },
  { 324, 4, 15, 11, 4, -11 },
  { 332, 9, 9, 11, 1, -10 },
  { 343, 9, 6, 11, 1, -9 },
  { 350, 8, 9, 11, 2, -10 },
  { 359, 8, 14, 11, 2, -14 },
  { 373, 11, 13, 11, 0, -13 },
  { 391, 11, 14, 11, 0, -14 },
  { 411, 10, 14, 11, 1, -14 },
  { 429, 10, 14, 11, 1, -14 },
  { 447, 10, 14, 11, 1, -14 },
  { 465, 9, 14, 11, 1, -14 },
  { 481, 9, 14, 11, 1, -14 },
  { 497, 9, 14, 11, 1, -14 },
  { 513, 9, 14, 11, 1, -14 },
  { 529, 8, 14, 11, 2, -14 },
  { 543, 9, 14, 11, 1, -14 },
  { 559, 11, 14, 11, 1, -14 },
  { 579, 9, 14, 11, 1, -14 },
  { 595, 9, 14, 11, 1, -14 },
  { 611, 9, 14, 11, 1, -14 },
  { 627, 10, 14, 11, 1, -14 },
  { 645, 10, 14, 11, 1, -14 },
  { 663, 10, 16, 11, 1, -14 },
  { 683, 10, 14, 11, 1, -14 },
  { 701, 10, 14, 11, 1, -14 },
  { 719, 11, 14, 11, 0, -14 },
  { 739, 9, 14, 11, 1, -14 },
  { 755, 11, 14, 11, 0, -14 },
  { 775, 11, 14, 11, 0, -14 },
  { 795, 11, 14, 11, 0, -14 },
  { 815, 11, 14, 11, 0, -14 },
  { 835, 10, 14, 11, 1, -14 },
  { 853, 4, 19, 11, 4, -16 },
  { 863, 8, 15, 11, 2, -14 },
  { 878, 4, 19, 11, 4, -16 },
  { 888, 8, 8, 11, 2, -14 },
  { 896, 9, 2, 11, 1, 0 },
  { 899, 4, 3, 11, 4, -14 },
  { 901, 9, 10, 11, 1, -10 },
  { 913, 9, 14, 11, 1, -14 },
  { 929, 9, 10, 11, 1, -10 },
  { 941, 9, 14, 11, 1, -14 },
  { 957, 9, 10, 11, 1, -10 },
  { 969, 10, 15, 11, 1, -15 },
  { 988, 9, 14, 11, 1, -10 },
  { 1004, 9, 14, 11, 1, -14 },
  { 1020, 8, 14, 11, 2, -14 },
  { 1034, 6, 18, 11, 2, -14 },
  { 1048, 10, 14, 11, 1, -14 },
  { 1066, 8, 14, 11, 2, -14 },
  { 1080, 10, 10, 11, 1, -10 },
  { 1093, 9, 10, 11, 1, -10 },
  { 1105, 9, 10, 11, 1, -10 },
  { 1117, 9, 14, 11, 1, -10 },
  { 1133, 9, 14, 11, 1, -10 },
  { 1149, 7, 10, 11, 3, -10 },
  { 1158, 9, 10, 11, 1, -10 },
  { 1170, 9, 12, 11, 1, -12 },
  { 1184, 9, 10, 11, 1, -10 },
  { 1196, 10, 10, 11, 1, -10 },
  { 1209, 11, 10, 11, 0, -10 },
  { 1223, 10, 10, 11, 1, -10 },
  { 1236, 10, 14, 11, 1, -10 },
  { 1254, 9, 10, 11, 1, -10 },
  { 1266, 6, 18, 11, 3, -15 },
  { 1280, 2, 18, 11, 5, -14 },
  { 1285, 6, 18, 11, 3, -15 },
  { 1299, 11, 4, 11, 0, -8 },
};

const GFXfont RobotoMono_SemiBold19pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold19pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOMONO_SEMIBOLD19PT7B_H_
