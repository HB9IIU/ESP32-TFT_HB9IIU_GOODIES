#ifndef _ROBOTOMONO_SEMIBOLD37PT7B_H_
#define _ROBOTOMONO_SEMIBOLD37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold37pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0x01, 0xE7, 0xFF, 0xFD, 0xE0, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0x01,
  0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x80,
  0x38, 0x70, 0x03, 0x87, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x07, 0x8F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0x71, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xE1,
  0xC0, 0x0E, 0x1C, 0x01, 0xE3, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C,
  0x38, 0x01, 0xC3, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0x1F,
  0x8F, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x0F, 0x7C, 0x03, 0xCF, 0x80, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03,
  0xDF, 0x01, 0xF7, 0xC0, 0x7C, 0xFE, 0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0xC0,
  0x7F, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xE7, 0x80, 0x0E, 0x3C, 0x38,
  0x70, 0xE3, 0x83, 0x87, 0x1C, 0x1C, 0x39, 0xC0, 0xE3, 0xCE, 0x07, 0xFC,
  0xE0, 0x1F, 0xC6, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC7, 0xC0, 0x0E, 0xFF, 0x00, 0xE7,
  0xFC, 0x07, 0x78, 0xE0, 0x73, 0xC7, 0x83, 0x1E, 0x3C, 0x38, 0xF1, 0xE0,
  0x07, 0x8E, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x60,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xF1, 0xE0, 0x0F,
  0x87, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1E, 0x00, 0xF9, 0xF0,
  0x03, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x83, 0xE7, 0xFE, 0x1E, 0x3E, 0xF8, 0xF3, 0xE7, 0xE7, 0x9E, 0x1F, 0xBC,
  0xF0, 0x7F, 0xEF, 0x81, 0xFE, 0x3C, 0x07, 0xF1, 0xF0, 0x3F, 0x0F, 0xE7,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xEF, 0x83, 0xFE, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xC0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80,
  0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00,
  0xC0, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x03, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C,
  0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0x80, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x81, 0xC0, 0x18,
  0x30, 0x6F, 0xCC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x81, 0xFE, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x07, 0x78, 0x03, 0xCF, 0x01, 0xE1, 0xE0, 0xF0, 0x7C,
  0x1C, 0x0E, 0x02, 0x02, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x3E, 0x79, 0xE0, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x79, 0xFB, 0xF7, 0xFF, 0xCF, 0x80, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xC3, 0xE7, 0xC0, 0xFB, 0xE0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x9F, 0x7F, 0xDF, 0x3F, 0xFE,
  0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xEF, 0x80, 0xF7,
  0xC0, 0xF9, 0xF0, 0x7C, 0xFE, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x70, 0x3F, 0x0F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0x87, 0xF1, 0xF8, 0xF8, 0x1F, 0x1E, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x03,
  0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x3F, 0x3E, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xFC,
  0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x07, 0xBE, 0x03, 0xEF, 0xC0,
  0xF9, 0xFD, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xDF, 0x00, 0xF3, 0xE0, 0x3E, 0x7C,
  0x07, 0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x3E, 0x0F, 0x07, 0xC3, 0xC0, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFE, 0x07, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0x7F, 0x86, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0x78, 0x07, 0x9F,
  0x03, 0xE7, 0xF3, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x7F, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0xFF, 0x3F, 0xBF, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x1F,
  0x03, 0xE7, 0xC0, 0xF9, 0xE0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0,
  0xF0, 0xFC, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFD, 0xFC,
  0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xF7, 0xC0, 0xF9, 0xFC, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0x80, 0x01, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xF3,
  0xE0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xE0, 0x7D, 0xFC, 0xFE, 0x7F, 0xFF, 0x3F,
  0xFF, 0x87, 0xF7, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x38,
  0xFB, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x7D, 0xFF, 0xFB, 0xF7, 0xC0, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x3E, 0x78, 0xF3, 0xC1, 0x00, 0x00, 0x01, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0xFF, 0x07, 0xFF, 0x1F, 0xF8, 0xFF, 0xE0, 0xFF, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0xE0, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0x00, 0x7F, 0x03, 0xFF, 0x1F, 0xFC, 0xFF, 0xE0, 0xFF, 0x80, 0xFE,
  0x00, 0xF0, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xE3, 0xF7, 0xC0, 0xFF, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xE0,
  0x1C, 0x1C, 0x00, 0xE3, 0x83, 0x0E, 0x38, 0xFE, 0x77, 0x1F, 0xE7, 0x73,
  0xCE, 0x7E, 0x38, 0xE7, 0xE3, 0x8E, 0x3E, 0x70, 0xE3, 0xE7, 0x0E, 0x7E,
  0x70, 0xC7, 0xE7, 0x0C, 0x7E, 0x70, 0xC7, 0xE7, 0x1C, 0x6E, 0x7B, 0xCE,
  0xE3, 0xFF, 0xC7, 0x3E, 0x78, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x02,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00, 0x3C, 0xF8, 0x01, 0xE3,
  0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x1E, 0x03,
  0xE0, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC7, 0xC0, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF8,
  0x00, 0xF7, 0xC0, 0x07, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1E,
  0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x3E, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xFF, 0x80,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE1, 0xF8, 0xF8, 0x0F, 0x9E, 0x01, 0xF7,
  0xC0, 0x1E, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xEF, 0x80, 0x3C, 0xF0, 0x0F, 0x9F,
  0x03, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x81, 0xF9,
  0xF0, 0x1F, 0x3E, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7B,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF,
  0x80, 0xF9, 0xF0, 0x7E, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x01, 0xFF,
  0xF0, 0xFF, 0xFE, 0x3F, 0x1F, 0x9F, 0x01, 0xF7, 0xC0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xDF, 0x00, 0xF7, 0xE0, 0x7C, 0xFE, 0x7F,
  0x1F, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0x9F, 0x07, 0xE7,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xF8, 0x03, 0xFF,
  0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0,
  0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F, 0x80, 0xFB, 0xF0,
  0x0F, 0xBE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFE, 0x7C, 0x0F, 0xC3, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F,
  0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF3, 0xFF, 0xFC, 0xEF, 0xFF, 0xBB, 0xFF, 0xFE, 0xFF, 0xBF, 0xBF, 0xEF,
  0xCF, 0xFB, 0xF3, 0xFE, 0x7C, 0xFF, 0x9E, 0x3F, 0xE7, 0x8F, 0xF8, 0xE3,
  0xFE, 0x30, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFE, 0xE1, 0xFF, 0xBC, 0x7F, 0xEF, 0x1F,
  0xF9, 0xE7, 0xFE, 0x79, 0xFF, 0x8F, 0x7F, 0xE3, 0xDF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xF0, 0x00, 0xC0, 0x01, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xF3, 0xF8, 0xF8, 0x1F, 0x3E, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0x7C, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x0F,
  0x9F, 0x03, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x0F,
  0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF,
  0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0x3F,
  0x87, 0xC0, 0xF8, 0x78, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x03, 0xCF, 0x80,
  0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0,
  0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3C, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x83, 0xFF, 0xF8,
  0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x08, 0xFF, 0xF8, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF0, 0x1F, 0xBC, 0x03, 0xEF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB, 0xC0, 0x7E, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xF0, 0x7C, 0x3C, 0x1F,
  0x0F, 0x03, 0xE3, 0xC0, 0xF8, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x00, 0xFB,
  0xC0, 0x3E, 0xF0, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0xF0, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0x9E, 0x00, 0xFB,
  0xC0, 0x1F, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xDF,
  0x01, 0xFB, 0xFD, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x1F, 0x7C, 0x0F, 0x9F, 0x03, 0xE3, 0xFF,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3E,
  0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF8, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xF0,
  0x07, 0x9E, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0xF0, 0xF0, 0xFF, 0x87, 0x87, 0xBC, 0x3C, 0x3D, 0xE1, 0xE1, 0xEF,
  0x8F, 0x8F, 0x7C, 0xFC, 0x79, 0xE7, 0xE3, 0xCF, 0x3F, 0x3E, 0x79, 0xF9,
  0xF3, 0xCF, 0xCF, 0x1E, 0x7F, 0x78, 0xF3, 0xFB, 0xC7, 0xBD, 0xDE, 0x3F,
  0xEE, 0xF0, 0xFE, 0x77, 0x87, 0xF3, 0xBC, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE,
  0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0x7C,
  0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x00, 0xFC, 0x01,
  0xFB, 0xE0, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F,
  0x87, 0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x01, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x0F, 0x8F, 0xC0,
  0x7C, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xFB, 0xE0, 0x0F,
  0x9F, 0x00, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x01, 0xF7, 0xC0,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xDC, 0x07, 0xBC,
  0x1E, 0x38, 0x3C, 0x78, 0x70, 0xF1, 0xE0, 0xF3, 0xC1, 0xEF, 0x03, 0xDE,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E,
  0x07, 0x83, 0xE0, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7C, 0x1F, 0x9E, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x07, 0xFF,
  0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0x3E, 0x78, 0x0F, 0xBE, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x7E, 0x7E, 0x7F, 0x9F, 0xFF, 0xE3, 0xFF, 0x78, 0x7F,
  0x9F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF1, 0xF0, 0x7B, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xEF, 0xC3, 0xF7, 0xC0, 0xFB, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3E, 0xFF, 0x7F, 0x7F, 0xFF, 0x3D, 0xFF, 0x1E, 0x7F,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x1F,
  0x9F, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xF7, 0xC0, 0x79, 0xF0,
  0x3E, 0x3F, 0x3F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x07, 0xC7, 0x8F, 0xFB, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7,
  0xE1, 0xFB, 0xE0, 0x7D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3D, 0xF0, 0x1E, 0xF8,
  0x1F, 0x3F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFD, 0xE1, 0xFC, 0xF0, 0x01, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x0F, 0x9F, 0x01, 0xF7,
  0xC0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x11, 0xF8, 0x0E, 0x3F, 0xDF,
  0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x84, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF8, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE7, 0xC3, 0xFD, 0xF1, 0xFF, 0xFC, 0xFF,
  0xFF, 0x7E, 0x0F, 0xDF, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7,
  0xC0, 0x7D, 0xF0, 0x3F, 0x3F, 0xBF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F,
  0x9F, 0x00, 0x07, 0xC0, 0x01, 0xE1, 0x00, 0xF8, 0xF0, 0x7E, 0x7F, 0xFF,
  0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0xF0, 0x79, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xEF,
  0xFE, 0xFF, 0xCF, 0xF8, 0xFC, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0xBC, 0x07, 0xCF, 0x03, 0xE3, 0xC1, 0xF0, 0xF0, 0xFC, 0x3C,
  0x7E, 0x0F, 0x3F, 0x03, 0xDF, 0x80, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFD, 0xF8, 0x3E, 0x3F, 0x0F, 0x07, 0xC3, 0xC1, 0xF8,
  0xF0, 0x3F, 0x3C, 0x07, 0xEF, 0x00, 0xFB, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xC7, 0x8F, 0xFE, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F,
  0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8,
  0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF,
  0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF0, 0xF8, 0x79, 0xFF, 0x3D,
  0xFF, 0x9F, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E,
  0x1F, 0x9F, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x7D,
  0xF0, 0x3E, 0x3F, 0xBF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xF1,
  0xF0, 0x7B, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xC3, 0xF7, 0xC0, 0xFB,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7D, 0xF0, 0x3E, 0xFE, 0x7F, 0x7F,
  0xFF, 0x3D, 0xFF, 0x1E, 0x7F, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC7, 0x8F, 0xFB, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xE1, 0xFB, 0xE0, 0x7D,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3D, 0xF0, 0x1E, 0xF8, 0x1F, 0x7F, 0x3F, 0x9F,
  0xFF, 0xC7, 0xFF, 0xE1, 0xFC, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0xF8,
  0x7F, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7C, 0x0F,
  0x9F, 0x01, 0xF7, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x7D, 0xF0,
  0x1F, 0x7E, 0x0F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFB, 0x80, 0xFF, 0xF0,
  0x1F, 0xFC, 0x03, 0xFE, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFB, 0xE3, 0xF9, 0xF0, 0xF8,
  0x01, 0xF7, 0xC0, 0x1E, 0x7C, 0x03, 0xE3, 0xC0, 0x3E, 0x3E, 0x03, 0xC3,
  0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF0,
  0x0F, 0x8F, 0x00, 0x79, 0xF0, 0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x9F, 0x9E, 0x79, 0xF9, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xE7,
  0x9B, 0x9E, 0x7B, 0x9D, 0xE3, 0xB9, 0xDC, 0x3B, 0x9F, 0xC3, 0xF9, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xE0, 0x78, 0xF8, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x3F, 0x1F, 0x07,
  0xC1, 0xF1, 0xF0, 0x3F, 0x7E, 0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0x7C,
  0x03, 0xEF, 0x80, 0xF8, 0xF8, 0x3E, 0x0F, 0x8F, 0xC1, 0xF9, 0xF0, 0x1F,
  0x7C, 0x01, 0xF0, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8,
  0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8,
  0x0F, 0x07, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x1E, 0x03, 0xF0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0xFE, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3F, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x0F, 0x80,
  0xFC, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xF0, 0x3F,
  0x03, 0xF0, 0x7F, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x80,
  0xF0, 0x08, 0x00, 0x0E, 0x00, 0x03, 0xF8, 0x07, 0x7F, 0xE0, 0xFF, 0xFF,
  0x0F, 0xF1, 0xFF, 0xEE, 0x07, 0xFE, 0xE0, 0x3F, 0xC0, 0x01, 0xF8,
};

const GFXglyph RobotoMono_SemiBold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 26, 22, 8, -26 },
  { 21, 11, 10, 22, 5, -28 },
  { 35, 20, 26, 22, 1, -26 },
  { 100, 18, 35, 22, 2, -31 },
  { 179, 21, 27, 22, 1, -27 },
  { 250, 21, 27, 22, 1, -27 },
  { 321, 4, 10, 22, 8, -28 },
  { 326, 10, 37, 22, 6, -29 },
  { 373, 10, 37, 22, 6, -29 },
  { 420, 18, 18, 22, 3, -26 },
  { 461, 18, 19, 22, 2, -22 },
  { 504, 7, 11, 22, 6, -4 },
  { 514, 15, 3, 22, 5, -13 },
  { 520, 7, 6, 22, 8, -6 },
  { 526, 15, 28, 22, 4, -26 },
  { 579, 17, 27, 22, 3, -27 },
  { 637, 12, 26, 22, 3, -26 },
  { 676, 19, 27, 22, 1, -27 },
  { 741, 18, 27, 22, 2, -27 },
  { 802, 19, 26, 22, 1, -26 },
  { 864, 18, 26, 22, 2, -26 },
  { 923, 18, 26, 22, 2, -26 },
  { 982, 19, 26, 22, 1, -26 },
  { 1044, 18, 27, 22, 2, -27 },
  { 1105, 17, 27, 22, 2, -27 },
  { 1163, 7, 21, 22, 8, -21 },
  { 1182, 7, 28, 22, 8, -21 },
  { 1207, 16, 17, 22, 3, -20 },
  { 1241, 17, 12, 22, 3, -17 },
  { 1267, 16, 17, 22, 3, -20 },
  { 1301, 17, 27, 22, 3, -27 },
  { 1359, 20, 26, 22, 1, -26 },
  { 1424, 21, 26, 22, 1, -26 },
  { 1493, 19, 26, 22, 2, -26 },
  { 1555, 19, 27, 22, 2, -27 },
  { 1620, 19, 26, 22, 2, -26 },
  { 1682, 17, 26, 22, 3, -26 },
  { 1738, 17, 26, 22, 3, -26 },
  { 1794, 18, 27, 22, 2, -27 },
  { 1855, 18, 26, 22, 2, -26 },
  { 1914, 16, 26, 22, 3, -26 },
  { 1966, 18, 26, 22, 2, -26 },
  { 2025, 20, 26, 22, 2, -26 },
  { 2090, 17, 26, 22, 3, -26 },
  { 2146, 18, 26, 22, 2, -26 },
  { 2205, 18, 26, 22, 2, -26 },
  { 2264, 19, 27, 22, 2, -27 },
  { 2329, 18, 26, 22, 3, -26 },
  { 2388, 20, 32, 22, 2, -27 },
  { 2468, 18, 26, 22, 3, -26 },
  { 2527, 19, 27, 22, 2, -27 },
  { 2592, 21, 26, 22, 1, -26 },
  { 2661, 18, 26, 22, 2, -26 },
  { 2720, 20, 26, 22, 1, -26 },
  { 2785, 21, 26, 22, 1, -26 },
  { 2854, 21, 26, 22, 1, -26 },
  { 2923, 21, 26, 22, 1, -26 },
  { 2992, 19, 26, 22, 2, -26 },
  { 3054, 8, 36, 22, 7, -30 },
  { 3090, 15, 28, 22, 4, -26 },
  { 3143, 8, 36, 22, 7, -30 },
  { 3179, 15, 14, 22, 4, -26 },
  { 3206, 16, 4, 22, 3, 0 },
  { 3214, 9, 5, 22, 7, -27 },
  { 3220, 18, 20, 22, 2, -20 },
  { 3265, 17, 28, 22, 3, -28 },
  { 3325, 18, 20, 22, 2, -20 },
  { 3370, 17, 28, 22, 2, -28 },
  { 3430, 18, 20, 22, 2, -20 },
  { 3475, 19, 29, 22, 2, -29 },
  { 3544, 18, 28, 22, 2, -20 },
  { 3607, 17, 28, 22, 3, -28 },
  { 3667, 16, 27, 22, 4, -27 },
  { 3721, 12, 35, 22, 4, -27 },
  { 3774, 18, 28, 22, 3, -28 },
  { 3837, 16, 28, 22, 4, -28 },
  { 3893, 20, 20, 22, 1, -20 },
  { 3943, 17, 20, 22, 3, -20 },
  { 3986, 18, 20, 22, 2, -20 },
  { 4031, 17, 28, 22, 3, -20 },
  { 4091, 17, 28, 22, 2, -20 },
  { 4151, 15, 20, 22, 5, -20 },
  { 4189, 18, 20, 22, 2, -20 },
  { 4234, 18, 24, 22, 2, -24 },
  { 4288, 17, 20, 22, 3, -20 },
  { 4331, 20, 20, 22, 1, -20 },
  { 4381, 20, 20, 22, 1, -20 },
  { 4431, 19, 20, 22, 2, -20 },
  { 4479, 21, 28, 22, 1, -20 },
  { 4553, 18, 20, 22, 2, -20 },
  { 4598, 12, 36, 22, 6, -29 },
  { 4652, 3, 33, 22, 10, -26 },
  { 4665, 12, 36, 22, 6, -29 },
  { 4719, 20, 8, 22, 1, -15 },
};

const GFXfont RobotoMono_SemiBold37pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold37pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOMONO_SEMIBOLD37PT7B_H_
