#ifndef _ROBOTOMONO_SEMIBOLD15PT7B_H_
#define _ROBOTOMONO_SEMIBOLD15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold15pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x90, 0x0B, 0x80, 0xDE, 0xA5, 0x20, 0x1B, 0x09, 0x04,
  0x8F, 0xF7, 0xF9, 0xB0, 0xD1, 0xFE, 0x24, 0x12, 0x1B, 0x00, 0x10, 0x71,
  0xFE, 0x3C, 0x6C, 0x0F, 0x07, 0x07, 0x8F, 0xBB, 0xE1, 0x02, 0x00, 0x70,
  0x68, 0x34, 0x9A, 0x87, 0x40, 0x40, 0x68, 0x2E, 0x35, 0x92, 0xC1, 0xC0,
  0x38, 0x7C, 0x4C, 0x4C, 0x78, 0x70, 0xF3, 0xDB, 0xCE, 0xCE, 0x7F, 0xFF,
  0x23, 0x4C, 0xC8, 0x88, 0x88, 0x8C, 0x46, 0x30, 0x84, 0x63, 0x33, 0x11,
  0x11, 0x33, 0x26, 0xC0, 0x18, 0x18, 0x92, 0xFF, 0x18, 0x38, 0x66, 0x24,
  0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0xFF, 0x80, 0xFC, 0xFC, 0x0C,
  0x61, 0x84, 0x30, 0xC2, 0x18, 0x61, 0x0C, 0x30, 0x38, 0xFB, 0x1E, 0x3C,
  0xFB, 0xF9, 0xE3, 0xC6, 0xD9, 0xF0, 0x09, 0xFF, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x39, 0xFB, 0x1C, 0x30, 0xC1, 0x86, 0x18, 0x61, 0xFF, 0xF8, 0x39,
  0xFB, 0x18, 0x30, 0xC7, 0x03, 0x03, 0xC7, 0xDD, 0xF0, 0x06, 0x0E, 0x0E,
  0x1E, 0x36, 0x26, 0x66, 0xFF, 0x7F, 0x06, 0x06, 0x7E, 0xFD, 0x02, 0x0F,
  0xDF, 0xC1, 0x83, 0xC7, 0xDD, 0xF0, 0x18, 0x71, 0x86, 0x0F, 0xDD, 0xF1,
  0xE3, 0xC7, 0xD9, 0xF0, 0xFF, 0xFC, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x30,
  0xC1, 0x80, 0x38, 0xFB, 0x1E, 0x3E, 0xC7, 0x3B, 0x63, 0xC7, 0xDD, 0xF0,
  0x38, 0xFB, 0x16, 0x3C, 0x78, 0xDF, 0x93, 0x0C, 0xF9, 0xC0, 0xEC, 0x00,
  0x3B, 0x6C, 0x00, 0x1B, 0x6B, 0x00, 0x06, 0x3F, 0xE6, 0x07, 0x83, 0xC0,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0xC1, 0xE0, 0xF0, 0x33, 0xDE, 0x20,
  0x00, 0x38, 0xFF, 0x18, 0x30, 0xE3, 0x86, 0x08, 0x00, 0x30, 0xE0, 0x0C,
  0x1F, 0x18, 0x4B, 0xE5, 0x5F, 0xAE, 0xD5, 0xAA, 0x5A, 0x30, 0x0F, 0x00,
  0x0C, 0x0E, 0x07, 0x02, 0xC3, 0x61, 0xB0, 0xC8, 0xFE, 0x7F, 0x31, 0xB0,
  0x60, 0xF8, 0xFE, 0xC6, 0xC6, 0xC6, 0xFC, 0xC6, 0xC3, 0xC2, 0xFE, 0xFC,
  0x38, 0xFF, 0x1E, 0x3C, 0x18, 0x30, 0x60, 0xC7, 0xDD, 0xF0, 0xF1, 0xFB,
  0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFB, 0xE0, 0xFF, 0xFF, 0x06, 0x0C,
  0x1F, 0xB0, 0x60, 0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xFF,
  0xE0, 0xC1, 0x83, 0x00, 0x38, 0xFF, 0x1E, 0x3C, 0x18, 0x33, 0xE3, 0xC7,
  0xCD, 0xF0, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xF1, 0xE3, 0xC7, 0x8F, 0x18,
  0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFF, 0xF8, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0xC7, 0xD9, 0xF0, 0xC7, 0xC6, 0xCC, 0xDC,
  0xD8, 0xF8, 0xF8, 0xCC, 0xCE, 0xC6, 0xC3, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0xFF, 0xF8, 0xC7, 0xDF, 0xBF, 0x7E, 0xFF, 0xF5, 0xEB,
  0xC7, 0x8F, 0x18, 0xC7, 0x8F, 0x9F, 0x3F, 0x7A, 0xF7, 0xEF, 0xCF, 0x9F,
  0x18, 0x38, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xDD, 0xF0, 0xF8,
  0xFE, 0xC6, 0xC3, 0xC6, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0x38, 0x7C,
  0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xEE, 0x7C, 0x07, 0x02, 0xF8,
  0xFE, 0xC6, 0xC6, 0xC6, 0xFE, 0xF8, 0xCC, 0xCC, 0xC6, 0xC7, 0x38, 0xFF,
  0x1E, 0x0E, 0x0F, 0x83, 0x83, 0xC3, 0xCD, 0xF0, 0xFF, 0xFF, 0xC2, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xDD, 0xF0, 0xC1, 0xB1, 0x98, 0xCC, 0x63,
  0x61, 0xB0, 0xD8, 0x6C, 0x1C, 0x0E, 0x07, 0x00, 0xC9, 0xE4, 0xD7, 0x6B,
  0xA7, 0x53, 0xB9, 0xDC, 0xEE, 0x77, 0x3B, 0x8C, 0x80, 0xE3, 0xB1, 0x8D,
  0xC6, 0xC1, 0xC0, 0xE0, 0x70, 0x6C, 0x36, 0x31, 0xB8, 0xE0, 0xC1, 0xB1,
  0x98, 0xC6, 0xC3, 0x60, 0xE0, 0x70, 0x10, 0x08, 0x04, 0x02, 0x00, 0xFF,
  0xFC, 0x38, 0x61, 0x83, 0x0C, 0x30, 0x61, 0xFF, 0xF8, 0xFB, 0x6D, 0xB6,
  0xDB, 0x6D, 0xC0, 0xC3, 0x04, 0x18, 0x60, 0x83, 0x0C, 0x10, 0x61, 0x83,
  0xED, 0xB6, 0xDB, 0x6D, 0xB7, 0xC0, 0x21, 0xC5, 0x16, 0xDA, 0x30, 0xFE,
  0xCC, 0x7D, 0xD8, 0x1B, 0xFE, 0x78, 0xF3, 0xBF, 0xC1, 0x83, 0x07, 0xEE,
  0xF8, 0xF1, 0xE3, 0xC7, 0xDF, 0xF0, 0x3C, 0xDF, 0x1E, 0x0C, 0x18, 0xFB,
  0xBE, 0x06, 0x0C, 0x1B, 0xFE, 0xF8, 0xF1, 0xE3, 0xC7, 0xDD, 0xF8, 0x3C,
  0xDF, 0x1F, 0xFF, 0xF8, 0x19, 0x9E, 0x06, 0x3C, 0xC1, 0x8F, 0xE6, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x80, 0x7F, 0xDF, 0x1E, 0x3C, 0x78, 0xFB, 0xBF,
  0x07, 0x9D, 0xF0, 0xC1, 0x83, 0x06, 0xEE, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F,
  0x18, 0x30, 0xC0, 0x3C, 0xF0, 0xC3, 0x0C, 0x33, 0xFF, 0xC0, 0x33, 0x0F,
  0xF3, 0x33, 0x33, 0x33, 0x3E, 0xC0, 0xC0, 0xC0, 0xC6, 0xCC, 0xD8, 0xF0,
  0xF8, 0xCC, 0xCE, 0xC7, 0xF8, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x19,
  0xFF, 0xF8, 0xBF, 0xFE, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0xDD, 0xDF, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0x7D, 0xDF, 0x1E, 0x3C, 0x78, 0xFB, 0xBE, 0xFD,
  0xDF, 0x1E, 0x3C, 0x78, 0xFB, 0xFE, 0xC1, 0x83, 0x00, 0x7F, 0xDF, 0x1E,
  0x3C, 0x78, 0xFB, 0xBF, 0x06, 0x0C, 0x18, 0xDF, 0xFC, 0x30, 0xC3, 0x0C,
  0x30, 0x7D, 0xDF, 0x03, 0xC3, 0xF8, 0xF1, 0xBE, 0x30, 0x63, 0xF9, 0x83,
  0x06, 0x0C, 0x18, 0x32, 0x3C, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFB, 0xBF,
  0xC7, 0x8D, 0x13, 0x66, 0xC5, 0x0E, 0x1C, 0xC9, 0xE4, 0x97, 0x4A, 0xE7,
  0x73, 0xB9, 0xD8, 0x4C, 0xC7, 0x6E, 0x7C, 0x38, 0x38, 0x7C, 0x6E, 0xC7,
  0xE1, 0xB1, 0x98, 0xC6, 0xC3, 0x60, 0xF0, 0x70, 0x18, 0x18, 0x0C, 0x1C,
  0x00, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x3F, 0xFF, 0x08, 0xCC, 0x63, 0x18,
  0x98, 0x21, 0x8C, 0x63, 0x0C, 0x20, 0xFF, 0xFC, 0x47, 0x08, 0x42, 0x10,
  0xC3, 0x31, 0x08, 0x42, 0x71, 0x00, 0x71, 0xFD, 0xCF,
};

const GFXglyph RobotoMono_SemiBold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 4, 9, 2, -11 },
  { 9, 9, 11, 9, 0, -11 },
  { 22, 7, 14, 9, 1, -12 },
  { 35, 9, 11, 9, 0, -11 },
  { 48, 8, 11, 9, 1, -11 },
  { 59, 2, 4, 9, 3, -11 },
  { 60, 4, 15, 9, 3, -12 },
  { 68, 4, 15, 9, 2, -12 },
  { 76, 8, 8, 9, 1, -11 },
  { 84, 7, 8, 9, 1, -9 },
  { 91, 2, 5, 9, 3, -2 },
  { 93, 6, 1, 9, 2, -5 },
  { 94, 3, 2, 9, 3, -2 },
  { 95, 6, 12, 9, 2, -11 },
  { 104, 7, 11, 9, 1, -11 },
  { 114, 5, 11, 9, 1, -11 },
  { 121, 7, 11, 9, 1, -11 },
  { 131, 7, 11, 9, 1, -11 },
  { 141, 8, 11, 9, 0, -11 },
  { 152, 7, 11, 9, 1, -11 },
  { 162, 7, 11, 9, 1, -11 },
  { 172, 7, 11, 9, 1, -11 },
  { 182, 7, 11, 9, 1, -11 },
  { 192, 7, 11, 9, 1, -11 },
  { 202, 3, 8, 9, 3, -8 },
  { 205, 3, 11, 9, 3, -8 },
  { 210, 7, 7, 9, 1, -8 },
  { 217, 7, 5, 9, 1, -7 },
  { 222, 7, 7, 9, 1, -8 },
  { 229, 7, 11, 9, 1, -11 },
  { 239, 9, 11, 9, 0, -11 },
  { 252, 9, 11, 9, 0, -11 },
  { 265, 8, 11, 9, 1, -11 },
  { 276, 7, 11, 9, 1, -11 },
  { 286, 7, 11, 9, 1, -11 },
  { 296, 7, 11, 9, 1, -11 },
  { 306, 7, 11, 9, 1, -11 },
  { 316, 7, 11, 9, 1, -11 },
  { 326, 7, 11, 9, 1, -11 },
  { 336, 7, 11, 9, 1, -11 },
  { 346, 7, 11, 9, 1, -11 },
  { 356, 8, 11, 9, 1, -11 },
  { 367, 7, 11, 9, 1, -11 },
  { 377, 7, 11, 9, 1, -11 },
  { 387, 7, 11, 9, 1, -11 },
  { 397, 7, 11, 9, 1, -11 },
  { 407, 8, 11, 9, 1, -11 },
  { 418, 8, 13, 9, 1, -11 },
  { 431, 8, 11, 9, 1, -11 },
  { 442, 7, 11, 9, 1, -11 },
  { 452, 9, 11, 9, 0, -11 },
  { 465, 7, 11, 9, 1, -11 },
  { 475, 9, 11, 9, 0, -11 },
  { 488, 9, 11, 9, 0, -11 },
  { 501, 9, 11, 9, 0, -11 },
  { 514, 9, 11, 9, 0, -11 },
  { 527, 7, 11, 9, 1, -11 },
  { 537, 3, 14, 9, 3, -12 },
  { 543, 6, 12, 9, 2, -11 },
  { 552, 3, 14, 9, 3, -12 },
  { 558, 6, 6, 9, 2, -11 },
  { 563, 7, 1, 9, 1, 0 },
  { 564, 3, 2, 9, 3, -11 },
  { 565, 7, 8, 9, 1, -8 },
  { 572, 7, 11, 9, 1, -11 },
  { 582, 7, 8, 9, 1, -8 },
  { 589, 7, 11, 9, 1, -11 },
  { 599, 7, 8, 9, 1, -8 },
  { 606, 7, 12, 9, 1, -12 },
  { 617, 7, 11, 9, 1, -8 },
  { 627, 7, 11, 9, 1, -11 },
  { 637, 6, 11, 9, 2, -11 },
  { 646, 4, 14, 9, 2, -11 },
  { 653, 8, 11, 9, 1, -11 },
  { 664, 7, 11, 9, 1, -11 },
  { 674, 7, 8, 9, 1, -8 },
  { 681, 7, 8, 9, 1, -8 },
  { 688, 7, 8, 9, 1, -8 },
  { 695, 7, 11, 9, 1, -8 },
  { 705, 7, 11, 9, 1, -8 },
  { 715, 6, 8, 9, 2, -8 },
  { 721, 7, 8, 9, 1, -8 },
  { 728, 7, 10, 9, 1, -10 },
  { 737, 7, 8, 9, 1, -8 },
  { 744, 7, 8, 9, 1, -8 },
  { 751, 9, 8, 9, 0, -8 },
  { 760, 8, 8, 9, 1, -8 },
  { 768, 9, 11, 9, 0, -8 },
  { 781, 7, 8, 9, 1, -8 },
  { 788, 5, 15, 9, 2, -12 },
  { 798, 1, 14, 9, 4, -11 },
  { 800, 5, 15, 9, 2, -12 },
  { 810, 8, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_SemiBold15pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold15pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOMONO_SEMIBOLD15PT7B_H_
