#ifndef _ROBOTOMONO_SEMIBOLD52PT7B_H_
#define _ROBOTOMONO_SEMIBOLD52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78,
  0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x1F, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78,
  0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x0F,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0x83, 0xFC,
  0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x1F,
  0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7C, 0x3E, 0x04, 0x03, 0xE0, 0xF0, 0x38, 0x1E, 0x07,
  0x83, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x3E, 0x0F, 0x0F,
  0x01, 0xF0, 0xF8, 0xF0, 0x0F, 0xCF, 0xCF, 0x80, 0x3F, 0xFC, 0x78, 0x00,
  0xFF, 0xE7, 0xC0, 0x03, 0xFC, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC7, 0xF8,
  0x00, 0x3C, 0x7F, 0xF0, 0x03, 0xE7, 0xFF, 0x80, 0x1E, 0x7E, 0x7E, 0x01,
  0xE3, 0xE1, 0xF0, 0x0F, 0x1F, 0x07, 0x80, 0xF0, 0xF0, 0x3C, 0x07, 0x87,
  0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x00, 0xC1, 0xF0, 0x78, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x1F, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x3E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0x0F,
  0xFF, 0x81, 0xF8, 0xFF, 0xFE, 0x0F, 0xCF, 0xF7, 0xF8, 0x7E, 0x7F, 0x1F,
  0xE3, 0xF3, 0xF0, 0x7F, 0x1F, 0xBF, 0x81, 0xFD, 0xF9, 0xFC, 0x07, 0xFF,
  0xCF, 0xE0, 0x3F, 0xFE, 0x7F, 0x00, 0xFF, 0xE3, 0xF8, 0x03, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xC3,
  0xFC, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xEF, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x08, 0x60,
  0x01, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7E,
  0x03, 0xF0, 0x07, 0x80, 0x18, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0x80, 0x78, 0x04, 0x7C, 0x1E,
  0x07, 0x1F, 0xC7, 0x8F, 0xEF, 0xFD, 0xEF, 0xFB, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x40, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3C,
  0x01, 0xE0, 0x03, 0x00, 0x70, 0x00, 0x40, 0x08, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7,
  0xE7, 0xE1, 0xE0, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFE, 0x7E, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0x7F, 0xFC, 0x7E, 0x7F, 0xFD, 0xFC, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x83, 0xFC,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0xFF,
  0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF8, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x1F, 0xF0, 0x7F, 0x87, 0xF0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE1, 0xFE, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xBF, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xF7, 0xE0, 0x01, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFE, 0xFF, 0x81,
  0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0xFE,
  0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F,
  0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3E, 0x07, 0xF0,
  0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7C, 0x03, 0xF8, 0x1F, 0x80,
  0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF9, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F,
  0x81, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF3, 0xF8, 0x03, 0xF9, 0xFC,
  0x01, 0xFC, 0x7F, 0x81, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x20, 0x03, 0xF1, 0xFF, 0x03, 0xFB, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xE0, 0x7F, 0x9F,
  0xE0, 0x1F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF8, 0x03, 0xF9, 0xFE, 0x03,
  0xFC, 0x7F, 0x83, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE1, 0xFE, 0x0F, 0xF1, 0xFE, 0x03, 0xF8, 0xFE, 0x00,
  0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0,
  0x0F, 0xE7, 0xF0, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFC, 0x0F, 0xF1, 0xFC, 0x01, 0xFC,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xF9, 0xFC, 0x01,
  0xFC, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x01, 0xFE, 0x7E, 0x00, 0xFE, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0xC3, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0x7E, 0x01,
  0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF3, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xE0, 0x40,
  0x1F, 0x87, 0xF8, 0xFF, 0x3F, 0xF7, 0xFE, 0x7F, 0x8F, 0xF0, 0xFC, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8,
  0x3F, 0x0F, 0xC0, 0xF0, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x03, 0xE0, 0xF0,
  0xF0, 0x7F, 0xC7, 0x8F, 0x07, 0xFF, 0x3C, 0x78, 0x7F, 0xF0, 0xE7, 0x87,
  0xC3, 0x87, 0x3C, 0x3C, 0x1C, 0x3D, 0xE1, 0xE1, 0xE1, 0xEF, 0x1E, 0x0F,
  0x0F, 0xF0, 0xF0, 0x78, 0x7F, 0x87, 0x83, 0xC3, 0xFC, 0x3C, 0x1E, 0x1D,
  0xE3, 0xE0, 0xF0, 0xEF, 0x1F, 0x07, 0x87, 0x78, 0xF8, 0x3C, 0x3B, 0xC7,
  0xC1, 0xE3, 0xDE, 0x3E, 0x0E, 0x1C, 0xF0, 0xF0, 0xF9, 0xE3, 0xC7, 0xFF,
  0xDF, 0x1E, 0x3F, 0xFF, 0xF0, 0xF0, 0xFE, 0x7F, 0x07, 0xC3, 0xE1, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x10, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01,
  0xFC, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0x3F, 0x80, 0x1F,
  0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x3F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x1F,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x1F,
  0xCF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0x8F,
  0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0x8F,
  0xFF, 0x0F, 0xE0, 0x3F, 0xE3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F,
  0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x01,
  0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x1F, 0xE3, 0xF8,
  0x7F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xCF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x00,
  0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF,
  0xF0, 0x03, 0xF8, 0xFF, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xFC,
  0x03, 0xFC, 0xFF, 0x03, 0xFC, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF1, 0xFC,
  0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x07,
  0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x1F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0x3F, 0x80, 0x1F,
  0xF1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F,
  0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC7,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xEF, 0xFF, 0xF1,
  0xFF, 0xFF, 0x78, 0xFF, 0xFF, 0xBE, 0x7F, 0xFF, 0xDF, 0x7D, 0xFF, 0xEF,
  0xBE, 0xFF, 0xF3, 0xDF, 0x7F, 0xF9, 0xFF, 0x3F, 0xFC, 0xFF, 0x9F, 0xFE,
  0x3F, 0xCF, 0xFF, 0x1F, 0xC7, 0xFF, 0x8F, 0xE3, 0xFF, 0xC7, 0xF1, 0xFF,
  0xE1, 0xF0, 0xFF, 0xF0, 0xF8, 0x7F, 0xF8, 0x7C, 0x3F, 0xFC, 0x1C, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xF8, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFB, 0xE0,
  0xFF, 0xFD, 0xF8, 0x7F, 0xFE, 0x7C, 0x3F, 0xFF, 0x3F, 0x1F, 0xFF, 0x8F,
  0x8F, 0xFF, 0xC7, 0xE7, 0xFF, 0xE1, 0xF3, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8,
  0x7E, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xC0,
  0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0x80, 0xFF, 0xCF, 0xE0, 0x0F, 0xF3, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0xBF, 0x80, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E,
  0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFE,
  0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0x03, 0xFF, 0xCF, 0xC0, 0x0F, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00,
  0x3F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFC,
  0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x01, 0xFC,
  0xFC, 0x00, 0xFF, 0x3F, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xF0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x83,
  0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F,
  0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xEF, 0xC0,
  0x03, 0xFB, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFE,
  0x00, 0x1F, 0xDF, 0xE0, 0x07, 0xF9, 0xFF, 0x01, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xF3,
  0xF8, 0x03, 0xF9, 0xFE, 0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xDF,
  0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0,
  0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x80,
  0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x7F, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x81, 0xFF, 0xF0,
  0x3E, 0x07, 0xEF, 0xC0, 0xF8, 0x1F, 0xBF, 0x03, 0xF0, 0x7E, 0x7E, 0x1F,
  0xC1, 0xF9, 0xF8, 0x7F, 0x07, 0xE7, 0xE1, 0xFC, 0x1F, 0x9F, 0x87, 0xF0,
  0x7E, 0x7E, 0x1F, 0xC3, 0xF1, 0xF8, 0x7F, 0x8F, 0xC7, 0xE1, 0xFE, 0x3F,
  0x1F, 0x8F, 0xF8, 0xFC, 0x3E, 0x3F, 0xE3, 0xF0, 0xFC, 0xFF, 0x8F, 0xC3,
  0xF3, 0xFE, 0x3F, 0x0F, 0xCF, 0x78, 0xF8, 0x3F, 0x3D, 0xF7, 0xE0, 0xFC,
  0xF7, 0xDF, 0x83, 0xF7, 0xDF, 0x7E, 0x07, 0xDF, 0x3D, 0xF8, 0x1F, 0x7C,
  0xF7, 0xE0, 0x7D, 0xE3, 0xDF, 0x81, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x3F,
  0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x87, 0xFC,
  0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00,
  0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F,
  0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0,
  0x3F, 0x80, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F,
  0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01,
  0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x7F, 0x1F, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0,
  0x1F, 0x1F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x07,
  0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F, 0xF1, 0xFC, 0x03,
  0xF8, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0xC0, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0xBF,
  0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x07, 0xFB,
  0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xCF, 0xC0, 0xFF, 0x87, 0xF0, 0x06, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0xFF,
  0xE0, 0xFD, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xEF,
  0xFC, 0xFF, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFF, 0x00,
  0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFC, 0xFF, 0xF0, 0xFC, 0x7F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x3F, 0x07, 0xFF, 0x3F, 0x0F, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xF7, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00,
  0x7F, 0x7F, 0x80, 0x7F, 0x3F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x03, 0xFE, 0x3F, 0x00, 0x20,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0x9F, 0xF8, 0xFF, 0x01, 0xFC, 0xFF,
  0x00, 0x7E, 0x7F, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x43, 0xFC, 0x00, 0x70, 0xFF, 0x80,
  0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xF8, 0x30, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x8F,
  0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0x9F,
  0xFD, 0xFE, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xFB,
  0xFC, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0xE0, 0x3F, 0xE7, 0xF0, 0x03, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x20, 0x01, 0xFC, 0x18, 0x00, 0xFE, 0x1E, 0x00,
  0xFE, 0x1F, 0xE7, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0xFC, 0x7F, 0xF0, 0xFC,
  0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xFE, 0xFF,
  0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x87, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x02,
  0xFC, 0x00, 0xFF, 0x3F, 0x00, 0x7F, 0x8F, 0xC0, 0x3F, 0xC3, 0xF0, 0x1F,
  0xE0, 0xFC, 0x0F, 0xF0, 0x3F, 0x07, 0xF8, 0x0F, 0xC3, 0xFC, 0x03, 0xF1,
  0xFE, 0x00, 0xFC, 0xFF, 0x00, 0x3F, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFE, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x0F, 0xC0,
  0xFF, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xF8, 0x3F, 0x00, 0xFF, 0x0F,
  0xC0, 0x1F, 0xE3, 0xF0, 0x07, 0xF8, 0xFC, 0x00, 0xFF, 0x3F, 0x00, 0x1F,
  0xEF, 0xC0, 0x03, 0xFC, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x1E,
  0x1F, 0xBF, 0xCF, 0xF3, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xBF, 0xFF, 0x0F, 0xE1, 0xFF, 0xE0, 0xF8, 0x3F,
  0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7C, 0x1F, 0xFE, 0x0F,
  0x83, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x3E, 0x0F, 0xFF, 0x07, 0xC1, 0xFF,
  0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7C,
  0x1F, 0xFE, 0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x3E, 0x0F, 0xFF,
  0x07, 0xC1, 0xFF, 0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0,
  0xFF, 0xF0, 0x7C, 0x1F, 0xFE, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0xC0, 0xFC,
  0x7F, 0xF0, 0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF,
  0xE7, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1,
  0xFF, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF7, 0xF0,
  0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0xFF, 0xE0, 0xFD, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xEF, 0xFC, 0xFF, 0x01, 0xFE,
  0xFE, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x83, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFD, 0xFF, 0xE0,
  0xFC, 0x7F, 0xC0, 0xFC, 0x04, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0x0F, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7F, 0x00, 0x3F, 0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x03, 0xFE, 0x3F,
  0x00, 0x20, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xEF,
  0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFE,
  0x07, 0xF8, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01,
  0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xA0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x10, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x7F, 0x01, 0xFF, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0x7F, 0x1F, 0xFE, 0x3F, 0x07, 0xFC,
  0x3F, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x7F,
  0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF1,
  0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x03, 0xE0, 0x7E, 0xF8,
  0x3F, 0x03, 0xE7, 0xC1, 0xFC, 0x3F, 0x3F, 0x0F, 0xE1, 0xF9, 0xF8, 0x7F,
  0x0F, 0xCF, 0xC3, 0xF8, 0x7E, 0x7E, 0x3F, 0xC3, 0xE1, 0xF1, 0xFF, 0x1F,
  0x0F, 0x8F, 0x78, 0xF8, 0x7C, 0x7B, 0xCF, 0xC3, 0xF3, 0xDE, 0x7E, 0x1F,
  0xBC, 0xF3, 0xE0, 0x7D, 0xE3, 0xDF, 0x03, 0xEF, 0x1E, 0xF8, 0x1F, 0x78,
  0xF7, 0xC0, 0xFB, 0xC7, 0xBE, 0x07, 0xDC, 0x3F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01,
  0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x7F, 0x80, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF9, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0x9F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x8F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x7E, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0xE0, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x40, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x10, 0x3F, 0xFC, 0x00,
  0xF7, 0xFF, 0xE0, 0x1F, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC,
  0x1F, 0xFF, 0xEF, 0x80, 0xFF, 0xFE, 0xF0, 0x07, 0xFF, 0xC7, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0x00,
};

const GFXglyph RobotoMono_SemiBold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 7, 37, 31, 12, -37 },
  { 34, 15, 13, 31, 8, -39 },
  { 59, 28, 37, 31, 1, -37 },
  { 189, 26, 48, 31, 3, -43 },
  { 345, 29, 39, 31, 1, -38 },
  { 487, 29, 39, 31, 2, -38 },
  { 629, 5, 13, 31, 12, -39 },
  { 638, 14, 53, 31, 9, -41 },
  { 731, 14, 53, 31, 8, -41 },
  { 824, 26, 26, 31, 4, -37 },
  { 909, 25, 27, 31, 3, -31 },
  { 994, 9, 16, 31, 9, -6 },
  { 1012, 21, 5, 31, 7, -19 },
  { 1026, 9, 9, 31, 11, -8 },
  { 1037, 20, 40, 31, 6, -37 },
  { 1137, 24, 39, 31, 4, -38 },
  { 1254, 16, 37, 31, 5, -37 },
  { 1328, 26, 37, 31, 2, -37 },
  { 1449, 25, 38, 31, 2, -37 },
  { 1568, 27, 37, 31, 2, -37 },
  { 1693, 25, 38, 31, 3, -37 },
  { 1812, 25, 38, 31, 3, -37 },
  { 1931, 26, 37, 31, 2, -37 },
  { 2052, 25, 38, 31, 3, -37 },
  { 2171, 24, 37, 31, 3, -37 },
  { 2282, 9, 30, 31, 12, -29 },
  { 2316, 11, 39, 31, 11, -29 },
  { 2370, 22, 24, 31, 4, -28 },
  { 2436, 24, 16, 31, 4, -24 },
  { 2484, 23, 24, 31, 4, -28 },
  { 2553, 24, 38, 31, 4, -38 },
  { 2667, 29, 37, 31, 1, -37 },
  { 2802, 30, 37, 31, 1, -37 },
  { 2941, 27, 37, 31, 3, -37 },
  { 3066, 27, 39, 31, 2, -38 },
  { 3198, 26, 37, 31, 3, -37 },
  { 3319, 24, 37, 31, 4, -37 },
  { 3430, 25, 37, 31, 4, -37 },
  { 3546, 27, 38, 31, 2, -37 },
  { 3675, 25, 37, 31, 3, -37 },
  { 3791, 21, 37, 31, 5, -37 },
  { 3889, 25, 38, 31, 3, -37 },
  { 4008, 29, 37, 31, 3, -37 },
  { 4143, 24, 37, 31, 4, -37 },
  { 4254, 25, 37, 31, 3, -37 },
  { 4370, 25, 37, 31, 3, -37 },
  { 4486, 27, 38, 31, 2, -37 },
  { 4615, 26, 37, 31, 4, -37 },
  { 4736, 29, 43, 31, 2, -37 },
  { 4892, 26, 37, 31, 4, -37 },
  { 5013, 27, 37, 31, 2, -37 },
  { 5138, 29, 37, 31, 1, -37 },
  { 5273, 25, 38, 31, 3, -37 },
  { 5392, 29, 37, 31, 1, -37 },
  { 5527, 30, 37, 31, 1, -37 },
  { 5666, 30, 37, 31, 1, -37 },
  { 5805, 30, 37, 31, 1, -37 },
  { 5944, 27, 37, 31, 2, -37 },
  { 6069, 11, 51, 31, 10, -43 },
  { 6140, 20, 40, 31, 6, -37 },
  { 6240, 11, 51, 31, 10, -43 },
  { 6311, 20, 20, 31, 6, -37 },
  { 6361, 23, 5, 31, 4, 0 },
  { 6376, 12, 7, 31, 10, -38 },
  { 6387, 25, 29, 31, 3, -28 },
  { 6478, 24, 40, 31, 4, -39 },
  { 6598, 24, 29, 31, 3, -28 },
  { 6685, 24, 40, 31, 3, -39 },
  { 6805, 25, 29, 31, 3, -28 },
  { 6896, 26, 40, 31, 3, -40 },
  { 7026, 25, 39, 31, 3, -28 },
  { 7148, 24, 39, 31, 4, -39 },
  { 7265, 23, 38, 31, 5, -38 },
  { 7375, 16, 49, 31, 6, -38 },
  { 7473, 26, 39, 31, 4, -39 },
  { 7600, 23, 39, 31, 5, -39 },
  { 7713, 27, 28, 31, 2, -28 },
  { 7808, 24, 28, 31, 4, -28 },
  { 7892, 25, 29, 31, 3, -28 },
  { 7983, 24, 39, 31, 4, -28 },
  { 8100, 24, 39, 31, 3, -28 },
  { 8217, 20, 28, 31, 8, -28 },
  { 8287, 25, 29, 31, 3, -28 },
  { 8378, 25, 35, 31, 3, -34 },
  { 8488, 24, 28, 31, 4, -27 },
  { 8572, 27, 27, 31, 2, -27 },
  { 8664, 29, 27, 31, 1, -27 },
  { 8762, 28, 27, 31, 2, -27 },
  { 8857, 30, 38, 31, 1, -27 },
  { 9000, 26, 27, 31, 3, -27 },
  { 9088, 17, 50, 31, 8, -41 },
  { 9195, 4, 47, 31, 14, -37 },
  { 9219, 17, 50, 31, 8, -41 },
  { 9326, 28, 11, 31, 1, -21 },
};

const GFXfont RobotoMono_SemiBold52pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold52pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOMONO_SEMIBOLD52PT7B_H_
