#ifndef _ROBOTOMONO_SEMIBOLD29PT7B_H_
#define _ROBOTOMONO_SEMIBOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold29pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0x03,
  0x9F, 0xF7, 0x00, 0xE3, 0xF1, 0xF8, 0xFC, 0x6E, 0x37, 0x1B, 0x8D, 0xC6,
  0x03, 0x18, 0x0E, 0x30, 0x1C, 0x60, 0x31, 0xC0, 0x63, 0x80, 0xC7, 0x1F,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x18, 0xE0, 0x31, 0xC0, 0x63, 0x01, 0xC6,
  0x1F, 0xFF, 0xBF, 0xFF, 0x0C, 0x70, 0x18, 0xE0, 0x71, 0x80, 0xE3, 0x01,
  0xC6, 0x03, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xF0, 0x1F,
  0xF0, 0xFF, 0xE7, 0xC7, 0x9E, 0x0F, 0x70, 0x3D, 0xC0, 0xF7, 0x80, 0x1F,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF,
  0x03, 0xFC, 0x0F, 0xF8, 0x3D, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x38, 0x00, 0xFE, 0x00, 0xEE, 0x00, 0xC6, 0x18,
  0xC6, 0x30, 0xC6, 0x70, 0xC6, 0x60, 0xFE, 0xE0, 0x7C, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x18, 0x06, 0x7E, 0x06, 0xFF, 0x0C, 0xE7,
  0x1C, 0xC7, 0x18, 0xC7, 0x00, 0xE7, 0x00, 0xFE, 0x00, 0x7C, 0x07, 0x80,
  0x1F, 0xE0, 0x1F, 0xF0, 0x3C, 0xF0, 0x3C, 0x70, 0x38, 0x70, 0x3C, 0x70,
  0x3D, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x87, 0x7B, 0xC7,
  0x7B, 0xEF, 0xF1, 0xEE, 0xF0, 0xFE, 0xF0, 0x7E, 0xF8, 0x7C, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0xCF, 0xFF, 0xFF, 0x02, 0x07, 0x0E, 0x1C, 0x3C, 0x38,
  0x78, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xF0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1E, 0x0F, 0x06, 0x02,
  0x40, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0F, 0x0F, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x1E,
  0x1C, 0x38, 0x38, 0xF0, 0x60, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x04, 0x38, 0x4E, 0x63, 0xBF, 0xFF, 0x1F, 0xFD, 0x03, 0x80, 0x0F,
  0x80, 0x3B, 0x80, 0xE7, 0x03, 0xC7, 0x83, 0x0E, 0x02, 0x08, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x7B, 0xDE, 0xF7, 0xB9, 0xDC, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x33, 0xFF, 0xF7, 0x80, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xF1,
  0xE7, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFD, 0xEF,
  0xFC, 0x7F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7B, 0xC3, 0xDF,
  0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0x83, 0xCF, 0xFF, 0xFF, 0xFF, 0x3E,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E,
  0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F,
  0x1F, 0x78, 0x3D, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x1F, 0xC0,
  0x7E, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x3D,
  0xE0, 0xF7, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0x38, 0x1E, 0x70,
  0x38, 0xE0, 0xE1, 0xC1, 0xC3, 0x87, 0x07, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x3F,
  0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x40, 0x7F, 0xE1, 0xFF, 0xCF, 0x9F, 0x84, 0x1E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xF8, 0x0E, 0xF0, 0x7B, 0xC1, 0xE7, 0xFF, 0x0F, 0xFC, 0x1F, 0xC0,
  0x01, 0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E,
  0x70, 0xEF, 0xE7, 0xFF, 0xBE, 0x3F, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xF0, 0x7B, 0xC3, 0xDF, 0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0x78, 0xF1, 0xFF, 0x07, 0xF0, 0xFF, 0xE7, 0x87, 0xF8, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xDF, 0xFE, 0xFF, 0xE1, 0xFC, 0x00, 0x0F,
  0x81, 0xFE, 0x1F, 0xF9, 0xF1, 0xEF, 0x07, 0x70, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x83, 0xFC, 0x1E, 0xFF, 0xF7, 0xFF, 0x9F, 0xBC, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x1F, 0x07, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x67, 0xBF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x06, 0x7B, 0xFF, 0xF0, 0x31, 0xF7, 0xDF,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x38, 0xE7, 0x9C,
  0x73, 0x82, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x0F, 0xF1, 0xFE, 0x3F,
  0x83, 0xF0, 0x1F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xF0, 0x03,
  0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0x07, 0xF9, 0xFF, 0x3F, 0xC1,
  0xF8, 0x0F, 0x00, 0x40, 0x00, 0x0F, 0xC1, 0xFF, 0x9F, 0xFE, 0xF0, 0xFF,
  0x03, 0xF8, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x38, 0x1C, 0x30, 0x0E,
  0x63, 0xE6, 0x67, 0xF6, 0xE6, 0x66, 0xCE, 0x67, 0xCC, 0x63, 0xCC, 0x66,
  0xCC, 0x66, 0xCC, 0x66, 0xCC, 0x66, 0xCF, 0xEC, 0xCF, 0xFC, 0xE2, 0x10,
  0x70, 0x00, 0x78, 0x20, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70,
  0x0E, 0x70, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x38, 0x3C, 0x3C, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7F, 0xFC, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0x8F, 0xCF, 0x03, 0xDE,
  0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x79, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0xCF, 0x03, 0xDE, 0x03, 0xBC, 0x07, 0xF8, 0x0E, 0xF0, 0x3D, 0xE0, 0xFB,
  0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1,
  0xE1, 0xE7, 0x81, 0xEF, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x0F,
  0x78, 0x1E, 0xF8, 0x78, 0xFF, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0xFC, 0x03,
  0xFF, 0x0F, 0xFE, 0x3C, 0xFC, 0xF0, 0xFB, 0xC1, 0xEF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0E, 0xF0, 0x7B, 0xC3, 0xCF, 0xFF, 0x3F, 0xF0, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x1F, 0xF0, 0xFF, 0xF1, 0xE1, 0xE7, 0x81, 0xEF, 0x03,
  0xDC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x87, 0xFF,
  0x0F, 0xFE, 0x03, 0xFC, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF8, 0x3C, 0xFF,
  0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xFF, 0xFC, 0xFF, 0xC1, 0xFC, 0x00, 0xF0,
  0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xE0, 0xF3,
  0xE0, 0xF3, 0xC0, 0xF7, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0xF9, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0,
  0x3C, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x3F, 0xFC, 0xFF, 0xF3, 0x7F, 0xDD, 0xFB, 0x77, 0xEF, 0xBF, 0xBE, 0xFE,
  0x7B, 0xF9, 0xEF, 0xE7, 0x3F, 0x9C, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3C, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x3F, 0xB9, 0xFD,
  0xCF, 0xEF, 0x7F, 0x3B, 0xF9, 0xDF, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0x87,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0x80, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1,
  0xE3, 0xE7, 0x83, 0xCF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xB8, 0x0F,
  0x78, 0x1C, 0xF8, 0x78, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x03,
  0xFF, 0xCF, 0xFF, 0xBC, 0x3F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07,
  0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C, 0x7C, 0x78, 0x3C, 0x78, 0x1E, 0x70,
  0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0x70, 0x1E, 0x78, 0x1E, 0x7C, 0x3C, 0x3F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0E, 0x00,
  0x04, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xE7, 0x8F, 0xCF, 0x03, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F,
  0xFE, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0x79, 0xE0, 0xF3, 0xC0,
  0xF7, 0x81, 0xEF, 0x01, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1,
  0xF7, 0x81, 0xEF, 0x01, 0xDE, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xF8, 0x07, 0x70,
  0x1E, 0xF0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x7B, 0xE1, 0xE7, 0xFF,
  0x0F, 0xFC, 0x1F, 0xC0, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x3C, 0x78,
  0x1C, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0xE3, 0x87,
  0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0xCF, 0xE3, 0xCE, 0xF3, 0xCE, 0xF7, 0xCE,
  0xF7, 0xCE, 0x77, 0xCE, 0x77, 0xEE, 0x76, 0xFE, 0x76, 0xFE, 0x76, 0xFC,
  0x7E, 0x7C, 0x7E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C,
  0x3C, 0x38, 0x3C, 0x38, 0xF0, 0x0F, 0xF8, 0x1E, 0x78, 0x1E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0x78,
  0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x78,
  0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xFC, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xFF, 0xFF, 0xFC, 0x06, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0xB8,
  0x39, 0xC3, 0x9C, 0x70, 0xE7, 0x0E, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF1, 0xE3, 0x87, 0x02, 0x00, 0xFF, 0x87, 0xFF, 0x3E, 0x3C, 0xF0,
  0x78, 0x01, 0xE0, 0x07, 0x8F, 0xFE, 0x7F, 0xFB, 0xC1, 0xEF, 0x07, 0xB8,
  0x1E, 0xF0, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xCF, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x10, 0x3F, 0xF8, 0xFF, 0xF3,
  0xF3, 0xEF, 0x07, 0xBC, 0x0E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xEF, 0x87, 0xBF, 0xFE, 0xFF, 0xF3, 0xDF, 0x80, 0x07,
  0x00, 0xFF, 0x0F, 0xFC, 0xFB, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x77, 0x87, 0xBF, 0xF8, 0xFF, 0xC3,
  0xF8, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x10,
  0xE7, 0xF7, 0x7F, 0xFB, 0xEF, 0xFC, 0x1F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x1E, 0xFF, 0xF3, 0xFF, 0x8F,
  0xDC, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0xF0, 0x3B, 0xC0, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x78, 0x19,
  0xFF, 0xF3, 0xFF, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x3F, 0xFE, 0xFF, 0xF8, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x06, 0x01, 0xFD, 0xDF,
  0xFE, 0xF9, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xFC, 0x0F, 0xE0, 0x7F, 0x87, 0xBF, 0xFC, 0xFF, 0xE3, 0xF7, 0x00, 0x39,
  0x03, 0xDC, 0x3E, 0xFF, 0xE7, 0xFE, 0x0F, 0xE0, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x18, 0x3D, 0xFC, 0xFF, 0xFB,
  0xF3, 0xEF, 0x07, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0xFF, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x83,
  0xC1, 0xE0, 0x60, 0x00, 0x01, 0xFE, 0xFF, 0x7F, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0xFF, 0x7F, 0xBF, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0x78, 0x3C, 0xF0, 0xF1, 0xE3, 0xC3,
  0xCF, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFB,
  0xE1, 0xE3, 0xC3, 0xC3, 0xC7, 0x87, 0xCF, 0x07, 0xDE, 0x07, 0xC0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x02,
  0x11, 0xDF, 0xFB, 0xFF, 0xFF, 0xBE, 0xFE, 0x38, 0xFC, 0x71, 0xF8, 0xE3,
  0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x38, 0xFC,
  0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0x00, 0x83, 0xDF, 0xCF, 0xFF, 0xBF, 0x3E,
  0xF0, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x07, 0x00, 0x7F,
  0x83, 0xFF, 0x1F, 0x7E, 0xF0, 0x7B, 0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0E, 0xF0, 0x79, 0xFF, 0xC3, 0xFF, 0x07,
  0xF0, 0x03, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0x7E, 0xF0, 0x7B, 0xC0, 0xEF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1E, 0xF0, 0x7B,
  0xFF, 0xEF, 0xFF, 0x3D, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x06, 0x01, 0xFD, 0xDF, 0xFE, 0xF9, 0xFF, 0x07,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F,
  0x87, 0xBF, 0xFC, 0xFF, 0xE3, 0xF7, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xCF, 0x7F, 0xFF, 0xEF, 0xFE, 0xFC, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x03, 0x00, 0x7F, 0x87, 0xFF, 0x1E, 0x1E, 0xF0,
  0x3B, 0xC0, 0x17, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xB8,
  0x0F, 0xF0, 0x3D, 0xF3, 0xE7, 0xFF, 0x07, 0xF8, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x0F, 0xFF, 0xFF, 0xFC, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xF8,
  0x3F, 0xC0, 0xFE, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xE0, 0xF7, 0xFF,
  0xBF, 0xDC, 0x7C, 0xE0, 0xF0, 0x1E, 0xF0, 0x3D, 0xE0, 0x71, 0xC1, 0xE3,
  0xC3, 0x87, 0x87, 0x07, 0x1E, 0x0E, 0x38, 0x0E, 0x70, 0x1D, 0xC0, 0x3B,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF1, 0xC7, 0xB8,
  0xE3, 0x9C, 0x71, 0xCE, 0x3C, 0xE7, 0x3E, 0x71, 0xDB, 0x38, 0xED, 0xB8,
  0x76, 0xDC, 0x3B, 0x7E, 0x1F, 0x9F, 0x0F, 0x8F, 0x83, 0xC7, 0xC1, 0xE3,
  0xC0, 0xF1, 0xE0, 0x78, 0x70, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x7C, 0x1E,
  0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0xF0, 0x1E, 0xF8, 0x1E, 0x78, 0x3C, 0x3C, 0x78, 0x1E, 0xF8, 0x1F, 0xF0,
  0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E,
  0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x80, 0xF0, 0x7C,
  0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x3C,
  0x3E, 0x0F, 0x83, 0xF0, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x70, 0x3C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x81, 0xE0, 0x7C, 0x1E, 0x1F, 0x1C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x3C, 0x1C, 0x00, 0x0C, 0x00,
  0x3F, 0x03, 0x7F, 0x87, 0x7F, 0xFF, 0x61, 0xFF, 0xE0, 0x7E, 0x00, 0x10,
};

const GFXglyph RobotoMono_SemiBold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 9, 8, 17, 4, -22 },
  { 24, 15, 21, 17, 1, -21 },
  { 64, 14, 27, 17, 2, -24 },
  { 112, 16, 21, 17, 1, -21 },
  { 154, 16, 21, 17, 1, -21 },
  { 196, 2, 8, 17, 7, -22 },
  { 198, 8, 30, 17, 5, -23 },
  { 228, 8, 30, 17, 4, -23 },
  { 258, 15, 15, 17, 2, -21 },
  { 287, 15, 15, 17, 1, -17 },
  { 316, 5, 9, 17, 5, -3 },
  { 322, 11, 3, 17, 4, -11 },
  { 327, 5, 5, 17, 6, -5 },
  { 331, 12, 23, 17, 3, -21 },
  { 366, 13, 21, 17, 2, -21 },
  { 401, 9, 21, 17, 3, -21 },
  { 425, 14, 21, 17, 1, -21 },
  { 462, 14, 21, 17, 1, -21 },
  { 499, 15, 21, 17, 1, -21 },
  { 539, 14, 21, 17, 2, -21 },
  { 576, 13, 21, 17, 2, -21 },
  { 611, 14, 21, 17, 1, -21 },
  { 648, 13, 21, 17, 2, -21 },
  { 683, 13, 21, 17, 2, -21 },
  { 718, 5, 17, 17, 7, -17 },
  { 729, 6, 23, 17, 6, -17 },
  { 747, 13, 14, 17, 2, -16 },
  { 770, 14, 9, 17, 2, -13 },
  { 786, 13, 14, 17, 2, -16 },
  { 809, 13, 21, 17, 2, -21 },
  { 844, 16, 20, 17, 1, -20 },
  { 884, 16, 21, 17, 1, -21 },
  { 926, 15, 21, 17, 2, -21 },
  { 966, 15, 21, 17, 1, -21 },
  { 1006, 14, 21, 17, 2, -21 },
  { 1043, 14, 21, 17, 2, -21 },
  { 1080, 14, 21, 17, 2, -21 },
  { 1117, 15, 21, 17, 1, -21 },
  { 1157, 13, 21, 17, 2, -21 },
  { 1192, 12, 21, 17, 3, -21 },
  { 1224, 13, 21, 17, 2, -21 },
  { 1259, 16, 21, 17, 2, -21 },
  { 1301, 14, 21, 17, 2, -21 },
  { 1338, 14, 21, 17, 2, -21 },
  { 1375, 13, 21, 17, 2, -21 },
  { 1410, 15, 21, 17, 1, -21 },
  { 1450, 14, 21, 17, 2, -21 },
  { 1487, 16, 25, 17, 1, -21 },
  { 1537, 15, 21, 17, 2, -21 },
  { 1577, 15, 21, 17, 1, -21 },
  { 1617, 16, 21, 17, 1, -21 },
  { 1659, 14, 21, 17, 2, -21 },
  { 1696, 16, 21, 17, 1, -21 },
  { 1738, 16, 21, 17, 1, -21 },
  { 1780, 16, 21, 17, 1, -21 },
  { 1822, 16, 21, 17, 1, -21 },
  { 1864, 15, 21, 17, 1, -21 },
  { 1904, 6, 29, 17, 6, -24 },
  { 1926, 12, 23, 17, 3, -21 },
  { 1961, 6, 29, 17, 6, -24 },
  { 1983, 12, 11, 17, 3, -21 },
  { 2000, 13, 3, 17, 2, 0 },
  { 2005, 6, 4, 17, 6, -21 },
  { 2008, 14, 16, 17, 2, -16 },
  { 2036, 14, 22, 17, 2, -22 },
  { 2075, 13, 16, 17, 2, -16 },
  { 2101, 13, 22, 17, 2, -22 },
  { 2137, 14, 16, 17, 2, -16 },
  { 2165, 14, 22, 17, 2, -22 },
  { 2204, 13, 22, 17, 2, -16 },
  { 2240, 14, 22, 17, 2, -22 },
  { 2279, 13, 21, 17, 3, -21 },
  { 2314, 9, 27, 17, 3, -21 },
  { 2345, 15, 22, 17, 2, -22 },
  { 2387, 13, 22, 17, 3, -22 },
  { 2423, 15, 16, 17, 1, -16 },
  { 2453, 14, 16, 17, 2, -16 },
  { 2481, 14, 16, 17, 2, -16 },
  { 2509, 14, 22, 17, 2, -16 },
  { 2548, 13, 22, 17, 2, -16 },
  { 2584, 12, 16, 17, 4, -16 },
  { 2608, 14, 16, 17, 2, -16 },
  { 2636, 13, 19, 17, 2, -19 },
  { 2667, 13, 15, 17, 2, -15 },
  { 2692, 15, 15, 17, 1, -15 },
  { 2721, 17, 15, 17, 0, -15 },
  { 2753, 16, 15, 17, 1, -15 },
  { 2783, 16, 21, 17, 1, -15 },
  { 2825, 14, 15, 17, 2, -15 },
  { 2852, 10, 28, 17, 4, -23 },
  { 2887, 2, 27, 17, 8, -21 },
  { 2894, 9, 28, 17, 5, -23 },
  { 2926, 16, 7, 17, 0, -12 },
};

const GFXfont RobotoMono_SemiBold29pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold29pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOMONO_SEMIBOLD29PT7B_H_
