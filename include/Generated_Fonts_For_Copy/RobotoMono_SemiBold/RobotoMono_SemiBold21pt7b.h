#ifndef _ROBOTOMONO_SEMIBOLD21PT7B_H_
#define _ROBOTOMONO_SEMIBOLD21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0D, 0xF8, 0xCF, 0x3C, 0xF3, 0xCF, 0x30,
  0x06, 0x40, 0x4C, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x08, 0x81, 0x98,
  0x19, 0x8F, 0xFE, 0xFF, 0xE1, 0x10, 0x13, 0x03, 0x30, 0x33, 0x00, 0x06,
  0x00, 0xC0, 0x7C, 0x1F, 0xE7, 0x1C, 0xE1, 0x9C, 0x3B, 0x80, 0x3C, 0x03,
  0xF0, 0x1F, 0x00, 0xEE, 0x0F, 0xC1, 0xDC, 0x73, 0xFE, 0x1F, 0x80, 0x80,
  0x10, 0x00, 0x78, 0x06, 0xC0, 0xCC, 0xCC, 0xC8, 0x4D, 0x87, 0x90, 0x03,
  0x00, 0x20, 0x06, 0x00, 0xDE, 0x0D, 0xB1, 0xB3, 0x13, 0x30, 0x1B, 0x01,
  0xE0, 0x1E, 0x03, 0xF0, 0x73, 0x07, 0x38, 0x73, 0x03, 0x70, 0x3C, 0x03,
  0xC0, 0x7E, 0x6E, 0xE6, 0xE7, 0xEE, 0x3C, 0xE3, 0xC7, 0xFC, 0x3E, 0xF0,
  0xFF, 0xF0, 0x08, 0xCC, 0xE6, 0x33, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xE3, 0x1C, 0x61, 0x84, 0x83, 0x06, 0x0C, 0x38, 0x61, 0x87, 0x1C, 0x70,
  0xC3, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x18, 0xC2, 0x00, 0x0C, 0x03, 0x00,
  0xC3, 0x32, 0xFF, 0xCF, 0xC1, 0xC0, 0xD8, 0x73, 0x18, 0xE0, 0x20, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x6D, 0xFD, 0x80, 0xFF, 0xFF, 0xFF, 0x7F, 0x70, 0x03, 0x81, 0x81,
  0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x06, 0x03, 0x03,
  0x81, 0x81, 0xC0, 0x1F, 0x0F, 0xE7, 0x1D, 0x87, 0x61, 0xF8, 0x7E, 0x7F,
  0xBF, 0xF9, 0xFC, 0x76, 0x1D, 0x87, 0x71, 0xCF, 0xE1, 0xF0, 0x04, 0xFF,
  0xFB, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x3F, 0x1F,
  0xEE, 0x3B, 0x87, 0xC1, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0x81, 0xC0,
  0xE0, 0x70, 0x3F, 0xFF, 0xFC, 0x3F, 0x1F, 0xEE, 0x1F, 0x87, 0x01, 0xC0,
  0x71, 0xF8, 0x7C, 0x03, 0x80, 0x70, 0x1F, 0x87, 0xE1, 0xDF, 0xE3, 0xF0,
  0x03, 0x80, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x37, 0x0C, 0xE3, 0x9C, 0x63,
  0x98, 0x73, 0xFF, 0xFF, 0xF0, 0x38, 0x07, 0x00, 0xE0, 0x3F, 0xDF, 0xF7,
  0x01, 0xC0, 0x70, 0x1B, 0x87, 0xF9, 0xCF, 0x01, 0xC0, 0x30, 0x0F, 0x87,
  0x71, 0xDF, 0xE1, 0xF0, 0x07, 0x07, 0xC3, 0xC1, 0xC0, 0x60, 0x3B, 0xCF,
  0xFB, 0xCF, 0xE1, 0xF8, 0x3E, 0x0F, 0x87, 0x71, 0xCF, 0xE1, 0xF0, 0xFF,
  0xFF, 0xF0, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80,
  0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0x1F, 0x1F, 0xE7, 0x1D, 0x87, 0x61,
  0xDC, 0x73, 0xF8, 0xFC, 0x7B, 0x98, 0x7E, 0x0F, 0x87, 0x71, 0xDF, 0xE3,
  0xF0, 0x1E, 0x1F, 0xE7, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xC7, 0x7F,
  0xCF, 0xF0, 0x18, 0x0E, 0x07, 0x0F, 0xC3, 0xC0, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xEE, 0xEE, 0xCC, 0x01, 0x87, 0xCF,
  0xDF, 0x0C, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0xC0, 0x78, 0x3F, 0x83, 0xF0, 0x38, 0xFD, 0xF9,
  0xE0, 0xC0, 0x00, 0x3E, 0x7F, 0xF8, 0xF8, 0x70, 0x38, 0x1C, 0x1C, 0x1C,
  0x1C, 0x0E, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x70, 0x07, 0x81, 0xFC, 0x30,
  0x62, 0x33, 0x67, 0xB4, 0xDB, 0x49, 0x95, 0x9B, 0xD9, 0xB5, 0x9B, 0x4F,
  0xE6, 0xEC, 0x60, 0x03, 0x98, 0x1F, 0x80, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF8, 0x0D, 0x80, 0xD8, 0x1D, 0xC1, 0x8C, 0x18, 0xC3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x70, 0x77, 0x07, 0xE0, 0x30, 0xFF, 0x1F, 0xFB, 0x87, 0x70, 0x7E,
  0x0F, 0xC1, 0xBF, 0xF7, 0xFC, 0xE1, 0xDC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F,
  0xFF, 0xBF, 0xC0, 0x1F, 0x07, 0xF1, 0xC7, 0x70, 0x6E, 0x0F, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x83, 0xF0, 0x67, 0x1C, 0xFF, 0x07, 0xC0,
  0xFE, 0x1F, 0xE3, 0x8E, 0x70, 0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0x70, 0xEE, 0x39, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xF0,
  0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE,
  0xFF, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1F, 0x07, 0xF1,
  0xC7, 0x70, 0x6E, 0x03, 0xC0, 0x38, 0x07, 0x3F, 0xE7, 0xFC, 0x1F, 0x83,
  0xF0, 0x77, 0x0E, 0x7F, 0x87, 0xE0, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0C, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0x87, 0xE1, 0xDF, 0xE3,
  0xF0, 0xE0, 0xFE, 0x1C, 0xE3, 0xCE, 0x38, 0xE7, 0x0E, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFF, 0x0F, 0x70, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x0E, 0xE0, 0xF0,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xF1, 0xFC, 0x7F, 0x3F, 0xEF, 0xFB, 0xFF,
  0xBE, 0xEF, 0xBB, 0xEE, 0xFB, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0C,
  0xE1, 0xFC, 0x7F, 0x1F, 0xE7, 0xF9, 0xFE, 0x7E, 0xDF, 0xB7, 0xE7, 0xF9,
  0xFE, 0x7F, 0x8F, 0xE3, 0xF8, 0x7E, 0x1C, 0x1F, 0x0F, 0xF1, 0xC7, 0x70,
  0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xE7,
  0x1C, 0xFF, 0x07, 0xC0, 0xFE, 0x3F, 0xEC, 0x3B, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0xFE, 0xFF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1F,
  0x07, 0xF1, 0xC7, 0x70, 0x6E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x67, 0x1C, 0xFF, 0x07, 0xF0, 0x0F, 0x00, 0xE0, 0x08,
  0xFF, 0x1F, 0xFB, 0x87, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x77, 0xFE, 0xFF,
  0x1C, 0x63, 0x8E, 0x70, 0xCE, 0x1D, 0xC1, 0xB8, 0x38, 0x1F, 0x0F, 0xF9,
  0xC7, 0x70, 0x7E, 0x00, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x83,
  0xF0, 0x7F, 0x0E, 0xFF, 0x87, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0x71, 0xDF, 0xE1, 0xF0,
  0xE0, 0x77, 0x07, 0x70, 0x67, 0x0E, 0x38, 0xE3, 0x8E, 0x38, 0xC1, 0x9C,
  0x1D, 0xC1, 0xD8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xE6,
  0x36, 0x73, 0x67, 0x36, 0x77, 0x67, 0x76, 0x77, 0x7F, 0x67, 0xD6, 0x3D,
  0xE3, 0xDE, 0x3D, 0xE3, 0x9E, 0x39, 0xE3, 0x8E, 0x38, 0xC0, 0x70, 0x77,
  0x0E, 0x38, 0xE1, 0x9C, 0x1D, 0xC0, 0xF8, 0x0F, 0x80, 0x70, 0x0F, 0x80,
  0xF8, 0x1D, 0xC3, 0x9C, 0x38, 0xE7, 0x07, 0xF0, 0x70, 0xF0, 0x77, 0x07,
  0x30, 0xE3, 0x8E, 0x18, 0xC1, 0xDC, 0x0D, 0x80, 0xF8, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xFF, 0xDF, 0xF8, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38,
  0x0E, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xF0, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x01,
  0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x0C, 0x07,
  0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF,
  0xF0, 0x1C, 0x0E, 0x0F, 0x06, 0xC3, 0x63, 0x19, 0x8D, 0xC7, 0xFF, 0xFF,
  0xC0, 0xF1, 0x86, 0x3F, 0x1F, 0xE6, 0x1E, 0x07, 0x1F, 0xDF, 0xF6, 0x1F,
  0x87, 0xE1, 0xDF, 0xF3, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xFB,
  0xFD, 0xC7, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x3F, 0x1F, 0xFD, 0xBC, 0x1F,
  0x1F, 0xE7, 0x1F, 0x83, 0xE0, 0x38, 0x0E, 0x03, 0x83, 0x71, 0xDF, 0xE1,
  0xF0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xCF, 0xF7, 0xFD, 0xC7, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xDC, 0x77, 0xFC, 0xFB, 0x1F, 0x07, 0xF1,
  0xC7, 0x70, 0x6F, 0xFD, 0xFF, 0xF8, 0x07, 0x00, 0x70, 0xC7, 0xF8, 0x7E,
  0x00, 0x07, 0xE1, 0xFC, 0x38, 0x0E, 0x01, 0xC1, 0xFF, 0xBF, 0xF0, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3E,
  0xDF, 0xF7, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x71, 0xDF, 0xF3,
  0xFC, 0x07, 0x21, 0xDF, 0xE3, 0xF0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0xFB, 0xFF, 0xC7, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0x1C, 0x0E, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x0E, 0x1C, 0x00, 0x07, 0xEF, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFB, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0xEC, 0x73, 0x38, 0xDC, 0x3E, 0x0F, 0xC3,
  0xB8, 0xCE, 0x31, 0xCC, 0x3B, 0x0F, 0xFC, 0x7E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE3, 0xFF, 0xFF,
  0xDF, 0xDF, 0xFF, 0x33, 0xE6, 0x7C, 0xCF, 0x99, 0xF3, 0x3E, 0x67, 0xCC,
  0xF9, 0x9F, 0x33, 0x80, 0xDF, 0x7F, 0xF8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x3F, 0x1F, 0xE7, 0x1F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0x71, 0xDF, 0xE1, 0xF0, 0xDE, 0x7F, 0xB8, 0xF8, 0x7C,
  0x1E, 0x0F, 0x07, 0x87, 0xE3, 0xFF, 0xB7, 0x98, 0x0C, 0x06, 0x03, 0x00,
  0x3E, 0xDF, 0xF7, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x71, 0xDF,
  0xF3, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0xEF, 0xFF, 0xF9, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x9F, 0xF6, 0x1D, 0x80, 0x7C,
  0x0F, 0xE0, 0x7F, 0x83, 0x60, 0xDF, 0xF3, 0xF8, 0x1C, 0x07, 0x01, 0xC3,
  0xFF, 0xFF, 0xC7, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F,
  0xC3, 0xF0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE3,
  0xFF, 0xDF, 0x60, 0xE0, 0xFC, 0x19, 0x87, 0x38, 0xC3, 0x18, 0x67, 0x0E,
  0xC0, 0xD8, 0x1E, 0x01, 0xC0, 0x38, 0x00, 0xE6, 0x36, 0x63, 0x67, 0x76,
  0x76, 0x6F, 0x67, 0xD6, 0x3D, 0x63, 0x9E, 0x39, 0xE3, 0x9C, 0x38, 0xC0,
  0xE0, 0xEE, 0x38, 0xEE, 0x0F, 0x81, 0xF0, 0x1C, 0x07, 0xC1, 0xDC, 0x3B,
  0x8E, 0x3B, 0x83, 0x80, 0xE0, 0xFC, 0x1D, 0xC7, 0x38, 0xE3, 0x18, 0x77,
  0x0E, 0xE0, 0xD8, 0x1F, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0xF0, 0x1E,
  0x00, 0xFF, 0xDF, 0xF8, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1F, 0xFF, 0xFF, 0x80, 0x0E, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x31, 0xC3, 0xC1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x38, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xE0, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C,
  0x1C, 0x78, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x63, 0x82, 0x00, 0x7C, 0x37,
  0xE7, 0xC7, 0xE2, 0x1C,
};

const GFXglyph RobotoMono_SemiBold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 6, 6, 13, 3, -16 },
  { 12, 12, 15, 13, 0, -15 },
  { 35, 11, 19, 13, 1, -17 },
  { 62, 12, 15, 13, 0, -15 },
  { 85, 12, 15, 13, 1, -15 },
  { 108, 2, 6, 13, 5, -16 },
  { 110, 5, 22, 13, 4, -17 },
  { 124, 6, 22, 13, 3, -17 },
  { 141, 10, 11, 13, 2, -15 },
  { 155, 10, 11, 13, 1, -12 },
  { 169, 3, 6, 13, 4, -2 },
  { 172, 8, 3, 13, 3, -8 },
  { 175, 4, 3, 13, 4, -3 },
  { 177, 9, 16, 13, 2, -15 },
  { 195, 10, 15, 13, 1, -15 },
  { 214, 6, 15, 13, 2, -15 },
  { 226, 10, 15, 13, 1, -15 },
  { 245, 10, 15, 13, 1, -15 },
  { 264, 11, 15, 13, 1, -15 },
  { 285, 10, 15, 13, 1, -15 },
  { 304, 10, 15, 13, 1, -15 },
  { 323, 10, 15, 13, 1, -15 },
  { 342, 10, 15, 13, 1, -15 },
  { 361, 10, 15, 13, 1, -15 },
  { 380, 3, 12, 13, 5, -12 },
  { 385, 4, 16, 13, 5, -12 },
  { 393, 9, 9, 13, 2, -11 },
  { 404, 9, 7, 13, 2, -10 },
  { 412, 9, 9, 13, 2, -11 },
  { 423, 9, 15, 13, 2, -15 },
  { 440, 12, 15, 13, 0, -15 },
  { 463, 12, 15, 13, 0, -15 },
  { 486, 11, 15, 13, 1, -15 },
  { 507, 11, 15, 13, 1, -15 },
  { 528, 11, 15, 13, 1, -15 },
  { 549, 9, 15, 13, 2, -15 },
  { 566, 10, 15, 13, 2, -15 },
  { 585, 11, 15, 13, 1, -15 },
  { 606, 10, 15, 13, 1, -15 },
  { 625, 9, 15, 13, 2, -15 },
  { 642, 10, 15, 13, 1, -15 },
  { 661, 12, 15, 13, 1, -15 },
  { 684, 9, 15, 13, 2, -15 },
  { 701, 10, 15, 13, 1, -15 },
  { 720, 10, 15, 13, 1, -15 },
  { 739, 11, 15, 13, 1, -15 },
  { 760, 10, 15, 13, 2, -15 },
  { 779, 11, 18, 13, 1, -15 },
  { 804, 11, 15, 13, 1, -15 },
  { 825, 11, 15, 13, 1, -15 },
  { 846, 12, 15, 13, 0, -15 },
  { 869, 10, 15, 13, 1, -15 },
  { 888, 12, 15, 13, 0, -15 },
  { 911, 12, 15, 13, 0, -15 },
  { 934, 12, 15, 13, 0, -15 },
  { 957, 12, 15, 13, 0, -15 },
  { 980, 11, 15, 13, 1, -15 },
  { 1001, 5, 20, 13, 4, -17 },
  { 1014, 9, 16, 13, 2, -15 },
  { 1032, 5, 20, 13, 4, -17 },
  { 1045, 9, 8, 13, 2, -15 },
  { 1054, 9, 2, 13, 2, 0 },
  { 1057, 5, 3, 13, 4, -15 },
  { 1059, 10, 11, 13, 1, -11 },
  { 1073, 9, 16, 13, 2, -16 },
  { 1091, 10, 11, 13, 1, -11 },
  { 1105, 10, 16, 13, 1, -16 },
  { 1125, 11, 11, 13, 1, -11 },
  { 1141, 11, 16, 13, 1, -16 },
  { 1163, 10, 15, 13, 1, -11 },
  { 1182, 9, 16, 13, 2, -16 },
  { 1200, 9, 15, 13, 2, -15 },
  { 1217, 7, 19, 13, 2, -15 },
  { 1234, 10, 16, 13, 2, -16 },
  { 1254, 9, 16, 13, 2, -16 },
  { 1272, 11, 11, 13, 1, -11 },
  { 1288, 9, 11, 13, 2, -11 },
  { 1301, 10, 11, 13, 1, -11 },
  { 1315, 9, 15, 13, 2, -11 },
  { 1332, 10, 15, 13, 1, -11 },
  { 1351, 8, 11, 13, 3, -11 },
  { 1362, 10, 11, 13, 1, -11 },
  { 1376, 10, 14, 13, 1, -14 },
  { 1394, 9, 11, 13, 2, -11 },
  { 1407, 11, 11, 13, 1, -11 },
  { 1423, 12, 11, 13, 0, -11 },
  { 1440, 11, 11, 13, 1, -11 },
  { 1456, 11, 15, 13, 1, -11 },
  { 1477, 11, 11, 13, 1, -11 },
  { 1493, 7, 20, 13, 3, -16 },
  { 1511, 2, 19, 13, 5, -15 },
  { 1516, 7, 20, 13, 3, -16 },
  { 1534, 12, 4, 13, 0, -8 },
};

const GFXfont RobotoMono_SemiBold21pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold21pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOMONO_SEMIBOLD21PT7B_H_
