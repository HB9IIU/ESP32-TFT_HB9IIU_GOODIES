#ifndef _ROBOTOMONO_SEMIBOLD24PT7B_H_
#define _ROBOTOMONO_SEMIBOLD24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold24pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x00, 0x7F, 0x70, 0xE7, 0xCF,
  0x9F, 0x3E, 0x78, 0xC0, 0x0C, 0x60, 0x63, 0x03, 0x38, 0x19, 0x80, 0xCC,
  0x7F, 0xFF, 0xFF, 0xE3, 0x18, 0x19, 0x80, 0xCC, 0x3F, 0xFD, 0xFF, 0xE3,
  0x18, 0x18, 0xC0, 0xCC, 0x06, 0x60, 0x63, 0x00, 0x06, 0x00, 0xC0, 0x18,
  0x1F, 0xC7, 0xFC, 0xE3, 0xF8, 0x3F, 0x07, 0xF0, 0x0F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xC0, 0x3F, 0x07, 0xE0, 0xFE, 0x3D, 0xFF, 0x1F, 0xC0,
  0x40, 0x08, 0x00, 0x7C, 0x01, 0xF8, 0x0E, 0x62, 0x39, 0x98, 0xE6, 0xC1,
  0xFB, 0x03, 0xD8, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x6F, 0x81, 0xBF,
  0x0D, 0xCC, 0x66, 0x30, 0x9C, 0xC0, 0x3F, 0x00, 0xF8, 0x1F, 0x01, 0xFC,
  0x0E, 0x70, 0x63, 0x83, 0x1C, 0x1D, 0xC0, 0xFC, 0x03, 0xC0, 0x3E, 0x03,
  0xF9, 0xFD, 0xCF, 0xC7, 0x7E, 0x3F, 0x70, 0xFB, 0xC7, 0x8F, 0xFE, 0x3F,
  0x38, 0xFF, 0xFF, 0xC0, 0x04, 0x31, 0xCE, 0x31, 0xC6, 0x18, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0x61, 0x87, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x06,
  0x1C, 0x38, 0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x63,
  0x8E, 0x31, 0xCE, 0x30, 0x06, 0x00, 0x60, 0x06, 0x0C, 0x62, 0xF6, 0xEF,
  0xFF, 0x0F, 0x00, 0xF0, 0x1B, 0x83, 0x98, 0x71, 0xC1, 0x08, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x77, 0x77, 0x76, 0xE4, 0xFF, 0xFF, 0xFF, 0xFC,
  0x6F, 0xF7, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C,
  0x0E, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x00, 0x3F,
  0x0F, 0xF3, 0xCF, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0xFF, 0x3F, 0xEE, 0xFF,
  0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xBC, 0xF3, 0xFC, 0x3F, 0x00, 0x03,
  0x1F, 0xFF, 0xFF, 0xCF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x87, 0xFC, 0x71, 0xEE, 0x0E, 0xE0, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03,
  0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0x87, 0xFC, 0x79, 0xEF, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFC, 0x0F, 0x80, 0x3E, 0x00, 0xE0, 0x07,
  0xE0, 0x7E, 0x0E, 0x79, 0xE7, 0xFC, 0x1F, 0x80, 0x01, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x0F, 0xC1, 0xDC, 0x1D, 0xC3, 0x9C, 0x31, 0xC7, 0x1C, 0xE1,
  0xCF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7F, 0xCF,
  0xF9, 0xFF, 0x30, 0x0E, 0x01, 0xC0, 0x3F, 0xC7, 0xFE, 0xE3, 0xC0, 0x3C,
  0x03, 0x80, 0x7E, 0x0F, 0xC3, 0xFC, 0xF3, 0xFE, 0x3F, 0x00, 0x07, 0x81,
  0xF8, 0x3F, 0x03, 0x80, 0x70, 0x07, 0x00, 0x7F, 0xCF, 0xFE, 0xF9, 0xEF,
  0x0F, 0xE0, 0x7E, 0x07, 0x70, 0x77, 0x0E, 0x79, 0xE3, 0xFC, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x00, 0x1F, 0x83, 0xFC, 0x79, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x78,
  0xE3, 0xFC, 0x1F, 0xC7, 0xFE, 0x70, 0xE7, 0x07, 0xF0, 0x77, 0x0F, 0x79,
  0xE3, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xFC, 0x79, 0xE7, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0x7F, 0x0F, 0x70, 0xF7, 0xFE, 0x3F, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x1F, 0xC1, 0xF0, 0x1E, 0x00, 0x73, 0xFE, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0xFF, 0xB8, 0x33, 0xDE, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x39,
  0xCE, 0x67, 0x10, 0x00, 0x40, 0x70, 0xFC, 0xFE, 0xFC, 0x38, 0x0F, 0x81,
  0xFC, 0x0F, 0xC0, 0xF0, 0x0C, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x80, 0x38, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0x70, 0x7C,
  0xFE, 0xFC, 0x3C, 0x0C, 0x00, 0x3F, 0x8F, 0xFB, 0xC7, 0xF0, 0x70, 0x0E,
  0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0x83, 0x8C, 0x06,
  0x23, 0xC9, 0x9D, 0x36, 0xC4, 0xDB, 0x33, 0x4C, 0xCD, 0x33, 0x24, 0xCC,
  0x9B, 0xF6, 0x67, 0x71, 0x80, 0x03, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3B, 0x80, 0xEE, 0x03,
  0x38, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x0F, 0xFC, 0x3F, 0xF8, 0xE0, 0xE7,
  0x03, 0x9C, 0x07, 0xF0, 0x1C, 0xFF, 0x0F, 0xFC, 0xE3, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE1, 0xEF, 0xFC, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x07, 0xE0,
  0x7E, 0x0E, 0xE3, 0xEF, 0xFC, 0xFF, 0x80, 0x1F, 0xC3, 0xFE, 0x78, 0xF7,
  0x07, 0xE0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x77, 0x07, 0x78, 0xE3, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0xF3,
  0xBF, 0x70, 0xEE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x1F, 0xC3, 0xBB, 0xF7, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDC, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x1F, 0xC3, 0xFE,
  0x78, 0xF7, 0x07, 0xF0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE3, 0xFE, 0x3F,
  0xE3, 0xFE, 0x07, 0xF0, 0x77, 0x07, 0x78, 0xF3, 0xFF, 0x1F, 0xC0, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x70, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0xE0, 0x7F, 0x0E, 0x79, 0xE7, 0xFC, 0x1F,
  0x80, 0xE0, 0xF7, 0x0F, 0x38, 0x71, 0xC7, 0x8E, 0x78, 0x77, 0x83, 0xB8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3D, 0xC1, 0xC7, 0x0E, 0x3C, 0x70, 0xE3,
  0x87, 0x9C, 0x1E, 0xE0, 0x78, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0xFF, 0xFF, 0xE0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF9, 0xFF, 0xBF,
  0xB7, 0xF7, 0xFE, 0xF7, 0xDE, 0xF9, 0xDF, 0x33, 0xE6, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xE0, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xFC,
  0x7F, 0xC7, 0xFE, 0x7F, 0xE7, 0xF6, 0x7F, 0x77, 0xF3, 0x7F, 0x3F, 0xF1,
  0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x1F, 0x83, 0xFC, 0x79, 0xE7,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x77, 0x0F, 0x79, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0x0F, 0xFC,
  0xE3, 0xEE, 0x0E, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0E, 0xFF, 0xEF, 0xFC,
  0xFC, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F,
  0x81, 0xFE, 0x1E, 0x78, 0xE1, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E,
  0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEF, 0x07, 0x38, 0x79, 0xE7, 0x87,
  0xF8, 0x1F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x20, 0xFF, 0x0F, 0xFC, 0xE3,
  0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1E, 0xFF, 0xCF, 0xF8, 0xFF,
  0x8E, 0x38, 0xE3, 0xCE, 0x1C, 0xE1, 0xEE, 0x0E, 0xE0, 0xF0, 0x1F, 0xC1,
  0xFF, 0x1E, 0x3C, 0xE0, 0xE7, 0x07, 0xB8, 0x01, 0xE0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x3C, 0x00, 0xEE, 0x07, 0xF8, 0x39, 0xE3, 0xC7, 0xFC,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC3, 0xFC, 0xF3, 0xFC, 0x3F, 0x00, 0xF0, 0x3D, 0xC0, 0xE7,
  0x83, 0x8E, 0x0E, 0x38, 0x78, 0xE1, 0xC3, 0xC7, 0x07, 0x1C, 0x1C, 0xE0,
  0x73, 0x80, 0xEE, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0xE3, 0x1D, 0x8E, 0x77, 0x39, 0xDC, 0xE7, 0x77, 0x99, 0xDE,
  0x67, 0x79, 0x9D, 0xFE, 0x36, 0xF8, 0xDB, 0xE3, 0xEF, 0x8F, 0x3E, 0x3C,
  0xF0, 0xF3, 0xC3, 0xC7, 0x0F, 0x1C, 0x1C, 0x70, 0x78, 0x3C, 0xE0, 0xE3,
  0xC7, 0x87, 0x1C, 0x1E, 0xE0, 0x3B, 0x80, 0xFC, 0x01, 0xF0, 0x07, 0x80,
  0x1F, 0x00, 0xFC, 0x03, 0xB8, 0x1C, 0xF0, 0x71, 0xC3, 0x87, 0x9E, 0x0E,
  0xF0, 0x3C, 0xF0, 0x1D, 0xE0, 0xE3, 0x83, 0x8E, 0x1C, 0x1C, 0x70, 0x73,
  0x80, 0xEE, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F,
  0xFF, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E,
  0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xFF, 0xFE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF,
  0xFF, 0x1C, 0x0E, 0x0F, 0x86, 0xC7, 0x63, 0x39, 0x8D, 0xC7, 0xC1, 0x80,
  0xFF, 0xFF, 0xF0, 0xF1, 0x8E, 0x0F, 0x83, 0xFC, 0x79, 0xE7, 0x0E, 0x00,
  0xE0, 0xFE, 0x3F, 0xE7, 0x8E, 0x70, 0xEF, 0x0E, 0x71, 0xE7, 0xFE, 0x3E,
  0x70, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xDE, 0x3F, 0xE7, 0xFE,
  0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x9E, 0xFF,
  0xDD, 0xF0, 0x0F, 0x83, 0xFC, 0x3F, 0xE7, 0x0E, 0x70, 0x7F, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x07, 0x78, 0xE3, 0xFE, 0x1F, 0x80, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x71, 0xE7, 0x3F, 0xF7, 0xFF, 0x70, 0xF7,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x70, 0xF7, 0x9F, 0x3F, 0xF1,
  0xF7, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x07, 0x70, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x02, 0x7C, 0xF3, 0xFE, 0x0F, 0xC0, 0x00, 0x80, 0xFC,
  0x3F, 0x8F, 0x01, 0xC0, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00,
  0x1F, 0x73, 0xFF, 0x7F, 0xF7, 0x0F, 0x70, 0x7F, 0x07, 0xE0, 0x7E, 0x07,
  0x70, 0x77, 0x07, 0x79, 0xF3, 0xFF, 0x1F, 0x70, 0x07, 0x20, 0xE7, 0xBE,
  0x3F, 0xC1, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xCE, 0x3F,
  0xF7, 0xFE, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1C, 0x04, 0x01, 0xC0, 0x38, 0x02, 0x00, 0x01, 0xFC,
  0x3F, 0x87, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0xFF, 0xFF, 0xFC, 0x04, 0x1C, 0x38, 0x20, 0x0F, 0xDF, 0xBF,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7B, 0xFF,
  0xBE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x1E, 0xE3,
  0xCE, 0x78, 0xE7, 0x0E, 0xE0, 0xFC, 0x0F, 0xE0, 0xFF, 0x0E, 0x70, 0xE3,
  0x8E, 0x3C, 0xE1, 0xEE, 0x0F, 0xFE, 0x1F, 0xC3, 0xF8, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFC, 0xEE, 0xEF, 0xFF, 0xFF, 0xFE, 0x73,
  0xE7, 0x3E, 0x73, 0xE7, 0x3E, 0x73, 0xE7, 0x3E, 0x73, 0xE7, 0x3E, 0x73,
  0xE7, 0x30, 0xE7, 0x9F, 0xFB, 0xFF, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0x0F, 0x83, 0xFC, 0x7F,
  0xE7, 0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0F, 0x79,
  0xE3, 0xFC, 0x1F, 0x80, 0xEF, 0x1F, 0xF3, 0xFF, 0x70, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0xCF, 0x7F, 0xEE, 0xF9, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x73, 0xFF, 0x7F, 0xF7, 0x0F, 0x70,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x77, 0x07, 0x79, 0xF3, 0xFF, 0x1F,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xE3, 0xFB, 0xFF, 0xFF,
  0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x00, 0x1F, 0x0F, 0xFB, 0xCF, 0x70, 0x7E, 0x01, 0xF8, 0x1F, 0xE0, 0x7E,
  0x01, 0xFC, 0x1F, 0x87, 0xBF, 0xE3, 0xF8, 0x3C, 0x07, 0x80, 0xF0, 0x7F,
  0xEF, 0xFD, 0xFF, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01,
  0xC0, 0x3C, 0x47, 0xF8, 0x7F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xCF, 0xBF, 0xF3, 0xEE, 0xE0,
  0x7E, 0x07, 0x70, 0x77, 0x0E, 0x30, 0xE3, 0x8C, 0x39, 0xC1, 0x9C, 0x1D,
  0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x00, 0xE3, 0x1D, 0x8C, 0x76, 0x39,
  0x9D, 0xE6, 0x77, 0x99, 0xDE, 0xE7, 0x7B, 0x8D, 0xBE, 0x34, 0xF0, 0xF3,
  0xC3, 0xCF, 0x0F, 0x1C, 0x18, 0x70, 0xF0, 0x7B, 0x87, 0x8E, 0x38, 0x7B,
  0x81, 0xFC, 0x07, 0xC0, 0x1C, 0x01, 0xF0, 0x1F, 0xC0, 0xEE, 0x0E, 0x38,
  0xE1, 0xEF, 0x07, 0x80, 0xE0, 0x3F, 0x03, 0xDC, 0x1C, 0xE0, 0xE7, 0x8E,
  0x1C, 0x70, 0xE7, 0x03, 0xB8, 0x1D, 0xC0, 0x7C, 0x03, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x00, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xF0, 0x02, 0x1C, 0x70, 0xE1, 0x83, 0x06,
  0x0C, 0x18, 0x71, 0xC7, 0x0F, 0x07, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xE1,
  0xC1, 0xC1, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0xE0, 0x70,
  0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1E, 0x0F, 0x1F, 0x3C, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0xF0, 0xE0, 0x18, 0x01, 0xF8, 0x77,
  0xF1, 0xB8, 0xFE, 0xC1, 0xF0, 0x01, 0x00,
};

const GFXglyph RobotoMono_SemiBold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 7, 6, 14, 3, -18 },
  { 16, 13, 17, 14, 1, -17 },
  { 44, 11, 22, 14, 2, -20 },
  { 75, 14, 17, 14, 0, -17 },
  { 105, 13, 17, 14, 1, -17 },
  { 133, 3, 6, 14, 5, -18 },
  { 136, 6, 24, 14, 4, -19 },
  { 154, 6, 24, 14, 4, -19 },
  { 172, 12, 12, 14, 2, -17 },
  { 190, 12, 12, 14, 1, -14 },
  { 208, 4, 8, 14, 4, -3 },
  { 212, 10, 3, 14, 3, -9 },
  { 216, 4, 4, 14, 5, -4 },
  { 218, 9, 18, 14, 3, -17 },
  { 239, 11, 17, 14, 2, -17 },
  { 263, 8, 17, 14, 2, -17 },
  { 280, 12, 17, 14, 1, -17 },
  { 306, 12, 17, 14, 1, -17 },
  { 332, 12, 17, 14, 1, -17 },
  { 358, 11, 17, 14, 2, -17 },
  { 382, 12, 17, 14, 1, -17 },
  { 408, 12, 17, 14, 1, -17 },
  { 434, 12, 17, 14, 1, -17 },
  { 460, 12, 17, 14, 1, -17 },
  { 486, 5, 14, 14, 5, -14 },
  { 495, 5, 19, 14, 5, -14 },
  { 507, 10, 11, 14, 2, -13 },
  { 521, 11, 7, 14, 2, -11 },
  { 531, 10, 11, 14, 2, -13 },
  { 545, 11, 17, 14, 2, -17 },
  { 569, 14, 17, 14, 0, -17 },
  { 599, 14, 17, 14, 0, -17 },
  { 629, 12, 17, 14, 2, -17 },
  { 655, 12, 17, 14, 1, -17 },
  { 681, 11, 17, 14, 2, -17 },
  { 705, 11, 17, 14, 2, -17 },
  { 729, 11, 17, 14, 2, -17 },
  { 753, 12, 17, 14, 1, -17 },
  { 779, 12, 17, 14, 1, -17 },
  { 805, 10, 17, 14, 2, -17 },
  { 827, 12, 17, 14, 1, -17 },
  { 853, 13, 17, 14, 2, -17 },
  { 881, 11, 17, 14, 2, -17 },
  { 905, 11, 17, 14, 2, -17 },
  { 929, 12, 17, 14, 1, -17 },
  { 955, 12, 17, 14, 1, -17 },
  { 981, 12, 17, 14, 2, -17 },
  { 1007, 13, 20, 14, 1, -17 },
  { 1040, 12, 17, 14, 2, -17 },
  { 1066, 13, 17, 14, 1, -17 },
  { 1094, 14, 17, 14, 0, -17 },
  { 1124, 11, 17, 14, 2, -17 },
  { 1148, 14, 17, 14, 0, -17 },
  { 1178, 14, 17, 14, 0, -17 },
  { 1208, 14, 17, 14, 0, -17 },
  { 1238, 14, 17, 14, 0, -17 },
  { 1268, 12, 17, 14, 1, -17 },
  { 1294, 5, 24, 14, 5, -20 },
  { 1309, 9, 18, 14, 3, -17 },
  { 1330, 5, 24, 14, 5, -20 },
  { 1345, 9, 9, 14, 3, -17 },
  { 1356, 10, 2, 14, 2, 0 },
  { 1359, 5, 3, 14, 5, -17 },
  { 1361, 12, 13, 14, 1, -13 },
  { 1381, 11, 18, 14, 2, -18 },
  { 1406, 12, 13, 14, 1, -13 },
  { 1426, 12, 18, 14, 1, -18 },
  { 1453, 12, 13, 14, 1, -13 },
  { 1473, 11, 19, 14, 2, -19 },
  { 1500, 12, 18, 14, 1, -13 },
  { 1527, 11, 18, 14, 2, -18 },
  { 1552, 11, 18, 14, 2, -18 },
  { 1577, 7, 23, 14, 3, -18 },
  { 1598, 12, 18, 14, 2, -18 },
  { 1625, 11, 18, 14, 2, -18 },
  { 1650, 12, 13, 14, 1, -13 },
  { 1670, 11, 13, 14, 2, -13 },
  { 1688, 12, 13, 14, 1, -13 },
  { 1708, 11, 18, 14, 2, -13 },
  { 1733, 12, 18, 14, 1, -13 },
  { 1760, 10, 13, 14, 3, -13 },
  { 1777, 11, 13, 14, 2, -13 },
  { 1795, 11, 16, 14, 2, -16 },
  { 1817, 11, 13, 14, 2, -13 },
  { 1835, 12, 13, 14, 1, -13 },
  { 1855, 14, 13, 14, 0, -13 },
  { 1878, 13, 13, 14, 1, -13 },
  { 1900, 13, 18, 14, 1, -13 },
  { 1930, 12, 13, 14, 1, -13 },
  { 1950, 7, 23, 14, 4, -19 },
  { 1971, 2, 22, 14, 6, -17 },
  { 1977, 8, 23, 14, 4, -19 },
  { 2000, 14, 6, 14, 0, -10 },
};

const GFXfont RobotoMono_SemiBold24pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold24pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOMONO_SEMIBOLD24PT7B_H_
