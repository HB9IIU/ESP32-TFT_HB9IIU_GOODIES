#ifndef _ROBOTOMONO_SEMIBOLD12PT7B_H_
#define _ROBOTOMONO_SEMIBOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xB6, 0x80, 0x14, 0x28, 0x93, 0xF2, 0x85, 0x3F, 0x24,
  0x58, 0x20, 0xCF, 0xB3, 0xC1, 0xC1, 0xA3, 0xCD, 0xE2, 0x00, 0x61, 0x5A,
  0xE3, 0x41, 0x02, 0x8A, 0x95, 0x0E, 0x10, 0xF1, 0xA3, 0xC3, 0x0E, 0x73,
  0xA6, 0x7E, 0xE0, 0x25, 0x2D, 0x24, 0xD9, 0x12, 0x91, 0x32, 0x49, 0x2D,
  0x68, 0x30, 0x8A, 0xDE, 0x31, 0x20, 0x21, 0x3F, 0xF2, 0x10, 0x5C, 0xF0,
  0xF0, 0x08, 0xC4, 0x23, 0x11, 0x8C, 0x46, 0x00, 0x37, 0xE3, 0x1B, 0xE6,
  0x39, 0x70, 0x17, 0xF3, 0x33, 0x33, 0x30, 0x31, 0xFC, 0x43, 0x08, 0x63,
  0x18, 0x7C, 0x77, 0xE2, 0x37, 0x0C, 0x31, 0xF0, 0x0C, 0x38, 0x71, 0x66,
  0xC9, 0xBF, 0x86, 0x0C, 0xFF, 0xF1, 0xEF, 0x84, 0x39, 0x78, 0x13, 0xB1,
  0x6F, 0xC6, 0x3B, 0x70, 0xFF, 0xF0, 0xC2, 0x08, 0x61, 0x0C, 0x60, 0x77,
  0xE3, 0x97, 0x6E, 0x39, 0x78, 0x67, 0xE3, 0x18, 0xFC, 0x22, 0x60, 0xF0,
  0x3C, 0xF0, 0x0F, 0x80, 0x1F, 0xB0, 0xF0, 0x80, 0xFF, 0xC1, 0xF0, 0xC3,
  0xC7, 0xE8, 0x00, 0x37, 0xF2, 0x11, 0x18, 0x04, 0x30, 0x3C, 0xB6, 0xAD,
  0x5A, 0xB7, 0x90, 0x1C, 0x10, 0x30, 0xE1, 0x42, 0xCC, 0x9F, 0x23, 0xC6,
  0xE3, 0xE8, 0xE2, 0xFA, 0x38, 0xE3, 0xF8, 0x18, 0xF9, 0x1A, 0x0C, 0x08,
  0x11, 0xB2, 0x3C, 0xC3, 0xE8, 0xA3, 0x8E, 0x38, 0xA6, 0xF0, 0xFF, 0xF8,
  0x20, 0xFA, 0x08, 0x20, 0xFC, 0xFF, 0xF8, 0x20, 0xFA, 0x08, 0x20, 0x80,
  0x33, 0xE8, 0xE0, 0x82, 0x78, 0xF3, 0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31,
  0x88, 0xFF, 0xC8, 0x42, 0x10, 0x84, 0xF8, 0x08, 0x42, 0x10, 0x86, 0x33,
  0x70, 0x8E, 0x29, 0xAC, 0xE3, 0xC9, 0xA2, 0x8C, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0xFC, 0xCF, 0x7D, 0xF7, 0xBE, 0xB8, 0xE3, 0x8C, 0x8E, 0x73,
  0xDA, 0xDE, 0x73, 0x88, 0x18, 0xF9, 0x12, 0x3C, 0x68, 0xD1, 0xB6, 0x38,
  0xE3, 0xE8, 0xE3, 0x9B, 0xC8, 0x20, 0x80, 0x33, 0xE8, 0xA3, 0x8E, 0x38,
  0xF2, 0x78, 0x30, 0x40, 0xE3, 0xE8, 0xE3, 0xFB, 0xC9, 0xA2, 0x8C, 0x33,
  0xE8, 0xF0, 0x70, 0x68, 0xF3, 0x78, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x8C, 0x63, 0x18, 0xC6, 0x3B, 0x70, 0xC6, 0x8D, 0x13, 0x66,
  0xC5, 0x0E, 0x1C, 0x18, 0xD3, 0xA7, 0x5A, 0xF6, 0xED, 0x9B, 0x36, 0x6C,
  0xC6, 0xC9, 0xB1, 0xC1, 0x87, 0x0B, 0x32, 0xC6, 0xC6, 0x8D, 0x91, 0x63,
  0x83, 0x04, 0x08, 0x10, 0xFF, 0xE1, 0x84, 0x31, 0x84, 0x30, 0xFC, 0xFB,
  0x6D, 0xB6, 0xDB, 0x70, 0xC2, 0x18, 0xC2, 0x18, 0x42, 0x18, 0x40, 0xED,
  0xB6, 0xDB, 0x6D, 0xF0, 0x21, 0x94, 0xAC, 0x80, 0xF8, 0xC4, 0xFC, 0x5F,
  0x19, 0xFC, 0x82, 0x08, 0x3E, 0x8A, 0x38, 0xB2, 0xF8, 0xFC, 0x61, 0x0C,
  0xBC, 0x08, 0x43, 0xF8, 0xC6, 0x39, 0x78, 0x7B, 0x2F, 0xE0, 0xC9, 0xE0,
  0x3C, 0x86, 0x3E, 0x61, 0x86, 0x18, 0x60, 0xFC, 0x63, 0x1C, 0xBC, 0x3F,
  0x20, 0x84, 0x21, 0xF8, 0xC6, 0x31, 0x88, 0x31, 0x81, 0xE3, 0x18, 0xC6,
  0xF8, 0x13, 0x07, 0x33, 0x33, 0x33, 0xF4, 0x82, 0x08, 0x66, 0xB3, 0x8F,
  0x26, 0x8C, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0xFF, 0xAF, 0x5E,
  0xBD, 0x7A, 0xC0, 0xFC, 0x63, 0x18, 0xC4, 0xFA, 0x28, 0xE3, 0xC9, 0xC0,
  0xFA, 0x28, 0xE2, 0xCB, 0xE8, 0x20, 0xFC, 0x63, 0x1C, 0xBC, 0x21, 0xFE,
  0x21, 0x08, 0x40, 0xFC, 0x7C, 0x38, 0xBC, 0x63, 0x3E, 0xC6, 0x31, 0x87,
  0x8C, 0x63, 0x1C, 0xBC, 0xC6, 0xC8, 0xB1, 0x43, 0x82, 0x00, 0xD6, 0xAD,
  0xB3, 0x66, 0xCD, 0x80, 0xCD, 0xE3, 0x1C, 0x5B, 0x30, 0xC6, 0xC8, 0xB1,
  0xC3, 0x83, 0x04, 0x38, 0x40, 0xF8, 0x63, 0x18, 0xC3, 0xF0, 0x36, 0x66,
  0x4C, 0x66, 0x62, 0x30, 0xFF, 0xE0, 0xC4, 0x44, 0x63, 0x64, 0x44, 0xC0,
  0x65, 0xFC, 0x30,
};

const GFXglyph RobotoMono_SemiBold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 9, 7, 3, -9 },
  { 3, 3, 3, 7, 2, -9 },
  { 5, 7, 9, 7, 0, -9 },
  { 13, 6, 11, 7, 1, -10 },
  { 22, 7, 9, 7, 0, -9 },
  { 30, 7, 9, 7, 0, -9 },
  { 38, 1, 3, 7, 3, -9 },
  { 39, 3, 13, 7, 2, -10 },
  { 44, 3, 13, 7, 2, -10 },
  { 49, 6, 6, 7, 1, -9 },
  { 54, 5, 6, 7, 1, -7 },
  { 58, 2, 3, 7, 2, -1 },
  { 59, 4, 1, 7, 2, -4 },
  { 60, 2, 2, 7, 3, -2 },
  { 61, 5, 10, 7, 1, -9 },
  { 68, 5, 9, 7, 1, -9 },
  { 74, 4, 9, 7, 1, -9 },
  { 79, 6, 9, 7, 0, -9 },
  { 86, 5, 9, 7, 1, -9 },
  { 92, 7, 9, 7, 0, -9 },
  { 100, 5, 9, 7, 1, -9 },
  { 106, 5, 9, 7, 1, -9 },
  { 112, 6, 9, 7, 0, -9 },
  { 119, 5, 9, 7, 1, -9 },
  { 125, 5, 9, 7, 1, -9 },
  { 131, 2, 7, 7, 3, -7 },
  { 133, 2, 9, 7, 3, -7 },
  { 136, 5, 5, 7, 1, -6 },
  { 140, 5, 4, 7, 1, -6 },
  { 143, 5, 5, 7, 1, -6 },
  { 147, 5, 9, 7, 1, -9 },
  { 153, 7, 8, 7, 0, -8 },
  { 160, 7, 9, 7, 0, -9 },
  { 168, 6, 9, 7, 1, -9 },
  { 175, 7, 9, 7, 0, -9 },
  { 183, 6, 9, 7, 1, -9 },
  { 190, 6, 9, 7, 1, -9 },
  { 197, 6, 9, 7, 1, -9 },
  { 204, 6, 9, 7, 1, -9 },
  { 211, 5, 9, 7, 1, -9 },
  { 217, 5, 9, 7, 1, -9 },
  { 223, 5, 9, 7, 1, -9 },
  { 229, 6, 9, 7, 1, -9 },
  { 236, 6, 9, 7, 1, -9 },
  { 243, 6, 9, 7, 1, -9 },
  { 250, 5, 9, 7, 1, -9 },
  { 256, 7, 9, 7, 0, -9 },
  { 264, 6, 9, 7, 1, -9 },
  { 271, 6, 11, 7, 1, -9 },
  { 280, 6, 9, 7, 1, -9 },
  { 287, 6, 9, 7, 1, -9 },
  { 294, 7, 9, 7, 0, -9 },
  { 302, 5, 9, 7, 1, -9 },
  { 308, 7, 9, 7, 0, -9 },
  { 316, 7, 9, 7, 0, -9 },
  { 324, 7, 9, 7, 0, -9 },
  { 332, 7, 9, 7, 0, -9 },
  { 340, 6, 9, 7, 1, -9 },
  { 347, 3, 12, 7, 2, -10 },
  { 352, 5, 10, 7, 1, -9 },
  { 359, 3, 12, 7, 2, -10 },
  { 364, 5, 5, 7, 1, -9 },
  { 368, 5, 1, 7, 1, 0 },
  { 369, 3, 2, 7, 2, -9 },
  { 370, 5, 6, 7, 1, -6 },
  { 374, 6, 9, 7, 1, -9 },
  { 381, 5, 6, 7, 1, -6 },
  { 385, 5, 9, 7, 1, -9 },
  { 391, 6, 6, 7, 1, -6 },
  { 396, 6, 9, 7, 1, -9 },
  { 403, 5, 9, 7, 1, -6 },
  { 409, 5, 9, 7, 1, -9 },
  { 415, 5, 9, 7, 1, -9 },
  { 421, 4, 12, 7, 1, -9 },
  { 427, 6, 9, 7, 1, -9 },
  { 434, 6, 9, 7, 1, -9 },
  { 441, 7, 6, 7, 0, -6 },
  { 447, 5, 6, 7, 1, -6 },
  { 451, 6, 6, 7, 1, -6 },
  { 456, 6, 8, 7, 1, -6 },
  { 462, 5, 8, 7, 1, -6 },
  { 467, 5, 6, 7, 2, -6 },
  { 471, 5, 6, 7, 1, -6 },
  { 475, 5, 8, 7, 1, -8 },
  { 480, 5, 6, 7, 1, -6 },
  { 484, 7, 6, 7, 0, -6 },
  { 490, 7, 6, 7, 0, -6 },
  { 496, 6, 6, 7, 1, -6 },
  { 501, 7, 9, 7, 0, -6 },
  { 509, 6, 6, 7, 1, -6 },
  { 514, 4, 11, 7, 2, -9 },
  { 520, 1, 11, 7, 3, -9 },
  { 522, 4, 11, 7, 2, -9 },
  { 528, 7, 3, 7, 0, -5 },
};

const GFXfont RobotoMono_SemiBold12pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold12pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOMONO_SEMIBOLD12PT7B_H_
