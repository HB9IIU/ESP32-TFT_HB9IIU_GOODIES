#ifndef _ROBOTOMONO_SEMIBOLD25PT7B_H_
#define _ROBOTOMONO_SEMIBOLD25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0x80, 0x06, 0x60, 0x73, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x7F,
  0xFF, 0xFF, 0xE3, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x31, 0xFF, 0xEF, 0xFF,
  0x18, 0xC0, 0xC6, 0x06, 0x30, 0x33, 0x83, 0x98, 0x00, 0x06, 0x00, 0x60,
  0x06, 0x01, 0xF8, 0x3F, 0xC7, 0xFE, 0xF0, 0xEE, 0x0F, 0xF0, 0x77, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0xE0, 0x0F, 0xE0, 0x7E, 0x0F,
  0xF9, 0xE7, 0xFE, 0x3F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x00, 0xFC,
  0x01, 0x98, 0x87, 0x31, 0x8E, 0x66, 0x0C, 0xCC, 0x1F, 0xB0, 0x1C, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0xC0, 0x37, 0xE0, 0x6C, 0xC1, 0x99, 0xC7,
  0x33, 0x84, 0x66, 0x00, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0x7F, 0x03, 0xFC,
  0x0E, 0x70, 0x38, 0xC0, 0xE7, 0x03, 0xB8, 0x0F, 0xC0, 0x1E, 0x00, 0xF8,
  0x77, 0xF1, 0xBD, 0xE6, 0xE3, 0xFB, 0x87, 0xEE, 0x0F, 0x3C, 0x7C, 0x7F,
  0xF8, 0xFE, 0xF0, 0xFF, 0xFC, 0x02, 0x1C, 0x30, 0xC3, 0x86, 0x1C, 0x38,
  0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xC1, 0xC3, 0x83, 0x07,
  0x07, 0x06, 0x06, 0x04, 0x81, 0x83, 0x83, 0x83, 0x87, 0x07, 0x0E, 0x1C,
  0x18, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xC3, 0x86, 0x1C,
  0x70, 0xC1, 0x00, 0x06, 0x00, 0x60, 0x06, 0x08, 0x60, 0xE6, 0x7F, 0xFF,
  0x3F, 0xC0, 0xF0, 0x1F, 0x01, 0x98, 0x39, 0xC7, 0x0E, 0x10, 0x80, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7B, 0xDE, 0xE7, 0x3B, 0x88,
  0xFF, 0xFF, 0xF0, 0x77, 0xFE, 0xE0, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0x1F, 0x07, 0xF1, 0xFF, 0x78,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x1F, 0xE7, 0xFD, 0xDF, 0xE3, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3B, 0xCE, 0x7F, 0xC7, 0xF0, 0x01, 0x0F, 0x7F, 0xFF,
  0xF7, 0x87, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x83, 0xFE, 0x7F, 0xE7, 0x0F, 0xF0,
  0x70, 0x07, 0x00, 0xF0, 0x1E, 0x0F, 0xC0, 0xFC, 0x00, 0xE0, 0x07, 0x00,
  0x7E, 0x07, 0xF0, 0x77, 0x9F, 0x7F, 0xE1, 0xF8, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x77, 0x83, 0xBC, 0x39, 0xE3, 0x8F,
  0x1C, 0x79, 0xC3, 0xCF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xB8, 0x07, 0x00, 0xC0, 0x39, 0x87,
  0xFC, 0xFF, 0xCC, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0xC1, 0xF8, 0x3F, 0x8F,
  0x7F, 0xC7, 0xF0, 0x03, 0xC0, 0xFC, 0x1F, 0xC3, 0xC0, 0x38, 0x07, 0x00,
  0x73, 0x87, 0xFE, 0xFF, 0xEF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x07,
  0x70, 0x77, 0xDE, 0x3F, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x0F, 0x83, 0xFE,
  0x7F, 0xE7, 0x0F, 0x70, 0x77, 0x07, 0x70, 0xF3, 0xDE, 0x1F, 0xC3, 0xFC,
  0x78, 0xE7, 0x07, 0x70, 0x7F, 0x07, 0x70, 0x77, 0x8F, 0x3F, 0xE1, 0xFC,
  0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x07,
  0x70, 0x77, 0x9F, 0x3F, 0xF1, 0xF7, 0x00, 0xE0, 0x0E, 0x01, 0xE1, 0xFC,
  0x1F, 0x81, 0xE0, 0xEF, 0xFF, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0x3B, 0xDE,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x73, 0x9C, 0xEE, 0x77, 0x08, 0x00, 0xE0,
  0x7C, 0x3F, 0xBF, 0x8F, 0x81, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3C,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0x03, 0xF8, 0x0F, 0xE0, 0x3E, 0x03, 0xC3, 0xFB, 0xFC,
  0xFC, 0x1E, 0x03, 0x00, 0x00, 0x1F, 0x8F, 0xF9, 0xFF, 0xF8, 0x7E, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0xFF, 0x0E, 0x1C, 0xE0,
  0x66, 0x39, 0xE7, 0xEF, 0x33, 0x7B, 0x1B, 0xD8, 0xCE, 0xC4, 0xE6, 0x27,
  0xB3, 0x3D, 0xFF, 0x67, 0x73, 0x80, 0x0E, 0x00, 0x3F, 0xC0, 0xFC, 0x00,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xDC, 0x03,
  0xB8, 0x07, 0x30, 0x0E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x0E, 0x07, 0x3C, 0x0E, 0x70, 0x1D, 0xE0, 0x3C, 0xFF, 0x0F,
  0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x1E, 0xFF, 0xCF,
  0xFE, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xEF,
  0xF8, 0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xE0, 0xE7, 0x07, 0xF0, 0x1F, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x03, 0xF8, 0x1D,
  0xC1, 0xCF, 0x9E, 0x3F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xF8, 0xFF, 0xCE,
  0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xFE, 0x0E, 0xE1, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xCF,
  0xFC, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x80, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x07,
  0xF8, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F,
  0x03, 0xB8, 0x1D, 0xC0, 0xEF, 0x9F, 0x3F, 0xF0, 0x7F, 0x00, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0xFF,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0x07, 0x70, 0xF7, 0x9E,
  0x3F, 0xE1, 0xF8, 0xE0, 0x7F, 0x07, 0xB8, 0x79, 0xC3, 0x8E, 0x3C, 0x73,
  0xC3, 0xBC, 0x1D, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xEF, 0x0E, 0x3C,
  0x70, 0xE3, 0x87, 0x9C, 0x1E, 0xE0, 0xF7, 0x03, 0xC0, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xFB, 0xFD, 0xB7, 0xDB, 0x7D, 0xF7,
  0xCE, 0x7E, 0xE7, 0xEE, 0x7E, 0xE7, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xF1, 0xFF,
  0x3F, 0xE7, 0xEE, 0xFD, 0xDF, 0x9B, 0xF3, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x1C, 0x0F, 0x81, 0xFF, 0x0F, 0xF8, 0xE1, 0xE7, 0x07,
  0x70, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xF8, 0x39, 0xC1, 0xCF, 0xBE, 0x3F, 0xE0, 0xFC, 0x00, 0xFF, 0x0F,
  0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE1, 0xFF,
  0xFE, 0xFF, 0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x0F, 0x80, 0xFF, 0x83, 0xFE, 0x1C, 0x1C, 0x70, 0x7B, 0xC0, 0xEE,
  0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B,
  0xC1, 0xE7, 0x07, 0x1F, 0x7C, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x10, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0,
  0x7E, 0x0F, 0xE3, 0xEF, 0xFC, 0xFF, 0x8E, 0x38, 0xE3, 0xCE, 0x1C, 0xE1,
  0xEE, 0x0E, 0xE0, 0xFE, 0x07, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xE0, 0xF7,
  0x03, 0xB8, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0xEF, 0x9F, 0x3F, 0xF0, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xDF, 0x7F, 0xC7, 0xF0, 0xF0, 0x1E,
  0xE0, 0x39, 0xE0, 0xF3, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x0F, 0x1E, 0x0E,
  0x38, 0x1C, 0x70, 0x38, 0xE0, 0x3B, 0x80, 0x77, 0x00, 0xEE, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0xE3, 0x8E, 0xE7, 0x1D,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7B, 0x9D, 0xF7, 0x3B, 0x6E, 0x36,
  0xDC, 0x6D, 0xB0, 0xFB, 0x61, 0xF7, 0xC3, 0xEF, 0x87, 0x8F, 0x0F, 0x1E,
  0x1E, 0x3C, 0x1C, 0x70, 0x38, 0xE0, 0xF0, 0x3F, 0xC1, 0xE7, 0x87, 0x1E,
  0x3C, 0x3C, 0xE0, 0x77, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xF0, 0x1D, 0xE0, 0xF3, 0x83, 0x8F, 0x1E, 0x1C, 0xF0, 0x7B,
  0xC0, 0xF0, 0xF0, 0x1E, 0xF0, 0x38, 0xE0, 0xF1, 0xC1, 0xC1, 0xC7, 0x83,
  0x8E, 0x07, 0x9C, 0x07, 0x70, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xF8, 0xE0, 0x38,
  0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0xFF,
  0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xFF, 0xF8, 0x1C, 0x07, 0x01, 0xE0, 0xF8, 0x37, 0x1D, 0xC6, 0x31,
  0x8E, 0xE1, 0xB0, 0x70, 0xFF, 0xFF, 0xFC, 0xF1, 0xE3, 0xC0, 0x3F, 0x8F,
  0xFB, 0x87, 0xF0, 0x70, 0x0E, 0x7F, 0xDF, 0xFF, 0x07, 0xE0, 0xFC, 0x1F,
  0xCF, 0xFF, 0xF7, 0xEE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xEF, 0x8F, 0xFC, 0xF1, 0xEE, 0x0E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xEE, 0x0E, 0xF9, 0xEF, 0xFC, 0xEF, 0x80, 0x1F, 0xC3, 0xFE,
  0x78, 0xF7, 0x07, 0x70, 0x77, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x07,
  0x7C, 0xF3, 0xFE, 0x1F, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x1F, 0x73, 0xFF, 0x78, 0xF7, 0x07, 0x70, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0x70, 0x77, 0x07, 0x7D, 0xF3, 0xFF, 0x1F, 0x70, 0x1F, 0xC1,
  0xFF, 0x1E, 0x3C, 0xE0, 0xE7, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70,
  0x03, 0xC1, 0x1F, 0x3C, 0x7F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x0F,
  0x11, 0xE0, 0x1C, 0x01, 0xC0, 0xFF, 0xEF, 0xFE, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x00, 0x1F, 0xF3, 0xFF, 0x78, 0xF7, 0x07, 0x70, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0x70, 0x77, 0x07, 0x7C, 0xF3, 0xFF, 0x1F, 0x70, 0x07, 0x20, 0x73,
  0x9F, 0x7F, 0xE1, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3B, 0xF7, 0xFF, 0xF1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0x80, 0x1E, 0x07, 0x80, 0xC0, 0x00,
  0x00, 0x3F, 0x8F, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x0F, 0x0E, 0x00, 0x00, 0x7E,
  0x7E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1E, 0xFE, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xE1, 0xEE, 0x3C, 0xE7, 0x8E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFF,
  0x0F, 0x70, 0xE7, 0x8E, 0x3C, 0xE1, 0xEE, 0x1E, 0xE0, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0xF7, 0xFF, 0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0xF3,
  0x9F, 0x9C, 0xFC, 0xE7, 0xE7, 0x3F, 0x39, 0xF9, 0xCF, 0xCE, 0x7E, 0x73,
  0x80, 0xEF, 0xDF, 0xFF, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0x1F, 0xC1, 0xFF, 0x1E, 0x3C,
  0xE0, 0xEF, 0x07, 0x70, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x73, 0x83, 0x9F,
  0x7C, 0x7F, 0xC1, 0xFC, 0x00, 0xFF, 0x8F, 0xFC, 0xF1, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x0E, 0xF3, 0xEF, 0xFC, 0xEF,
  0x8E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1F, 0xF3, 0xFF, 0x78,
  0xF7, 0x07, 0x70, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77, 0x07, 0x7C,
  0xF3, 0xFF, 0x1F, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xEF,
  0xFF, 0xEF, 0xFB, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x00, 0x3F, 0x8F, 0xFF, 0xC3, 0xF0, 0x7F, 0x00, 0xFC,
  0x0F, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC3, 0xBF, 0xF3, 0xF8, 0x1C, 0x03,
  0x80, 0x70, 0x7F, 0xFF, 0xFE, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x47, 0xF8, 0x7F, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xCF, 0xBF,
  0xF3, 0xEE, 0xE0, 0x3B, 0x83, 0x9C, 0x1C, 0xE0, 0xE3, 0x8E, 0x1C, 0x70,
  0x63, 0x03, 0xB8, 0x1D, 0xC0, 0x6C, 0x03, 0xE0, 0x1F, 0x00, 0x70, 0x00,
  0xE3, 0x9D, 0xCE, 0x77, 0x39, 0xDC, 0xE7, 0x77, 0x9D, 0xDB, 0x63, 0x6D,
  0x8D, 0xB6, 0x36, 0xF8, 0xF3, 0xE3, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0xF0,
  0x7B, 0xC3, 0x8F, 0x38, 0x3B, 0xC0, 0xFC, 0x07, 0xC0, 0x1E, 0x01, 0xF8,
  0x1F, 0xC0, 0xEF, 0x0E, 0x3C, 0xF0, 0xEF, 0x03, 0x80, 0xE0, 0x3F, 0xC0,
  0xE7, 0x07, 0x9E, 0x1C, 0x38, 0xF0, 0xE3, 0x81, 0xCE, 0x07, 0x70, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x7C, 0x01, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0x07, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38,
  0xF8, 0xE0, 0xF8, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0xE0, 0x70, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x1C, 0x1F, 0x07, 0x1F, 0x1C, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x30, 0xF0, 0xE0, 0x3C, 0x01, 0xFC, 0x37, 0xF9,
  0xF8, 0xFE, 0x40, 0xF8,
};

const GFXglyph RobotoMono_SemiBold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 18, 15, 6, -18 },
  { 8, 7, 7, 15, 4, -19 },
  { 15, 13, 18, 15, 1, -18 },
  { 45, 12, 24, 15, 2, -21 },
  { 81, 15, 18, 15, 0, -18 },
  { 115, 14, 18, 15, 1, -18 },
  { 147, 2, 7, 15, 6, -19 },
  { 149, 7, 26, 15, 4, -20 },
  { 172, 7, 26, 15, 4, -20 },
  { 195, 12, 13, 15, 2, -18 },
  { 215, 12, 13, 15, 1, -15 },
  { 235, 5, 8, 15, 4, -3 },
  { 240, 10, 2, 15, 3, -9 },
  { 243, 5, 4, 15, 5, -4 },
  { 246, 10, 20, 15, 3, -18 },
  { 271, 11, 18, 15, 2, -18 },
  { 296, 8, 18, 15, 2, -18 },
  { 314, 12, 18, 15, 1, -18 },
  { 341, 12, 18, 15, 1, -18 },
  { 368, 13, 18, 15, 1, -18 },
  { 398, 11, 18, 15, 2, -18 },
  { 423, 12, 18, 15, 1, -18 },
  { 450, 12, 18, 15, 1, -18 },
  { 477, 12, 18, 15, 1, -18 },
  { 504, 12, 18, 15, 1, -18 },
  { 531, 4, 14, 15, 6, -14 },
  { 538, 5, 19, 15, 5, -14 },
  { 550, 11, 11, 15, 2, -13 },
  { 566, 11, 8, 15, 2, -12 },
  { 577, 11, 11, 15, 2, -13 },
  { 593, 11, 18, 15, 2, -18 },
  { 618, 13, 18, 15, 1, -18 },
  { 648, 15, 18, 15, 0, -18 },
  { 682, 12, 18, 15, 2, -18 },
  { 709, 13, 18, 15, 1, -18 },
  { 739, 12, 18, 15, 2, -18 },
  { 766, 12, 18, 15, 2, -18 },
  { 793, 12, 18, 15, 2, -18 },
  { 820, 13, 18, 15, 1, -18 },
  { 850, 11, 18, 15, 2, -18 },
  { 875, 11, 18, 15, 2, -18 },
  { 900, 12, 18, 15, 1, -18 },
  { 927, 13, 18, 15, 2, -18 },
  { 957, 12, 18, 15, 2, -18 },
  { 984, 12, 18, 15, 2, -18 },
  { 1011, 11, 18, 15, 2, -18 },
  { 1036, 13, 18, 15, 1, -18 },
  { 1066, 12, 18, 15, 2, -18 },
  { 1093, 14, 21, 15, 1, -18 },
  { 1130, 12, 18, 15, 2, -18 },
  { 1157, 13, 18, 15, 1, -18 },
  { 1187, 15, 18, 15, 0, -18 },
  { 1221, 11, 18, 15, 2, -18 },
  { 1246, 15, 18, 15, 0, -18 },
  { 1280, 15, 18, 15, 0, -18 },
  { 1314, 14, 18, 15, 1, -18 },
  { 1346, 15, 18, 15, 0, -18 },
  { 1380, 13, 18, 15, 1, -18 },
  { 1410, 5, 25, 15, 5, -21 },
  { 1426, 10, 20, 15, 3, -18 },
  { 1451, 5, 25, 15, 5, -21 },
  { 1467, 10, 10, 15, 3, -18 },
  { 1480, 11, 2, 15, 2, 0 },
  { 1483, 6, 3, 15, 5, -18 },
  { 1486, 11, 13, 15, 2, -13 },
  { 1504, 12, 19, 15, 2, -19 },
  { 1533, 12, 13, 15, 1, -13 },
  { 1553, 12, 19, 15, 1, -19 },
  { 1582, 13, 13, 15, 1, -13 },
  { 1604, 12, 19, 15, 2, -19 },
  { 1633, 12, 18, 15, 1, -13 },
  { 1660, 11, 19, 15, 2, -19 },
  { 1687, 10, 18, 15, 3, -18 },
  { 1710, 8, 23, 15, 3, -18 },
  { 1733, 12, 19, 15, 2, -19 },
  { 1762, 12, 19, 15, 2, -19 },
  { 1791, 13, 13, 15, 1, -13 },
  { 1813, 11, 13, 15, 2, -13 },
  { 1831, 13, 13, 15, 1, -13 },
  { 1853, 12, 18, 15, 2, -13 },
  { 1880, 12, 18, 15, 1, -13 },
  { 1907, 10, 13, 15, 4, -13 },
  { 1924, 11, 13, 15, 2, -13 },
  { 1942, 11, 16, 15, 2, -16 },
  { 1964, 11, 13, 15, 2, -13 },
  { 1982, 13, 13, 15, 1, -13 },
  { 2004, 14, 13, 15, 0, -13 },
  { 2027, 13, 13, 15, 1, -13 },
  { 2049, 14, 18, 15, 1, -13 },
  { 2081, 12, 13, 15, 2, -13 },
  { 2101, 8, 24, 15, 4, -20 },
  { 2125, 2, 23, 15, 7, -18 },
  { 2131, 8, 24, 15, 4, -20 },
  { 2155, 14, 5, 15, 0, -10 },
};

const GFXfont RobotoMono_SemiBold25pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold25pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOMONO_SEMIBOLD25PT7B_H_
