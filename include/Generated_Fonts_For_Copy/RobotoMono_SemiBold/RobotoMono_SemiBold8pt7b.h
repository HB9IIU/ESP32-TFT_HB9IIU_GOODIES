#ifndef _ROBOTOMONO_SEMIBOLD8PT7B_H_
#define _ROBOTOMONO_SEMIBOLD8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x32, 0xBE, 0xAE, 0x30, 0x5E, 0xC7, 0x7A, 0xC6, 0x98,
  0x66, 0x8C, 0x62, 0x98, 0xDB, 0x3C, 0xC0, 0x6A, 0x48, 0x91, 0x95, 0x56,
  0x4D, 0x6A, 0x22, 0xF2, 0x58, 0xE0, 0x80, 0x25, 0x25, 0x00, 0xD6, 0xFB,
  0xC0, 0x75, 0x50, 0x69, 0x12, 0x4F, 0x6D, 0x13, 0x97, 0x13, 0x55, 0xF1,
  0xF3, 0x1B, 0xC0, 0x24, 0x7D, 0x57, 0xF1, 0x12, 0x24, 0x65, 0x57, 0xD7,
  0x65, 0x97, 0x16, 0x90, 0x9C, 0x71, 0x80, 0xE3, 0x80, 0xC7, 0x00, 0xF4,
  0xA0, 0x80, 0x33, 0x77, 0xAB, 0x30, 0x21, 0x14, 0xA7, 0x44, 0xEA, 0xAE,
  0x9E, 0x75, 0x88, 0x97, 0xD6, 0xDB, 0xC0, 0xF2, 0x79, 0xC0, 0xF2, 0x79,
  0x00, 0x75, 0x8B, 0xD7, 0xDD, 0xDF, 0xDD, 0xE9, 0x25, 0xC0, 0x11, 0x11,
  0x97, 0xBA, 0xCC, 0xAB, 0x92, 0x49, 0xC0, 0xB7, 0xFB, 0x40, 0xDD, 0xFF,
  0xDD, 0x65, 0x99, 0x97, 0xCA, 0xBE, 0x88, 0x62, 0xA5, 0x39, 0x38, 0x60,
  0xCA, 0xAE, 0xAB, 0x72, 0xD0, 0x69, 0xB8, 0xF9, 0x08, 0x42, 0x10, 0x55,
  0x55, 0xD7, 0x9A, 0x94, 0xA6, 0x10, 0xAD, 0x6C, 0xA5, 0x28, 0x9A, 0x98,
  0x45, 0x6C, 0x8A, 0x94, 0x42, 0x10, 0xF1, 0x22, 0x4F, 0xFF, 0x91, 0x24,
  0x40, 0xFF, 0x5A, 0x80, 0xE0, 0x80, 0x73, 0xD7, 0x93, 0xDB, 0xC0, 0x7C,
  0x47, 0x11, 0x79, 0x57, 0x7F, 0x47, 0x6B, 0xA4, 0x80, 0x7D, 0x57, 0x56,
  0x93, 0xDB, 0x40, 0x43, 0x25, 0xC0, 0x4D, 0x57, 0x88, 0xEC, 0xCB, 0xC9,
  0x25, 0xC0, 0xFB, 0xBB, 0xF6, 0xD0, 0x79, 0x97, 0xF6, 0xF9, 0x00, 0x79,
  0x57, 0x11, 0xF2, 0x40, 0xF8, 0xF0, 0x6F, 0x66, 0x30, 0xB6, 0xF0, 0xDA,
  0x98, 0x40, 0xAD, 0x94, 0xA0, 0xD9, 0x1D, 0xB0, 0xDA, 0x94, 0x42, 0x20,
  0x72, 0x4F, 0x69, 0x44, 0x98, 0xFF, 0xC9, 0x14, 0xB0, 0xE8, 0x80,
};

const GFXglyph RobotoMono_SemiBold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 3, 8, 5, 1, -7 },
  { 10, 5, 6, 5, 0, -6 },
  { 14, 5, 6, 5, 0, -6 },
  { 18, 1, 2, 5, 2, -6 },
  { 19, 3, 8, 5, 1, -6 },
  { 22, 2, 8, 5, 1, -6 },
  { 24, 4, 4, 5, 1, -6 },
  { 26, 4, 4, 5, 0, -5 },
  { 28, 2, 3, 5, 1, -1 },
  { 29, 3, 1, 5, 1, -3 },
  { 30, 1, 1, 5, 2, -1 },
  { 31, 3, 6, 5, 1, -6 },
  { 34, 3, 6, 5, 1, -6 },
  { 37, 2, 6, 5, 1, -6 },
  { 39, 4, 6, 5, 0, -6 },
  { 42, 4, 6, 5, 0, -6 },
  { 45, 4, 6, 5, 0, -6 },
  { 48, 3, 6, 5, 1, -6 },
  { 51, 4, 6, 5, 0, -6 },
  { 54, 4, 6, 5, 0, -6 },
  { 57, 4, 6, 5, 0, -6 },
  { 60, 4, 6, 5, 0, -6 },
  { 63, 1, 4, 5, 2, -4 },
  { 64, 1, 6, 5, 2, -4 },
  { 65, 3, 3, 5, 1, -4 },
  { 67, 3, 3, 5, 1, -4 },
  { 69, 3, 3, 5, 1, -4 },
  { 71, 3, 6, 5, 1, -6 },
  { 74, 5, 6, 5, 0, -6 },
  { 78, 5, 6, 5, 0, -6 },
  { 82, 4, 6, 5, 1, -6 },
  { 85, 4, 6, 5, 0, -6 },
  { 88, 3, 6, 5, 1, -6 },
  { 91, 3, 6, 5, 1, -6 },
  { 94, 3, 6, 5, 1, -6 },
  { 97, 4, 6, 5, 0, -6 },
  { 100, 4, 6, 5, 0, -6 },
  { 103, 3, 6, 5, 1, -6 },
  { 106, 4, 6, 5, 0, -6 },
  { 109, 4, 6, 5, 1, -6 },
  { 112, 3, 6, 5, 1, -6 },
  { 115, 3, 6, 5, 1, -6 },
  { 118, 4, 6, 5, 0, -6 },
  { 121, 4, 6, 5, 0, -6 },
  { 124, 4, 6, 5, 1, -6 },
  { 127, 5, 7, 5, 0, -6 },
  { 132, 4, 6, 5, 1, -6 },
  { 135, 5, 6, 5, 0, -6 },
  { 139, 5, 6, 5, 0, -6 },
  { 143, 4, 6, 5, 0, -6 },
  { 146, 5, 6, 5, 0, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 5, 6, 5, 0, -6 },
  { 162, 4, 6, 5, 0, -6 },
  { 165, 1, 8, 5, 2, -7 },
  { 166, 3, 6, 5, 1, -6 },
  { 169, 1, 8, 5, 2, -7 },
  { 170, 3, 3, 5, 1, -6 },
  { 172, 3, 1, 5, 1, 0 },
  { 173, 1, 1, 5, 2, -6 },
  { 174, 4, 4, 5, 0, -4 },
  { 176, 3, 6, 5, 1, -6 },
  { 179, 4, 4, 5, 0, -4 },
  { 181, 4, 6, 5, 0, -6 },
  { 184, 4, 4, 5, 0, -4 },
  { 186, 3, 6, 5, 1, -6 },
  { 189, 4, 6, 5, 0, -4 },
  { 192, 3, 6, 5, 1, -6 },
  { 195, 3, 6, 5, 1, -6 },
  { 198, 2, 8, 5, 1, -6 },
  { 200, 4, 6, 5, 1, -6 },
  { 203, 3, 6, 5, 1, -6 },
  { 206, 4, 4, 5, 0, -4 },
  { 208, 3, 4, 5, 1, -4 },
  { 210, 4, 4, 5, 0, -4 },
  { 212, 3, 6, 5, 1, -4 },
  { 215, 4, 6, 5, 0, -4 },
  { 218, 3, 4, 5, 1, -4 },
  { 220, 3, 4, 5, 1, -4 },
  { 222, 4, 5, 5, 0, -5 },
  { 225, 3, 4, 5, 1, -4 },
  { 227, 5, 4, 5, 0, -4 },
  { 230, 5, 4, 5, 0, -4 },
  { 233, 5, 4, 5, 0, -4 },
  { 236, 5, 6, 5, 0, -4 },
  { 240, 4, 4, 5, 0, -4 },
  { 242, 3, 7, 5, 1, -6 },
  { 245, 1, 8, 5, 2, -6 },
  { 246, 3, 7, 5, 1, -6 },
  { 249, 5, 2, 5, 0, -3 },
};

const GFXfont RobotoMono_SemiBold8pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold8pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOMONO_SEMIBOLD8PT7B_H_
