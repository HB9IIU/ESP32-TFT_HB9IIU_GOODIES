#ifndef _ROBOTOMONO_SEMIBOLD45PT7B_H_
#define _ROBOTOMONO_SEMIBOLD45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold45pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xE7, 0xEF, 0xFF, 0xFF, 0x3E, 0x78, 0x7D, 0xE1, 0xF7, 0x87, 0xDE, 0x1F,
  0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9C, 0x1E, 0x70, 0x79, 0xC1, 0xE7, 0x07,
  0xBC, 0x1E, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x0E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03, 0xC1, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x0F, 0x0F, 0x00, 0x07, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF0,
  0xF0, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF8, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x78, 0x00,
  0x38, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0x1F, 0xE3, 0xF0, 0x1F,
  0x9F, 0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x7E, 0x7F, 0x87,
  0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E,
  0x3E, 0x00, 0x0F, 0x0F, 0x06, 0x07, 0x87, 0x83, 0x83, 0xC3, 0xC3, 0xC1,
  0xE1, 0xE3, 0xC0, 0xF0, 0xF1, 0xE0, 0x78, 0x79, 0xE0, 0x3F, 0xF8, 0xE0,
  0x0F, 0xFC, 0xF0, 0x03, 0xFC, 0x70, 0x00, 0x10, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x0C, 0x00, 0x0F, 0x3F, 0xC0, 0x0F, 0x3F, 0xF0, 0x07, 0x3F, 0xF8, 0x07,
  0x9E, 0x1E, 0x03, 0x8F, 0x0F, 0x03, 0xC7, 0x87, 0x81, 0xC3, 0xC3, 0xC1,
  0xE1, 0xE1, 0xE0, 0x20, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83,
  0xE0, 0x07, 0xE3, 0xE0, 0x01, 0xF7, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFE, 0x0F, 0x8F, 0xFF, 0x07, 0xCF, 0xCF, 0xC3, 0xEF, 0xC3, 0xF1, 0xF7,
  0xE1, 0xFD, 0xFB, 0xF0, 0x7F, 0xF9, 0xF8, 0x1F, 0xFC, 0xFC, 0x07, 0xFC,
  0x7E, 0x03, 0xFE, 0x3F, 0x00, 0xFE, 0x0F, 0xE1, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDE, 0xF7, 0xBD, 0xE0, 0x00, 0x20, 0x06, 0x01, 0xE0, 0x3F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xE0, 0x06, 0x40, 0x06, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x04, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x08, 0x0E, 0x02, 0x3E, 0x1C, 0x1E, 0x7F,
  0x38, 0xFC, 0xFF, 0xFF, 0xFA, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xF7, 0x80, 0x07, 0xC7,
  0x80, 0x0F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xF0, 0x1E,
  0x00, 0x40, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x7C, 0xF9, 0xE7, 0xC7, 0x04, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF8, 0xFE, 0x3F,
  0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xBF, 0xFD, 0xF9, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0x7C, 0x01, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0x7F, 0x1F, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0C,
  0x01, 0xF0, 0x1F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xF0, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x8F, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0,
  0x1F, 0x3F, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x87, 0xF1,
  0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0x80, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE7, 0xE0, 0x1F,
  0x9F, 0xE1, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xF3, 0xF0, 0x01,
  0xF3, 0xF0, 0x03, 0xE3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x0F,
  0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x3E,
  0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFD, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3C, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x80,
  0xFC, 0xFE, 0x1F, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x9F, 0xE0, 0x7C,
  0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xF3, 0xFE, 0x7F, 0x03,
  0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD,
  0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8,
  0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xF1, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF8, 0xFE, 0x3F,
  0x03, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F,
  0x9F, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x1F, 0xC1, 0xF8,
  0xFC, 0x07, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFC, 0xFE, 0x1F, 0xE7,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x8F, 0xF1,
  0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0x80, 0x7E, 0x7C, 0x01, 0xFB, 0xF0,
  0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFD, 0xF0, 0x03,
  0xF7, 0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0x3F, 0x87, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x83, 0xFF, 0xBE, 0x07, 0xFC, 0xF8, 0x03, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7E, 0x3E, 0x3F, 0x9F, 0xEF, 0xF7, 0xFB, 0xF8, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC7, 0xC3,
  0xE1, 0xE1, 0xF0, 0x70, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0x0F,
  0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x78, 0x03, 0xC0,
  0x78, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x78, 0x3F, 0x1E, 0x3C, 0x3F, 0xE7,
  0x1C, 0x3F, 0xE3, 0x9E, 0x3E, 0x71, 0xCE, 0x1E, 0x38, 0xF7, 0x1E, 0x1C,
  0x7F, 0x8F, 0x0E, 0x1F, 0xC7, 0x07, 0x0F, 0xE7, 0x83, 0x8F, 0xF3, 0xC1,
  0xC7, 0x71, 0xE0, 0xE3, 0xB8, 0xF0, 0xF1, 0xDE, 0x78, 0x78, 0xEF, 0x3C,
  0x3C, 0xF7, 0x8F, 0x3E, 0x73, 0xC7, 0xFF, 0xF8, 0xE1, 0xFB, 0xF8, 0x78,
  0x78, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x1C, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC,
  0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xC0, 0x0F,
  0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x80,
  0x7F, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF3,
  0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7D, 0xF8, 0x01, 0xFB, 0xF0,
  0x07, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x87, 0xE0, 0x3F, 0x9F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xBE, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xFE, 0x3F,
  0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F, 0x3F, 0x00, 0xFE, 0xFC, 0x01,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xF0, 0x1F, 0xCF,
  0xC0, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3,
  0xFC, 0x7F, 0x87, 0xF0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0x7E,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E,
  0xFE, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xFF, 0x1F, 0xF1, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x07, 0xE7,
  0xE0, 0x3F, 0x9F, 0xE3, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0xFC, 0x01,
  0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F,
  0xE0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x7F,
  0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x03,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xBD, 0xEF, 0xFE, 0xF7, 0xBF, 0xFB, 0xDE, 0xFF,
  0xE7, 0xFB, 0xFF, 0x9F, 0xCF, 0xFE, 0x7F, 0x3F, 0xF9, 0xFC, 0xFF, 0xE3,
  0xE3, 0xFF, 0x8F, 0x8F, 0xFE, 0x3E, 0x3F, 0xF8, 0x70, 0xFF, 0xE1, 0xC3,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFE, 0xF8, 0xFF, 0xF7, 0xC7, 0xFF, 0x9F, 0x3F, 0xFC, 0xF9,
  0xFF, 0xE3, 0xCF, 0xFF, 0x1F, 0x7F, 0xF8, 0x7B, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x7F,
  0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xBE, 0x00,
  0x3E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xFE, 0x7F,
  0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xEF, 0xC0,
  0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7F, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x81,
  0xF8, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0xFC, 0x00,
  0x3E, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xF8, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x80, 0x7F,
  0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x3F,
  0x00, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F,
  0xC7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0xC7, 0xE0, 0x1F, 0xDF, 0x80, 0x1F, 0xBF,
  0x00, 0x3F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0xFD, 0xFC, 0x03, 0xF9, 0xFE, 0x0F, 0xE3,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xDF,
  0x80, 0xFC, 0xFF, 0x1F, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x0F,
  0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F,
  0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0xC3, 0xE0, 0xFB, 0xE1,
  0xF8, 0xFD, 0xF1, 0xFC, 0x7E, 0xF8, 0xFE, 0x3E, 0x7C, 0x7F, 0x1F, 0x3E,
  0x3F, 0x8F, 0x9F, 0x1F, 0xC7, 0xCF, 0x8F, 0xE3, 0xE7, 0xE7, 0x79, 0xF1,
  0xF7, 0xBC, 0xF8, 0xFB, 0xDE, 0xF8, 0x7D, 0xEF, 0x7C, 0x3E, 0xF7, 0xBE,
  0x1F, 0x7B, 0xDF, 0x0F, 0xBC, 0xFF, 0x87, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F,
  0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE1,
  0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFC,
  0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xF8,
  0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x87,
  0xE0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x7F,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x3F, 0x01,
  0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xDF, 0x80,
  0x07, 0xE7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F,
  0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0xF7, 0xC0, 0x3D, 0xF0, 0x1F, 0x3C, 0x07,
  0x8F, 0x83, 0xE1, 0xE0, 0xF8, 0x7C, 0x3C, 0x1F, 0x1F, 0x03, 0xC7, 0x80,
  0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3C, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7,
  0xF0, 0xFE, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F,
  0x81, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F,
  0xBF, 0x01, 0xFD, 0xFC, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0xF7, 0xE1, 0xFE, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x1F, 0xC1, 0xFB, 0xFF, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0x7F, 0xDF, 0xC0, 0x7E, 0xFE, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0x7F, 0xC7, 0xFB, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0xFD, 0xFF, 0xC7, 0xE7, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFD, 0xFF, 0x3F,
  0x81, 0xF9, 0xF8, 0x07, 0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x80, 0xFC,
  0xFF, 0x0F, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x7E, 0x1F, 0xFB, 0xF1, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFD, 0xFF, 0x7F, 0xEF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0xC7, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x1F, 0xFD, 0xF8, 0x3F, 0xCF, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xDF, 0xF1, 0xFC, 0x0F, 0xC7,
  0xE0, 0x1F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x87, 0xF0, 0x07, 0x1F,
  0xF0, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0xF8, 0x7F, 0xE7, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF7, 0xFD, 0xFF, 0xBF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0,
  0x0F, 0xDF, 0x80, 0xFE, 0xFF, 0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC4, 0x00,
  0xFC, 0x70, 0x07, 0xE3, 0xE0, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x1F, 0xE1, 0xF9, 0xFF,
  0x8F, 0xDF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0x3F, 0xDF, 0xC0, 0x7F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x00,
  0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF3,
  0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x0F,
  0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x03, 0xC0, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xF7, 0xE0, 0x1F, 0xCF, 0xC0, 0x7F, 0x1F,
  0x81, 0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x1F, 0xC0, 0xFC, 0x7F, 0x01, 0xF9,
  0xFC, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x7F, 0x01, 0xFC, 0x7F,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE,
  0x3F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFC,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xF1, 0xF9, 0xF7, 0xF7, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F,
  0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF,
  0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8,
  0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87,
  0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7F,
  0x87, 0xE7, 0xFE, 0x3F, 0x7F, 0xF9, 0xFF, 0xFF, 0xEF, 0xFD, 0xFF, 0x7F,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xFE, 0xFF, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7E,
  0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xFE, 0x3F, 0xC1, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFC, 0xFF,
  0x07, 0xEF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFD, 0xFF, 0x7F,
  0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFD,
  0xFE, 0x1F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF7, 0xFF, 0x1F, 0x9F,
  0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0xF8, 0x7F, 0xEF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7,
  0xFD, 0xFF, 0xBF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xDF, 0x80, 0xFE, 0xFF, 0x0F, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F,
  0xF7, 0xE0, 0xFF, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7, 0xF0, 0x7F, 0x3F,
  0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7E,
  0xFC, 0x07, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF,
  0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE1, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFE, 0x1F,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0x7C, 0x7F, 0xF3, 0xE0, 0xFE, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xFC, 0x7E,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x3C, 0x0F, 0xFC,
  0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC3, 0xEF, 0x83, 0xE1, 0xF3,
  0xE3, 0xF0, 0xF9, 0xF1, 0xF8, 0x7C, 0xF8, 0xFE, 0x3E, 0x7C, 0x7F, 0x1E,
  0x3E, 0x3B, 0x8F, 0x0F, 0x3D, 0xCF, 0x87, 0x9E, 0xE7, 0xC3, 0xEE, 0x7B,
  0xE1, 0xF7, 0x3D, 0xF0, 0xFB, 0x8E, 0xF0, 0x3F, 0xC7, 0x78, 0x1F, 0xE3,
  0xBC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0x01, 0xFC,
  0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0xFE,
  0x00, 0x7F, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF8, 0x3F,
  0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01,
  0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xDF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xD0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x07, 0xFC, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFD, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0xF8,
  0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xF0, 0x1F,
  0xE0, 0x0F, 0xC0, 0x7F, 0x81, 0xFF, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00,
  0xFE, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x0F,
  0x7F, 0xF8, 0x0F, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x1F, 0xF8, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFE, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x40,
};

const GFXglyph RobotoMono_SemiBold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 32, 27, 10, -32 },
  { 29, 14, 12, 27, 6, -34 },
  { 50, 25, 32, 27, 1, -32 },
  { 150, 22, 42, 27, 3, -37 },
  { 266, 25, 32, 27, 1, -32 },
  { 366, 25, 32, 27, 2, -32 },
  { 466, 5, 12, 27, 10, -34 },
  { 474, 12, 46, 27, 8, -36 },
  { 543, 12, 46, 27, 7, -36 },
  { 612, 23, 22, 27, 3, -32 },
  { 676, 22, 24, 27, 2, -27 },
  { 742, 7, 14, 27, 8, -5 },
  { 755, 18, 4, 27, 6, -16 },
  { 764, 8, 7, 27, 10, -7 },
  { 771, 18, 35, 27, 5, -32 },
  { 850, 21, 32, 27, 3, -32 },
  { 934, 14, 32, 27, 4, -32 },
  { 990, 22, 32, 27, 2, -32 },
  { 1078, 22, 32, 27, 2, -32 },
  { 1166, 24, 32, 27, 1, -32 },
  { 1262, 21, 32, 27, 3, -32 },
  { 1346, 22, 32, 27, 2, -32 },
  { 1434, 22, 32, 27, 2, -32 },
  { 1522, 21, 32, 27, 3, -32 },
  { 1606, 22, 32, 27, 2, -32 },
  { 1694, 8, 25, 27, 10, -25 },
  { 1719, 9, 34, 27, 10, -25 },
  { 1758, 20, 21, 27, 3, -24 },
  { 1811, 20, 14, 27, 4, -21 },
  { 1846, 19, 21, 27, 4, -24 },
  { 1896, 20, 32, 27, 4, -32 },
  { 1976, 25, 32, 27, 1, -32 },
  { 2076, 26, 32, 27, 1, -32 },
  { 2180, 23, 32, 27, 3, -32 },
  { 2272, 23, 32, 27, 2, -32 },
  { 2364, 22, 32, 27, 3, -32 },
  { 2452, 22, 32, 27, 3, -32 },
  { 2540, 22, 32, 27, 3, -32 },
  { 2628, 23, 32, 27, 2, -32 },
  { 2720, 21, 32, 27, 3, -32 },
  { 2804, 19, 32, 27, 4, -32 },
  { 2880, 22, 32, 27, 2, -32 },
  { 2968, 24, 32, 27, 3, -32 },
  { 3064, 20, 32, 27, 4, -32 },
  { 3144, 22, 32, 27, 3, -32 },
  { 3232, 21, 32, 27, 3, -32 },
  { 3316, 23, 32, 27, 2, -32 },
  { 3408, 23, 32, 27, 3, -32 },
  { 3500, 25, 38, 27, 2, -32 },
  { 3619, 23, 32, 27, 3, -32 },
  { 3711, 23, 32, 27, 2, -32 },
  { 3803, 25, 32, 27, 1, -32 },
  { 3903, 21, 32, 27, 3, -32 },
  { 3987, 25, 32, 27, 1, -32 },
  { 4087, 25, 32, 27, 1, -32 },
  { 4187, 26, 32, 27, 1, -32 },
  { 4291, 26, 32, 27, 1, -32 },
  { 4395, 23, 32, 27, 2, -32 },
  { 4487, 10, 44, 27, 9, -37 },
  { 4542, 18, 35, 27, 5, -32 },
  { 4621, 9, 44, 27, 9, -37 },
  { 4671, 18, 17, 27, 5, -32 },
  { 4710, 20, 4, 27, 3, 0 },
  { 4720, 10, 7, 27, 9, -33 },
  { 4729, 21, 24, 27, 3, -24 },
  { 4792, 21, 34, 27, 3, -34 },
  { 4882, 21, 24, 27, 3, -24 },
  { 4945, 21, 34, 27, 3, -34 },
  { 5035, 22, 24, 27, 3, -24 },
  { 5101, 22, 35, 27, 3, -35 },
  { 5198, 21, 33, 27, 3, -24 },
  { 5285, 21, 34, 27, 3, -34 },
  { 5375, 19, 33, 27, 5, -33 },
  { 5454, 14, 43, 27, 5, -33 },
  { 5530, 23, 34, 27, 3, -34 },
  { 5628, 20, 34, 27, 4, -34 },
  { 5713, 23, 24, 27, 2, -24 },
  { 5782, 21, 24, 27, 3, -24 },
  { 5845, 23, 24, 27, 2, -24 },
  { 5914, 21, 33, 27, 3, -24 },
  { 6001, 21, 33, 27, 3, -24 },
  { 6088, 18, 24, 27, 6, -24 },
  { 6142, 21, 24, 27, 3, -24 },
  { 6205, 21, 30, 27, 3, -30 },
  { 6284, 21, 24, 27, 3, -24 },
  { 6347, 23, 24, 27, 2, -24 },
  { 6416, 25, 24, 27, 1, -24 },
  { 6491, 24, 24, 27, 2, -24 },
  { 6563, 26, 34, 27, 1, -24 },
  { 6674, 22, 24, 27, 3, -24 },
  { 6740, 15, 43, 27, 7, -35 },
  { 6821, 3, 41, 27, 12, -32 },
  { 6837, 15, 43, 27, 7, -35 },
  { 6918, 24, 10, 27, 1, -18 },
};

const GFXfont RobotoMono_SemiBold45pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold45pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOMONO_SEMIBOLD45PT7B_H_
