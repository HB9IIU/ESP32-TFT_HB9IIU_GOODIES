#ifndef _ROBOTOMONO_SEMIBOLD13PT7B_H_
#define _ROBOTOMONO_SEMIBOLD13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xBB, 0xBA, 0x16, 0x29, 0xF9, 0x22, 0x5F, 0xCA,
  0x14, 0x48, 0x10, 0x47, 0xB3, 0xC5, 0x83, 0x83, 0xC7, 0x37, 0x84, 0xF0,
  0x94, 0xD8, 0x68, 0x10, 0x16, 0x2B, 0x2B, 0x0E, 0x79, 0xB3, 0x63, 0x86,
  0x3E, 0xA7, 0x66, 0xF6, 0xF0, 0x36, 0x44, 0xCC, 0xCC, 0xC4, 0x42, 0x10,
  0x84, 0x62, 0x23, 0x32, 0x22, 0x64, 0x80, 0x12, 0x5F, 0xCC, 0x79, 0x30,
  0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x00, 0x57, 0xFF, 0xC0, 0xF0, 0x0C, 0x61,
  0x84, 0x30, 0x82, 0x18, 0x43, 0x00, 0x7B, 0x3C, 0xF7, 0xFF, 0x3C, 0xF3,
  0x78, 0x3F, 0xB3, 0x33, 0x33, 0x30, 0x7C, 0x8B, 0x18, 0x20, 0xC3, 0x0C,
  0x30, 0x7E, 0xFB, 0x30, 0xC6, 0x38, 0x38, 0xF3, 0x78, 0x0C, 0x38, 0x71,
  0x66, 0xC9, 0xBF, 0x86, 0x0C, 0x7F, 0x0C, 0x3E, 0xCC, 0x38, 0xF3, 0x78,
  0x39, 0x8C, 0x2E, 0xCE, 0x38, 0xF3, 0x78, 0xFE, 0x0C, 0x10, 0x60, 0x83,
  0x04, 0x18, 0x30, 0x7B, 0x3C, 0xF6, 0x7B, 0x38, 0xF3, 0x78, 0x7B, 0x28,
  0xE3, 0xDD, 0xF0, 0x8E, 0x70, 0xF0, 0x3C, 0xF0, 0x3F, 0xC0, 0x0C, 0xFE,
  0x38, 0x3C, 0x30, 0xFC, 0x00, 0x3F, 0x83, 0xC1, 0xC7, 0xF2, 0x00, 0x7B,
  0x30, 0xC2, 0x18, 0xC0, 0x0C, 0x30, 0x3C, 0x85, 0x7D, 0x3A, 0xB5, 0x7D,
  0xA0, 0x3C, 0x18, 0x18, 0x3C, 0x3C, 0x24, 0x66, 0x7E, 0x42, 0xC3, 0xFB,
  0x3C, 0x73, 0xFB, 0x1C, 0x73, 0xF8, 0x7B, 0x38, 0x60, 0x82, 0x08, 0x73,
  0x78, 0xFB, 0x3C, 0xF1, 0xC7, 0x3C, 0xF6, 0xF0, 0xFF, 0x0C, 0x30, 0xFB,
  0x0C, 0x30, 0xFC, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xC0, 0x7B, 0x38,
  0x60, 0x9E, 0x78, 0x73, 0x78, 0x8E, 0x38, 0xE3, 0xFE, 0x38, 0xE3, 0x8C,
  0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0x0C, 0x30, 0xC3, 0x0C, 0x38,
  0xF3, 0x78, 0xCF, 0xB3, 0x67, 0x8F, 0x1B, 0x36, 0x66, 0xC6, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xFC, 0xCF, 0x7F, 0x6D, 0xB6, 0x98, 0x61, 0x84,
  0xCF, 0x3E, 0xEB, 0xBE, 0x79, 0xE3, 0x8C, 0x7B, 0x38, 0xE1, 0x86, 0x18,
  0xF3, 0x78, 0xFB, 0x3C, 0x71, 0xFF, 0xCC, 0x30, 0xC0, 0x79, 0x9A, 0x34,
  0x28, 0x50, 0xA3, 0x66, 0x78, 0x1C, 0x10, 0xF9, 0x9B, 0x16, 0x6F, 0x9B,
  0x32, 0x66, 0xC6, 0x7B, 0x3C, 0x38, 0x78, 0x38, 0x73, 0x78, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x8E, 0x38, 0xE3, 0x8E, 0x3C,
  0xF3, 0x78, 0xC3, 0x66, 0x66, 0x64, 0x2C, 0x3C, 0x38, 0x18, 0x18, 0xDB,
  0xDA, 0x5A, 0x5A, 0x5A, 0x7E, 0x6E, 0x66, 0x64, 0xE7, 0x66, 0x3C, 0x38,
  0x18, 0x3C, 0x3C, 0x66, 0xC7, 0xC3, 0x66, 0x24, 0x3C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xFC, 0x31, 0x84, 0x31, 0x84, 0x30, 0xFC, 0xFA, 0xAA, 0xAA,
  0xC0, 0x86, 0x30, 0x86, 0x10, 0x86, 0x10, 0xC0, 0xF5, 0x55, 0x55, 0xC0,
  0x30, 0xC7, 0x92, 0xCC, 0xFC, 0xE0, 0x7B, 0x30, 0xFF, 0xCF, 0x3F, 0xC0,
  0xC3, 0x0C, 0x3E, 0xCF, 0x3C, 0xF3, 0xCF, 0xE0, 0x7B, 0x3C, 0xE0, 0x83,
  0x37, 0x80, 0x0C, 0x30, 0xDF, 0xCF, 0x38, 0xE3, 0xCD, 0xF0, 0x7B, 0x3C,
  0xFF, 0x83, 0x17, 0x80, 0x1C, 0xC2, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x80,
  0x7F, 0x3C, 0xE3, 0x8F, 0x37, 0xC3, 0xF8, 0xC0, 0xC3, 0x0C, 0x3E, 0xCF,
  0x3C, 0xF3, 0xCF, 0x30, 0x10, 0xC0, 0x3C, 0x30, 0xC3, 0x0C, 0x33, 0xF0,
  0x10, 0xC0, 0xE1, 0x08, 0x42, 0x10, 0x85, 0xEE, 0x00, 0xC1, 0x83, 0x06,
  0x6D, 0x9E, 0x3C, 0x6C, 0xD9, 0x9C, 0xF3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x33, 0xF0, 0xF7, 0xB7, 0x6E, 0xDD, 0xBB, 0x76, 0x80, 0xBB, 0x3C, 0xF3,
  0xCF, 0x3C, 0xC0, 0x7B, 0x38, 0xE3, 0x8F, 0x37, 0x80, 0xFB, 0x3C, 0xF3,
  0xCF, 0x3F, 0xB0, 0xC3, 0x00, 0x7F, 0x3C, 0xE3, 0x8F, 0x37, 0xC3, 0x0C,
  0x30, 0xBF, 0xF1, 0x8C, 0x63, 0x00, 0x7B, 0x3C, 0x1E, 0x0F, 0x37, 0x80,
  0x61, 0x8F, 0xD8, 0x61, 0x86, 0x08, 0x3C, 0xCF, 0x3C, 0xF3, 0xCF, 0x37,
  0xC0, 0xC6, 0xCD, 0x91, 0x23, 0xC3, 0x06, 0x00, 0xD3, 0xDA, 0x5A, 0x5A,
  0x6E, 0x6E, 0x64, 0xCD, 0x27, 0x8C, 0x79, 0x2C, 0xC0, 0xC3, 0x66, 0x66,
  0x34, 0x3C, 0x18, 0x18, 0x10, 0x70, 0x60, 0xFC, 0x31, 0x8C, 0x63, 0x0F,
  0xC0, 0x32, 0x22, 0x2E, 0xC6, 0x22, 0x23, 0xFF, 0xF0, 0xC4, 0x66, 0x63,
  0x36, 0x66, 0x6C, 0x73, 0xBC, 0x10,
};

const GFXglyph RobotoMono_SemiBold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 6, 12, 8, 1, -11 },
  { 23, 8, 9, 8, 0, -9 },
  { 32, 7, 9, 8, 1, -9 },
  { 40, 1, 4, 8, 3, -10 },
  { 41, 4, 13, 8, 2, -10 },
  { 48, 4, 13, 8, 2, -10 },
  { 55, 6, 6, 8, 1, -9 },
  { 60, 6, 7, 8, 1, -8 },
  { 66, 2, 4, 8, 2, -2 },
  { 67, 5, 2, 8, 2, -5 },
  { 69, 2, 2, 8, 3, -2 },
  { 70, 6, 10, 8, 1, -9 },
  { 78, 6, 9, 8, 1, -9 },
  { 85, 4, 9, 8, 1, -9 },
  { 90, 7, 9, 8, 0, -9 },
  { 98, 6, 9, 8, 1, -9 },
  { 105, 7, 9, 8, 0, -9 },
  { 113, 6, 9, 8, 1, -9 },
  { 120, 6, 9, 8, 1, -9 },
  { 127, 7, 9, 8, 0, -9 },
  { 135, 6, 9, 8, 1, -9 },
  { 142, 6, 9, 8, 1, -9 },
  { 149, 2, 7, 8, 3, -7 },
  { 151, 2, 9, 8, 3, -7 },
  { 154, 6, 6, 8, 1, -7 },
  { 159, 6, 4, 8, 1, -6 },
  { 162, 6, 6, 8, 1, -7 },
  { 167, 6, 9, 8, 1, -9 },
  { 174, 7, 9, 8, 0, -9 },
  { 182, 8, 9, 8, 0, -9 },
  { 191, 6, 9, 8, 1, -9 },
  { 198, 6, 9, 8, 1, -9 },
  { 205, 6, 9, 8, 1, -9 },
  { 212, 6, 9, 8, 1, -9 },
  { 219, 6, 9, 8, 1, -9 },
  { 226, 6, 9, 8, 1, -9 },
  { 233, 6, 9, 8, 1, -9 },
  { 240, 6, 9, 8, 1, -9 },
  { 247, 6, 9, 8, 1, -9 },
  { 254, 7, 9, 8, 1, -9 },
  { 262, 6, 9, 8, 1, -9 },
  { 269, 6, 9, 8, 1, -9 },
  { 276, 6, 9, 8, 1, -9 },
  { 283, 6, 9, 8, 1, -9 },
  { 290, 6, 9, 8, 1, -9 },
  { 297, 7, 11, 8, 1, -9 },
  { 307, 7, 9, 8, 1, -9 },
  { 315, 6, 9, 8, 1, -9 },
  { 322, 8, 9, 8, 0, -9 },
  { 331, 6, 9, 8, 1, -9 },
  { 338, 8, 9, 8, 0, -9 },
  { 347, 8, 9, 8, 0, -9 },
  { 356, 8, 9, 8, 0, -9 },
  { 365, 8, 9, 8, 0, -9 },
  { 374, 6, 9, 8, 1, -9 },
  { 381, 2, 13, 8, 3, -11 },
  { 385, 5, 10, 8, 2, -9 },
  { 392, 2, 13, 8, 3, -11 },
  { 396, 6, 5, 8, 1, -9 },
  { 400, 6, 1, 8, 1, 0 },
  { 401, 3, 1, 8, 3, -9 },
  { 402, 6, 7, 8, 1, -7 },
  { 408, 6, 10, 8, 1, -10 },
  { 416, 6, 7, 8, 1, -7 },
  { 422, 6, 10, 8, 1, -10 },
  { 430, 6, 7, 8, 1, -7 },
  { 436, 6, 10, 8, 1, -10 },
  { 444, 6, 10, 8, 1, -7 },
  { 452, 6, 10, 8, 1, -10 },
  { 460, 6, 10, 8, 1, -10 },
  { 468, 5, 13, 8, 1, -10 },
  { 477, 7, 10, 8, 1, -10 },
  { 486, 6, 10, 8, 1, -10 },
  { 494, 7, 7, 8, 0, -7 },
  { 501, 6, 7, 8, 1, -7 },
  { 507, 6, 7, 8, 1, -7 },
  { 513, 6, 10, 8, 1, -7 },
  { 521, 6, 10, 8, 1, -7 },
  { 529, 5, 7, 8, 2, -7 },
  { 534, 6, 7, 8, 1, -7 },
  { 540, 6, 9, 8, 1, -9 },
  { 547, 6, 7, 8, 1, -7 },
  { 553, 7, 7, 8, 0, -7 },
  { 560, 8, 7, 8, 0, -7 },
  { 567, 6, 7, 8, 1, -7 },
  { 573, 8, 10, 8, 0, -7 },
  { 583, 6, 7, 8, 1, -7 },
  { 589, 4, 12, 8, 2, -10 },
  { 595, 1, 12, 8, 3, -9 },
  { 597, 4, 12, 8, 2, -10 },
  { 603, 7, 3, 8, 0, -5 },
};

const GFXfont RobotoMono_SemiBold13pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold13pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _ROBOTOMONO_SEMIBOLD13PT7B_H_
