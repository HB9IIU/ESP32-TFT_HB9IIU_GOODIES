#ifndef _ROBOTOMONO_SEMIBOLD28PT7B_H_
#define _ROBOTOMONO_SEMIBOLD28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold28pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x00, 0x6F, 0xF7, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xC3, 0xC3, 0x07, 0x18, 0x0C, 0x70, 0x18, 0xE0,
  0x31, 0x80, 0x63, 0x01, 0xC6, 0x1F, 0xFF, 0xBF, 0xFF, 0x0C, 0x60, 0x18,
  0xC0, 0x71, 0x80, 0xE3, 0x0F, 0xFF, 0xDF, 0xFF, 0x86, 0x30, 0x0C, 0x60,
  0x38, 0xC0, 0x73, 0x80, 0xC7, 0x01, 0x8C, 0x00, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x1F, 0x83, 0xFF, 0x3F, 0xF9, 0xE1, 0xEE, 0x07, 0x70, 0x3B, 0x80,
  0x1E, 0x00, 0x7C, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x3F,
  0x01, 0xFC, 0x0F, 0xE0, 0xF7, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x67, 0x10, 0xE3, 0x18, 0xE3,
  0x38, 0x63, 0x30, 0x7F, 0x70, 0x3E, 0x60, 0x08, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x3E, 0x07, 0x7F, 0x06, 0x63, 0x0E, 0x63, 0x0C,
  0x63, 0x00, 0x63, 0x00, 0x7F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x3C, 0xF0, 0x38, 0x70, 0x38, 0x70, 0x3C, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0x0F, 0x00, 0x3F, 0x0E, 0x7F, 0x8E, 0x73, 0xCE, 0xF1, 0xEE, 0xF1,
  0xFE, 0xF0, 0xFC, 0xF0, 0x78, 0x7F, 0xFC, 0x7F, 0xFE, 0x1F, 0xDF, 0xFF,
  0xFF, 0xF8, 0x06, 0x1C, 0x70, 0xE3, 0x8E, 0x1C, 0x38, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x1C, 0x1C, 0x1C,
  0x38, 0x38, 0x30, 0x40, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E,
  0x0E, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1C, 0x1C, 0x38, 0x70, 0xE0, 0x40, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x63, 0x0B, 0xED, 0xFF, 0xFF, 0xC3, 0xF0, 0x07, 0x80, 0x3F,
  0x01, 0xCE, 0x0E, 0x3C, 0x38, 0x70, 0x40, 0x80, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x7B, 0xDE, 0xE7,
  0x3B, 0x9C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0xE0, 0x00, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xFC, 0xE1, 0xEF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x9F, 0xFF, 0xDF, 0xF8,
  0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x70, 0xF3, 0xFF, 0x8F, 0xF8,
  0x3F, 0x80, 0x00, 0x83, 0xCF, 0xFF, 0xFF, 0xBF, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1E, 0x1E, 0xF0, 0x7B, 0xC0, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0x70, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xFC, 0x0F, 0x78, 0x79, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0xEF, 0x03,
  0xBC, 0x1C, 0xF0, 0xE3, 0xC3, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x7F, 0xF3,
  0xFF, 0x9F, 0xFC, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xF8, 0x7F,
  0xE7, 0xFF, 0x8C, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFC, 0x0F,
  0xF0, 0x73, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0x03, 0xC0, 0x7E, 0x07, 0xF0,
  0x7C, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0xF8, 0xFF, 0xE7, 0xFF, 0xBC,
  0x3D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0xF3, 0xFF,
  0x8F, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xFD, 0xE1, 0xEF, 0x07, 0x78,
  0x3B, 0xC1, 0xCE, 0x1E, 0x7F, 0xE1, 0xFE, 0x0F, 0xF8, 0xF1, 0xEF, 0x07,
  0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0x9F, 0xF8, 0x3F, 0x80,
  0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0, 0xEF, 0x03,
  0xFC, 0x0F, 0x70, 0x3D, 0xE0, 0xF7, 0xCF, 0xCF, 0xFE, 0x1F, 0xB8, 0x08,
  0xE0, 0x07, 0x80, 0x1C, 0x01, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xC0, 0x7F,
  0xFE, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xE0, 0x79, 0xF7, 0xDE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xE7, 0x9E, 0x71, 0xC7, 0x38,
  0x00, 0x10, 0x0F, 0x03, 0xF0, 0xFF, 0x7F, 0x8F, 0xC0, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x01, 0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0,
  0x07, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xE0, 0x7F,
  0x1F, 0xE7, 0xF8, 0x3F, 0x01, 0xE0, 0x08, 0x00, 0x00, 0x1F, 0xC1, 0xFF,
  0x9F, 0xFC, 0xF0, 0xFF, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x78, 0x03, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x1F, 0xE0, 0x71, 0xE1,
  0xC0, 0xE7, 0x08, 0xCC, 0x7C, 0xF9, 0xD9, 0xE7, 0x33, 0xCC, 0x67, 0x98,
  0xCF, 0x31, 0x9E, 0xE3, 0x3C, 0xC6, 0x59, 0x9D, 0xB3, 0xFE, 0x73, 0x18,
  0x60, 0x00, 0xF0, 0x40, 0xFF, 0x80, 0x7E, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xF0,
  0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x78, 0x3C, 0x78, 0x38, 0x38, 0x3F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xE0, 0x0F,
  0xFF, 0x83, 0xFF, 0xCF, 0xFF, 0xB8, 0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x03,
  0xB8, 0x1E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFF, 0x38, 0x1E, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0xEF, 0xFF, 0x3F, 0xF0, 0x0F,
  0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x81, 0xCE, 0x03, 0xBC, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x5C, 0x07, 0x38, 0x0E, 0x78, 0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F,
  0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x38, 0x7C, 0xE0, 0xFB, 0x81, 0xEE,
  0x03, 0xB8, 0x0E, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3B,
  0x80, 0xEE, 0x07, 0xB8, 0x1E, 0xE1, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F,
  0x0F, 0x78, 0x1D, 0xC0, 0x7F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x77, 0x01, 0xDE, 0x07, 0x78, 0x1C,
  0xFF, 0xF1, 0xFF, 0xC3, 0xFC, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0x03, 0xDC, 0x0F, 0x78, 0x79,
  0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0xE0, 0x3F, 0xC0, 0xFB, 0x81, 0xE7, 0x07,
  0x8E, 0x1E, 0x1C, 0x7C, 0x38, 0xF0, 0x73, 0xC0, 0xEF, 0x01, 0xFE, 0x03,
  0xFE, 0x07, 0xFE, 0x0F, 0xBC, 0x1E, 0x3C, 0x38, 0x7C, 0x70, 0x78, 0xE0,
  0x79, 0xC0, 0xF3, 0x80, 0xF7, 0x01, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x7F, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x9F,
  0xFE, 0xFF, 0xF7, 0xFD, 0xB7, 0xEF, 0xBF, 0x7D, 0xF9, 0xCF, 0xCE, 0x7E,
  0x73, 0xF3, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x70, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xF1,
  0xFD, 0xCF, 0xEE, 0x7F, 0x3B, 0xF9, 0xDF, 0xCF, 0xFE, 0x3F, 0xF1, 0xFF,
  0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xF0, 0x0F, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xC7, 0x83, 0xCE, 0x03, 0xBC, 0x07, 0x78,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0x9C, 0x07, 0x3C, 0x1E, 0x78, 0x78, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00,
  0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC3, 0xEF, 0xFF, 0x3F, 0xF8, 0xFE, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xE7, 0x83, 0xCE, 0x03, 0xBC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xDC, 0x07, 0x3C, 0x1E, 0x78, 0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0xFF, 0x83, 0xFF, 0x8F, 0xFF,
  0x3C, 0x1E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x7B, 0xCF,
  0xEF, 0xFF, 0x3F, 0xF0, 0xF1, 0xC3, 0xC7, 0x8F, 0x0F, 0x3C, 0x3C, 0xF0,
  0x7B, 0xC1, 0xEF, 0x03, 0xFC, 0x0F, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xC1, 0xE7, 0x81, 0xEE, 0x03, 0xDE, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0x78, 0x1E, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFE, 0x0F, 0xF0, 0xF3, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7B, 0x81, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x1C, 0x3C,
  0x3C, 0x78, 0x78, 0xE0, 0x71, 0xC0, 0xF7, 0x81, 0xEE, 0x01, 0xDC, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF1,
  0xC7, 0x71, 0xC7, 0x71, 0xC7, 0x71, 0xC7, 0x73, 0xC7, 0x73, 0xE7, 0x7B,
  0xEF, 0x7B, 0xEE, 0x3B, 0x6E, 0x3B, 0x6E, 0x3B, 0x6E, 0x3F, 0x7E, 0x3F,
  0x7E, 0x3E, 0x7E, 0x3E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x38, 0x3C,
  0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0, 0x1E, 0x70, 0x3C, 0x78, 0x3C,
  0x3C, 0x78, 0x3C, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0x78,
  0x1C, 0x78, 0x3C, 0x38, 0x38, 0x3C, 0x78, 0x1C, 0x70, 0x1E, 0xF0, 0x0E,
  0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xFF, 0xF0, 0x0E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F,
  0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x7C, 0x0F, 0x83, 0xB8, 0x77, 0x0C, 0x73,
  0x8E, 0x71, 0xDC, 0x1F, 0x83, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF1,
  0xE3, 0x87, 0x1F, 0x83, 0xFF, 0x1F, 0xFD, 0xE1, 0xEF, 0x07, 0x00, 0x38,
  0x7F, 0xCF, 0xFE, 0xF8, 0x77, 0x03, 0xB8, 0x1D, 0xC1, 0xEF, 0xFF, 0x3F,
  0xFC, 0xFD, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xDF, 0x1F, 0xFC, 0xFF, 0xF7, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFF, 0xFD, 0xFF, 0xCE,
  0x7C, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xF1, 0xEF, 0x07, 0xF0, 0x3F,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x1F, 0xE0, 0xF7, 0xFF, 0x1F,
  0xF0, 0x7F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x7D, 0xE7, 0xFF, 0x7F, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xDF, 0xFE, 0xFF, 0xF1,
  0xF7, 0x80, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF0, 0xFF, 0x07, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x01, 0xF0, 0x67, 0xFF, 0x9F,
  0xF8, 0x7F, 0x80, 0x00, 0x70, 0x0F, 0xF0, 0x7F, 0xC3, 0xE1, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x1F, 0x39, 0xFD, 0xDF, 0xFF, 0xF0,
  0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F,
  0xE0, 0xF7, 0xFF, 0x9F, 0xFC, 0x7D, 0xE0, 0x0F, 0x20, 0x7B, 0x87, 0xBF,
  0xFC, 0x7F, 0xC0, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xDF, 0x1F, 0xFE, 0xFF, 0xF7, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0x80, 0x02, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x02, 0x03, 0xC1, 0xE0, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x7F, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x1E, 0xFF, 0x7F, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xBC, 0x3C, 0xF1, 0xE3, 0xCF,
  0x0F, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3E, 0xF0, 0xF1,
  0xE3, 0xC7, 0xCF, 0x0F, 0x3C, 0x1E, 0xF0, 0x7C, 0xFF, 0x0F, 0xF0, 0xFF,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0x39, 0xFF, 0xFB, 0xFF, 0xF7, 0x1C, 0xFE,
  0x39, 0xFC, 0x73, 0xF8, 0xE7, 0xF1, 0xCF, 0xE3, 0x9F, 0xC7, 0x3F, 0x8E,
  0x7F, 0x1C, 0xFE, 0x39, 0xFC, 0x73, 0xF8, 0xE7, 0x80, 0xE7, 0xC7, 0x7F,
  0xBF, 0xFD, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xE0, 0x07, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0x78, 0x3D, 0xC0, 0xFF, 0x01, 0xFC, 0x07,
  0xF0, 0x1D, 0xC0, 0x77, 0x83, 0xDE, 0x0F, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE,
  0x00, 0xE7, 0xC7, 0x7F, 0x3F, 0xFD, 0xE1, 0xEF, 0x07, 0xF8, 0x3F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0x7F, 0xF3,
  0xDF, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x1F, 0x39, 0xFF, 0xDF, 0xFF, 0xE1, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0xF7, 0xFF, 0xBF, 0xFC, 0x7D,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xE3,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0xC1, 0xFF, 0x9F,
  0xFD, 0xE0, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x0F, 0xE0, 0xFF, 0x8F, 0xBF, 0xF8, 0x7F, 0x00, 0x1E, 0x00, 0xF0,
  0x07, 0x81, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xFF, 0x0F,
  0xF8, 0x3F, 0xC0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7, 0xFF,
  0xBF, 0xDC, 0xFC, 0xE0, 0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0xF3, 0xC1, 0xC3,
  0x83, 0x87, 0x0F, 0x0F, 0x1C, 0x0E, 0x38, 0x1C, 0xF0, 0x1D, 0xC0, 0x3B,
  0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xF1, 0xC7, 0x71,
  0xC7, 0x71, 0xC7, 0x73, 0xC7, 0x73, 0xCE, 0x73, 0xEE, 0x3B, 0x6E, 0x3B,
  0x6E, 0x3F, 0x6E, 0x3E, 0x6C, 0x3E, 0x7C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1C, 0x3C, 0xF8, 0x1E, 0xF0, 0x78, 0xF1, 0xE0, 0xF3, 0xC1, 0xEF,
  0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x7B, 0xC0,
  0xF3, 0xC3, 0xC7, 0x8F, 0x07, 0xBE, 0x07, 0x80, 0xF0, 0x0F, 0xF0, 0x1E,
  0x78, 0x1E, 0x78, 0x3C, 0x38, 0x3C, 0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x70,
  0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x83, 0x8F, 0xC7, 0x83, 0xE0, 0x38, 0x1E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x70, 0x1C, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xF8, 0x3C,
  0x7E, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70,
  0x70, 0x30, 0x00, 0x3E, 0x04, 0x7F, 0x87, 0x7F, 0xCF, 0x61, 0xFE, 0xE0,
  0xFC, 0x00, 0x38,
};

const GFXglyph RobotoMono_SemiBold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 20, 17, 6, -20 },
  { 11, 8, 7, 17, 4, -21 },
  { 18, 15, 20, 17, 1, -20 },
  { 56, 13, 26, 17, 2, -23 },
  { 99, 16, 20, 17, 0, -20 },
  { 139, 16, 20, 17, 1, -20 },
  { 179, 3, 7, 17, 6, -21 },
  { 182, 7, 28, 17, 5, -22 },
  { 207, 8, 28, 17, 4, -22 },
  { 235, 14, 14, 17, 2, -20 },
  { 260, 14, 14, 17, 1, -16 },
  { 285, 5, 8, 17, 5, -3 },
  { 290, 11, 3, 17, 4, -10 },
  { 295, 5, 4, 17, 6, -4 },
  { 298, 11, 22, 17, 3, -20 },
  { 329, 13, 20, 17, 2, -20 },
  { 362, 9, 20, 17, 2, -20 },
  { 385, 14, 20, 17, 1, -20 },
  { 420, 14, 20, 17, 1, -20 },
  { 455, 14, 20, 17, 1, -20 },
  { 490, 13, 20, 17, 2, -20 },
  { 523, 13, 20, 17, 2, -20 },
  { 556, 14, 20, 17, 1, -20 },
  { 591, 13, 20, 17, 2, -20 },
  { 624, 14, 20, 17, 1, -20 },
  { 659, 5, 15, 17, 6, -15 },
  { 669, 6, 20, 17, 6, -15 },
  { 684, 12, 13, 17, 2, -15 },
  { 704, 13, 9, 17, 2, -13 },
  { 719, 13, 13, 17, 2, -15 },
  { 741, 13, 20, 17, 2, -20 },
  { 774, 15, 20, 17, 1, -20 },
  { 812, 16, 20, 17, 1, -20 },
  { 852, 14, 20, 17, 2, -20 },
  { 887, 15, 20, 17, 1, -20 },
  { 925, 14, 20, 17, 2, -20 },
  { 960, 13, 20, 17, 2, -20 },
  { 993, 13, 20, 17, 2, -20 },
  { 1026, 14, 20, 17, 1, -20 },
  { 1061, 13, 20, 17, 2, -20 },
  { 1094, 11, 20, 17, 3, -20 },
  { 1122, 14, 20, 17, 1, -20 },
  { 1157, 15, 20, 17, 2, -20 },
  { 1195, 13, 20, 17, 2, -20 },
  { 1228, 13, 20, 17, 2, -20 },
  { 1261, 13, 20, 17, 2, -20 },
  { 1294, 15, 20, 17, 1, -20 },
  { 1332, 14, 20, 17, 2, -20 },
  { 1367, 15, 23, 17, 1, -20 },
  { 1411, 14, 20, 17, 2, -20 },
  { 1446, 15, 20, 17, 1, -20 },
  { 1484, 16, 20, 17, 0, -20 },
  { 1524, 13, 20, 17, 2, -20 },
  { 1557, 15, 20, 17, 1, -20 },
  { 1595, 16, 20, 17, 0, -20 },
  { 1635, 16, 20, 17, 1, -20 },
  { 1675, 16, 20, 17, 1, -20 },
  { 1715, 15, 20, 17, 1, -20 },
  { 1753, 6, 28, 17, 6, -23 },
  { 1774, 11, 22, 17, 3, -20 },
  { 1805, 6, 28, 17, 5, -23 },
  { 1826, 11, 11, 17, 3, -20 },
  { 1842, 13, 3, 17, 2, 0 },
  { 1847, 6, 4, 17, 6, -20 },
  { 1850, 13, 15, 17, 2, -15 },
  { 1875, 13, 21, 17, 2, -21 },
  { 1910, 13, 15, 17, 2, -15 },
  { 1935, 13, 21, 17, 2, -21 },
  { 1970, 13, 15, 17, 2, -15 },
  { 1995, 14, 22, 17, 2, -22 },
  { 2034, 13, 21, 17, 2, -15 },
  { 2069, 13, 21, 17, 2, -21 },
  { 2104, 12, 21, 17, 3, -21 },
  { 2136, 9, 27, 17, 3, -21 },
  { 2167, 14, 21, 17, 2, -21 },
  { 2204, 12, 21, 17, 3, -21 },
  { 2236, 15, 15, 17, 1, -15 },
  { 2265, 13, 15, 17, 2, -15 },
  { 2290, 14, 15, 17, 1, -15 },
  { 2317, 13, 21, 17, 2, -15 },
  { 2352, 13, 21, 17, 2, -15 },
  { 2387, 11, 15, 17, 4, -15 },
  { 2408, 13, 15, 17, 2, -15 },
  { 2433, 13, 18, 17, 2, -18 },
  { 2463, 13, 15, 17, 2, -15 },
  { 2488, 15, 15, 17, 1, -15 },
  { 2517, 16, 15, 17, 0, -15 },
  { 2547, 15, 15, 17, 1, -15 },
  { 2576, 16, 21, 17, 1, -15 },
  { 2618, 13, 15, 17, 2, -15 },
  { 2643, 9, 27, 17, 4, -22 },
  { 2674, 3, 26, 17, 7, -20 },
  { 2684, 9, 27, 17, 5, -22 },
  { 2715, 16, 6, 17, 0, -11 },
};

const GFXfont RobotoMono_SemiBold28pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold28pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _ROBOTOMONO_SEMIBOLD28PT7B_H_
