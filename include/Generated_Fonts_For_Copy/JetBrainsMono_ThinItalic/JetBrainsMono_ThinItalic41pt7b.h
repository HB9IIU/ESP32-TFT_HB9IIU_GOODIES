#ifndef _JETBRAINSMONO_THINITALIC41PT7B_H_
#define _JETBRAINSMONO_THINITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x38,
  0x39, 0x81, 0x9C, 0x0C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0x81, 0xCC, 0x0C,
  0x60, 0x63, 0x03, 0x38, 0x19, 0x81, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x18,
  0x0E, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x70,
  0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x1F, 0xFF,
  0xFF, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0xE0, 0x01, 0x80,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x06, 0x03, 0x08, 0xFF, 0xFF, 0xF0, 0x0C, 0x06,
  0x00, 0x1C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0x8C,
  0x70, 0x38, 0x61, 0x81, 0x83, 0x0C, 0x1C, 0x10, 0x70, 0xC0, 0x83, 0x86,
  0x0C, 0x18, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x80,
  0x01, 0xE4, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0xDE, 0x00, 0x04, 0x38, 0x00, 0x20, 0xC0, 0x01, 0x06, 0x00, 0x18, 0x38,
  0x00, 0xC1, 0xC6, 0x06, 0x0C, 0x30, 0x30, 0x61, 0x81, 0x03, 0x0C, 0x08,
  0x38, 0x70, 0xC1, 0x81, 0xC6, 0x38, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x3F, 0xC0, 0x0E, 0x03,
  0x06, 0x00, 0xC0, 0x60, 0x60, 0x18, 0x04, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x60, 0x0C, 0x06, 0x0C, 0x00, 0xC0, 0x61, 0x80, 0x0C, 0x0C, 0x38, 0x00,
  0xC0, 0xC3, 0x00, 0x0C, 0x0C, 0x60, 0x00, 0xE3, 0x8C, 0x00, 0x07, 0xF1,
  0x80, 0x00, 0x08, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x01, 0x8F, 0xE0, 0x00, 0x31, 0x86, 0x00, 0x06,
  0x30, 0x30, 0x00, 0xC3, 0x03, 0x00, 0x18, 0x60, 0x30, 0x03, 0x06, 0x03,
  0x00, 0x30, 0x60, 0x20, 0x06, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x60, 0x18,
  0x06, 0x06, 0x03, 0x00, 0x60, 0xC0, 0x60, 0x07, 0xF8, 0x0C, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0C, 0x0E, 0x00, 0x60, 0x18,
  0x03, 0x80, 0x70, 0x0C, 0x00, 0xC0, 0x30, 0x07, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0xE6, 0x00, 0x06, 0x1C, 0x03, 0x38, 0x30, 0x18,
  0xC0, 0xE0, 0xC3, 0x01, 0x83, 0x1C, 0x03, 0x18, 0x60, 0x0E, 0xC1, 0x80,
  0x1B, 0x06, 0x00, 0x78, 0x18, 0x00, 0xC0, 0x60, 0x07, 0x81, 0x80, 0x3F,
  0x06, 0x01, 0xCC, 0x1C, 0x0E, 0x38, 0x3D, 0xF0, 0x60, 0x7F, 0x00, 0xC0,
  0x39, 0x8C, 0xE7, 0x39, 0xCC, 0x63, 0x39, 0x80, 0x00, 0x00, 0x80, 0x03,
  0x80, 0x07, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0x80, 0x02, 0x00, 0x03,
  0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x02, 0x01, 0xC0, 0x5E,
  0x0C, 0x0F, 0xFC, 0x63, 0xF8, 0xFB, 0x7E, 0x01, 0xFF, 0x80, 0x01, 0xC0,
  0x00, 0x1A, 0x00, 0x01, 0xD8, 0x00, 0x1C, 0xE0, 0x01, 0xC3, 0x00, 0x0C,
  0x1C, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x0E, 0x02, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x87, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x30, 0x18, 0x18,
  0x0C, 0x00, 0xFF, 0xF8, 0x31, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0x81, 0xC0, 0xE0, 0x0E,
  0x0C, 0x00, 0x61, 0xC0, 0x07, 0x18, 0x00, 0x71, 0x80, 0x07, 0x38, 0x00,
  0x63, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xE3, 0x0F,
  0x0E, 0x70, 0xF0, 0xC7, 0x0F, 0x0C, 0x60, 0x60, 0xC6, 0x00, 0x0C, 0x60,
  0x00, 0xC6, 0x00, 0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x18, 0xC0, 0x01, 0x8C,
  0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x30, 0x60, 0x06, 0x07, 0x81, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x60,
  0x03, 0x98, 0x03, 0x86, 0x01, 0xC1, 0x80, 0xC0, 0xE0, 0x20, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xE0, 0x1C, 0x0C, 0x00, 0x60,
  0xE0, 0x03, 0x86, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00,
  0x60, 0xE0, 0x0E, 0x07, 0x01, 0xC0, 0x3E, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x30, 0x60, 0x1C, 0x30, 0x06, 0x18,
  0x01, 0x8E, 0x00, 0x67, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x9F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x07, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x38, 0x01, 0x9F,
  0xF0, 0x1B, 0x0F, 0x81, 0xC0, 0x38, 0x38, 0x01, 0x83, 0x80, 0x1C, 0x30,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x0E, 0x00, 0x30,
  0x60, 0x06, 0x07, 0x00, 0xC0, 0x3E, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0xFC, 0x07, 0xFF, 0xC1, 0xE0, 0x78, 0xE0, 0x0E, 0x30, 0x01,
  0xD8, 0x00, 0x36, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0xB0, 0x00, 0xC6, 0x00, 0x61, 0xC0,
  0x38, 0x3E, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0x80,
  0x01, 0xB0, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x03, 0x38, 0x00, 0x66, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00,
  0xE0, 0x1C, 0x06, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x1C, 0x30, 0x00,
  0xE1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x01, 0x80, 0x38, 0x0E,
  0x03, 0x80, 0x38, 0x30, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x80,
  0x07, 0x07, 0x00, 0x70, 0x1C, 0x06, 0x00, 0x70, 0x70, 0x01, 0x83, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x0C, 0x1C, 0x00, 0xE0, 0x70, 0x0E, 0x01, 0xF7, 0xE0, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xC0, 0x30, 0xE0, 0x06, 0x30, 0x01,
  0x98, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0xB8, 0x00, 0xC6, 0x00, 0x71, 0xC0,
  0x78, 0x3F, 0xFC, 0x07, 0xF3, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x0F, 0xC7,
  0xE3, 0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x1F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE0, 0x01,
  0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x03, 0xF0, 0x1F, 0xC0, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFB, 0xE0, 0x07, 0x00, 0xE0,
  0x1C, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x1F, 0x18, 0xC0,
  0x7F, 0xE1, 0x81, 0xC3, 0xC7, 0x07, 0x03, 0x8C, 0x0C, 0x03, 0x18, 0x18,
  0x06, 0x30, 0x60, 0x0C, 0x60, 0xC0, 0x38, 0xC1, 0x80, 0x63, 0x83, 0x00,
  0xC6, 0x06, 0x01, 0x8C, 0x0C, 0x03, 0x18, 0x38, 0x06, 0x30, 0x70, 0x1C,
  0x60, 0x60, 0x70, 0xC0, 0xE1, 0xE3, 0x80, 0xFE, 0xC6, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0D, 0x80,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x0C, 0xC0, 0x01, 0x88, 0x00, 0x61, 0x00,
  0x0C, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x03, 0x00,
  0x60, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x18, 0x18, 0x03, 0x03,
  0x00, 0x60, 0xFF, 0xFC, 0x18, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x19, 0xC0, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x07, 0x80,
  0x00, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0C, 0x01, 0xC0, 0xC0, 0x0E,
  0x0C, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00,
  0x61, 0x80, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x38, 0x03, 0x83, 0x01,
  0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x30, 0x03, 0x83, 0x00, 0x18, 0x30,
  0x01, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0xC6,
  0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x01, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0x00,
  0xE0, 0x60, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80,
  0x03, 0x18, 0x00, 0x41, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0x60, 0x07,
  0x03, 0x00, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x30, 0x0E, 0x06, 0x00, 0xE0, 0xC0, 0x0C, 0x18, 0x01, 0xC6, 0x00,
  0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x63, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x30,
  0x60, 0x1C, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC3, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFC, 0x03, 0x00, 0xE0, 0x60, 0x06, 0x0C, 0x00, 0x60, 0xC0,
  0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x41, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x07, 0xFC, 0x30, 0x7F, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C,
  0x60, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01,
  0x86, 0x00, 0x30, 0x60, 0x07, 0x03, 0x00, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0x00, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C,
  0x00, 0x60, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61,
  0x80, 0x0E, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x38, 0x00, 0xC3, 0x00, 0x0C,
  0x3F, 0xFF, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01,
  0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00,
  0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0,
  0x07, 0x0C, 0x00, 0x60, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03,
  0x07, 0x00, 0x18, 0x18, 0x01, 0x80, 0xE0, 0x1C, 0x03, 0xEF, 0xC0, 0x0F,
  0xF8, 0x00, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x01, 0xC0, 0x1C, 0x06, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0x38,
  0x1C, 0x00, 0xC0, 0x60, 0x03, 0xFF, 0x00, 0x0C, 0x0E, 0x00, 0x30, 0x18,
  0x00, 0xC0, 0x60, 0x03, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x38, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x07, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xE0, 0xC0, 0x01, 0x83, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xD0,
  0x06, 0x83, 0x40, 0x1E, 0x0D, 0x80, 0xD8, 0x36, 0x03, 0x60, 0xD8, 0x19,
  0x83, 0x20, 0x46, 0x18, 0x83, 0x30, 0x63, 0x08, 0xC1, 0x8C, 0x63, 0x06,
  0x31, 0x0C, 0x18, 0x4C, 0x30, 0x61, 0x20, 0xC3, 0x07, 0x87, 0x0C, 0x1C,
  0x18, 0x30, 0x70, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60,
  0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01,
  0x83, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x30, 0xF0, 0x03, 0x0F, 0x00, 0x30,
  0xF0, 0x03, 0x0F, 0x00, 0x60, 0xD8, 0x06, 0x19, 0x80, 0x61, 0x98, 0x06,
  0x19, 0x80, 0x61, 0x88, 0x06, 0x18, 0xC0, 0xC1, 0x8C, 0x0C, 0x30, 0xC0,
  0xC3, 0x04, 0x0C, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x30, 0x61, 0x83, 0x02,
  0x18, 0x30, 0x31, 0x86, 0x03, 0x18, 0x60, 0x31, 0x86, 0x03, 0x18, 0x60,
  0x1B, 0x06, 0x01, 0xB0, 0x60, 0x1B, 0x0C, 0x01, 0xB0, 0xC0, 0x0F, 0x0C,
  0x00, 0xF0, 0xC0, 0x0F, 0x0C, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x0C, 0x07, 0x03, 0x00, 0x70, 0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x18,
  0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x9C, 0x00, 0x63,
  0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xCE,
  0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x18, 0x38,
  0x06, 0x03, 0xEF, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0x00, 0x38, 0x18, 0x00, 0xE0, 0xC0, 0x03, 0x06, 0x00, 0x1C, 0x60,
  0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x30, 0x00, 0xE3, 0x80, 0x06, 0x18, 0x00, 0xE0, 0xC0, 0x1E, 0x07, 0xFF,
  0xE0, 0x3F, 0xF8, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0C, 0x07, 0x03, 0x00, 0x70,
  0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x0C, 0x60, 0x01, 0x9C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C,
  0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xCE, 0x00, 0x31, 0x80, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x60,
  0x03, 0x0C, 0x00, 0xE1, 0x80, 0x18, 0x38, 0x06, 0x03, 0xEF, 0x80, 0x1F,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0x00, 0x78, 0x18, 0x00, 0xE0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x1C, 0x30,
  0x00, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0xE0, 0xC0, 0x7E, 0x07, 0xFF, 0xC0,
  0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x06, 0x06,
  0x00, 0x30, 0x30, 0x01, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0x60,
  0x60, 0x03, 0x03, 0x00, 0x1C, 0x30, 0x00, 0xE1, 0x80, 0x06, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x71, 0x80,
  0x03, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x1C, 0x00, 0x60,
  0x70, 0x0E, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x61,
  0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06,
  0x18, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00,
  0xC3, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x00, 0x18, 0x70, 0x01, 0x86, 0x00,
  0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x30, 0x60,
  0x03, 0x06, 0x00, 0x70, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x3E, 0xF8, 0x00,
  0xFF, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0xCC,
  0x00, 0x19, 0x80, 0x06, 0x38, 0x00, 0xC3, 0x00, 0x38, 0x60, 0x06, 0x0C,
  0x00, 0xC1, 0x80, 0x30, 0x30, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x0E, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18,
  0x60, 0x03, 0x0C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x40, 0x38, 0x0D, 0x00, 0xE0, 0x7C, 0x07, 0x81, 0xB0, 0x1E,
  0x06, 0xC0, 0x58, 0x1B, 0x03, 0x40, 0xCC, 0x0D, 0x03, 0x30, 0x24, 0x0C,
  0xC1, 0x90, 0x33, 0x06, 0x41, 0x8C, 0x11, 0x06, 0x30, 0x44, 0x18, 0xC3,
  0x10, 0xC3, 0x0C, 0x43, 0x0C, 0x21, 0x0C, 0x31, 0x84, 0x30, 0xC6, 0x11,
  0x83, 0x10, 0x46, 0x0C, 0xC1, 0x18, 0x33, 0x04, 0x40, 0xC8, 0x13, 0x03,
  0x20, 0x4C, 0x0D, 0x81, 0x30, 0x34, 0x05, 0x80, 0xD0, 0x16, 0x03, 0xC0,
  0x58, 0x0A, 0x01, 0x40, 0x28, 0x07, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0xF0,
  0x00, 0x03, 0x00, 0x03, 0x81, 0xC0, 0x03, 0x80, 0x60, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x0C, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x06, 0x00,
  0x18, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0x98, 0x00, 0x18, 0xC0, 0x01, 0x83, 0x00, 0x1C,
  0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0,
  0x60, 0x03, 0x07, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x03, 0x38, 0x00,
  0x19, 0x80, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xB0, 0x01, 0x98, 0x03, 0x18, 0x07,
  0x18, 0x06, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x0C, 0x38, 0x0E, 0x30,
  0x06, 0x70, 0x06, 0xE0, 0x06, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0x1C, 0x61, 0x8C, 0x00, 0xF8, 0x60, 0x7F, 0xCC, 0x1C, 0x0F, 0x86,
  0x00, 0xE1, 0x80, 0x1C, 0x30, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x31, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0,
  0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80,
  0x1C, 0x30, 0x03, 0x87, 0x01, 0xB0, 0x7D, 0xEE, 0x07, 0xF9, 0x80, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x61, 0xF0, 0x19, 0xFF, 0x06, 0xC0, 0xE1, 0xC0, 0x18,
  0x70, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x63, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00,
  0x66, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x63,
  0x40, 0x30, 0xDE, 0x78, 0x33, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x1C, 0x0E, 0x06, 0x00, 0xE1, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x31,
  0x80, 0x06, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x01, 0x8C,
  0x00, 0x61, 0x80, 0x0C, 0x30, 0x03, 0x07, 0x00, 0xE0, 0x7F, 0xF8, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0x86, 0x03, 0xFE,
  0x60, 0x70, 0x3E, 0x0C, 0x01, 0xC1, 0x80, 0x1C, 0x18, 0x00, 0xC3, 0x00,
  0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0x87, 0x00, 0x18, 0x60,
  0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x70, 0x60, 0x07, 0x07, 0x01, 0xB0,
  0x3E, 0xF7, 0x01, 0xFE, 0x60, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x38,
  0x30, 0x06, 0x18, 0x01, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x37, 0xFF, 0xF9, 0xFF, 0xFE, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x18, 0x70, 0x0C, 0x0F, 0x9E, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x60, 0x7F, 0xCC, 0x1C, 0x0F,
  0x86, 0x00, 0xE1, 0x80, 0x1C, 0x30, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x31, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18,
  0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0x60, 0x03, 0x0E, 0x00, 0xE0,
  0xC0, 0x2C, 0x1F, 0x79, 0x80, 0xFE, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x0F, 0x80, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x61, 0xF0, 0x19,
  0xFF, 0x06, 0xC0, 0xE1, 0xC0, 0x18, 0x70, 0x07, 0x38, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x39, 0x80, 0x0C, 0x60,
  0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01,
  0x80, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x0F, 0xFC, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x18, 0x00, 0x61, 0x80, 0x0E, 0x18,
  0x01, 0xC1, 0x80, 0x38, 0x18, 0x07, 0x03, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x30, 0x38, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0x06, 0x00,
  0x60, 0x30, 0x06, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x60, 0x0C,
  0x06, 0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00,
  0x38, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x07,
  0xFE, 0x0C, 0xF0, 0xF0, 0x3F, 0xE7, 0xE0, 0xE1, 0xA1, 0x83, 0x07, 0x06,
  0x1C, 0x1C, 0x18, 0x60, 0x60, 0x61, 0x81, 0x81, 0x86, 0x06, 0x06, 0x18,
  0x18, 0x18, 0x60, 0x60, 0x63, 0x03, 0x01, 0x8C, 0x0C, 0x0C, 0x30, 0x30,
  0x30, 0xC0, 0xC0, 0xC3, 0x03, 0x03, 0x0C, 0x0C, 0x0C, 0x60, 0x30, 0x31,
  0x81, 0x81, 0x86, 0x06, 0x06, 0x18, 0x18, 0x18, 0x60, 0x60, 0x61, 0x81,
  0x81, 0x8E, 0x06, 0x06, 0x00, 0x18, 0x7C, 0x06, 0x7F, 0xC1, 0xB0, 0x38,
  0x70, 0x06, 0x1C, 0x01, 0xCE, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x73, 0x00, 0x18, 0xC0, 0x06, 0x60, 0x01, 0x98, 0x00,
  0x66, 0x00, 0x19, 0x80, 0x0E, 0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x60, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x70, 0x38, 0x30, 0x06, 0x18, 0x01, 0xC6, 0x00, 0x33, 0x00,
  0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x37, 0x00, 0x19, 0x80, 0x06,
  0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x71, 0x80, 0x18, 0x70, 0x0C, 0x0F, 0xBE, 0x00, 0xFF,
  0x00, 0x0C, 0x3E, 0x01, 0x9F, 0xF0, 0x36, 0x07, 0x07, 0x00, 0x60, 0xE0,
  0x06, 0x38, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x0C, 0x60, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x31, 0x80, 0x06, 0x30, 0x01, 0x86, 0x00, 0x31, 0xC0, 0x06, 0x38, 0x01,
  0x86, 0x80, 0x60, 0xDE, 0x78, 0x19, 0xFE, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x60, 0x7F, 0xCC, 0x1C, 0x0F, 0x86, 0x00, 0xE1, 0x80,
  0x1C, 0x30, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00,
  0x31, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00,
  0x63, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x1C, 0x30, 0x03,
  0x87, 0x01, 0xB0, 0x7D, 0xEE, 0x07, 0xF9, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x0C, 0x7E, 0x01, 0xBF, 0xF0, 0x3E, 0x07, 0x0F, 0x00, 0x61, 0xC0,
  0x0E, 0x38, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xF0, 0x38, 0x07, 0x0E, 0x00, 0x61, 0x80, 0x0C, 0x70, 0x01, 0x8C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x01, 0x8E, 0x00, 0x70, 0xF8, 0x7C,
  0x0F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x18, 0x00, 0x63,
  0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x01, 0x8C,
  0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x06, 0x38,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x1C, 0x60,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x1C, 0x38, 0x03, 0x03, 0x01, 0xC0, 0x7D,
  0xF0, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1B, 0x00,
  0x0E, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x18, 0x60, 0x0C,
  0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x0C, 0x0C, 0x01,
  0x06, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x98, 0x00, 0x26,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x60, 0x3C, 0x06,
  0x03, 0xC0, 0xE0, 0x3C, 0x0A, 0x06, 0xC0, 0xA0, 0x6C, 0x1A, 0x06, 0xC1,
  0x20, 0xCC, 0x32, 0x0C, 0xC3, 0x20, 0xCC, 0x22, 0x18, 0xC6, 0x21, 0x8C,
  0x62, 0x18, 0xC4, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x33, 0x0C, 0x83, 0x60,
  0xD8, 0x36, 0x0D, 0x83, 0x60, 0xD0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0xE0,
  0x70, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x80, 0xC0, 0x06, 0x07, 0x00, 0x0C,
  0x38, 0x00, 0x30, 0xC0, 0x00, 0x66, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xB0, 0x00, 0x0C, 0xC0, 0x00,
  0x61, 0x80, 0x03, 0x06, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x30, 0x07, 0x00,
  0x60, 0x38, 0x01, 0x80, 0xC0, 0x03, 0x0E, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0xE3, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x00, 0xC3, 0x00, 0x18,
  0x60, 0x07, 0x0C, 0x00, 0xE1, 0xC0, 0x6C, 0x1F, 0x79, 0x81, 0xFE, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x81, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0x03,
  0x07, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00,
  0x67, 0xF0, 0x0D, 0xC3, 0x01, 0xB0, 0x30, 0x36, 0x07, 0x0C, 0xC0, 0x73,
  0xB0, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_ThinItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 9, 30, 25, 8, -30 },
  { 35, 13, 12, 25, 8, -30 },
  { 55, 24, 30, 25, 1, -30 },
  { 145, 21, 42, 25, 2, -36 },
  { 256, 28, 30, 25, -1, -30 },
  { 361, 22, 30, 25, 1, -30 },
  { 444, 5, 12, 25, 12, -30 },
  { 452, 17, 40, 25, 7, -35 },
  { 537, 16, 40, 25, 2, -35 },
  { 617, 21, 21, 25, 3, -25 },
  { 673, 19, 19, 25, 3, -23 },
  { 719, 9, 13, 25, 5, -6 },
  { 734, 13, 1, 25, 6, -14 },
  { 736, 6, 6, 25, 8, -6 },
  { 741, 23, 39, 25, 1, -34 },
  { 854, 20, 30, 25, 3, -30 },
  { 929, 18, 30, 25, 2, -30 },
  { 997, 21, 30, 25, 2, -30 },
  { 1076, 20, 30, 25, 3, -30 },
  { 1151, 18, 30, 25, 3, -30 },
  { 1219, 20, 30, 25, 3, -30 },
  { 1294, 18, 30, 25, 3, -30 },
  { 1362, 19, 30, 25, 5, -30 },
  { 1434, 21, 30, 25, 2, -30 },
  { 1513, 18, 30, 25, 5, -30 },
  { 1581, 9, 23, 25, 8, -23 },
  { 1607, 12, 30, 25, 5, -23 },
  { 1652, 19, 21, 25, 4, -24 },
  { 1702, 19, 11, 25, 3, -19 },
  { 1729, 19, 21, 25, 2, -24 },
  { 1779, 16, 30, 25, 7, -30 },
  { 1839, 23, 37, 25, 1, -30 },
  { 1946, 19, 30, 25, 1, -30 },
  { 2018, 20, 30, 25, 3, -30 },
  { 2093, 20, 30, 25, 3, -30 },
  { 2168, 19, 30, 25, 3, -30 },
  { 2240, 21, 30, 25, 3, -30 },
  { 2319, 21, 30, 25, 3, -30 },
  { 2398, 20, 30, 25, 3, -30 },
  { 2473, 20, 30, 25, 3, -30 },
  { 2548, 20, 30, 25, 3, -30 },
  { 2623, 21, 30, 25, 2, -30 },
  { 2702, 22, 30, 25, 3, -30 },
  { 2785, 17, 30, 25, 3, -30 },
  { 2849, 22, 30, 25, 2, -30 },
  { 2932, 20, 30, 25, 3, -30 },
  { 3007, 19, 30, 25, 3, -30 },
  { 3079, 21, 30, 25, 3, -30 },
  { 3158, 19, 37, 25, 3, -30 },
  { 3246, 21, 30, 25, 3, -30 },
  { 3325, 21, 30, 25, 2, -30 },
  { 3404, 20, 30, 25, 5, -30 },
  { 3479, 20, 30, 25, 3, -30 },
  { 3554, 19, 30, 25, 6, -30 },
  { 3626, 22, 30, 25, 4, -30 },
  { 3709, 25, 30, 25, 0, -30 },
  { 3803, 21, 30, 25, 5, -30 },
  { 3882, 21, 30, 25, 2, -30 },
  { 3961, 15, 39, 25, 7, -34 },
  { 4035, 11, 39, 25, 7, -34 },
  { 4089, 15, 39, 25, 4, -34 },
  { 4163, 16, 16, 25, 5, -30 },
  { 4195, 20, 2, 25, 0, 1 },
  { 4200, 5, 6, 25, 12, -32 },
  { 4204, 19, 23, 25, 3, -23 },
  { 4259, 18, 30, 25, 3, -30 },
  { 4327, 19, 23, 25, 3, -23 },
  { 4382, 20, 30, 25, 3, -30 },
  { 4457, 18, 23, 25, 3, -23 },
  { 4509, 25, 37, 25, -1, -30 },
  { 4625, 19, 30, 25, 3, -23 },
  { 4697, 18, 30, 25, 3, -30 },
  { 4765, 18, 31, 25, 2, -31 },
  { 4835, 20, 38, 25, 1, -31 },
  { 4930, 20, 30, 25, 3, -30 },
  { 5005, 16, 30, 25, 5, -30 },
  { 5065, 22, 23, 25, 1, -23 },
  { 5129, 18, 23, 25, 3, -23 },
  { 5181, 18, 23, 25, 3, -23 },
  { 5233, 19, 30, 25, 2, -23 },
  { 5305, 19, 30, 25, 3, -23 },
  { 5377, 19, 23, 25, 3, -23 },
  { 5432, 19, 23, 25, 3, -23 },
  { 5487, 18, 29, 25, 4, -29 },
  { 5553, 19, 23, 25, 3, -23 },
  { 5608, 18, 23, 25, 5, -23 },
  { 5660, 20, 23, 25, 4, -23 },
  { 5718, 22, 23, 25, 1, -23 },
  { 5782, 19, 30, 25, 3, -23 },
  { 5854, 20, 23, 25, 2, -23 },
  { 5912, 20, 39, 25, 4, -34 },
  { 6010, 8, 39, 25, 9, -34 },
  { 6049, 19, 39, 25, 2, -34 },
  { 6142, 19, 7, 25, 3, -18 },
};

const GFXfont JetBrainsMono_ThinItalic41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_THINITALIC41PT7B_H_
