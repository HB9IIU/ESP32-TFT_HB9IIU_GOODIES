#ifndef _JETBRAINSMONO_THINITALIC56PT7B_H_
#define _JETBRAINSMONO_THINITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x00, 0x3C, 0x03,
  0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x7B, 0xC0, 0x39, 0xE0,
  0x1C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x9C, 0x03, 0x8E, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x71, 0x80, 0x39, 0xC0, 0x18, 0xE0, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7E, 0x67, 0xC0, 0x0F, 0x0E, 0x1E, 0x01, 0xE0, 0xE0, 0xE0, 0x1C,
  0x0C, 0x0F, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x00, 0xC0,
  0x70, 0x70, 0x1C, 0x07, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x78, 0x18, 0x00, 0x03, 0x81, 0x80, 0x00, 0x3C, 0x18,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x1F, 0x30, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0x3E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x0C, 0x03, 0x87, 0x00, 0xC0, 0x38, 0x70, 0x0C, 0x03,
  0x87, 0x00, 0xC0, 0x70, 0x70, 0x0C, 0x07, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x18, 0x1E, 0x03, 0xC1, 0x83, 0xC0, 0x1F, 0x18, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3C, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x0F, 0x0E, 0x00, 0x06, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x01, 0x80, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0xC0,
  0x0E, 0x00, 0x30, 0x03, 0x00, 0x70, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x03,
  0x00, 0x70, 0x0C, 0x00, 0x1C, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x06, 0x03,
  0x80, 0x01, 0xC0, 0x18, 0x1C, 0x00, 0x06, 0x00, 0x60, 0xE0, 0x00, 0x1C,
  0x03, 0x87, 0x00, 0x00, 0x70, 0x0C, 0x38, 0x00, 0x01, 0xE0, 0xF0, 0xC0,
  0x00, 0x03, 0xFF, 0x86, 0x00, 0x00, 0x07, 0xF8, 0x38, 0x00, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x60, 0xFF, 0x00, 0x00, 0x03, 0x87, 0xFE, 0x00, 0x00, 0x1C, 0x38, 0x3C,
  0x00, 0x00, 0xE1, 0xC0, 0x70, 0x00, 0x07, 0x06, 0x00, 0xC0, 0x00, 0x38,
  0x38, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x70,
  0x00, 0x38, 0x0C, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x07, 0x00, 0x0E, 0x01,
  0xC0, 0x18, 0x00, 0x70, 0x07, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x03,
  0x83, 0x80, 0x1C, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x70, 0x0F, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xB8, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x1C, 0x70, 0x1C, 0x01, 0xC7,
  0x00, 0xF0, 0x0E, 0x38, 0x03, 0x80, 0xE1, 0x80, 0x0E, 0x0E, 0x1C, 0x00,
  0x70, 0x60, 0xE0, 0x01, 0xC7, 0x07, 0x00, 0x0F, 0x70, 0x38, 0x00, 0x3B,
  0x01, 0xC0, 0x00, 0xF8, 0x0E, 0x00, 0x07, 0x80, 0x60, 0x00, 0x3C, 0x07,
  0x00, 0x01, 0xF0, 0x38, 0x00, 0x1F, 0x81, 0xC0, 0x01, 0xCE, 0x07, 0x00,
  0x1C, 0x70, 0x3C, 0x03, 0xC1, 0xC1, 0xF0, 0x7C, 0x0E, 0x07, 0xFF, 0xC0,
  0x38, 0x1F, 0xF8, 0x00, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x3C, 0xE3, 0x9E,
  0x79, 0xE7, 0x9E, 0x73, 0xCF, 0x3C, 0xF3, 0x8E, 0x38, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x20, 0x03, 0x80, 0x0B, 0xC0, 0x1C, 0x01, 0xDF, 0xC0, 0xC0, 0x7F,
  0xFF, 0x86, 0x1F, 0xF0, 0xFF, 0x33, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x10, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x3C, 0x00, 0x3C,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0xE0, 0x3C, 0x0E, 0x1C,
  0x0F, 0x81, 0xC3, 0x81, 0xF8, 0x38, 0x70, 0x3E, 0x07, 0x0E, 0x03, 0xC0,
  0xE3, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1E, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x80,
  0x78, 0x01, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xE7, 0x00, 0x03, 0xC3, 0x80,
  0x03, 0xC1, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x01, 0x00, 0x38,
  0x01, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7C, 0x0F,
  0xC0, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0,
  0x78, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x80,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x06, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x0E,
  0x38, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x81, 0xF8, 0x00, 0x71, 0xFF, 0xC0, 0x0E, 0x7F, 0xFC,
  0x01, 0xF8, 0x07, 0xC0, 0x36, 0x00, 0x38, 0x0F, 0x80, 0x07, 0x81, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x0F,
  0x80, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x83, 0x80, 0x01, 0x9F, 0xF8, 0x01, 0xFF, 0xFF,
  0x01, 0xF8, 0x0F, 0xC1, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x07, 0x81, 0xE0, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xC0,
  0x00, 0x07, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3C,
  0x0F, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x30,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x1C, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x1C,
  0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x07, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03,
  0x98, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x7C, 0x07, 0x80, 0x7E, 0x01, 0xFF, 0xFB, 0x00, 0x1F, 0xF9, 0xC0,
  0x00, 0xF0, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x1F, 0xF0, 0xFE, 0x0F, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x3E, 0x07, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x01, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x04, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x3F, 0xCE, 0x0E, 0x00,
  0x7F, 0xEE, 0x0E, 0x00, 0xFD, 0xFE, 0x0E, 0x01, 0xE0, 0x3E, 0x0E, 0x03,
  0x80, 0x1E, 0x0C, 0x03, 0x80, 0x1C, 0x1C, 0x03, 0x00, 0x1C, 0x1C, 0x07,
  0x00, 0x1C, 0x1C, 0x07, 0x00, 0x1C, 0x1C, 0x07, 0x00, 0x1C, 0x1C, 0x07,
  0x00, 0x1C, 0x18, 0x07, 0x00, 0x1C, 0x38, 0x06, 0x00, 0x18, 0x38, 0x0E,
  0x00, 0x38, 0x38, 0x0E, 0x00, 0x38, 0x38, 0x0E, 0x00, 0x38, 0x38, 0x0E,
  0x00, 0x38, 0x30, 0x0E, 0x00, 0x78, 0x70, 0x0E, 0x00, 0x70, 0x70, 0x0E,
  0x00, 0xF0, 0x70, 0x0F, 0x01, 0xB0, 0x70, 0x07, 0xFF, 0x70, 0x70, 0x03,
  0xFE, 0x70, 0x70, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x30,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00,
  0x70, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x03, 0x80, 0x70,
  0x00, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x18,
  0x00, 0x38, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0x80,
  0x07, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x0C, 0x00, 0x0F, 0x03, 0x80, 0x03,
  0xC0, 0x70, 0x03, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x38,
  0x01, 0xF8, 0x06, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x78, 0x30, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x03, 0xE0,
  0x7C, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0C, 0x00,
  0x7C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x18, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0C, 0x00,
  0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xF0,
  0x38, 0x00, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0x00,
  0x1E, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x03, 0xFF, 0xC7,
  0x00, 0xFF, 0xF1, 0xC0, 0x7F, 0xFC, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x61, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x70,
  0x1E, 0x00, 0x38, 0x03, 0xE0, 0x7C, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0C,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x07, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x70,
  0x0F, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x07,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0xD8, 0x00, 0x36, 0x06,
  0xC0, 0x03, 0xF0, 0x76, 0x00, 0x1B, 0x83, 0xB0, 0x01, 0xDC, 0x1D, 0xC0,
  0x0C, 0xC0, 0xE6, 0x00, 0xE6, 0x06, 0x30, 0x06, 0x70, 0x31, 0x80, 0x73,
  0x81, 0x8C, 0x03, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0xE1, 0x81, 0x87, 0x07,
  0x0C, 0x1C, 0x30, 0x38, 0x60, 0xC3, 0x81, 0x83, 0x0E, 0x1C, 0x0C, 0x1C,
  0x60, 0xE0, 0xE0, 0x66, 0x07, 0x07, 0x03, 0x30, 0x38, 0x38, 0x1B, 0x01,
  0x81, 0xC0, 0xD8, 0x1C, 0x0E, 0x07, 0x80, 0xE0, 0x60, 0x1C, 0x07, 0x07,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x78, 0x00, 0x0C,
  0x0F, 0x80, 0x03, 0x81, 0xF0, 0x00, 0x70, 0x76, 0x00, 0x0E, 0x0E, 0xC0,
  0x01, 0xC1, 0xD8, 0x00, 0x30, 0x3B, 0x80, 0x06, 0x07, 0x30, 0x01, 0xC0,
  0xC6, 0x00, 0x38, 0x18, 0xC0, 0x07, 0x07, 0x1C, 0x00, 0xE0, 0xE3, 0x80,
  0x1C, 0x1C, 0x30, 0x03, 0x03, 0x86, 0x00, 0xE0, 0x60, 0xE0, 0x1C, 0x0C,
  0x1C, 0x03, 0x83, 0x81, 0x80, 0x70, 0x70, 0x30, 0x0E, 0x0E, 0x07, 0x01,
  0x81, 0xC0, 0xE0, 0x30, 0x38, 0x0C, 0x0E, 0x06, 0x01, 0x81, 0xC1, 0xC0,
  0x38, 0x38, 0x38, 0x07, 0x07, 0x07, 0x00, 0x60, 0xC0, 0xE0, 0x0C, 0x18,
  0x1C, 0x01, 0xC7, 0x03, 0x00, 0x38, 0xE0, 0x60, 0x07, 0x1C, 0x1C, 0x00,
  0x63, 0x83, 0x80, 0x0C, 0x60, 0x70, 0x01, 0xCC, 0x0E, 0x00, 0x39, 0x81,
  0x80, 0x03, 0x70, 0x30, 0x00, 0x6E, 0x0E, 0x00, 0x0F, 0xC1, 0xC0, 0x01,
  0xF8, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0x03, 0xE0, 0x07, 0x00,
  0x3C, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x30, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x87,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0x70, 0x00, 0xF0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0x00, 0x3C, 0x03,
  0x80, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x7C, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x13, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x7C, 0x07, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x0F, 0x01, 0xC0, 0x03, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03,
  0x80, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x06, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C,
  0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00,
  0x06, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0C, 0x07, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C,
  0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x18,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x70, 0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x07, 0x38, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x30, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x03,
  0x80, 0x30, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00,
  0x60, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x0D, 0xC0, 0x0F, 0x00, 0x77, 0x00, 0x7C, 0x01, 0xDC, 0x01,
  0xB0, 0x06, 0x70, 0x06, 0xC0, 0x39, 0xC0, 0x3B, 0x00, 0xE7, 0x00, 0xDC,
  0x03, 0x9C, 0x03, 0x70, 0x0C, 0x60, 0x0D, 0xC0, 0x71, 0x80, 0x66, 0x01,
  0xC6, 0x01, 0x98, 0x06, 0x18, 0x06, 0x60, 0x18, 0x60, 0x39, 0x80, 0xE1,
  0x80, 0xC6, 0x03, 0x86, 0x03, 0x18, 0x0C, 0x18, 0x1C, 0x60, 0x70, 0x60,
  0x61, 0x81, 0xC1, 0x81, 0x86, 0x06, 0x06, 0x06, 0x18, 0x18, 0x18, 0x30,
  0x60, 0xE0, 0x60, 0xC1, 0x83, 0x83, 0x83, 0x06, 0x0C, 0x0E, 0x18, 0x18,
  0x70, 0x38, 0x60, 0x61, 0xC0, 0xE1, 0x81, 0x86, 0x03, 0x8E, 0x06, 0x18,
  0x0E, 0x30, 0x18, 0xE0, 0x38, 0xC0, 0x63, 0x80, 0xE3, 0x01, 0x8C, 0x03,
  0x98, 0x06, 0x30, 0x0E, 0x60, 0x19, 0xC0, 0x39, 0x80, 0x67, 0x00, 0xEC,
  0x01, 0x98, 0x03, 0xB0, 0x06, 0xE0, 0x0E, 0xC0, 0x1B, 0x80, 0x3E, 0x00,
  0x6C, 0x00, 0xF8, 0x01, 0xB0, 0x03, 0x60, 0x07, 0xC0, 0x0D, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x03, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x80, 0x0C,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x01,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xDC, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x38, 0x70, 0x00, 0xF0, 0xE0, 0x01,
  0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x38, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x38, 0x00,
  0x70, 0xF0, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0xDE, 0x00, 0x03,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x00, 0x3F, 0xE1, 0xC0,
  0x3F, 0xFC, 0x70, 0x1F, 0x03, 0x98, 0x0F, 0x00, 0x76, 0x07, 0x00, 0x0F,
  0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x1C, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18,
  0x38, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC0,
  0xF0, 0x03, 0x70, 0x1E, 0x03, 0x98, 0x07, 0xFF, 0xCE, 0x00, 0x7F, 0xC3,
  0x80, 0x01, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x83, 0xFC, 0x01, 0xC7, 0xFF, 0x80, 0xEF, 0x03, 0xE0, 0x76, 0x00, 0x70,
  0x3E, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x0F, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00,
  0x18, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x80, 0x07, 0x87,
  0x60, 0x07, 0x83, 0xB8, 0x0F, 0x81, 0xCF, 0xFF, 0x80, 0xE3, 0xFF, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x3C, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x3C, 0x03, 0xE0, 0x7C, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x87, 0x00, 0x7F, 0xF8,
  0xE0, 0x1F, 0x03, 0x9C, 0x07, 0x80, 0x3B, 0x01, 0xC0, 0x03, 0xE0, 0x78,
  0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0xC0, 0x78, 0x01, 0xB8, 0x07, 0x80, 0xE6, 0x00, 0xFF, 0xF9, 0xC0, 0x07,
  0xFC, 0x38, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8,
  0x03, 0xE0, 0x7C, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x0E,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x30, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0x80, 0xFF,
  0xF1, 0xC0, 0xF8, 0x1C, 0xC0, 0xF0, 0x07, 0x60, 0xE0, 0x01, 0xF0, 0xE0,
  0x00, 0x78, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x1C,
  0x30, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xC7, 0x00, 0x01, 0xE1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0xF8, 0x1E, 0x01, 0xDC, 0x07, 0xFF, 0xCE, 0x01, 0xFF, 0x87, 0x00, 0x3E,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x83, 0xFC, 0x01, 0xC7, 0xFF, 0x80, 0xE7, 0x03, 0xE0, 0x76, 0x00, 0x70,
  0x3E, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xE0, 0x00,
  0x38, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x60, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xC0, 0x03,
  0xC0, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x01,
  0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x38, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70,
  0x07, 0x00, 0x07, 0x00, 0x60, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x7F, 0xFC, 0x06, 0x3F, 0x07, 0xE0, 0x37, 0xFC, 0xFF, 0x83, 0xB1,
  0xE4, 0x3C, 0x1E, 0x07, 0xC0, 0xF0, 0xE0, 0x1C, 0x03, 0x87, 0x00, 0xE0,
  0x1C, 0x38, 0x07, 0x00, 0xE1, 0x80, 0x30, 0x06, 0x1C, 0x01, 0x80, 0x70,
  0xE0, 0x1C, 0x03, 0x87, 0x00, 0xE0, 0x1C, 0x38, 0x07, 0x00, 0xE1, 0xC0,
  0x38, 0x07, 0x0C, 0x01, 0x80, 0x30, 0x60, 0x0C, 0x01, 0x87, 0x00, 0xE0,
  0x1C, 0x38, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x07, 0x0E, 0x01, 0xC0, 0x38,
  0x70, 0x0E, 0x01, 0xC3, 0x00, 0x60, 0x0C, 0x38, 0x07, 0x00, 0xE1, 0xC0,
  0x38, 0x07, 0x0E, 0x01, 0xC0, 0x38, 0x70, 0x0E, 0x01, 0xC3, 0x80, 0x70,
  0x0E, 0x18, 0x03, 0x00, 0x61, 0xC0, 0x18, 0x03, 0x0E, 0x01, 0xC0, 0x38,
  0x70, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0x0E, 0x00, 0x0E, 0x0F, 0xF0, 0x07,
  0x1F, 0xFE, 0x03, 0x9C, 0x0F, 0x81, 0xD8, 0x01, 0xC0, 0xF8, 0x00, 0x70,
  0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xE1, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x06, 0x1C, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x30, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x60, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x3C, 0x07, 0xC0,
  0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x01, 0x87, 0xFC,
  0x00, 0x71, 0xFF, 0xE0, 0x0E, 0xF0, 0x3E, 0x01, 0xF8, 0x01, 0xC0, 0x3E,
  0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0xC0, 0x01,
  0xC0, 0xF8, 0x00, 0x78, 0x1D, 0x80, 0x1E, 0x03, 0xB8, 0x0F, 0x80, 0x73,
  0xFF, 0xE0, 0x0E, 0x3F, 0xF0, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xC0, 0x3F, 0xFC, 0x70, 0x1F,
  0x03, 0x98, 0x0F, 0x00, 0x76, 0x07, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x0E, 0x0C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x03, 0x70, 0x1E,
  0x03, 0x98, 0x07, 0xFF, 0xCE, 0x00, 0x7F, 0xC3, 0x80, 0x01, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x1F, 0xF0, 0x03, 0x9F, 0xFF,
  0x00, 0xEF, 0x03, 0xE0, 0x3F, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x03, 0xC0,
  0x01, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x0F,
  0x00, 0x07, 0x07, 0xC0, 0x0F, 0x81, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x83, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x06,
  0x0E, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x03, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x06,
  0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x07, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0x80,
  0x03, 0x81, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x60,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x38, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00,
  0x6E, 0x00, 0xF0, 0x0E, 0xE0, 0x1B, 0x00, 0xEE, 0x01, 0xB0, 0x0C, 0xE0,
  0x1B, 0x01, 0xCE, 0x03, 0x30, 0x1C, 0xE0, 0x33, 0x01, 0x8E, 0x07, 0x30,
  0x38, 0xE0, 0x63, 0x03, 0x8E, 0x06, 0x30, 0x38, 0xE0, 0xE3, 0x03, 0x0E,
  0x0C, 0x30, 0x70, 0xE0, 0xC3, 0x07, 0x0E, 0x1C, 0x30, 0x60, 0xE1, 0x83,
  0x0E, 0x0E, 0x18, 0x30, 0xE0, 0xE3, 0x83, 0x0C, 0x0E, 0x30, 0x31, 0xC0,
  0xE3, 0x03, 0x1C, 0x0E, 0x70, 0x31, 0x80, 0xE6, 0x03, 0x38, 0x0E, 0xE0,
  0x33, 0x80, 0xEC, 0x03, 0x30, 0x0E, 0xC0, 0x37, 0x00, 0x6C, 0x03, 0xF0,
  0x07, 0x80, 0x36, 0x00, 0x78, 0x03, 0x60, 0x07, 0x80, 0x3E, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x03,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0x87,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x0C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x87, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0xF8, 0x3C,
  0x00, 0xDC, 0x1F, 0x00, 0xCC, 0x07, 0xFF, 0xCE, 0x00, 0xFF, 0xC7, 0x00,
  0x1F, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0x8F, 0xF0, 0x00,
  0xCF, 0x7C, 0x00, 0xEE, 0x07, 0x00, 0x76, 0x03, 0xC0, 0x3F, 0x00, 0xE0,
  0x1B, 0x80, 0x38, 0x1D, 0xC0, 0x0E, 0x1E, 0xE0, 0x07, 0xFE, 0x60, 0x00,
  0xFE, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 11, 41, 34, 12, -41 },
  { 58, 17, 17, 34, 11, -41 },
  { 95, 33, 41, 34, 1, -41 },
  { 265, 28, 57, 34, 3, -49 },
  { 465, 38, 41, 34, -1, -41 },
  { 660, 29, 42, 34, 2, -41 },
  { 813, 6, 17, 34, 17, -41 },
  { 826, 22, 54, 34, 10, -47 },
  { 975, 22, 54, 34, 3, -47 },
  { 1124, 29, 28, 34, 3, -34 },
  { 1226, 26, 26, 34, 4, -32 },
  { 1311, 12, 17, 34, 7, -8 },
  { 1337, 18, 3, 34, 8, -20 },
  { 1344, 8, 9, 34, 11, -8 },
  { 1353, 31, 52, 34, 2, -46 },
  { 1555, 27, 42, 34, 4, -41 },
  { 1697, 25, 41, 34, 3, -41 },
  { 1826, 28, 41, 34, 3, -41 },
  { 1970, 27, 42, 34, 4, -41 },
  { 2112, 24, 41, 34, 5, -41 },
  { 2235, 27, 42, 34, 4, -41 },
  { 2377, 25, 42, 34, 4, -41 },
  { 2509, 26, 41, 34, 7, -41 },
  { 2643, 28, 42, 34, 3, -41 },
  { 2790, 26, 41, 34, 6, -41 },
  { 2924, 12, 32, 34, 11, -31 },
  { 2972, 16, 40, 34, 7, -31 },
  { 3052, 26, 28, 34, 5, -32 },
  { 3143, 25, 15, 34, 5, -26 },
  { 3190, 26, 28, 34, 3, -32 },
  { 3281, 22, 41, 34, 9, -41 },
  { 3394, 32, 51, 34, 1, -41 },
  { 3598, 26, 41, 34, 1, -41 },
  { 3732, 27, 41, 34, 4, -41 },
  { 3871, 26, 42, 34, 5, -41 },
  { 4008, 26, 41, 34, 4, -41 },
  { 4142, 29, 41, 34, 4, -41 },
  { 4291, 29, 41, 34, 4, -41 },
  { 4440, 26, 42, 34, 5, -41 },
  { 4577, 27, 41, 34, 4, -41 },
  { 4716, 27, 41, 34, 4, -41 },
  { 4855, 29, 42, 34, 2, -41 },
  { 5008, 30, 41, 34, 4, -41 },
  { 5162, 23, 41, 34, 4, -41 },
  { 5280, 29, 41, 34, 3, -41 },
  { 5429, 27, 41, 34, 4, -41 },
  { 5568, 26, 42, 34, 5, -41 },
  { 5705, 29, 41, 34, 4, -41 },
  { 5854, 26, 51, 34, 5, -41 },
  { 6020, 28, 41, 34, 4, -41 },
  { 6164, 28, 42, 34, 3, -41 },
  { 6311, 27, 41, 34, 7, -41 },
  { 6450, 28, 42, 34, 4, -41 },
  { 6597, 26, 41, 34, 8, -41 },
  { 6731, 30, 41, 34, 5, -41 },
  { 6885, 34, 41, 34, 0, -41 },
  { 7060, 28, 41, 34, 7, -41 },
  { 7204, 29, 41, 34, 3, -41 },
  { 7353, 21, 52, 34, 9, -46 },
  { 7490, 15, 52, 34, 10, -46 },
  { 7588, 21, 52, 34, 5, -46 },
  { 7725, 23, 22, 34, 6, -41 },
  { 7789, 28, 3, 34, 0, 1 },
  { 7800, 8, 8, 34, 16, -44 },
  { 7808, 26, 32, 34, 4, -31 },
  { 7912, 25, 42, 34, 4, -41 },
  { 8044, 25, 32, 34, 5, -31 },
  { 8144, 27, 42, 34, 4, -41 },
  { 8286, 24, 32, 34, 5, -31 },
  { 8382, 34, 51, 34, -1, -41 },
  { 8599, 25, 41, 34, 5, -31 },
  { 8728, 25, 41, 34, 4, -41 },
  { 8857, 25, 43, 34, 3, -43 },
  { 8992, 28, 53, 34, 1, -43 },
  { 9178, 28, 41, 34, 4, -41 },
  { 9322, 22, 41, 34, 6, -41 },
  { 9435, 29, 31, 34, 2, -31 },
  { 9548, 25, 31, 34, 4, -31 },
  { 9645, 24, 32, 34, 5, -31 },
  { 9741, 27, 41, 34, 2, -31 },
  { 9880, 26, 41, 34, 4, -31 },
  { 10014, 26, 31, 34, 5, -31 },
  { 10115, 25, 32, 34, 4, -31 },
  { 10215, 25, 39, 34, 6, -39 },
  { 10337, 26, 32, 34, 4, -31 },
  { 10441, 25, 31, 34, 7, -31 },
  { 10538, 28, 31, 34, 5, -31 },
  { 10647, 29, 31, 34, 2, -31 },
  { 10760, 25, 41, 34, 4, -31 },
  { 10889, 27, 31, 34, 3, -31 },
  { 10994, 27, 52, 34, 6, -46 },
  { 11170, 11, 52, 34, 12, -46 },
  { 11242, 27, 52, 34, 2, -46 },
  { 11418, 25, 10, 34, 5, -25 },
};

const GFXfont JetBrainsMono_ThinItalic56pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic56pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _JETBRAINSMONO_THINITALIC56PT7B_H_
