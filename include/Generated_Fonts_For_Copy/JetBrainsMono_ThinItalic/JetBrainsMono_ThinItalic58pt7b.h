#ifndef _JETBRAINSMONO_THINITALIC58PT7B_H_
#define _JETBRAINSMONO_THINITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0x80, 0x3C,
  0x07, 0x9C, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x39,
  0xE0, 0x3C, 0xE0, 0x1E, 0x70, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0x9E, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x38, 0xE0, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xC7, 0x3E, 0x00, 0x3C, 0x18, 0x3C, 0x00, 0xE0, 0x60, 0x70,
  0x07, 0x01, 0x81, 0xE0, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xE0, 0x30, 0x0C, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xF0, 0x60, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x07, 0xC6, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x33, 0xE0, 0x00, 0x00, 0xC3, 0xC0, 0x00,
  0x03, 0x07, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x60,
  0x1C, 0x1C, 0x01, 0x80, 0x70, 0x70, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x07,
  0x07, 0x00, 0xE0, 0x38, 0x1C, 0x03, 0x00, 0xE0, 0x78, 0x0C, 0x07, 0x00,
  0xF0, 0x30, 0x3C, 0x03, 0xE0, 0xC1, 0xE0, 0x07, 0xE7, 0x3F, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x01,
  0xFF, 0xC0, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x01, 0x80, 0x1C, 0x03, 0x80,
  0x07, 0x00, 0x30, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x07, 0x00, 0x06, 0x00, 0x60,
  0x1C, 0x00, 0x0C, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0x18,
  0x38, 0x00, 0x03, 0x80, 0x70, 0xE0, 0x00, 0x03, 0x81, 0xC3, 0x80, 0x00,
  0x07, 0xFF, 0x0E, 0x00, 0x00, 0x07, 0xFC, 0x1C, 0x00, 0x00, 0x03, 0xE0,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0xFC, 0x00, 0x00, 0x03, 0x87, 0xFE, 0x00, 0x00, 0x0E, 0x1E, 0x3C,
  0x00, 0x00, 0x38, 0x70, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x38, 0x00, 0x03,
  0x83, 0x80, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x60, 0x00, 0x38, 0x1C, 0x00,
  0xC0, 0x00, 0x60, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x07, 0x00, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0x80, 0x18, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0xE0, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x0C,
  0x00, 0x1C, 0x07, 0x00, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x00, 0x3F,
  0xF0, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE0, 0xF0, 0x01, 0xC7, 0x01, 0xE0,
  0x07, 0x3C, 0x03, 0x80, 0x38, 0xE0, 0x0F, 0x01, 0xC3, 0x80, 0x1C, 0x06,
  0x0E, 0x00, 0x78, 0x38, 0x70, 0x00, 0xE1, 0xC1, 0xC0, 0x01, 0xCE, 0x07,
  0x00, 0x07, 0xB8, 0x1C, 0x00, 0x0F, 0xC0, 0x70, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x78, 0x06, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0xC0, 0xE0, 0x00,
  0x77, 0x01, 0xC0, 0x03, 0xCE, 0x07, 0x00, 0x1E, 0x38, 0x1E, 0x00, 0xF0,
  0x70, 0x3C, 0x0F, 0x81, 0xE0, 0xFF, 0xF8, 0x03, 0x80, 0xFF, 0x80, 0x07,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0xF3, 0xCF, 0x3C, 0xF3, 0x9E, 0x79, 0xE7,
  0x9C, 0x71, 0xC7, 0x1C, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x40, 0x07, 0x80,
  0x01, 0xC0, 0x1C, 0x00, 0xEF, 0xC0, 0x70, 0x1F, 0xBF, 0xE1, 0xC3, 0xFF,
  0x3F, 0xE6, 0x3F, 0xE0, 0x1F, 0xDB, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x3C, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0xE1, 0xC0, 0xF0, 0x1E, 0x3C, 0x0F, 0x81, 0xC3, 0x81, 0xF8, 0x1C, 0x38,
  0x0F, 0x81, 0xC3, 0x80, 0xF8, 0x1C, 0x38, 0x02, 0x01, 0xC3, 0x80, 0x00,
  0x3C, 0x78, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x87, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3E, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x1F, 0x0E, 0x00,
  0x0F, 0x03, 0x80, 0x0F, 0x80, 0xE0, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x1C,
  0x00, 0x40, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x3C,
  0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x78, 0x00,
  0xE0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x07, 0xE0, 0x00, 0xE1, 0xFF, 0xC0, 0x0E, 0x7F, 0xFE, 0x00, 0xEE, 0x01,
  0xF0, 0x0F, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x80,
  0x00, 0xE7, 0xFE, 0x00, 0x77, 0xFF, 0xC0, 0x1B, 0x80, 0xF8, 0x0F, 0x80,
  0x0F, 0x07, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0x60, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x03, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80,
  0x7C, 0x0F, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7,
  0x80, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x3C, 0x70, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x07, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x07, 0xC0, 0x07, 0x80,
  0x3F, 0x01, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x83, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x00, 0xFF, 0x3E, 0xE0, 0x07,
  0xFF, 0xB8, 0x00, 0x7F, 0x8E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF,
  0x07, 0xF8, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xF8, 0x1F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x0F, 0xC0, 0x10, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x3F, 0x86, 0x0E, 0x00, 0x7F,
  0xF7, 0x07, 0x00, 0x7F, 0xFB, 0x83, 0x80, 0x78, 0x07, 0xC1, 0xC0, 0x38,
  0x01, 0xE0, 0xE0, 0x3C, 0x00, 0xF0, 0x70, 0x1C, 0x00, 0x70, 0x70, 0x0E,
  0x00, 0x38, 0x38, 0x07, 0x00, 0x1C, 0x1C, 0x03, 0x80, 0x0E, 0x0E, 0x03,
  0x80, 0x07, 0x07, 0x01, 0xC0, 0x03, 0x83, 0x80, 0xE0, 0x01, 0xC3, 0x80,
  0x70, 0x01, 0xC1, 0xC0, 0x38, 0x00, 0xE0, 0xE0, 0x1C, 0x00, 0x70, 0x70,
  0x1C, 0x00, 0x38, 0x38, 0x0E, 0x00, 0x1C, 0x1C, 0x07, 0x00, 0x1E, 0x0C,
  0x03, 0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0x0B, 0x07, 0x00, 0x78, 0x1F, 0x83,
  0x80, 0x1F, 0xFD, 0xC1, 0xC0, 0x0F, 0xFC, 0xE0, 0xE0, 0x00, 0xF8, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x18,
  0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x1C,
  0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x18, 0x00, 0x30, 0x07, 0x00,
  0x06, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1C, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0x80, 0x1F, 0x80, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x30, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C,
  0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x0C, 0x00, 0x3E, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x1E, 0x06, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x78, 0x07, 0xC0, 0x1E, 0x00, 0x3C,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x86, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x3F, 0x03,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0x80, 0x7F, 0x00, 0x38,
  0x00, 0xF8, 0x03, 0x80, 0x03, 0xC0, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38,
  0x18, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x30, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x06, 0x00, 0x0F,
  0x00, 0xE0, 0x03, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x78,
  0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x03, 0xFF, 0xE1, 0xC0, 0x7F, 0xFC, 0x70, 0x0F, 0xFF,
  0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x03,
  0xC0, 0x07, 0x80, 0x3F, 0x03, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x70, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x30, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x70, 0x03, 0xE0, 0x07, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x78, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x70, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xB0,
  0x1B, 0x80, 0x07, 0xE0, 0x37, 0x00, 0x0D, 0xC0, 0x66, 0x00, 0x3B, 0x81,
  0xCC, 0x00, 0x67, 0x03, 0x98, 0x01, 0xCC, 0x07, 0x38, 0x03, 0x38, 0x0E,
  0x70, 0x0E, 0x70, 0x1C, 0x60, 0x18, 0xE0, 0x30, 0xC0, 0x61, 0xC0, 0xE1,
  0x80, 0xC3, 0x81, 0xC3, 0x83, 0x06, 0x03, 0x83, 0x0E, 0x1C, 0x07, 0x06,
  0x18, 0x38, 0x0E, 0x0C, 0x70, 0x70, 0x1C, 0x18, 0xC0, 0xE0, 0x30, 0x3B,
  0x81, 0xC0, 0xE0, 0x36, 0x03, 0x01, 0xC0, 0x7C, 0x0E, 0x03, 0x80, 0xF0,
  0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x1F,
  0x00, 0x01, 0x80, 0xF8, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0xE0, 0x37, 0x00,
  0x07, 0x01, 0xB8, 0x00, 0x38, 0x1C, 0xC0, 0x01, 0xC0, 0xE6, 0x00, 0x0C,
  0x07, 0x38, 0x00, 0xE0, 0x39, 0xC0, 0x07, 0x01, 0xCE, 0x00, 0x38, 0x0C,
  0x30, 0x01, 0xC0, 0x61, 0xC0, 0x0E, 0x07, 0x0E, 0x00, 0x60, 0x38, 0x70,
  0x07, 0x01, 0xC1, 0x80, 0x38, 0x0E, 0x0C, 0x01, 0xC0, 0x70, 0x70, 0x0E,
  0x03, 0x03, 0x80, 0x70, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0x60, 0x70, 0x18, 0x03,
  0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x0E, 0x00, 0xE0, 0xC0, 0x70, 0x03, 0x0E,
  0x03, 0x80, 0x18, 0x70, 0x1C, 0x00, 0xE3, 0x80, 0xC0, 0x07, 0x1C, 0x0E,
  0x00, 0x38, 0xE0, 0x70, 0x00, 0xC6, 0x03, 0x80, 0x07, 0x70, 0x1C, 0x00,
  0x3B, 0x80, 0xE0, 0x01, 0xDC, 0x07, 0x00, 0x06, 0xE0, 0x30, 0x00, 0x3F,
  0x03, 0x80, 0x01, 0xF0, 0x1C, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x3C, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x78, 0x07, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x7C,
  0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x78, 0x07,
  0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x06, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x03, 0xC0,
  0x07, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xE0, 0x03, 0xF8, 0x07, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x3E, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0x80, 0x70,
  0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x60, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xE0, 0x0F, 0x80, 0x07,
  0x80, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C,
  0x0E, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00,
  0x07, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E,
  0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0,
  0x03, 0x80, 0x38, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x03, 0x80, 0x07, 0x00,
  0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x38,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x70, 0x03,
  0xC0, 0x0E, 0x70, 0x03, 0xC0, 0x0E, 0x70, 0x03, 0xC0, 0x0E, 0x70, 0x07,
  0xC0, 0x1C, 0x70, 0x06, 0xC0, 0x1C, 0x70, 0x06, 0xC0, 0x1C, 0x70, 0x0E,
  0xC0, 0x18, 0x70, 0x0C, 0xC0, 0x38, 0x70, 0x0C, 0xC0, 0x38, 0x70, 0x1C,
  0xC0, 0x38, 0x70, 0x18, 0xC0, 0x30, 0x70, 0x18, 0xC0, 0x70, 0x70, 0x18,
  0xC0, 0x70, 0x70, 0x38, 0xC0, 0x60, 0x70, 0x30, 0xC0, 0xE0, 0x60, 0x30,
  0xC0, 0xE0, 0x60, 0x70, 0xC0, 0xE0, 0x60, 0x60, 0xC0, 0xC0, 0x60, 0x60,
  0xC1, 0xC0, 0x60, 0xE0, 0xC1, 0xC0, 0x60, 0xC0, 0xC1, 0x80, 0x60, 0xC0,
  0xC1, 0x80, 0x60, 0xC0, 0xC3, 0x80, 0x61, 0x80, 0xC3, 0x80, 0x61, 0x80,
  0xC3, 0x00, 0x61, 0x80, 0xC7, 0x00, 0xE3, 0x80, 0xC7, 0x00, 0xE3, 0x00,
  0xC7, 0x00, 0xE3, 0x00, 0xC6, 0x00, 0xE7, 0x00, 0xCE, 0x00, 0xE6, 0x00,
  0xCE, 0x00, 0xE6, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0xDC, 0x00, 0xEC, 0x00,
  0xDC, 0x00, 0xEC, 0x00, 0xDC, 0x00, 0xEC, 0x00, 0xD8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x78, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x38, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1E,
  0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0xF0,
  0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80,
  0x00, 0x3F, 0xF0, 0xE0, 0x0F, 0xFF, 0x1C, 0x07, 0xC0, 0xF3, 0x81, 0xE0,
  0x07, 0xE0, 0x78, 0x00, 0x7C, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0,
  0x70, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x1F, 0x03, 0xC0,
  0x0E, 0xC0, 0x3E, 0x03, 0xB8, 0x03, 0xFF, 0xE7, 0x00, 0x3F, 0xF0, 0xE0,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0xFF, 0x80, 0x1C, 0xFF, 0xF8, 0x06, 0x78, 0x1F, 0x03, 0xB0,
  0x01, 0xC0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E, 0xC0, 0x07, 0x83, 0xBC,
  0x07, 0xC0, 0xE7, 0xFF, 0xC0, 0x38, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x07, 0xE0, 0x1F, 0x00,
  0x3C, 0x07, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x0F, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x0F, 0xC1,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x0F, 0xFC, 0x38, 0x00, 0xFF, 0xF1, 0xC0, 0x1F, 0x03, 0xCE, 0x01,
  0xE0, 0x07, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x78, 0x0E, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x03, 0xE0, 0x1C, 0x00, 0x1F, 0x00, 0xF0, 0x03, 0xB0, 0x03, 0xE0, 0x3B,
  0x80, 0x0F, 0xFF, 0x9C, 0x00, 0x3F, 0xF0, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0xF0, 0x03,
  0xC0, 0x70, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x73, 0x80, 0x00, 0x39, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x0E,
  0x0E, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE1,
  0xC0, 0x3F, 0xFC, 0x70, 0x3E, 0x07, 0x9C, 0x1E, 0x00, 0x7E, 0x0F, 0x00,
  0x0F, 0x83, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x38,
  0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x18, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x38, 0x60, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x0E, 0x00, 0x37, 0x03, 0xE0, 0x3D,
  0xC0, 0x7F, 0xFC, 0x70, 0x0F, 0xFE, 0x18, 0x00, 0x7C, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0xFF, 0x80, 0x1C, 0xFF, 0xF8, 0x06, 0x78, 0x1F, 0x03, 0xB8, 0x03, 0xC0,
  0xF8, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xF0, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x06, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x03, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0x00, 0x18, 0x00, 0xF0, 0x01, 0xC0,
  0x0F, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x70, 0x0F, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0xE0,
  0x07, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x03,
  0x80, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x07, 0x3F, 0x87, 0xF0, 0x19, 0xFF, 0x3F, 0xE0, 0x6C,
  0x3D, 0x87, 0x81, 0xE0, 0x74, 0x0F, 0x0F, 0x01, 0xE0, 0x1C, 0x38, 0x07,
  0x80, 0x70, 0xE0, 0x1C, 0x01, 0xC3, 0x80, 0x70, 0x07, 0x0E, 0x01, 0xC0,
  0x18, 0x30, 0x07, 0x00, 0xE1, 0xC0, 0x1C, 0x03, 0x87, 0x00, 0x60, 0x0E,
  0x1C, 0x01, 0x80, 0x38, 0x70, 0x0E, 0x00, 0xE1, 0xC0, 0x38, 0x03, 0x06,
  0x00, 0xE0, 0x1C, 0x38, 0x03, 0x80, 0x70, 0xE0, 0x0E, 0x01, 0xC3, 0x80,
  0x30, 0x07, 0x0E, 0x01, 0xC0, 0x1C, 0x38, 0x07, 0x00, 0x60, 0xE0, 0x1C,
  0x03, 0x83, 0x00, 0x70, 0x0E, 0x1C, 0x01, 0xC0, 0x38, 0x70, 0x06, 0x00,
  0xE1, 0xC0, 0x38, 0x03, 0x87, 0x00, 0xE0, 0x0E, 0x1C, 0x03, 0x80, 0x30,
  0x60, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0x07, 0x0E, 0x00, 0xC0, 0x1C, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x0F, 0xF8, 0x01, 0xCF, 0xFF, 0x80, 0xE7, 0x81,
  0xF0, 0x3B, 0x80, 0x3C, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0xF0,
  0x00, 0x38, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x1C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0xF0, 0x03, 0xC0,
  0x70, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x8C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x07, 0x80, 0x0E, 0x01, 0xF0, 0x1E, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xC3, 0xFE, 0x00, 0x1C,
  0xFF, 0xF8, 0x03, 0x9E, 0x07, 0xC0, 0x3B, 0x00, 0x1C, 0x03, 0xE0, 0x00,
  0xE0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0E, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xE0, 0x3B, 0x00, 0x1E,
  0x03, 0xBC, 0x07, 0xC0, 0x39, 0xFF, 0xF0, 0x03, 0x87, 0xFE, 0x00, 0x38,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0xE0, 0x0F, 0xFF, 0x1C, 0x07, 0xC0, 0xF3, 0x81, 0xE0, 0x07, 0xE0,
  0x78, 0x00, 0x7C, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00,
  0x1E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x1C, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x1C, 0x00, 0x1F, 0x03, 0xC0, 0x0F, 0xC0,
  0x3E, 0x07, 0xB8, 0x03, 0xFF, 0xE7, 0x00, 0x3F, 0xF0, 0xE0, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x0F, 0xF8, 0x00,
  0xE7, 0xFF, 0xC0, 0x39, 0xE0, 0x7C, 0x07, 0x70, 0x03, 0xC0, 0xF8, 0x00,
  0x38, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xC0, 0x3E, 0x01, 0xC0, 0x01, 0xE0, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x3C,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0x78, 0x01, 0xE0,
  0x0F, 0x81, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x03, 0x80,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0xE0,
  0x01, 0xC0, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x06, 0x18, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x60, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x1A, 0x00,
  0xEE, 0x00, 0xD8, 0x07, 0x70, 0x0E, 0xC0, 0x3B, 0x80, 0x66, 0x01, 0x9C,
  0x03, 0x30, 0x1C, 0xE0, 0x39, 0x80, 0xE7, 0x01, 0x8C, 0x06, 0x18, 0x0C,
  0x60, 0x70, 0xC0, 0xE3, 0x03, 0x86, 0x06, 0x18, 0x18, 0x30, 0x30, 0xC1,
  0xC1, 0x83, 0x86, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xC1, 0x87, 0x03,
  0x0E, 0x0C, 0x38, 0x18, 0x60, 0x61, 0x80, 0xC7, 0x03, 0x1C, 0x06, 0x38,
  0x18, 0xE0, 0x31, 0x80, 0xC6, 0x01, 0x9C, 0x06, 0x70, 0x0C, 0xC0, 0x33,
  0x80, 0x66, 0x01, 0x98, 0x03, 0x70, 0x0D, 0xC0, 0x1B, 0x00, 0x6E, 0x00,
  0xD8, 0x03, 0x60, 0x07, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x03,
  0x80, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0x70, 0x00, 0x5C, 0x1E, 0x00, 0x37, 0x03, 0xE0, 0x3B, 0x80, 0x7F, 0xFC,
  0xE0, 0x0F, 0xFC, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x8F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xC7, 0xF8, 0x00,
  0x33, 0xFF, 0x80, 0x1C, 0xE0, 0xE0, 0x07, 0x70, 0x1C, 0x01, 0xD8, 0x03,
  0x80, 0x76, 0x00, 0xF0, 0x1B, 0x80, 0x1C, 0x0E, 0xE0, 0x03, 0xFF, 0x38,
  0x00, 0x7F, 0x8E, 0x00, 0x0F, 0x80,
};

const GFXglyph JetBrainsMono_ThinItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 11, 42, 35, 12, -42 },
  { 59, 17, 17, 35, 12, -42 },
  { 96, 34, 42, 35, 1, -42 },
  { 275, 30, 58, 35, 3, -50 },
  { 493, 39, 43, 35, -1, -43 },
  { 703, 30, 44, 35, 2, -43 },
  { 868, 6, 17, 35, 17, -42 },
  { 881, 23, 56, 35, 10, -49 },
  { 1042, 23, 56, 35, 3, -49 },
  { 1203, 30, 29, 35, 4, -35 },
  { 1312, 26, 27, 35, 5, -33 },
  { 1400, 13, 18, 35, 7, -9 },
  { 1430, 19, 2, 35, 8, -20 },
  { 1435, 9, 9, 35, 11, -8 },
  { 1446, 32, 54, 35, 2, -48 },
  { 1662, 28, 44, 35, 4, -43 },
  { 1816, 26, 42, 35, 3, -42 },
  { 1953, 30, 43, 35, 3, -43 },
  { 2115, 28, 43, 35, 4, -42 },
  { 2266, 25, 42, 35, 5, -42 },
  { 2398, 28, 43, 35, 4, -42 },
  { 2549, 26, 43, 35, 4, -42 },
  { 2689, 28, 42, 35, 7, -42 },
  { 2836, 28, 44, 35, 4, -43 },
  { 2990, 27, 43, 35, 6, -43 },
  { 3136, 13, 33, 35, 11, -32 },
  { 3190, 17, 41, 35, 7, -32 },
  { 3278, 26, 29, 35, 6, -34 },
  { 3373, 26, 16, 35, 5, -27 },
  { 3425, 27, 29, 35, 3, -34 },
  { 3523, 22, 42, 35, 10, -42 },
  { 3639, 33, 53, 35, 1, -43 },
  { 3858, 27, 42, 35, 1, -42 },
  { 4000, 28, 42, 35, 4, -42 },
  { 4147, 27, 44, 35, 5, -43 },
  { 4296, 28, 42, 35, 4, -42 },
  { 4443, 30, 42, 35, 4, -42 },
  { 4601, 31, 42, 35, 4, -42 },
  { 4764, 27, 44, 35, 5, -43 },
  { 4913, 29, 42, 35, 4, -42 },
  { 5066, 28, 42, 35, 4, -42 },
  { 5213, 30, 43, 35, 2, -42 },
  { 5375, 31, 42, 35, 4, -42 },
  { 5538, 24, 42, 35, 4, -42 },
  { 5664, 31, 42, 35, 3, -42 },
  { 5827, 29, 42, 35, 4, -42 },
  { 5980, 27, 44, 35, 5, -43 },
  { 6129, 30, 42, 35, 4, -42 },
  { 6287, 27, 53, 35, 5, -43 },
  { 6466, 29, 42, 35, 4, -42 },
  { 6619, 30, 44, 35, 3, -43 },
  { 6784, 29, 42, 35, 7, -42 },
  { 6937, 28, 43, 35, 5, -42 },
  { 7088, 27, 42, 35, 8, -42 },
  { 7230, 32, 42, 35, 5, -42 },
  { 7398, 34, 42, 35, 1, -42 },
  { 7577, 29, 42, 35, 7, -42 },
  { 7730, 30, 42, 35, 3, -42 },
  { 7888, 22, 54, 35, 9, -48 },
  { 8037, 15, 54, 35, 11, -48 },
  { 8139, 22, 54, 35, 5, -48 },
  { 8288, 24, 22, 35, 6, -42 },
  { 8354, 29, 3, 35, 0, 1 },
  { 8365, 9, 9, 35, 16, -46 },
  { 8376, 27, 33, 35, 4, -32 },
  { 8488, 26, 43, 35, 4, -42 },
  { 8628, 26, 33, 35, 5, -32 },
  { 8736, 29, 43, 35, 4, -42 },
  { 8892, 25, 33, 35, 5, -32 },
  { 8996, 37, 52, 35, -2, -42 },
  { 9237, 26, 42, 35, 5, -32 },
  { 9374, 26, 42, 35, 4, -42 },
  { 9511, 26, 44, 35, 3, -44 },
  { 9654, 29, 54, 35, 1, -44 },
  { 9850, 29, 42, 35, 4, -42 },
  { 10003, 22, 42, 35, 7, -42 },
  { 10119, 30, 32, 35, 2, -32 },
  { 10239, 26, 32, 35, 4, -32 },
  { 10343, 25, 33, 35, 5, -32 },
  { 10447, 28, 42, 35, 2, -32 },
  { 10594, 27, 42, 35, 4, -32 },
  { 10736, 27, 32, 35, 5, -32 },
  { 10844, 27, 33, 35, 4, -32 },
  { 10956, 26, 41, 35, 6, -41 },
  { 11090, 26, 33, 35, 5, -32 },
  { 11198, 26, 32, 35, 7, -32 },
  { 11302, 29, 32, 35, 5, -32 },
  { 11418, 30, 32, 35, 2, -32 },
  { 11538, 26, 42, 35, 5, -32 },
  { 11675, 28, 32, 35, 3, -32 },
  { 11787, 28, 54, 35, 6, -48 },
  { 11976, 12, 54, 35, 12, -48 },
  { 12057, 28, 54, 35, 2, -48 },
  { 12246, 26, 11, 35, 5, -26 },
};

const GFXfont JetBrainsMono_ThinItalic58pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic58pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _JETBRAINSMONO_THINITALIC58PT7B_H_
