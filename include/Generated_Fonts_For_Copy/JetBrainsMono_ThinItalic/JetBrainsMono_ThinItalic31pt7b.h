#ifndef _JETBRAINSMONO_THINITALIC31PT7B_H_
#define _JETBRAINSMONO_THINITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0x81,
  0x02, 0x04, 0x08, 0x20, 0x00, 0x00, 0x07, 0x1E, 0x1C, 0x00, 0x60, 0xD8,
  0x66, 0x19, 0x86, 0x61, 0x98, 0x64, 0x1B, 0x04, 0xC1, 0x30, 0xC0, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x08, 0x10, 0x06, 0x0C, 0x01, 0x03, 0x00, 0xC0,
  0x80, 0x30, 0x60, 0xFF, 0xFF, 0x06, 0x04, 0x01, 0x83, 0x00, 0x40, 0xC0,
  0x30, 0x20, 0x0C, 0x18, 0x02, 0x04, 0x01, 0x81, 0x03, 0xFF, 0xF8, 0x10,
  0x20, 0x0C, 0x18, 0x03, 0x06, 0x00, 0x81, 0x00, 0x60, 0xC0, 0x18, 0x30,
  0x0C, 0x08, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x1F,
  0x00, 0xFF, 0x83, 0x13, 0x8C, 0x23, 0x10, 0xC6, 0x21, 0x8C, 0x42, 0x00,
  0x84, 0x01, 0x88, 0x03, 0x90, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0x70, 0x02,
  0x30, 0x04, 0x60, 0x08, 0x40, 0x30, 0xD8, 0x61, 0x30, 0x82, 0x61, 0x0C,
  0x42, 0x30, 0xE4, 0xC0, 0xFF, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x00, 0x01, 0xC0, 0x08, 0x3F, 0x00, 0x83, 0x08, 0x08, 0x10, 0x60,
  0xC0, 0x82, 0x0C, 0x0C, 0x10, 0xC0, 0x60, 0x8C, 0x03, 0x0C, 0x40, 0x18,
  0x44, 0x00, 0x7E, 0x40, 0x01, 0x86, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x67, 0xC0, 0x02, 0x63, 0x00, 0x22, 0x08, 0x02, 0x30, 0x40, 0x31,
  0x82, 0x03, 0x08, 0x10, 0x30, 0x41, 0x83, 0x02, 0x08, 0x10, 0x18, 0xC3,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x06, 0x0C, 0x04, 0x06, 0x0C,
  0x06, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0F,
  0x00, 0x3B, 0x00, 0x21, 0x83, 0x60, 0x82, 0x60, 0xC6, 0x40, 0x6C, 0x40,
  0x68, 0x40, 0x30, 0xC0, 0x30, 0xC0, 0x78, 0xC0, 0xCC, 0x61, 0x8C, 0x3F,
  0x06, 0x76, 0x66, 0x66, 0x6C, 0xCC, 0x00, 0x18, 0x03, 0x80, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0x70, 0x00, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0xE0, 0x08, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0xE1, 0x83, 0xF9, 0x9F, 0x1F, 0x78, 0x01, 0x80, 0x02, 0x80,
  0x06, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x30, 0x60, 0x60, 0x30, 0x20, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x3F, 0xFF, 0x81, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x0C, 0x71, 0x8E, 0x30, 0xC6, 0x10, 0xC2,
  0x00, 0xFF, 0xE0, 0x77, 0xFD, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF8,
  0x30, 0x30, 0xC0, 0x31, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30,
  0x06, 0x40, 0x09, 0x86, 0x13, 0x1C, 0x66, 0x18, 0xCC, 0x01, 0x98, 0x03,
  0x20, 0x06, 0x40, 0x09, 0x80, 0x33, 0x00, 0x62, 0x00, 0x86, 0x03, 0x0F,
  0x1C, 0x07, 0xE0, 0x00, 0x00, 0x60, 0x07, 0x00, 0xD8, 0x1C, 0xC1, 0x86,
  0x08, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x83, 0xFF, 0xE0, 0x01, 0xF0, 0x0F, 0x78, 0x30, 0x38,
  0xC0, 0x33, 0x00, 0x26, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x19, 0x80, 0x33,
  0x00, 0x46, 0x01, 0x86, 0x02, 0x0E, 0x1C, 0x0F, 0xE0, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x06, 0x20, 0x33, 0x01, 0x30, 0x0B, 0x00, 0xD0, 0x06,
  0xFF, 0xF7, 0xFF, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0F, 0xFE, 0x1F, 0xFC, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x11, 0xE0, 0x6F, 0xF0, 0xE0, 0x61, 0x80, 0x43, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x33, 0x00, 0x62,
  0x00, 0x86, 0x03, 0x0E, 0x1C, 0x07, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x27, 0x01, 0xFF, 0x0E, 0x06, 0x30, 0x19, 0x80, 0x34, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x2C, 0x01, 0xB0, 0x06, 0x60, 0x31, 0xC3, 0x81, 0xF8,
  0x00, 0x7F, 0xFE, 0xFF, 0xF9, 0x00, 0x36, 0x00, 0x4C, 0x01, 0x98, 0x02,
  0x30, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x0F,
  0x78, 0x30, 0x30, 0xC0, 0x31, 0x80, 0x62, 0x00, 0xC4, 0x01, 0x88, 0x02,
  0x18, 0x08, 0x18, 0x60, 0x1F, 0x80, 0x1E, 0x00, 0xC6, 0x03, 0x06, 0x08,
  0x06, 0x30, 0x04, 0x40, 0x09, 0x80, 0x13, 0x00, 0x26, 0x00, 0xC4, 0x03,
  0x0E, 0x0C, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x3D, 0xE1, 0x81, 0x8C, 0x03,
  0x20, 0x05, 0x80, 0x14, 0x00, 0x50, 0x03, 0x40, 0x0D, 0x00, 0x26, 0x01,
  0x98, 0x0C, 0x3D, 0xF0, 0x7C, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x1C, 0x7C,
  0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3E, 0x78,
  0xF0, 0x07, 0x87, 0xC3, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x08, 0x0C,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x04, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x20, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0x20, 0x00,
  0x3E, 0x03, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0xC1, 0xF8, 0x1E, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x00,
  0xFC, 0x01, 0xEF, 0x01, 0x80, 0xC1, 0x80, 0x31, 0x80, 0x18, 0x80, 0x0C,
  0xC0, 0x06, 0x60, 0x03, 0x30, 0x7D, 0x90, 0x73, 0xC8, 0x60, 0xEC, 0x30,
  0x26, 0x10, 0x13, 0x08, 0x19, 0x84, 0x0C, 0x86, 0x06, 0x43, 0x03, 0x61,
  0x81, 0x30, 0xC1, 0x98, 0x71, 0x4C, 0x1F, 0x66, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xF0, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x90, 0x06, 0x40,
  0x11, 0x00, 0xC4, 0x03, 0x10, 0x08, 0x60, 0x61, 0x81, 0x06, 0x0C, 0x18,
  0x20, 0x21, 0x80, 0x87, 0xFE, 0x10, 0x08, 0xC0, 0x22, 0x00, 0xD8, 0x03,
  0x40, 0x0F, 0x00, 0x3C, 0x00, 0x40, 0x0F, 0xC0, 0x3F, 0xF0, 0x60, 0x30,
  0xC0, 0x31, 0x80, 0x62, 0x00, 0xC4, 0x01, 0x98, 0x02, 0x30, 0x0C, 0x60,
  0x30, 0xC1, 0xC1, 0xFF, 0x02, 0x03, 0x84, 0x03, 0x18, 0x03, 0x30, 0x06,
  0x60, 0x0C, 0x80, 0x11, 0x00, 0x22, 0x00, 0xCC, 0x03, 0x18, 0x3C, 0x3F,
  0xE0, 0x00, 0x03, 0xE0, 0x3D, 0xE1, 0x81, 0xCC, 0x03, 0x30, 0x04, 0x80,
  0x12, 0x00, 0xD8, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x48, 0x03, 0x20,
  0x0C, 0xC0, 0x61, 0x83, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x60,
  0x70, 0xC0, 0x61, 0x80, 0x42, 0x00, 0xC4, 0x01, 0x98, 0x02, 0x30, 0x04,
  0x60, 0x08, 0xC0, 0x31, 0x00, 0x62, 0x00, 0xC4, 0x01, 0x98, 0x02, 0x30,
  0x04, 0x60, 0x18, 0x80, 0x31, 0x00, 0x42, 0x01, 0x8C, 0x06, 0x18, 0x78,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0x86, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0xFF, 0x82, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x03, 0xE0, 0x3D, 0xE1, 0x81, 0xCC, 0x03, 0x30, 0x04, 0x80,
  0x12, 0x00, 0xD8, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x43,
  0xFB, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0x80, 0x1A, 0x00, 0x48, 0x03, 0x20,
  0x0C, 0xC0, 0x61, 0x83, 0x03, 0xF8, 0x00, 0x08, 0x02, 0x30, 0x04, 0x60,
  0x08, 0xC0, 0x31, 0x80, 0x62, 0x00, 0xC4, 0x01, 0x18, 0x02, 0x30, 0x04,
  0x60, 0x18, 0xC0, 0x31, 0xFF, 0xE2, 0x00, 0xC4, 0x01, 0x18, 0x02, 0x30,
  0x0C, 0x60, 0x18, 0x80, 0x31, 0x00, 0x62, 0x00, 0x8C, 0x01, 0x18, 0x02,
  0x30, 0x0C, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x40, 0x08, 0x40,
  0x18, 0x40, 0x18, 0x60, 0x30, 0x30, 0x60, 0x1F, 0xC0, 0x08, 0x01, 0x8C,
  0x01, 0x86, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xC0, 0x80, 0x40, 0x40, 0x60,
  0x60, 0x60, 0x30, 0x20, 0x18, 0x30, 0x0C, 0x30, 0x07, 0xF8, 0x02, 0x0C,
  0x01, 0x02, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x20, 0x20, 0x18, 0x10,
  0x0C, 0x08, 0x02, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x60, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0xFF, 0xE0,
  0x0C, 0x01, 0x87, 0x01, 0xC2, 0x81, 0xE1, 0x40, 0xB1, 0xA0, 0xD0, 0xD0,
  0x48, 0x6C, 0x6C, 0x22, 0x26, 0x11, 0x33, 0x08, 0x91, 0x8C, 0x58, 0x86,
  0x38, 0x43, 0x0C, 0x21, 0x80, 0x30, 0x80, 0x18, 0x40, 0x0C, 0x60, 0x04,
  0x30, 0x02, 0x18, 0x01, 0x0C, 0x01, 0x84, 0x00, 0xC2, 0x00, 0x63, 0x00,
  0x20, 0x0C, 0x02, 0x38, 0x04, 0x70, 0x08, 0xE0, 0x31, 0x60, 0x62, 0x40,
  0xC4, 0x81, 0x19, 0x02, 0x33, 0x04, 0x62, 0x18, 0xC4, 0x31, 0x08, 0x62,
  0x18, 0xC4, 0x31, 0x18, 0x22, 0x30, 0x44, 0x60, 0xD8, 0x81, 0xB1, 0x01,
  0x62, 0x02, 0x8C, 0x07, 0x18, 0x0E, 0x30, 0x0C, 0x00, 0x03, 0xE0, 0x3D,
  0xC1, 0x81, 0x8C, 0x03, 0x30, 0x0C, 0x80, 0x32, 0x00, 0xD8, 0x02, 0x60,
  0x09, 0x80, 0x24, 0x01, 0x90, 0x06, 0x40, 0x1B, 0x00, 0x6C, 0x01, 0x30,
  0x04, 0x80, 0x32, 0x00, 0xC8, 0x03, 0x20, 0x08, 0xC0, 0x61, 0x87, 0x03,
  0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x18, 0x06, 0x18, 0x03, 0x18, 0x03,
  0x10, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x02, 0x30, 0x06, 0x30, 0x0C,
  0x20, 0x78, 0x3F, 0xE0, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x03, 0xE0, 0x3D, 0xC1, 0x81, 0x8C, 0x03, 0x30, 0x0C, 0x80, 0x32, 0x00,
  0xD8, 0x02, 0x60, 0x09, 0x80, 0x24, 0x01, 0x90, 0x06, 0x40, 0x1B, 0x00,
  0x6C, 0x01, 0x30, 0x04, 0x80, 0x32, 0x00, 0xC8, 0x03, 0x20, 0x08, 0xC0,
  0x61, 0x87, 0x03, 0xF0, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x0F, 0xE0, 0x1F, 0xFC, 0x18, 0x0E, 0x18, 0x06, 0x18,
  0x03, 0x10, 0x03, 0x10, 0x03, 0x30, 0x02, 0x30, 0x06, 0x30, 0x04, 0x30,
  0x1C, 0x3F, 0xF0, 0x3F, 0xC0, 0x20, 0xC0, 0x60, 0xC0, 0x60, 0x40, 0x60,
  0x60, 0x40, 0x60, 0x40, 0x20, 0x40, 0x30, 0xC0, 0x30, 0xC0, 0x10, 0xC0,
  0x18, 0x01, 0xF0, 0x0F, 0x78, 0x30, 0x38, 0xC0, 0x31, 0x00, 0x62, 0x00,
  0xC4, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0D, 0x80, 0x13, 0x00,
  0x26, 0x00, 0xCE, 0x03, 0x0E, 0x0C, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x08, 0x02, 0x30, 0x04, 0x60, 0x08, 0xC0,
  0x31, 0x00, 0x62, 0x00, 0xC4, 0x01, 0x98, 0x02, 0x30, 0x04, 0x60, 0x18,
  0xC0, 0x31, 0x00, 0x62, 0x00, 0xCC, 0x01, 0x18, 0x02, 0x30, 0x04, 0x60,
  0x18, 0x80, 0x31, 0x00, 0x43, 0x01, 0x86, 0x02, 0x06, 0x1C, 0x07, 0xE0,
  0x00, 0xC0, 0x07, 0x80, 0x09, 0x00, 0x32, 0x00, 0x44, 0x01, 0x88, 0x03,
  0x18, 0x0C, 0x30, 0x18, 0x60, 0x20, 0xC0, 0xC1, 0x81, 0x01, 0x06, 0x02,
  0x08, 0x04, 0x30, 0x08, 0x60, 0x18, 0x80, 0x33, 0x00, 0x64, 0x00, 0xD8,
  0x00, 0xA0, 0x01, 0x40, 0x03, 0x80, 0x06, 0x00, 0x00, 0xC0, 0xC1, 0xE0,
  0xE0, 0xB0, 0x70, 0xD8, 0x38, 0x6C, 0x38, 0x26, 0x14, 0x13, 0x0A, 0x19,
  0x8D, 0x0C, 0xC4, 0x84, 0x62, 0x42, 0x31, 0x23, 0x11, 0x11, 0x08, 0x88,
  0x84, 0x44, 0xC2, 0x42, 0x61, 0x21, 0x20, 0x90, 0x90, 0x58, 0x58, 0x28,
  0x28, 0x14, 0x14, 0x0A, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x80, 0x18, 0x18, 0x06, 0x01, 0x00, 0x80, 0x30, 0x30, 0x06, 0x0C,
  0x00, 0x41, 0x00, 0x0C, 0x40, 0x00, 0x98, 0x00, 0x1E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x60, 0x00, 0xC4, 0x00, 0x10, 0xC0,
  0x06, 0x18, 0x01, 0x81, 0x00, 0x20, 0x30, 0x0C, 0x02, 0x03, 0x00, 0x60,
  0xC0, 0x0C, 0x30, 0x00, 0xC0, 0x80, 0x03, 0x80, 0x0D, 0x00, 0x32, 0x00,
  0x46, 0x01, 0x84, 0x06, 0x08, 0x08, 0x18, 0x30, 0x10, 0xC0, 0x21, 0x00,
  0x66, 0x00, 0x58, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x23,
  0xFF, 0xE0, 0x0F, 0xE1, 0xFC, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x60, 0x0F, 0xE0, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x40,
  0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30, 0x10, 0x10, 0x18, 0x18, 0x18,
  0x08, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x06, 0x06, 0x02, 0x02, 0x03, 0x0F,
  0xE1, 0xFC, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x0F, 0xE0, 0x00, 0x80, 0x0E, 0x00, 0xF0, 0x06, 0x80, 0x66, 0x02,
  0x30, 0x31, 0x83, 0x04, 0x18, 0x31, 0x81, 0x88, 0x05, 0xC0, 0x30, 0xFF,
  0xFE, 0xC6, 0x23, 0x07, 0xE6, 0x18, 0x28, 0x60, 0x31, 0x80, 0x63, 0x00,
  0xC4, 0x01, 0x88, 0x02, 0x30, 0x04, 0x60, 0x08, 0xC0, 0x31, 0x00, 0x62,
  0x00, 0xC4, 0x01, 0x88, 0x06, 0x18, 0x0C, 0x18, 0x78, 0x1F, 0xB0, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x3F, 0x0D,
  0x06, 0x38, 0x0C, 0xC0, 0x33, 0x00, 0xC8, 0x03, 0x20, 0x0C, 0x80, 0x26,
  0x00, 0x98, 0x02, 0x60, 0x19, 0x00, 0x64, 0x01, 0x98, 0x04, 0xE0, 0x33,
  0xC3, 0x8D, 0xF8, 0x00, 0x0F, 0xE0, 0xC1, 0x8C, 0x06, 0xC0, 0x36, 0x01,
  0xA0, 0x0D, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x68,
  0x03, 0x40, 0x13, 0x01, 0x8C, 0x38, 0x3F, 0x00, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC1, 0xF9, 0x06, 0x0A, 0x18,
  0x0C, 0x60, 0x18, 0xC0, 0x31, 0x00, 0x62, 0x00, 0xCC, 0x01, 0x18, 0x02,
  0x30, 0x0C, 0x40, 0x18, 0x80, 0x31, 0x00, 0x62, 0x01, 0x86, 0x03, 0x06,
  0x1E, 0x07, 0xEC, 0x00, 0x0F, 0xE0, 0xC1, 0x8C, 0x06, 0xC0, 0x36, 0x01,
  0xA0, 0x0D, 0x00, 0x7F, 0xFE, 0xFF, 0xF6, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x01, 0x40, 0x13, 0x01, 0x8C, 0x38, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x03,
  0xFC, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x0F, 0xFF, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x7F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xCC, 0x60, 0xA3, 0x01, 0x98, 0x06,
  0x60, 0x19, 0x00, 0x64, 0x01, 0xB0, 0x04, 0xC0, 0x13, 0x00, 0xCC, 0x03,
  0x30, 0x0C, 0xC0, 0x71, 0x82, 0x87, 0xFA, 0x07, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x01, 0xC3, 0xFE, 0x0F, 0x80, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x3F, 0x0D, 0x06,
  0x38, 0x0C, 0xC0, 0x33, 0x00, 0xC8, 0x03, 0x20, 0x0C, 0x80, 0x26, 0x00,
  0x98, 0x02, 0x60, 0x19, 0x00, 0x64, 0x01, 0x90, 0x04, 0xC0, 0x13, 0x00,
  0x4C, 0x03, 0x00, 0x00, 0x40, 0x07, 0x80, 0x3C, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x1F, 0xFF, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x0F, 0xF0,
  0x1F, 0x00, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x07, 0x10, 0x0C, 0x30, 0x08, 0x30, 0x18, 0x30,
  0x30, 0x30, 0x60, 0x20, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x61, 0x80, 0x60,
  0xC0, 0x60, 0xC0, 0x40, 0x60, 0x40, 0x20, 0x40, 0x30, 0xC0, 0x10, 0xC0,
  0x18, 0xFE, 0x0F, 0xE0, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x81, 0x0F, 0xE0,
  0x17, 0x9E, 0x18, 0xE3, 0x30, 0xC3, 0x30, 0xC3, 0x30, 0xC3, 0x20, 0x83,
  0x20, 0x82, 0x20, 0x82, 0x60, 0x82, 0x61, 0x86, 0x61, 0x86, 0x41, 0x86,
  0x41, 0x06, 0x41, 0x04, 0xC1, 0x04, 0xC3, 0x0C, 0xC3, 0x0C, 0x13, 0xF0,
  0xD0, 0x63, 0x80, 0xCC, 0x03, 0x30, 0x0C, 0x80, 0x32, 0x00, 0xC8, 0x02,
  0x60, 0x09, 0x80, 0x26, 0x01, 0x90, 0x06, 0x40, 0x19, 0x00, 0x4C, 0x01,
  0x30, 0x04, 0xC0, 0x30, 0x0F, 0xE0, 0xC1, 0x8C, 0x06, 0xC0, 0x36, 0x01,
  0xA0, 0x0D, 0x00, 0x78, 0x02, 0xC0, 0x16, 0x00, 0xA0, 0x0D, 0x00, 0x68,
  0x03, 0x40, 0x13, 0x01, 0x8C, 0x38, 0x3F, 0x00, 0x09, 0xF8, 0x34, 0x18,
  0x70, 0x18, 0xC0, 0x31, 0x80, 0x62, 0x00, 0xC4, 0x01, 0x88, 0x02, 0x30,
  0x04, 0x60, 0x08, 0xC0, 0x31, 0x00, 0x62, 0x00, 0xC6, 0x01, 0x1C, 0x06,
  0x3C, 0x38, 0x6F, 0xC0, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x07, 0xE6, 0x18, 0x28, 0x60, 0x31, 0x80, 0x63,
  0x00, 0xC4, 0x01, 0x88, 0x02, 0x30, 0x04, 0x60, 0x08, 0xC0, 0x31, 0x00,
  0x62, 0x00, 0xC4, 0x01, 0x88, 0x06, 0x18, 0x0C, 0x18, 0x78, 0x1F, 0xB0,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x37, 0xF0, 0xF0, 0xE3, 0x01, 0x8C, 0x02, 0x20, 0x0D, 0x80, 0x36, 0x00,
  0x98, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x00, 0x07, 0xF8, 0x70, 0x71, 0x00, 0xCC,
  0x01, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0xE0,
  0x01, 0x80, 0x02, 0x00, 0x0B, 0x00, 0x6C, 0x01, 0x18, 0x1C, 0x3F, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03, 0xFF, 0xF0, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x1F, 0x80, 0x10, 0x06, 0x60, 0x08, 0xC0, 0x11, 0x80, 0x63, 0x00,
  0xC4, 0x01, 0x88, 0x03, 0x30, 0x04, 0x60, 0x08, 0xC0, 0x11, 0x80, 0x62,
  0x00, 0xC4, 0x01, 0x0C, 0x06, 0x18, 0x08, 0x18, 0x70, 0x1F, 0x80, 0x80,
  0x0E, 0x00, 0x6C, 0x01, 0x30, 0x0C, 0x40, 0x21, 0x01, 0x84, 0x04, 0x18,
  0x30, 0x60, 0x80, 0x86, 0x02, 0x10, 0x08, 0xC0, 0x22, 0x00, 0xD8, 0x03,
  0x40, 0x07, 0x00, 0x18, 0x00, 0x81, 0x03, 0x06, 0x0E, 0x0E, 0x1C, 0x1C,
  0x28, 0x48, 0xD0, 0x91, 0xA1, 0x22, 0x44, 0x4C, 0x88, 0x99, 0x31, 0x22,
  0x42, 0xC4, 0x85, 0x8B, 0x0A, 0x14, 0x14, 0x28, 0x38, 0x70, 0x60, 0xC0,
  0xC0, 0x18, 0x03, 0x0C, 0x06, 0x0C, 0x0C, 0x06, 0x18, 0x06, 0x10, 0x03,
  0x30, 0x01, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x04,
  0x60, 0x0C, 0x30, 0x18, 0x30, 0x30, 0x18, 0x60, 0x18, 0xC0, 0x0C, 0x30,
  0x04, 0xC0, 0x33, 0x00, 0xC8, 0x03, 0x20, 0x0C, 0x80, 0x26, 0x00, 0x98,
  0x02, 0x60, 0x19, 0x80, 0x64, 0x01, 0x90, 0x04, 0x60, 0x31, 0x81, 0x43,
  0xFB, 0x03, 0x8C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC1,
  0xFE, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0x00, 0x0E,
  0x00, 0x7C, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x1F, 0x80, 0x7F, 0x00, 0x03, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x3E, 0x00, 0x0C, 0x30, 0x82, 0x08, 0x61, 0x86, 0x10,
  0x41, 0x0C, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x18, 0x61, 0x04, 0x10, 0xC3,
  0x0C, 0x30, 0x80, 0x07, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x3F, 0x80, 0x7F, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x0F, 0x80, 0x00, 0x38, 0x0D,
  0xF0, 0x3C, 0x60, 0xA0, 0xC2, 0x81, 0xDA, 0x03, 0xC0,
};

const GFXglyph JetBrainsMono_ThinItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 23, 19, 6, -23 },
  { 22, 10, 10, 19, 6, -23 },
  { 35, 18, 23, 19, 1, -23 },
  { 87, 15, 31, 19, 2, -27 },
  { 146, 21, 23, 19, -1, -23 },
  { 207, 16, 23, 19, 1, -23 },
  { 253, 4, 10, 19, 9, -23 },
  { 258, 13, 30, 19, 5, -26 },
  { 307, 12, 30, 19, 2, -26 },
  { 352, 16, 16, 19, 2, -19 },
  { 384, 15, 15, 19, 2, -18 },
  { 413, 6, 10, 19, 4, -5 },
  { 421, 11, 1, 19, 4, -11 },
  { 423, 5, 4, 19, 6, -4 },
  { 426, 17, 29, 19, 1, -26 },
  { 488, 15, 23, 19, 2, -23 },
  { 532, 13, 23, 19, 2, -23 },
  { 570, 15, 23, 19, 2, -23 },
  { 614, 15, 23, 19, 2, -23 },
  { 658, 13, 23, 19, 3, -23 },
  { 696, 15, 23, 19, 2, -23 },
  { 740, 14, 23, 19, 2, -23 },
  { 781, 15, 23, 19, 4, -23 },
  { 825, 15, 23, 19, 2, -23 },
  { 869, 14, 23, 19, 3, -23 },
  { 910, 7, 17, 19, 6, -17 },
  { 925, 9, 22, 19, 4, -17 },
  { 950, 14, 16, 19, 3, -18 },
  { 978, 14, 8, 19, 3, -14 },
  { 992, 14, 16, 19, 2, -18 },
  { 1020, 12, 23, 19, 5, -23 },
  { 1055, 17, 29, 19, 1, -23 },
  { 1117, 14, 23, 19, 1, -23 },
  { 1158, 15, 23, 19, 2, -23 },
  { 1202, 14, 23, 19, 3, -23 },
  { 1243, 15, 23, 19, 2, -23 },
  { 1287, 16, 23, 19, 2, -23 },
  { 1333, 17, 23, 19, 2, -23 },
  { 1382, 14, 23, 19, 3, -23 },
  { 1423, 15, 23, 19, 2, -23 },
  { 1467, 15, 23, 19, 2, -23 },
  { 1511, 16, 23, 19, 1, -23 },
  { 1557, 17, 23, 19, 2, -23 },
  { 1606, 13, 23, 19, 2, -23 },
  { 1644, 17, 23, 19, 1, -23 },
  { 1693, 15, 23, 19, 2, -23 },
  { 1737, 14, 23, 19, 3, -23 },
  { 1778, 16, 23, 19, 2, -23 },
  { 1824, 14, 29, 19, 3, -23 },
  { 1875, 16, 23, 19, 2, -23 },
  { 1921, 15, 23, 19, 2, -23 },
  { 1965, 15, 23, 19, 4, -23 },
  { 2009, 15, 23, 19, 2, -23 },
  { 2053, 15, 23, 19, 4, -23 },
  { 2097, 17, 23, 19, 3, -23 },
  { 2146, 19, 23, 19, 0, -23 },
  { 2201, 15, 23, 19, 4, -23 },
  { 2245, 17, 23, 19, 1, -23 },
  { 2294, 11, 29, 19, 5, -26 },
  { 2334, 8, 29, 19, 6, -26 },
  { 2363, 11, 29, 19, 3, -26 },
  { 2403, 13, 12, 19, 3, -23 },
  { 2423, 15, 1, 19, 0, 1 },
  { 2425, 4, 4, 19, 9, -24 },
  { 2427, 15, 17, 19, 2, -17 },
  { 2459, 14, 23, 19, 2, -23 },
  { 2500, 13, 17, 19, 3, -17 },
  { 2528, 15, 23, 19, 2, -23 },
  { 2572, 13, 17, 19, 3, -17 },
  { 2600, 19, 29, 19, -1, -23 },
  { 2669, 14, 23, 19, 3, -17 },
  { 2710, 14, 23, 19, 2, -23 },
  { 2751, 13, 24, 19, 2, -24 },
  { 2790, 15, 30, 19, 1, -24 },
  { 2847, 16, 23, 19, 2, -23 },
  { 2893, 12, 23, 19, 4, -23 },
  { 2928, 16, 17, 19, 1, -17 },
  { 2962, 14, 17, 19, 2, -17 },
  { 2992, 13, 17, 19, 3, -17 },
  { 3020, 15, 23, 19, 1, -17 },
  { 3064, 15, 23, 19, 2, -17 },
  { 3108, 14, 17, 19, 3, -17 },
  { 3138, 14, 17, 19, 2, -17 },
  { 3168, 14, 22, 19, 3, -22 },
  { 3207, 15, 17, 19, 2, -17 },
  { 3239, 14, 17, 19, 4, -17 },
  { 3269, 15, 17, 19, 3, -17 },
  { 3301, 16, 17, 19, 1, -17 },
  { 3335, 14, 23, 19, 2, -17 },
  { 3376, 14, 17, 19, 2, -17 },
  { 3406, 15, 29, 19, 3, -26 },
  { 3461, 6, 29, 19, 7, -26 },
  { 3483, 15, 29, 19, 1, -26 },
  { 3538, 14, 6, 19, 3, -14 },
};

const GFXfont JetBrainsMono_ThinItalic31pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic31pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _JETBRAINSMONO_THINITALIC31PT7B_H_
