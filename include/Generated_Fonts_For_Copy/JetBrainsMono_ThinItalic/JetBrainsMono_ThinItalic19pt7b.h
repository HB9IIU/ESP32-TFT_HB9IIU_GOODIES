#ifndef _JETBRAINSMONO_THINITALIC19PT7B_H_
#define _JETBRAINSMONO_THINITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x22, 0x24, 0x44, 0x00, 0xCC, 0xCF, 0x28, 0xA2, 0x8A,
  0x20, 0x02, 0x20, 0x84, 0x11, 0x02, 0x23, 0xFE, 0x11, 0x04, 0x20, 0x88,
  0x11, 0x1F, 0xF8, 0x88, 0x11, 0x04, 0x20, 0x88, 0x00, 0x02, 0x00, 0x80,
  0x20, 0x3C, 0x14, 0x89, 0x22, 0x48, 0x90, 0x24, 0x07, 0x00, 0x60, 0x24,
  0x08, 0xA2, 0x28, 0x91, 0x24, 0x7E, 0x04, 0x01, 0x00, 0x40, 0x1C, 0x12,
  0x42, 0x22, 0x44, 0x44, 0x44, 0x82, 0x90, 0x12, 0x00, 0x40, 0x09, 0xC1,
  0x22, 0x12, 0x22, 0x44, 0x44, 0x48, 0x38, 0x0F, 0x04, 0x42, 0x08, 0x80,
  0x20, 0x04, 0x03, 0x01, 0x23, 0x8C, 0xA1, 0x48, 0x22, 0x08, 0x85, 0x3E,
  0x20, 0xEA, 0xA0, 0x03, 0x04, 0x18, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0x18, 0x10, 0x18, 0x18,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x82, 0x0C, 0x31,
  0x80, 0x04, 0x01, 0x00, 0x42, 0x11, 0x77, 0x83, 0x01, 0x40, 0x58, 0x22,
  0x10, 0xC0, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x13,
  0x26, 0x48, 0xFC, 0x5B, 0x00, 0x00, 0x40, 0x10, 0x08, 0x06, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x00, 0xC0, 0x20, 0x00, 0x0F, 0x04, 0x22, 0x08, 0x82, 0x40, 0x90, 0x24,
  0xC9, 0x32, 0x40, 0x90, 0x6C, 0x13, 0x04, 0x42, 0x0F, 0x00, 0x06, 0x0A,
  0x32, 0x22, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0xFF,
  0x0F, 0x0C, 0x22, 0x0D, 0x01, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x06, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x3F, 0xC0, 0x3F, 0x80, 0x40, 0x40, 0x40, 0x40,
  0x70, 0x04, 0x02, 0x01, 0x00, 0xA0, 0x50, 0x24, 0x23, 0xE0, 0x01, 0x02,
  0x04, 0x08, 0x10, 0x10, 0x21, 0x42, 0x82, 0x82, 0xFE, 0x02, 0x02, 0x04,
  0x1F, 0x90, 0x08, 0x04, 0x02, 0x01, 0xF8, 0x84, 0x81, 0x00, 0x80, 0x80,
  0x48, 0x24, 0x21, 0xE0, 0x03, 0x01, 0x01, 0x01, 0x01, 0x00, 0x80, 0xFC,
  0xC2, 0x40, 0xC0, 0x60, 0x50, 0x24, 0x21, 0xE0, 0x7F, 0xA0, 0x50, 0x50,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x06, 0x02, 0x03, 0x00,
  0x0F, 0x04, 0x22, 0x08, 0x82, 0x20, 0x8C, 0x40, 0xE0, 0x58, 0x61, 0x10,
  0x48, 0x12, 0x04, 0x43, 0x1F, 0x80, 0x1E, 0x10, 0x90, 0x50, 0x18, 0x14,
  0x0B, 0x04, 0xDC, 0x14, 0x02, 0x02, 0x02, 0x02, 0x03, 0x00, 0x27, 0x60,
  0x00, 0x00, 0x4C, 0xC0, 0x08, 0x71, 0x80, 0x00, 0x00, 0x00, 0x10, 0xC2,
  0x18, 0x42, 0x00, 0x00, 0x81, 0x87, 0x0C, 0x08, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x18, 0x30, 0x60, 0xC0, 0x00, 0x7C, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x0C, 0x30, 0x20, 0x40, 0x00, 0x00, 0xC0, 0xC0, 0x07, 0xC1, 0x0C, 0x40,
  0x90, 0x12, 0x02, 0x47, 0xC9, 0x0A, 0x21, 0x44, 0x49, 0x09, 0x21, 0x26,
  0x64, 0x74, 0x80, 0x10, 0x02, 0x00, 0x3C, 0x00, 0x03, 0x01, 0x81, 0x40,
  0xA0, 0x50, 0x48, 0x24, 0x21, 0x10, 0x9F, 0xC8, 0x24, 0x14, 0x0E, 0x04,
  0x3F, 0x08, 0x22, 0x08, 0x82, 0x20, 0x88, 0x67, 0xF1, 0x0C, 0x41, 0x10,
  0x24, 0x09, 0x04, 0x83, 0x3F, 0x00, 0x1E, 0x10, 0x90, 0x48, 0x34, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x90, 0x48, 0x63, 0xC0, 0x3E, 0x10,
  0xC8, 0x24, 0x12, 0x09, 0x05, 0x02, 0x81, 0x41, 0x20, 0x90, 0x48, 0x28,
  0x27, 0xE0, 0x1F, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xF1, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x3F, 0xC0, 0x3F, 0xC8, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0xF9, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x00, 0x1E, 0x10, 0x90, 0x48, 0x34, 0x04, 0x02, 0x01, 0x1E, 0x81,
  0x40, 0xA0, 0x90, 0x48, 0x63, 0xC0, 0x20, 0x48, 0x22, 0x08, 0x82, 0x20,
  0x88, 0x27, 0xF9, 0x02, 0x41, 0x10, 0x44, 0x11, 0x04, 0x81, 0x20, 0x40,
  0x3F, 0x82, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x87, 0xF0, 0x07, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x00, 0xA0, 0x50, 0x28, 0x23, 0xE0, 0x20, 0x48, 0x32, 0x08,
  0x84, 0x21, 0x08, 0x87, 0xC1, 0x10, 0x42, 0x10, 0x84, 0x21, 0x04, 0x81,
  0x20, 0x40, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x40, 0xFF, 0x30, 0xCC, 0x33, 0x14, 0xC5, 0x4A, 0x92, 0xA4,
  0xC9, 0x32, 0x40, 0x90, 0x28, 0x12, 0x04, 0x81, 0x20, 0x40, 0x30, 0x4C,
  0x23, 0x08, 0xA2, 0x28, 0x8A, 0x24, 0x89, 0x12, 0x45, 0x11, 0x44, 0x51,
  0x0C, 0x83, 0x20, 0xC0, 0x1E, 0x21, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81,
  0x82, 0x82, 0x82, 0x82, 0x84, 0x78, 0x3F, 0x08, 0x32, 0x04, 0x81, 0x20,
  0x48, 0x24, 0x19, 0xF8, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x00,
  0x1E, 0x21, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82,
  0x84, 0x78, 0x08, 0x08, 0x04, 0x3F, 0x08, 0x22, 0x04, 0x81, 0x20, 0x48,
  0x24, 0x11, 0xF8, 0x44, 0x10, 0x84, 0x21, 0x08, 0x81, 0x20, 0x40, 0x0F,
  0x04, 0x22, 0x08, 0x82, 0x20, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x28,
  0x0A, 0x04, 0x41, 0x1F, 0x80, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x00, 0x40,
  0xA0, 0x50, 0x48, 0x24, 0x12, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x20, 0x90,
  0x48, 0x43, 0xC0, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x84, 0x88, 0x48,
  0x50, 0x50, 0x50, 0x60, 0x60, 0x8C, 0x63, 0x18, 0xCA, 0x52, 0x94, 0xA5,
  0x2A, 0x52, 0x94, 0xA5, 0x31, 0x8C, 0x63, 0x18, 0x86, 0x21, 0x00, 0x10,
  0x22, 0x08, 0x21, 0x04, 0x40, 0x90, 0x0A, 0x01, 0x80, 0x30, 0x0A, 0x02,
  0x20, 0x44, 0x10, 0x44, 0x09, 0x81, 0x80, 0x80, 0x50, 0x24, 0x11, 0x04,
  0x22, 0x09, 0x02, 0x40, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x00, 0x3F, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x10,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x3F, 0xC0, 0x1E, 0x20, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0xE0, 0xC2,
  0x10, 0x84, 0x10, 0x84, 0x20, 0x84, 0x21, 0x08, 0x21, 0x08, 0x40, 0x3E,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x08, 0x11, 0xE0, 0x0C, 0x0C, 0x14, 0x12, 0x22, 0x42, 0x42, 0x81, 0xFF,
  0x80, 0xC8, 0x80, 0x0E, 0x08, 0xC8, 0x28, 0x14, 0x0A, 0x09, 0x04, 0x82,
  0x41, 0x21, 0x8F, 0x40, 0x20, 0x10, 0x08, 0x05, 0xC3, 0x11, 0x05, 0x02,
  0x81, 0x41, 0x20, 0x90, 0x48, 0x2C, 0x25, 0xE0, 0x1C, 0x22, 0x41, 0x81,
  0x80, 0x80, 0x80, 0x80, 0x82, 0x84, 0x78, 0x00, 0x40, 0x20, 0x08, 0x3A,
  0x11, 0x88, 0x24, 0x09, 0x02, 0x41, 0x10, 0x44, 0x11, 0x04, 0x43, 0x0F,
  0x40, 0x1C, 0x22, 0x41, 0x81, 0x81, 0xFE, 0x80, 0x80, 0x82, 0x84, 0x78,
  0x00, 0xF0, 0x10, 0x01, 0x00, 0x20, 0x02, 0x11, 0xFE, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0xF8, 0x00, 0x1C, 0x23, 0x41, 0x81, 0x81, 0x82, 0x82, 0x82, 0x86, 0x7A,
  0x02, 0x04, 0x04, 0xF8, 0x20, 0x10, 0x08, 0x05, 0xC3, 0x11, 0x05, 0x02,
  0x81, 0x41, 0x20, 0x90, 0x48, 0x28, 0x14, 0x08, 0x02, 0x06, 0x02, 0x00,
  0x38, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x00,
  0x80, 0x30, 0x08, 0x00, 0x1F, 0x00, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x3F, 0x00, 0x20, 0x08,
  0x02, 0x00, 0x81, 0x20, 0x88, 0x44, 0x21, 0x10, 0x7C, 0x11, 0x04, 0x41,
  0x08, 0x42, 0x20, 0x40, 0xF8, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x3F, 0x19, 0x9B, 0xA4, 0x49, 0x12, 0x48,
  0xA2, 0x28, 0x8A, 0x22, 0x89, 0x22, 0x49, 0x10, 0x0E, 0x18, 0x88, 0x28,
  0x14, 0x0A, 0x09, 0x04, 0x82, 0x41, 0x40, 0xA0, 0x40, 0x1C, 0x22, 0x41,
  0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0x78, 0x0E, 0x18, 0x88, 0x28,
  0x14, 0x0A, 0x09, 0x04, 0x82, 0x41, 0x61, 0x2F, 0x10, 0x08, 0x04, 0x00,
  0x0E, 0x08, 0xC8, 0x28, 0x14, 0x0A, 0x09, 0x04, 0x82, 0x41, 0x21, 0x8F,
  0x40, 0x40, 0x20, 0x10, 0x0C, 0x73, 0x41, 0x41, 0x41, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x0E, 0x18, 0xC8, 0x28, 0x02, 0x01, 0xF0, 0x04, 0x02,
  0x81, 0x60, 0x9F, 0x80, 0x18, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x3E, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x82,
  0x82, 0x84, 0x78, 0x81, 0xA0, 0x90, 0x88, 0x44, 0x42, 0x20, 0xA0, 0x50,
  0x30, 0x18, 0x00, 0x88, 0xCC, 0x66, 0x55, 0x2A, 0x95, 0x53, 0x29, 0x94,
  0xC4, 0x42, 0x00, 0x60, 0xC4, 0x41, 0x20, 0x30, 0x08, 0x05, 0x01, 0x40,
  0x88, 0x42, 0x20, 0x40, 0x41, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x86,
  0x7A, 0x04, 0x04, 0x04, 0xF8, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0,
  0x40, 0x40, 0x40, 0x7F, 0x80, 0x01, 0x83, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x78, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x0E, 0x00, 0x11, 0x22, 0x22, 0x22, 0x24, 0x44, 0x44, 0x48, 0x88, 0x38,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x07, 0xC2, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x70, 0x00, 0xF1, 0x89, 0x8E,
};

const GFXglyph JetBrainsMono_ThinItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 14, 11, 4, -14 },
  { 8, 6, 6, 11, 4, -14 },
  { 13, 11, 14, 11, 0, -14 },
  { 33, 10, 20, 11, 1, -17 },
  { 58, 12, 14, 11, 0, -14 },
  { 79, 10, 14, 11, 1, -14 },
  { 97, 2, 6, 11, 6, -14 },
  { 99, 8, 18, 11, 3, -16 },
  { 117, 7, 18, 11, 1, -16 },
  { 133, 10, 10, 11, 1, -12 },
  { 146, 8, 9, 11, 2, -11 },
  { 155, 4, 6, 11, 2, -3 },
  { 158, 6, 1, 11, 3, -7 },
  { 159, 3, 3, 11, 4, -3 },
  { 161, 10, 18, 11, 1, -16 },
  { 184, 10, 14, 11, 1, -14 },
  { 202, 8, 14, 11, 1, -14 },
  { 216, 10, 14, 11, 1, -14 },
  { 234, 9, 14, 11, 1, -14 },
  { 250, 8, 14, 11, 2, -14 },
  { 264, 9, 14, 11, 1, -14 },
  { 280, 9, 14, 11, 1, -14 },
  { 296, 9, 14, 11, 2, -14 },
  { 312, 10, 14, 11, 1, -14 },
  { 330, 9, 14, 11, 2, -14 },
  { 346, 4, 11, 11, 4, -11 },
  { 352, 6, 14, 11, 2, -11 },
  { 363, 9, 9, 11, 2, -11 },
  { 374, 8, 5, 11, 2, -9 },
  { 379, 9, 9, 11, 1, -11 },
  { 390, 8, 14, 11, 3, -14 },
  { 404, 11, 17, 11, 0, -14 },
  { 428, 9, 14, 11, 0, -14 },
  { 444, 10, 14, 11, 1, -14 },
  { 462, 9, 14, 11, 2, -14 },
  { 478, 9, 14, 11, 1, -14 },
  { 494, 10, 14, 11, 1, -14 },
  { 512, 10, 14, 11, 1, -14 },
  { 530, 9, 14, 11, 2, -14 },
  { 546, 10, 14, 11, 1, -14 },
  { 564, 9, 14, 11, 1, -14 },
  { 580, 9, 14, 11, 1, -14 },
  { 596, 10, 14, 11, 1, -14 },
  { 614, 8, 14, 11, 1, -14 },
  { 628, 10, 14, 11, 1, -14 },
  { 646, 10, 14, 11, 1, -14 },
  { 664, 8, 14, 11, 2, -14 },
  { 678, 10, 14, 11, 1, -14 },
  { 696, 8, 17, 11, 2, -14 },
  { 713, 10, 14, 11, 1, -14 },
  { 731, 10, 14, 11, 1, -14 },
  { 749, 10, 14, 11, 2, -14 },
  { 767, 9, 14, 11, 2, -14 },
  { 783, 8, 14, 11, 3, -14 },
  { 797, 10, 14, 11, 2, -14 },
  { 815, 11, 14, 11, 0, -14 },
  { 835, 10, 14, 11, 2, -14 },
  { 853, 10, 14, 11, 1, -14 },
  { 871, 7, 18, 11, 3, -16 },
  { 887, 5, 18, 11, 3, -16 },
  { 899, 7, 18, 11, 2, -16 },
  { 915, 8, 8, 11, 2, -14 },
  { 923, 9, 1, 11, 0, 0 },
  { 925, 3, 3, 11, 5, -15 },
  { 927, 9, 11, 11, 1, -11 },
  { 940, 9, 14, 11, 1, -14 },
  { 956, 8, 11, 11, 2, -11 },
  { 967, 10, 14, 11, 1, -14 },
  { 985, 8, 11, 11, 2, -11 },
  { 996, 12, 17, 11, -1, -14 },
  { 1022, 8, 14, 11, 2, -11 },
  { 1036, 9, 14, 11, 1, -14 },
  { 1052, 8, 15, 11, 1, -15 },
  { 1067, 10, 18, 11, 0, -15 },
  { 1090, 10, 14, 11, 1, -14 },
  { 1108, 8, 14, 11, 2, -14 },
  { 1122, 10, 11, 11, 1, -11 },
  { 1136, 9, 11, 11, 1, -11 },
  { 1149, 8, 11, 11, 2, -11 },
  { 1160, 9, 14, 11, 1, -11 },
  { 1176, 9, 14, 11, 1, -11 },
  { 1192, 8, 11, 11, 2, -11 },
  { 1203, 9, 11, 11, 1, -11 },
  { 1216, 8, 13, 11, 2, -13 },
  { 1229, 8, 10, 11, 2, -10 },
  { 1239, 9, 10, 11, 2, -10 },
  { 1251, 9, 10, 11, 2, -10 },
  { 1263, 10, 10, 11, 1, -10 },
  { 1276, 8, 13, 11, 2, -10 },
  { 1289, 9, 10, 11, 1, -10 },
  { 1301, 9, 18, 11, 2, -16 },
  { 1322, 4, 18, 11, 4, -16 },
  { 1331, 9, 18, 11, 1, -16 },
  { 1352, 8, 3, 11, 2, -8 },
};

const GFXfont JetBrainsMono_ThinItalic19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_THINITALIC19PT7B_H_
