#ifndef _JETBRAINSMONO_THINITALIC59PT7B_H_
#define _JETBRAINSMONO_THINITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C,
  0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x3C, 0xF0, 0x0E, 0x38,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xE3,
  0x3F, 0x00, 0x1E, 0x1C, 0x3C, 0x00, 0xF0, 0x70, 0x78, 0x07, 0x81, 0xC0,
  0xE0, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x18, 0x0F, 0x03, 0x80, 0x60, 0x3C,
  0x0E, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xF0,
  0x30, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0xC7, 0x00, 0x00, 0x0F, 0xD8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30, 0x3C, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0x80, 0x38, 0x70, 0x06, 0x01, 0xC1, 0xC0, 0x18, 0x07, 0x07, 0x00, 0x60,
  0x1C, 0x1C, 0x03, 0x80, 0x70, 0x70, 0x0E, 0x03, 0x81, 0xE0, 0x30, 0x1E,
  0x03, 0xC0, 0xC0, 0xF0, 0x07, 0x83, 0x07, 0x80, 0x1F, 0x8C, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0xFF, 0xE0, 0x00, 0x38,
  0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x03,
  0x80, 0x07, 0x00, 0x30, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x07, 0x00, 0x06, 0x00,
  0x70, 0x1C, 0x00, 0x0C, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x01, 0x80, 0xE0,
  0x00, 0x70, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x01, 0xC0,
  0x18, 0x38, 0x00, 0x03, 0xC0, 0x70, 0xE0, 0x00, 0x03, 0xC3, 0xC3, 0x80,
  0x00, 0x03, 0xFF, 0x0E, 0x00, 0x00, 0x03, 0xFC, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC1, 0xFE, 0x00, 0x00, 0x03, 0x87, 0xFF, 0x00, 0x00, 0x0E, 0x1E,
  0x1E, 0x00, 0x00, 0x38, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0xC0, 0x1C, 0x00,
  0x03, 0x83, 0x80, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x70, 0x00, 0x38, 0x0C,
  0x00, 0xE0, 0x00, 0x70, 0x18, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x03, 0x00,
  0x07, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x01, 0xC0,
  0x0C, 0x00, 0x1C, 0x03, 0x80, 0x38, 0x00, 0x1E, 0x1E, 0x00, 0xE0, 0x00,
  0x3F, 0xF8, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x0F, 0x03, 0x80, 0x07, 0x1C, 0x03, 0x80, 0x1C, 0x78, 0x07, 0x80,
  0x70, 0xE0, 0x07, 0x01, 0xC1, 0xC0, 0x0F, 0x03, 0x83, 0x80, 0x0E, 0x0E,
  0x07, 0x00, 0x0E, 0x38, 0x1C, 0x00, 0x1E, 0x70, 0x38, 0x00, 0x1D, 0xC0,
  0x70, 0x00, 0x3F, 0x00, 0xE0, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x38, 0x03,
  0x80, 0x00, 0xF0, 0x07, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x0F, 0xF0, 0x1C,
  0x00, 0x3C, 0xE0, 0x38, 0x00, 0xF0, 0xE0, 0x78, 0x03, 0xC1, 0xC0, 0x7C,
  0x1F, 0x01, 0xC0, 0xFF, 0xF8, 0x03, 0xC0, 0x7F, 0xC0, 0x03, 0xC0, 0x18,
  0x00, 0x00, 0x00, 0x3C, 0xF3, 0x9E, 0x79, 0xE7, 0x9E, 0x7B, 0xCF, 0x3C,
  0xF3, 0x8E, 0x38, 0xE3, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x0E, 0x00, 0x3F, 0x80, 0x38, 0x07, 0xFF, 0xC0, 0xC0,
  0xFF, 0x7F, 0xC3, 0x0F, 0xF8, 0x3F, 0xCC, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x1C, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x1F, 0xDF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFC, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x38, 0x38, 0x06, 0x01, 0xC1, 0xC0, 0xF8, 0x0E, 0x1E, 0x07, 0xE0,
  0x70, 0xF0, 0x3F, 0x07, 0x87, 0x01, 0xF0, 0x3C, 0x38, 0x07, 0x81, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x3C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xFE, 0x3F,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x1E, 0x70, 0x00, 0x1F, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x83, 0x80,
  0x07, 0x80, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x20, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x07, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x38,
  0x07, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0xF0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE1, 0xFF, 0x00, 0x0E, 0x3F, 0xFE, 0x00, 0x73, 0xE3, 0xF8, 0x03,
  0xB8, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x38, 0x07, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0xFE, 0x00, 0x0E,
  0xFF, 0xF0, 0x03, 0xBF, 0xFF, 0x00, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x1F,
  0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x03,
  0xC0, 0x1F, 0x01, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF3, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x1E,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x3C, 0x70,
  0x00, 0x0E, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x07, 0xC0, 0xF8, 0x07, 0xF0,
  0x1F, 0xFF, 0xB8, 0x03, 0xFF, 0x9C, 0x00, 0x1F, 0x8E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F,
  0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xE0, 0x7E, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x0C,
  0x0E, 0x07, 0x00, 0x1F, 0xF3, 0x83, 0x80, 0x1F, 0xFE, 0xE0, 0xE0, 0x0F,
  0x83, 0xB8, 0x38, 0x03, 0x80, 0x2C, 0x0E, 0x01, 0xC0, 0x07, 0x03, 0x80,
  0x70, 0x01, 0xC0, 0xE0, 0x38, 0x00, 0x70, 0x70, 0x0E, 0x00, 0x1C, 0x1C,
  0x03, 0x80, 0x07, 0x07, 0x00, 0xE0, 0x01, 0xC1, 0xC0, 0x38, 0x00, 0xE0,
  0x70, 0x1C, 0x00, 0x38, 0x1C, 0x07, 0x00, 0x0E, 0x06, 0x01, 0xC0, 0x03,
  0x83, 0x80, 0x70, 0x00, 0xE0, 0xE0, 0x1C, 0x00, 0x38, 0x38, 0x07, 0x00,
  0x1C, 0x0E, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x70, 0x01, 0xC0, 0xE0, 0x1C,
  0x00, 0xF0, 0x70, 0x07, 0x80, 0x7C, 0x1C, 0x01, 0xF0, 0x37, 0x07, 0x00,
  0x3F, 0xF9, 0x81, 0xC0, 0x07, 0xFC, 0x60, 0x70, 0x00, 0x78, 0x20, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x03,
  0x80, 0x03, 0x80, 0x38, 0x00, 0x70, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00,
  0x1C, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x70, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x03,
  0x80, 0x03, 0xC0, 0x1C, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x70, 0x01, 0xF8, 0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC0, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x3C, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x80,
  0x03, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0xF8, 0x03, 0x80,
  0x03, 0xC0, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x30, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0xF0,
  0x0E, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC0, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x7F, 0xFC, 0x38, 0x0F, 0xFF, 0xC3,
  0x00, 0xFF, 0xF8, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C,
  0x07, 0x80, 0x03, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x18, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00, 0x70, 0x07, 0x00, 0x01,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x78, 0x03, 0x80, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x03, 0x80, 0x07, 0x00, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0x70,
  0x3B, 0x00, 0x0E, 0xE0, 0x66, 0x00, 0x19, 0x80, 0xCC, 0x00, 0x77, 0x03,
  0x9C, 0x00, 0xCE, 0x07, 0x38, 0x03, 0x9C, 0x0E, 0x30, 0x06, 0x38, 0x1C,
  0x60, 0x1C, 0x70, 0x38, 0xC0, 0x30, 0xC0, 0x71, 0xC0, 0xE3, 0x81, 0xC3,
  0x81, 0x87, 0x03, 0x83, 0x07, 0x0E, 0x07, 0x06, 0x0C, 0x1C, 0x0E, 0x0C,
  0x38, 0x38, 0x1C, 0x1C, 0x60, 0x60, 0x38, 0x39, 0x81, 0xC0, 0x60, 0x33,
  0x03, 0x81, 0xC0, 0x6C, 0x07, 0x03, 0x80, 0xD8, 0x0E, 0x07, 0x01, 0xE0,
  0x1C, 0x0E, 0x01, 0xC0, 0x30, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x1F,
  0x00, 0x01, 0xC0, 0xF8, 0x00, 0x0E, 0x07, 0xE0, 0x00, 0x70, 0x3F, 0x00,
  0x03, 0x01, 0xF8, 0x00, 0x38, 0x0C, 0xC0, 0x01, 0xC0, 0x67, 0x00, 0x0E,
  0x07, 0x38, 0x00, 0x70, 0x39, 0xC0, 0x03, 0x81, 0xC6, 0x00, 0x18, 0x0E,
  0x30, 0x01, 0xC0, 0x71, 0xC0, 0x0E, 0x03, 0x0E, 0x00, 0x70, 0x38, 0x30,
  0x03, 0x81, 0xC1, 0x80, 0x1C, 0x0E, 0x0E, 0x00, 0xE0, 0x70, 0x70, 0x06,
  0x03, 0x81, 0x80, 0x70, 0x18, 0x0C, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E,
  0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0x60, 0x30, 0x1C, 0x03,
  0x83, 0x80, 0xE0, 0x1C, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x70, 0x03, 0x07,
  0x03, 0x80, 0x1C, 0x38, 0x1C, 0x00, 0xE1, 0x80, 0xE0, 0x07, 0x1C, 0x07,
  0x00, 0x18, 0xE0, 0x30, 0x00, 0xE7, 0x03, 0x80, 0x07, 0x38, 0x1C, 0x00,
  0x39, 0xC0, 0xE0, 0x00, 0xCE, 0x07, 0x00, 0x06, 0x60, 0x38, 0x00, 0x3F,
  0x01, 0x80, 0x01, 0xF8, 0x1C, 0x00, 0x0F, 0xC0, 0xE0, 0x00, 0x3E, 0x07,
  0x00, 0x01, 0xF0, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x86, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x00,
  0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x80, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x1E,
  0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x7C, 0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x1C, 0x03, 0x80, 0x01, 0xF0, 0x1C, 0x00, 0x3F, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x70, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x1E, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x18, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x38,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x30, 0x01, 0xE0, 0x07, 0x30, 0x01, 0xE0, 0x07, 0x30,
  0x03, 0xE0, 0x07, 0x70, 0x03, 0x60, 0x0E, 0x70, 0x03, 0x60, 0x0E, 0x70,
  0x07, 0x60, 0x0E, 0x70, 0x06, 0x60, 0x0C, 0x70, 0x06, 0x60, 0x1C, 0x70,
  0x06, 0x60, 0x1C, 0x70, 0x0E, 0x60, 0x1C, 0x70, 0x0C, 0xE0, 0x38, 0x70,
  0x0C, 0xE0, 0x38, 0x70, 0x1C, 0xE0, 0x38, 0x70, 0x18, 0xE0, 0x30, 0x70,
  0x18, 0xE0, 0x70, 0x70, 0x38, 0xE0, 0x70, 0x70, 0x30, 0xE0, 0x70, 0x70,
  0x30, 0xE0, 0x60, 0x70, 0x30, 0xC0, 0xE0, 0x70, 0x60, 0xC0, 0xE0, 0x70,
  0x60, 0xC0, 0xC0, 0x70, 0x60, 0xC1, 0xC0, 0x60, 0xE0, 0xC1, 0xC0, 0x60,
  0xC0, 0xC1, 0xC0, 0x60, 0xC0, 0xC1, 0x80, 0x61, 0xC0, 0xC3, 0x80, 0x61,
  0x80, 0xC3, 0x80, 0x61, 0x80, 0xC3, 0x00, 0x63, 0x80, 0xC3, 0x00, 0x63,
  0x00, 0xC7, 0x00, 0x63, 0x00, 0xC7, 0x00, 0xE3, 0x00, 0xC6, 0x00, 0xE6,
  0x00, 0xCE, 0x00, 0xE6, 0x00, 0xCE, 0x00, 0xE6, 0x00, 0xCE, 0x00, 0xEE,
  0x00, 0xCC, 0x00, 0xEC, 0x00, 0xDC, 0x00, 0xEC, 0x00, 0xDC, 0x00, 0xEC,
  0x00, 0xD8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0x78, 0x01, 0xE0, 0x38, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x1E, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xF0, 0x70, 0x38, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xFC, 0x70, 0x1F, 0xFF, 0x9C, 0x0F, 0x00, 0x77, 0x07, 0x80, 0x0D,
  0xC3, 0xC0, 0x01, 0xF0, 0xE0, 0x00, 0x7C, 0x70, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0xF0, 0x70, 0x00, 0x7C, 0x1E, 0x00, 0x37, 0x03, 0xE0, 0x39,
  0xC0, 0x7F, 0xFC, 0x70, 0x0F, 0xFC, 0x38, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x1F, 0xE0,
  0x03, 0x8F, 0xFF, 0x00, 0x73, 0xFF, 0xF0, 0x0E, 0xE0, 0x1F, 0x03, 0xB0,
  0x00, 0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x07,
  0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x1F, 0x00, 0x0F, 0x07, 0x70,
  0x03, 0xC0, 0xE7, 0x01, 0xF0, 0x1C, 0x7F, 0xFC, 0x03, 0x87, 0xFE, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x1F, 0x00, 0x3C, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0xC0, 0x07, 0xFF,
  0x1C, 0x01, 0xFF, 0xF9, 0xC0, 0x3C, 0x01, 0xDC, 0x07, 0x80, 0x0D, 0xC0,
  0xF0, 0x00, 0x7C, 0x0E, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x38, 0x1C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x30, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x7C, 0x07,
  0x80, 0x0D, 0xC0, 0x3E, 0x03, 0x9C, 0x01, 0xFF, 0xF1, 0xC0, 0x0F, 0xFC,
  0x38, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x01,
  0xE0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x39, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0,
  0x70, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x3E, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFC,
  0x70, 0x1F, 0xFF, 0x9C, 0x0F, 0x00, 0x77, 0x07, 0x80, 0x0D, 0xC3, 0xC0,
  0x01, 0xF0, 0xE0, 0x00, 0x7C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x78,
  0x70, 0x00, 0x3E, 0x1E, 0x00, 0x1B, 0x83, 0xC0, 0x0F, 0xC0, 0xF8, 0x0F,
  0x70, 0x1F, 0xFF, 0x9C, 0x01, 0xFF, 0x87, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x1F, 0xE0, 0x03, 0x8F, 0xFF, 0x00, 0x73, 0xFF,
  0xF0, 0x0E, 0xE0, 0x1F, 0x03, 0xB0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x41, 0xC0, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0xE0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x70,
  0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x06, 0x01, 0xE0,
  0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0xF0, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x0E, 0xFF, 0x8F, 0xF0, 0x1B, 0xDF,
  0x3F, 0xF0, 0x34, 0x0E, 0xC1, 0xE0, 0x70, 0x1F, 0x01, 0xC1, 0xE0, 0x1C,
  0x03, 0x83, 0x80, 0x38, 0x07, 0x07, 0x00, 0x70, 0x0E, 0x0E, 0x00, 0xC0,
  0x1C, 0x1C, 0x03, 0x80, 0x38, 0x38, 0x07, 0x00, 0x70, 0xE0, 0x0E, 0x00,
  0xE1, 0xC0, 0x1C, 0x03, 0x83, 0x80, 0x38, 0x07, 0x07, 0x00, 0x60, 0x0E,
  0x0E, 0x01, 0xC0, 0x1C, 0x1C, 0x03, 0x80, 0x38, 0x30, 0x07, 0x00, 0x70,
  0xE0, 0x0E, 0x00, 0xC1, 0xC0, 0x1C, 0x03, 0x83, 0x80, 0x30, 0x07, 0x07,
  0x00, 0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0x1C, 0x18, 0x03, 0x80, 0x38, 0x70,
  0x07, 0x00, 0x70, 0xE0, 0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x03, 0x83, 0x80,
  0x30, 0x07, 0x07, 0x00, 0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0x1C, 0x38, 0x03,
  0x80, 0x38, 0x70, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x01, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0xE3, 0xFF, 0xC0, 0x1C, 0xFF, 0xFC, 0x03, 0xB8, 0x07, 0xC0,
  0xEC, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x78, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x38, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x3E, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0E, 0x3F, 0xFC,
  0x00, 0x73, 0xFF, 0xF0, 0x03, 0xB8, 0x07, 0xC0, 0x3B, 0x00, 0x0E, 0x01,
  0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x01, 0xF0,
  0x00, 0xF0, 0x1D, 0xC0, 0x0F, 0x00, 0xE7, 0x01, 0xF0, 0x07, 0x1F, 0xFF,
  0x00, 0x38, 0x7F, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xFC, 0x70, 0x1F, 0xFF, 0x9C, 0x0F, 0x00, 0x77, 0x07, 0x80,
  0x0D, 0xC3, 0xC0, 0x01, 0xF0, 0xE0, 0x00, 0x7C, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x7C, 0x1E, 0x00, 0x37, 0x03, 0xE0,
  0x39, 0xC0, 0x7F, 0xFC, 0x70, 0x0F, 0xFC, 0x38, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0xE3, 0xFF, 0xC0, 0x1C, 0xFF, 0xFC, 0x03, 0xB8, 0x07, 0xC0, 0xEC, 0x00,
  0x3C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xF0,
  0x03, 0xE0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0E, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x0F, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x06, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00,
  0xC0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x07, 0x80,
  0x1D, 0x80, 0x1E, 0x00, 0x66, 0x00, 0x78, 0x03, 0x98, 0x03, 0x60, 0x0E,
  0x60, 0x0D, 0x80, 0x31, 0x80, 0x36, 0x01, 0xC6, 0x01, 0x98, 0x07, 0x18,
  0x06, 0x60, 0x18, 0x60, 0x19, 0x80, 0xE1, 0x80, 0xC6, 0x03, 0x86, 0x03,
  0x18, 0x0C, 0x18, 0x1C, 0x60, 0x70, 0x60, 0x61, 0x81, 0xC1, 0x81, 0x86,
  0x06, 0x06, 0x0E, 0x18, 0x38, 0x18, 0x30, 0x60, 0xE0, 0x60, 0xC1, 0x83,
  0x01, 0x87, 0x06, 0x1C, 0x06, 0x18, 0x18, 0x70, 0x18, 0x60, 0x61, 0x80,
  0x63, 0x81, 0x8E, 0x01, 0x8C, 0x07, 0x38, 0x06, 0x30, 0x1C, 0xC0, 0x19,
  0xC0, 0x77, 0x00, 0x66, 0x01, 0xDC, 0x01, 0x98, 0x07, 0x60, 0x06, 0xE0,
  0x1F, 0x80, 0x1B, 0x00, 0x7E, 0x00, 0x6C, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3E, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38,
  0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00,
  0x37, 0x03, 0xE0, 0x39, 0xC0, 0x7F, 0xFC, 0x70, 0x0F, 0xFC, 0x18, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xE3, 0xFE, 0x00, 0x1C, 0xF1, 0xE0, 0x03, 0xB8, 0x1E, 0x00, 0x67, 0x01,
  0xE0, 0x0C, 0xC0, 0x1C, 0x03, 0x98, 0x01, 0xC0, 0x77, 0x00, 0x3C, 0x1C,
  0xE0, 0x03, 0xFF, 0x1C, 0x00, 0x3F, 0xC3, 0x80, 0x00, 0xC0, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 12, 43, 35, 12, -43 },
  { 66, 18, 18, 35, 12, -43 },
  { 107, 35, 43, 35, 1, -43 },
  { 296, 30, 59, 35, 3, -51 },
  { 518, 39, 43, 35, -1, -43 },
  { 728, 31, 45, 35, 2, -44 },
  { 903, 6, 18, 35, 18, -43 },
  { 917, 24, 57, 35, 10, -50 },
  { 1088, 23, 57, 35, 3, -50 },
  { 1252, 30, 30, 35, 4, -36 },
  { 1365, 27, 27, 35, 5, -33 },
  { 1457, 13, 18, 35, 7, -9 },
  { 1487, 19, 3, 35, 9, -21 },
  { 1495, 9, 9, 35, 11, -8 },
  { 1506, 33, 55, 35, 2, -49 },
  { 1733, 29, 45, 35, 4, -44 },
  { 1897, 26, 43, 35, 3, -43 },
  { 2037, 30, 44, 35, 3, -44 },
  { 2202, 29, 44, 35, 4, -43 },
  { 2362, 26, 43, 35, 5, -43 },
  { 2502, 29, 44, 35, 4, -43 },
  { 2662, 27, 44, 35, 4, -43 },
  { 2811, 28, 43, 35, 7, -43 },
  { 2962, 29, 45, 35, 4, -44 },
  { 3126, 26, 44, 35, 7, -44 },
  { 3269, 13, 34, 35, 11, -33 },
  { 3325, 17, 42, 35, 7, -33 },
  { 3415, 27, 29, 35, 6, -34 },
  { 3513, 27, 17, 35, 5, -28 },
  { 3571, 28, 29, 35, 3, -34 },
  { 3673, 23, 43, 35, 10, -43 },
  { 3797, 34, 55, 35, 1, -44 },
  { 4031, 28, 43, 35, 1, -43 },
  { 4182, 29, 43, 35, 4, -43 },
  { 4338, 28, 45, 35, 5, -44 },
  { 4496, 28, 43, 35, 4, -43 },
  { 4647, 30, 43, 35, 4, -43 },
  { 4809, 31, 43, 35, 4, -43 },
  { 4976, 28, 45, 35, 5, -44 },
  { 5134, 29, 43, 35, 4, -43 },
  { 5290, 29, 43, 35, 4, -43 },
  { 5446, 31, 44, 35, 2, -43 },
  { 5617, 32, 43, 35, 4, -43 },
  { 5789, 25, 43, 35, 4, -43 },
  { 5924, 31, 43, 35, 3, -43 },
  { 6091, 29, 43, 35, 4, -43 },
  { 6247, 27, 45, 35, 5, -44 },
  { 6399, 30, 43, 35, 4, -43 },
  { 6561, 27, 55, 35, 5, -44 },
  { 6747, 30, 43, 35, 4, -43 },
  { 6909, 30, 45, 35, 3, -44 },
  { 7078, 29, 43, 35, 7, -43 },
  { 7234, 28, 44, 35, 5, -43 },
  { 7388, 28, 43, 35, 8, -43 },
  { 7539, 32, 43, 35, 5, -43 },
  { 7711, 35, 43, 35, 1, -43 },
  { 7900, 30, 43, 35, 7, -43 },
  { 8062, 30, 43, 35, 3, -43 },
  { 8224, 22, 55, 35, 9, -49 },
  { 8376, 15, 55, 35, 11, -49 },
  { 8480, 22, 55, 35, 6, -49 },
  { 8632, 24, 23, 35, 6, -43 },
  { 8701, 29, 3, 35, 0, 1 },
  { 8712, 8, 8, 35, 17, -46 },
  { 8720, 26, 34, 35, 5, -33 },
  { 8831, 27, 44, 35, 4, -43 },
  { 8980, 26, 34, 35, 5, -33 },
  { 9091, 28, 44, 35, 5, -43 },
  { 9245, 26, 34, 35, 5, -33 },
  { 9356, 37, 54, 35, -2, -43 },
  { 9606, 26, 44, 35, 5, -33 },
  { 9749, 27, 43, 35, 4, -43 },
  { 9895, 26, 45, 35, 3, -45 },
  { 10042, 30, 56, 35, 1, -45 },
  { 10252, 30, 43, 35, 4, -43 },
  { 10414, 23, 43, 35, 7, -43 },
  { 10538, 31, 33, 35, 2, -33 },
  { 10666, 27, 33, 35, 4, -33 },
  { 10778, 26, 34, 35, 5, -33 },
  { 10889, 29, 44, 35, 2, -33 },
  { 11049, 26, 44, 35, 5, -33 },
  { 11192, 27, 33, 35, 5, -33 },
  { 11304, 27, 34, 35, 4, -33 },
  { 11419, 26, 41, 35, 6, -41 },
  { 11553, 27, 33, 35, 5, -32 },
  { 11665, 26, 32, 35, 7, -32 },
  { 11769, 30, 32, 35, 5, -32 },
  { 11889, 31, 32, 35, 2, -32 },
  { 12013, 26, 43, 35, 5, -32 },
  { 12153, 28, 32, 35, 3, -32 },
  { 12265, 29, 55, 35, 6, -49 },
  { 12465, 11, 55, 35, 13, -49 },
  { 12541, 29, 55, 35, 2, -49 },
  { 12741, 27, 11, 35, 5, -26 },
};

const GFXfont JetBrainsMono_ThinItalic59pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic59pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _JETBRAINSMONO_THINITALIC59PT7B_H_
