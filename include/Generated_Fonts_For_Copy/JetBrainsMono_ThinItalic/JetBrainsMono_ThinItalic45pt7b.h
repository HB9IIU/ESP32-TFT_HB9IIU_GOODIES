#ifndef _JETBRAINSMONO_THINITALIC45PT7B_H_
#define _JETBRAINSMONO_THINITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x60, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0x83, 0xE3, 0xF1,
  0xF0, 0x78, 0x00, 0x38, 0x1C, 0xE0, 0x77, 0x03, 0x9C, 0x0E, 0x70, 0x39,
  0xC0, 0xE7, 0x03, 0x98, 0x0C, 0x60, 0x33, 0x81, 0xCE, 0x07, 0x38, 0x1C,
  0xC0, 0x63, 0x01, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x00,
  0xC0, 0x38, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x07, 0x00, 0x06, 0x01, 0x80,
  0x03, 0x80, 0x60, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x03,
  0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0xC0, 0x18, 0x00, 0x30,
  0x0E, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x70, 0x00,
  0xE0, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x00, 0xC0,
  0x01, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x0C, 0x03,
  0x80, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x1C, 0x00, 0x18,
  0x06, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x30, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xFC, 0x03, 0xC4, 0x78, 0x0C, 0x30, 0xE0, 0x60, 0xC1, 0xC3, 0x83,
  0x07, 0x0C, 0x0C, 0x1C, 0x30, 0x30, 0x70, 0xC0, 0xC0, 0x03, 0x02, 0x00,
  0x0C, 0x18, 0x00, 0x38, 0x60, 0x00, 0xE1, 0x80, 0x01, 0xC6, 0x00, 0x03,
  0xD8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x33,
  0xC0, 0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x08, 0x18, 0x00, 0x60, 0x70,
  0x01, 0x81, 0xC0, 0x06, 0x07, 0x30, 0x18, 0x18, 0xC0, 0x60, 0x63, 0x81,
  0x83, 0x8E, 0x04, 0x0C, 0x1C, 0x30, 0x70, 0x78, 0xC7, 0x80, 0xFF, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x0C,
  0x07, 0xF8, 0x00, 0x60, 0x38, 0x70, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x06,
  0x03, 0x00, 0xE0, 0x18, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x18, 0x01, 0x80,
  0xC0, 0xC0, 0x0C, 0x03, 0x06, 0x00, 0x30, 0x0C, 0x30, 0x00, 0xC0, 0x61,
  0x80, 0x03, 0x01, 0x8E, 0x00, 0x06, 0x0C, 0x30, 0x00, 0x1F, 0xE1, 0x80,
  0x00, 0x1F, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x1F, 0xE0, 0x00,
  0x18, 0xE1, 0xC0, 0x00, 0xC7, 0x03, 0x00, 0x06, 0x18, 0x0C, 0x00, 0x30,
  0x60, 0x30, 0x01, 0x83, 0x00, 0xC0, 0x0E, 0x0C, 0x03, 0x00, 0x70, 0x30,
  0x0C, 0x01, 0x80, 0xC0, 0x60, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x0C, 0x06,
  0x03, 0x00, 0x38, 0x30, 0x18, 0x00, 0x7F, 0x80, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x70, 0x78, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x38, 0x07, 0x18, 0x1C, 0x06, 0x30, 0x0C, 0x0C,
  0x30, 0x0E, 0x1C, 0x30, 0x07, 0x18, 0x30, 0x03, 0x30, 0x70, 0x03, 0xF0,
  0x70, 0x01, 0xE0, 0x60, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x03, 0xE0,
  0x60, 0x07, 0x70, 0x70, 0x0E, 0x30, 0x78, 0x1C, 0x38, 0x3F, 0xF8, 0x18,
  0x1F, 0xE0, 0x0C, 0x77, 0x77, 0x7E, 0xEE, 0xEE, 0xCC, 0xCC, 0x00, 0x00,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x80, 0x01, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x10, 0x06, 0x00,
  0xF8, 0x1C, 0x0F, 0xFC, 0x30, 0xFE, 0x7F, 0x27, 0xF0, 0x3F, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x77, 0x00, 0x01,
  0xC6, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0x38, 0x06, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x0E, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0xFD, 0xFB, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x3C,
  0x0F, 0x01, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x00, 0x70, 0xC0, 0x01,
  0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x71, 0x80, 0x01, 0x86,
  0x00, 0x06, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x83, 0x83, 0x8C, 0x1E,
  0x0E, 0x30, 0x7C, 0x30, 0xC1, 0xE0, 0xC7, 0x03, 0x03, 0x1C, 0x00, 0x1C,
  0x70, 0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x18, 0x60,
  0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x70, 0x01,
  0xC1, 0xC0, 0x0E, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xEC, 0x00, 0x7B, 0x80, 0x1C, 0x70,
  0x0F, 0x0C, 0x03, 0x81, 0x80, 0x60, 0x30, 0x10, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xF0, 0x07, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xC0, 0x01,
  0xC3, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x70, 0x60,
  0x01, 0x81, 0xC0, 0x0C, 0x07, 0x80, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x18, 0x30, 0x07, 0x0E, 0x00, 0xC3, 0x80, 0x18, 0xE0, 0x03, 0x38, 0x00,
  0x66, 0x00, 0x0D, 0xC0, 0x03, 0xB0, 0x00, 0x77, 0xFF, 0xFC, 0xFF, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x07, 0x00, 0x0C, 0xFF, 0x80, 0x77, 0x9F, 0x01, 0xB0,
  0x1E, 0x07, 0x80, 0x38, 0x1C, 0x00, 0x70, 0x60, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x86, 0x00, 0x0C, 0x18, 0x00,
  0x70, 0x60, 0x01, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x70, 0x07, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x63, 0xE0, 0x0E, 0xFF, 0x80, 0xF8, 0x7C, 0x1E, 0x00, 0xE3, 0xC0, 0x0E,
  0x38, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00,
  0x0C, 0x60, 0x01, 0xC7, 0x00, 0x38, 0x38, 0x07, 0x01, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xD8, 0x00, 0x0C, 0xC0, 0x00,
  0xEE, 0x00, 0x06, 0x70, 0x00, 0x73, 0x80, 0x03, 0x18, 0x00, 0x38, 0xC0,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1C,
  0x07, 0x00, 0xC0, 0x0E, 0x06, 0x00, 0x18, 0x38, 0x00, 0x70, 0xC0, 0x01,
  0xC3, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x03,
  0x80, 0x1C, 0x07, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x1E, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0x3C, 0x00, 0x70, 0x38, 0x07, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0xC0, 0x03, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0xE0,
  0x00, 0x63, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xC1, 0xC0, 0x06, 0x07, 0x80, 0x70, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0x01, 0xC1, 0xC0, 0x0E, 0x18, 0x00,
  0x63, 0x80, 0x07, 0x70, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0x60,
  0x00, 0xC7, 0x00, 0x1C, 0x78, 0x03, 0x83, 0xC0, 0xF8, 0x1F, 0xFB, 0x00,
  0x7E, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x00, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x60, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x10, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0E, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x70, 0x07, 0xC6, 0x18,
  0x07, 0xF9, 0x86, 0x03, 0xC3, 0x61, 0x81, 0xC0, 0x78, 0x60, 0x60, 0x0C,
  0x18, 0x18, 0x03, 0x0E, 0x0E, 0x00, 0xC3, 0x03, 0x80, 0x30, 0xC0, 0xC0,
  0x1C, 0x30, 0x30, 0x07, 0x0C, 0x0C, 0x01, 0x83, 0x03, 0x00, 0x61, 0xC0,
  0xC0, 0x18, 0x70, 0x70, 0x06, 0x18, 0x1C, 0x03, 0x86, 0x07, 0x00, 0xE1,
  0x80, 0xE0, 0x70, 0x60, 0x3F, 0xEC, 0x18, 0x07, 0xF3, 0x0E, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x80, 0x00, 0xEC, 0x00,
  0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x06, 0x0E, 0x00, 0x30, 0x30, 0x03,
  0x01, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18,
  0x06, 0x00, 0xC0, 0x70, 0x07, 0x03, 0x00, 0x38, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00, 0x0C, 0x70, 0x00, 0x63,
  0x00, 0x03, 0x18, 0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00, 0x03, 0xE0, 0x00,
  0x18, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x60, 0x1F, 0x01, 0x80, 0x0E,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x87, 0x00, 0x0C, 0x18, 0x00,
  0x70, 0x60, 0x03, 0x81, 0x80, 0x1C, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xE0, 0x0F, 0x03, 0x80, 0x0E, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x70, 0xC0,
  0x01, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0x80, 0x01,
  0x86, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x01, 0xC1, 0x80, 0x0E, 0x0E,
  0x00, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0x00, 0xE0, 0x3C, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x86, 0x00, 0x1C,
  0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x19, 0xC0, 0x01, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x71, 0x80, 0x03, 0x0E, 0x00, 0x38,
  0x30, 0x03, 0x81, 0xC0, 0x38, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xFE, 0x01, 0x80, 0xF8, 0x0C, 0x01, 0xE0, 0xE0, 0x07,
  0x07, 0x00, 0x1C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0xC3, 0x00, 0x06, 0x38, 0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x18,
  0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x31, 0xC0, 0x03, 0x8E, 0x00,
  0x1C, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x8E,
  0x00, 0x0C, 0x70, 0x00, 0xE3, 0x00, 0x06, 0x18, 0x00, 0x70, 0xC0, 0x03,
  0x06, 0x00, 0x38, 0x30, 0x03, 0x83, 0x80, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xE0, 0x3C,
  0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x86, 0x00, 0x1C, 0x60, 0x00, 0x63, 0x00,
  0x03, 0x18, 0x00, 0x19, 0xC0, 0x01, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x03, 0xFF, 0x18, 0x1F, 0xF8, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x33, 0x80, 0x03, 0x9C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x71, 0x80, 0x03, 0x0E, 0x00, 0x38, 0x30, 0x03, 0x81, 0xC0,
  0x38, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x60, 0x00, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x60,
  0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0,
  0x03, 0x87, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xE0, 0x01, 0xC3, 0x80, 0x06, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x1C, 0x00,
  0x38, 0x70, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x60, 0x00, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0,
  0x01, 0x80, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x61, 0xC0, 0x01, 0xC3,
  0x80, 0x03, 0x07, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x07, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x18, 0x0E,
  0x00, 0x38, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x0C, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x18, 0x03, 0x00, 0x18,
  0x07, 0x00, 0x18, 0x0E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x38,
  0x0C, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x07, 0x00, 0x30, 0x07, 0x00, 0x70, 0x03, 0x00, 0x70, 0x03, 0x80, 0x60,
  0x03, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x60,
  0x00, 0xC0, 0xE0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F,
  0x07, 0x80, 0x1B, 0x06, 0x80, 0x1B, 0x06, 0xC0, 0x36, 0x06, 0xC0, 0x36,
  0x0C, 0xC0, 0x66, 0x0C, 0xC0, 0x66, 0x0C, 0x40, 0xC6, 0x0C, 0x60, 0xCE,
  0x0C, 0x61, 0x8C, 0x0C, 0x61, 0x8C, 0x1C, 0x63, 0x0C, 0x18, 0x23, 0x0C,
  0x18, 0x36, 0x0C, 0x18, 0x36, 0x1C, 0x18, 0x3C, 0x1C, 0x18, 0x3C, 0x18,
  0x38, 0x00, 0x18, 0x38, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x38,
  0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x70, 0x00, 0x30, 0x70, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60,
  0x60, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x0C,
  0x1E, 0x00, 0x30, 0x78, 0x00, 0xC1, 0xE0, 0x03, 0x0F, 0x80, 0x1C, 0x32,
  0x00, 0x60, 0xCC, 0x01, 0x83, 0x30, 0x06, 0x0C, 0xC0, 0x18, 0x33, 0x00,
  0x60, 0xC6, 0x03, 0x87, 0x18, 0x0C, 0x18, 0x60, 0x30, 0x61, 0x80, 0xC1,
  0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0xE0, 0xC1, 0xC3, 0x01,
  0x86, 0x0C, 0x06, 0x18, 0x30, 0x18, 0x60, 0xC0, 0x61, 0x83, 0x00, 0xC6,
  0x1C, 0x03, 0x38, 0x60, 0x0C, 0xC1, 0x80, 0x33, 0x06, 0x00, 0xEC, 0x18,
  0x01, 0xB0, 0x60, 0x06, 0xC1, 0x80, 0x1B, 0x0E, 0x00, 0x78, 0x30, 0x00,
  0xE0, 0xC0, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xE0, 0x38,
  0x0C, 0x00, 0xE0, 0xE0, 0x03, 0x06, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00,
  0x06, 0x18, 0x00, 0x31, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x60, 0x00, 0xE3,
  0x00, 0x07, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x70, 0x00,
  0x63, 0x00, 0x07, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x01, 0xC6, 0x00, 0x0C,
  0x30, 0x00, 0x61, 0x80, 0x07, 0x0E, 0x00, 0x30, 0x30, 0x03, 0x81, 0xC0,
  0x38, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x18, 0x03, 0xE0, 0x30, 0x00, 0xE0, 0xE0, 0x00, 0xC1, 0xC0, 0x01,
  0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x38, 0xE0, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x06,
  0x00, 0x0E, 0x0C, 0x00, 0x78, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00,
  0xE0, 0x38, 0x0C, 0x00, 0xE0, 0xE0, 0x03, 0x06, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x06, 0x18, 0x00, 0x31, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x60,
  0x00, 0xE3, 0x00, 0x07, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x70, 0x00, 0x63, 0x00, 0x07, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x01, 0xC6,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x07, 0x0E, 0x00, 0x30, 0x30, 0x03,
  0x81, 0xC0, 0x38, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x18, 0x03, 0xE0, 0x30, 0x01, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0x83,
  0x00, 0x03, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x30, 0xE0, 0x00, 0xE1, 0x80, 0x01, 0x83, 0x00, 0x07, 0x06, 0x00,
  0x1C, 0x0C, 0x00, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xE0, 0x70,
  0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0xC0, 0x0C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x1C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x38, 0x00, 0x70, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3C,
  0x07, 0x80, 0xC0, 0x0E, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xC0, 0x01,
  0xC3, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x73, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xC1, 0xC0, 0x07, 0x07, 0x80, 0x78, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x06, 0x18, 0x00, 0x31, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x60,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x8E, 0x00, 0x1C,
  0x70, 0x00, 0xE3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x70, 0x00, 0x63, 0x80, 0x07, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x38, 0xC0, 0x01,
  0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x07, 0x0E, 0x00, 0x30, 0x30,
  0x03, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0xE6, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x80, 0x0C,
  0x1C, 0x00, 0xE0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0xE0, 0x0E, 0x06, 0x00,
  0x30, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x0C,
  0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0x07, 0x30, 0x00, 0x3B, 0x00, 0x00,
  0xD8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x1C, 0x03, 0x60, 0x1C, 0x03, 0x60, 0x14, 0x03, 0x60, 0x34,
  0x07, 0x60, 0x3C, 0x06, 0x60, 0x2C, 0x06, 0x60, 0x6C, 0x0E, 0x60, 0x6C,
  0x0C, 0x60, 0x6C, 0x0C, 0x60, 0x4C, 0x0C, 0x60, 0xCC, 0x1C, 0x60, 0xCC,
  0x18, 0x60, 0x8C, 0x18, 0x61, 0x8C, 0x18, 0x61, 0x8C, 0x30, 0xE1, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x70, 0xC3, 0x0C, 0x60, 0xC6, 0x0C,
  0x60, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0xC0, 0xC4, 0x0C, 0xC0, 0xCC, 0x0C,
  0xC0, 0xCC, 0x0C, 0xC0, 0xC8, 0x0D, 0x80, 0xD8, 0x0D, 0x80, 0xD8, 0x0D,
  0x80, 0xD0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x07,
  0x00, 0x06, 0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x18, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0E, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0xC0,
  0x00, 0x19, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x07, 0x00,
  0x0C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x1C, 0x01, 0x80, 0x18, 0x07,
  0x00, 0x30, 0x0C, 0x00, 0x70, 0x38, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80,
  0x01, 0xC7, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x30, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xFF,
  0xE0, 0x7F, 0xE0, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x01, 0xB0, 0x00, 0xCC,
  0x00, 0x73, 0x80, 0x18, 0xE0, 0x0E, 0x18, 0x03, 0x06, 0x01, 0xC1, 0xC0,
  0xE0, 0x30, 0x30, 0x0C, 0x1C, 0x03, 0x86, 0x00, 0xE3, 0x80, 0x19, 0xC0,
  0x06, 0x60, 0x01, 0xF8, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE1, 0x83, 0x0E, 0x18, 0x70, 0x00, 0xFE, 0x18, 0x0F, 0xFC, 0xC1, 0xE0,
  0x7E, 0x1C, 0x01, 0xE0, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC3,
  0x00, 0x0E, 0x38, 0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x06, 0x18, 0x00, 0x31, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x60,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x87, 0x00, 0x1C,
  0x38, 0x01, 0xE0, 0xE0, 0x1E, 0x03, 0xFF, 0xB0, 0x0F, 0xF1, 0x80, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x7F, 0x80, 0xCF, 0xFC,
  0x0D, 0x80, 0xE1, 0xE0, 0x06, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x18, 0x00,
  0x31, 0x80, 0x03, 0x18, 0x00, 0x33, 0x80, 0x07, 0x38, 0x00, 0x73, 0x00,
  0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x67, 0x00, 0x06, 0x70,
  0x00, 0xE6, 0x00, 0x0C, 0x60, 0x00, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0x87,
  0x00, 0x38, 0xF8, 0x07, 0x0C, 0xFF, 0xE0, 0xC7, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xF8, 0x0F, 0x03, 0xC0, 0xC0, 0x0E, 0x18, 0x00, 0xE3, 0x80,
  0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x18,
  0xE0, 0x03, 0x86, 0x00, 0x70, 0x70, 0x0E, 0x03, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0xFE, 0x18, 0x07, 0xFE, 0x60, 0x78, 0x1F, 0x83, 0x80, 0x3C, 0x0C, 0x00,
  0x70, 0x70, 0x01, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xC0, 0x01, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0,
  0x01, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x60, 0x00, 0xC1, 0x80, 0x03,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x0F, 0x03,
  0x80, 0x78, 0x07, 0xFF, 0x60, 0x0F, 0xF1, 0x80, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x3C, 0x0F, 0x06, 0x00, 0x61, 0x80, 0x0E, 0x70, 0x00, 0xCC, 0x00,
  0x19, 0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03, 0xBF, 0xFF,
  0xE7, 0xFF, 0xFC, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xCE, 0x00, 0x31, 0xC0, 0x0E,
  0x1C, 0x03, 0x81, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x30, 0x3F,
  0xF3, 0x0F, 0x03, 0xF1, 0xC0, 0x1E, 0x18, 0x00, 0xE3, 0x80, 0x0E, 0x30,
  0x00, 0xE3, 0x00, 0x0E, 0x70, 0x00, 0xE6, 0x00, 0x0E, 0x60, 0x00, 0xC6,
  0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x1C,
  0xE0, 0x01, 0x8E, 0x00, 0x38, 0x60, 0x03, 0x87, 0x00, 0x58, 0x78, 0x1D,
  0x83, 0xFF, 0xB8, 0x0F, 0xE3, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x7F, 0x80, 0xCF, 0xFC, 0x0D, 0x81, 0xE1, 0xE0,
  0x06, 0x1E, 0x00, 0x71, 0xC0, 0x07, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18,
  0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63,
  0x00, 0x06, 0x30, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xE6, 0x00, 0x0C,
  0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x1C, 0xE0, 0x01,
  0xCC, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x30, 0x00, 0xE0, 0x60,
  0x03, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x18, 0x07, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x06, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0E, 0x00,
  0x70, 0x0C, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x38, 0x06,
  0x00, 0x38, 0x0C, 0x00, 0x30, 0x38, 0x00, 0x70, 0x70, 0x00, 0x60, 0xC0,
  0x00, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x19, 0xF0, 0xF8, 0x37, 0xF3, 0xF8, 0x68,
  0x78, 0x30, 0xE0, 0xF0, 0x71, 0x80, 0xC0, 0xE3, 0x03, 0x81, 0xCE, 0x07,
  0x03, 0x1C, 0x0C, 0x06, 0x30, 0x18, 0x0C, 0x60, 0x30, 0x18, 0xC0, 0x60,
  0x31, 0x80, 0xC0, 0xE3, 0x03, 0x81, 0x8E, 0x06, 0x03, 0x18, 0x0C, 0x06,
  0x30, 0x18, 0x0C, 0x60, 0x30, 0x18, 0xC0, 0x60, 0x71, 0x81, 0xC0, 0xE7,
  0x03, 0x01, 0x8E, 0x06, 0x03, 0x18, 0x0C, 0x06, 0x30, 0x18, 0x0C, 0x60,
  0x30, 0x38, 0xC0, 0xE0, 0x70, 0x0C, 0x3F, 0x80, 0xCF, 0xFC, 0x0D, 0x81,
  0xE1, 0xE0, 0x06, 0x1E, 0x00, 0x71, 0xC0, 0x07, 0x18, 0x00, 0x31, 0x80,
  0x03, 0x18, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x63, 0x00, 0x06, 0x30,
  0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xE6,
  0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x1C,
  0xE0, 0x01, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x3C, 0x0F, 0x06, 0x00, 0x61, 0x80, 0x0E, 0x70, 0x00, 0xCC, 0x00,
  0x19, 0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00,
  0x66, 0x00, 0x0C, 0xC0, 0x01, 0xB8, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x01,
  0xD8, 0x00, 0x33, 0x00, 0x06, 0x60, 0x01, 0xCE, 0x00, 0x30, 0xC0, 0x0E,
  0x1C, 0x03, 0x81, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x06, 0x3F, 0xC0, 0x33,
  0xFF, 0x01, 0xB0, 0x1C, 0x1E, 0x00, 0x60, 0xF0, 0x03, 0x87, 0x00, 0x0C,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00,
  0x0E, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC7,
  0x00, 0x06, 0x38, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x70, 0x01,
  0xC3, 0x80, 0x0C, 0x3C, 0x00, 0xE1, 0xF0, 0x0E, 0x0C, 0xFF, 0xE0, 0x63,
  0xFC, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x18, 0x1F, 0xFC, 0xC1, 0xE0, 0x7E, 0x1C, 0x01, 0xE0, 0xC0, 0x07,
  0x0E, 0x00, 0x38, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x38, 0x00, 0x71, 0x80,
  0x03, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x31,
  0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00,
  0x30, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01, 0xE0, 0xE0, 0x1E, 0x03,
  0xFF, 0xB0, 0x0F, 0xF1, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x0C, 0x7F, 0x00, 0xEF, 0xFE, 0x07, 0xE0, 0x78, 0x34, 0x01,
  0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x38,
  0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xFF, 0x01, 0xC0, 0x3C, 0x1C, 0x00, 0xE1, 0xC0, 0x03, 0x0C, 0x00, 0x1C,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x19, 0x80, 0x01,
  0xCE, 0x00, 0x0C, 0x70, 0x00, 0xE1, 0xC0, 0x0E, 0x07, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x18, 0x00,
  0x31, 0x80, 0x03, 0x38, 0x00, 0x73, 0x80, 0x07, 0x30, 0x00, 0x63, 0x00,
  0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x70, 0x00, 0x67, 0x00, 0x0E, 0x60,
  0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xCE,
  0x00, 0x1C, 0xE0, 0x01, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8E, 0x00, 0x38,
  0xE0, 0x03, 0x06, 0x00, 0x70, 0x70, 0x1E, 0x03, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0xE0, 0x00, 0x3B, 0x00, 0x03, 0x98, 0x00, 0x18, 0xC0, 0x01, 0xC6,
  0x00, 0x0C, 0x38, 0x00, 0xE0, 0xC0, 0x06, 0x06, 0x00, 0x70, 0x30, 0x03,
  0x01, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x30, 0x1C, 0x01, 0x80, 0xC0, 0x0C,
  0x0E, 0x00, 0x60, 0x60, 0x03, 0x07, 0x00, 0x1C, 0x30, 0x00, 0x63, 0x80,
  0x03, 0x18, 0x00, 0x19, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x0F, 0x80, 0x70,
  0x1B, 0x01, 0xE0, 0x36, 0x03, 0xC0, 0xEC, 0x05, 0x81, 0x98, 0x1B, 0x03,
  0x30, 0x36, 0x0E, 0x60, 0x4C, 0x18, 0xC1, 0x98, 0x31, 0x83, 0x30, 0x63,
  0x04, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x43, 0x18, 0x31,
  0x86, 0x30, 0x63, 0x0C, 0x60, 0xC4, 0x19, 0x81, 0x98, 0x33, 0x03, 0x30,
  0x66, 0x06, 0xC0, 0xD8, 0x0D, 0x81, 0xB0, 0x1B, 0x03, 0x60, 0x34, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x03, 0x00,
  0x0E, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x30, 0x00, 0xC0,
  0x70, 0x00, 0xE0, 0xE0, 0x00, 0x61, 0xC0, 0x00, 0x71, 0x80, 0x00, 0x33,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x76, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x83,
  0x80, 0x03, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x00,
  0xE0, 0x18, 0x00, 0x60, 0x30, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x38, 0x00,
  0x73, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x06, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60,
  0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0xCE, 0x00, 0x1C, 0xC0, 0x01, 0x8C,
  0x00, 0x18, 0xC0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x86, 0x00, 0x78,
  0x78, 0x1B, 0x03, 0xFF, 0x30, 0x1F, 0xE3, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x3C, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18,
  0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x33,
  0xF8, 0x03, 0x71, 0xC0, 0x36, 0x0E, 0x03, 0xC0, 0x70, 0x3C, 0x03, 0x86,
  0xC0, 0x1F, 0xEC, 0x00, 0xF8,
};

const GFXglyph JetBrainsMono_ThinItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 9, 33, 27, 9, -33 },
  { 39, 14, 14, 27, 9, -33 },
  { 64, 26, 33, 27, 1, -33 },
  { 172, 22, 45, 27, 3, -39 },
  { 296, 30, 33, 27, -1, -33 },
  { 420, 24, 33, 27, 1, -33 },
  { 519, 4, 14, 27, 14, -33 },
  { 526, 18, 44, 27, 8, -38 },
  { 625, 18, 44, 27, 2, -38 },
  { 724, 23, 22, 27, 3, -27 },
  { 788, 20, 21, 27, 4, -25 },
  { 841, 10, 14, 27, 5, -7 },
  { 859, 14, 2, 27, 7, -16 },
  { 863, 7, 6, 27, 8, -6 },
  { 869, 25, 42, 27, 2, -37 },
  { 1001, 22, 33, 27, 3, -33 },
  { 1092, 19, 33, 27, 3, -33 },
  { 1171, 23, 33, 27, 2, -33 },
  { 1266, 22, 33, 27, 3, -33 },
  { 1357, 19, 33, 27, 4, -33 },
  { 1436, 22, 33, 27, 3, -33 },
  { 1527, 20, 33, 27, 3, -33 },
  { 1610, 21, 33, 27, 6, -33 },
  { 1697, 22, 33, 27, 3, -33 },
  { 1788, 20, 33, 27, 5, -33 },
  { 1871, 11, 25, 27, 8, -25 },
  { 1906, 14, 32, 27, 5, -25 },
  { 1962, 21, 22, 27, 4, -26 },
  { 2020, 20, 12, 27, 4, -21 },
  { 2050, 20, 22, 27, 3, -26 },
  { 2105, 18, 33, 27, 7, -33 },
  { 2180, 26, 41, 27, 1, -33 },
  { 2314, 21, 33, 27, 1, -33 },
  { 2401, 22, 33, 27, 3, -33 },
  { 2492, 21, 33, 27, 4, -33 },
  { 2579, 21, 33, 27, 3, -33 },
  { 2666, 23, 33, 27, 3, -33 },
  { 2761, 24, 33, 27, 3, -33 },
  { 2860, 21, 33, 27, 4, -33 },
  { 2947, 22, 33, 27, 3, -33 },
  { 3038, 22, 33, 27, 3, -33 },
  { 3129, 23, 33, 27, 2, -33 },
  { 3224, 24, 33, 27, 3, -33 },
  { 3323, 19, 33, 27, 3, -33 },
  { 3402, 24, 33, 27, 2, -33 },
  { 3501, 22, 33, 27, 3, -33 },
  { 3592, 21, 33, 27, 4, -33 },
  { 3679, 23, 33, 27, 3, -33 },
  { 3774, 21, 41, 27, 4, -33 },
  { 3882, 23, 33, 27, 3, -33 },
  { 3977, 22, 33, 27, 3, -33 },
  { 4068, 22, 33, 27, 6, -33 },
  { 4159, 21, 33, 27, 4, -33 },
  { 4246, 21, 33, 27, 6, -33 },
  { 4333, 24, 33, 27, 4, -33 },
  { 4432, 27, 33, 27, 0, -33 },
  { 4544, 23, 33, 27, 5, -33 },
  { 4639, 24, 33, 27, 2, -33 },
  { 4738, 17, 42, 27, 7, -37 },
  { 4828, 12, 42, 27, 8, -37 },
  { 4891, 17, 42, 27, 4, -37 },
  { 4981, 18, 18, 27, 5, -33 },
  { 5022, 22, 2, 27, 0, 1 },
  { 5028, 6, 6, 27, 13, -35 },
  { 5033, 21, 25, 27, 3, -25 },
  { 5099, 20, 33, 27, 3, -33 },
  { 5182, 20, 25, 27, 4, -25 },
  { 5245, 22, 33, 27, 3, -33 },
  { 5336, 19, 25, 27, 4, -25 },
  { 5396, 28, 41, 27, -1, -33 },
  { 5540, 20, 33, 27, 4, -25 },
  { 5623, 20, 33, 27, 3, -33 },
  { 5706, 20, 34, 27, 2, -34 },
  { 5791, 22, 42, 27, 1, -34 },
  { 5907, 23, 33, 27, 3, -33 },
  { 6002, 18, 33, 27, 5, -33 },
  { 6077, 23, 25, 27, 2, -25 },
  { 6149, 20, 25, 27, 3, -25 },
  { 6212, 19, 25, 27, 4, -25 },
  { 6272, 21, 33, 27, 2, -25 },
  { 6359, 21, 33, 27, 3, -25 },
  { 6446, 21, 25, 27, 4, -25 },
  { 6512, 21, 25, 27, 3, -25 },
  { 6578, 20, 32, 27, 5, -32 },
  { 6658, 20, 25, 27, 4, -25 },
  { 6721, 21, 25, 27, 5, -25 },
  { 6787, 23, 25, 27, 4, -25 },
  { 6859, 24, 25, 27, 1, -25 },
  { 6934, 20, 33, 27, 4, -25 },
  { 7017, 21, 25, 27, 3, -25 },
  { 7083, 21, 42, 27, 5, -37 },
  { 7194, 9, 42, 27, 10, -37 },
  { 7242, 21, 42, 27, 2, -37 },
  { 7353, 20, 8, 27, 4, -20 },
};

const GFXfont JetBrainsMono_ThinItalic45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_THINITALIC45PT7B_H_
