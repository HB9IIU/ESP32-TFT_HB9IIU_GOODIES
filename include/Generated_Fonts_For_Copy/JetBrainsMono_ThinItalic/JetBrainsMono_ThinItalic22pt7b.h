#ifndef _JETBRAINSMONO_THINITALIC22PT7B_H_
#define _JETBRAINSMONO_THINITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x22, 0x24, 0x44, 0x40, 0x00, 0xCC, 0x62, 0x8D, 0x1A,
  0x24, 0x48, 0xA1, 0x00, 0x06, 0x10, 0x42, 0x04, 0x20, 0x86, 0x08, 0x47,
  0xFF, 0x10, 0xC1, 0x08, 0x10, 0x82, 0x10, 0xFF, 0xE2, 0x10, 0x42, 0x04,
  0x20, 0x42, 0x08, 0x40, 0x01, 0x00, 0x20, 0x04, 0x07, 0xE1, 0x96, 0x24,
  0x48, 0x89, 0x10, 0x32, 0x03, 0x40, 0x38, 0x02, 0xC0, 0x4C, 0x08, 0x81,
  0x16, 0x22, 0x44, 0xC9, 0x30, 0xFC, 0x04, 0x00, 0x80, 0x10, 0x00, 0x0F,
  0x02, 0x22, 0x08, 0x44, 0x20, 0x88, 0x81, 0x12, 0x02, 0x2C, 0x07, 0x90,
  0x00, 0x40, 0x01, 0x00, 0x04, 0xF0, 0x12, 0x20, 0x44, 0x41, 0x90, 0x82,
  0x21, 0x08, 0x46, 0x60, 0x78, 0x0F, 0x83, 0x18, 0x41, 0x08, 0x01, 0x00,
  0x20, 0x06, 0x01, 0xC0, 0x44, 0x28, 0xCA, 0x09, 0x41, 0xC8, 0x11, 0x07,
  0x21, 0xA3, 0xC2, 0xFE, 0xA8, 0x00, 0x81, 0x83, 0x03, 0x01, 0x01, 0x00,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x20, 0x10, 0x04, 0x01, 0x80, 0x40, 0x10, 0x0E, 0x01, 0x80, 0x60, 0x10,
  0x08, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04,
  0x06, 0x02, 0x02, 0x03, 0x06, 0x04, 0x00, 0x02, 0x00, 0x20, 0x02, 0x0C,
  0x23, 0x3D, 0xE0, 0x60, 0x0A, 0x01, 0xB0, 0x31, 0x06, 0x18, 0x20, 0x80,
  0x04, 0x01, 0x00, 0x40, 0x30, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x06,
  0x00, 0x32, 0x64, 0xC8, 0x80, 0xFE, 0x6E, 0xE0, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x08, 0x00, 0x1F, 0x8C, 0x32, 0x05, 0x01, 0x40, 0x50, 0x14, 0x0F, 0x33,
  0x8C, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0xA0, 0x4C, 0x31, 0xF0, 0x03, 0x01,
  0x41, 0x90, 0x84, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x18, 0x04, 0x01, 0x00, 0x43, 0xFF, 0x0F, 0xC2, 0x0C, 0x80, 0x90, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x07, 0xFE, 0x1F, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x01, 0xC0, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x64, 0x08, 0x81, 0x10,
  0x41, 0xF0, 0x00, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x41, 0x60,
  0xA0, 0x60, 0x7F, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x3F, 0xC8, 0x02, 0x00,
  0x80, 0x60, 0x11, 0x85, 0xB1, 0x82, 0x40, 0x80, 0x20, 0x08, 0x02, 0x81,
  0xA0, 0x4C, 0x21, 0xF0, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x02, 0x01,
  0x70, 0xE6, 0x20, 0x50, 0x14, 0x05, 0x01, 0x40, 0x50, 0x26, 0x18, 0xF8,
  0xFF, 0xE0, 0x18, 0x0A, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x06, 0x01, 0x00, 0x0F, 0xC3, 0x0C, 0x40,
  0x90, 0x12, 0x02, 0x20, 0x86, 0x60, 0x30, 0x19, 0x04, 0x11, 0x01, 0x20,
  0x24, 0x04, 0x81, 0x10, 0x61, 0xF8, 0x1F, 0x8C, 0x36, 0x05, 0x01, 0x40,
  0x50, 0x14, 0x0D, 0x02, 0x73, 0x87, 0x40, 0x20, 0x10, 0x0C, 0x02, 0x01,
  0x00, 0x80, 0x39, 0xCC, 0x00, 0x00, 0x00, 0x03, 0x39, 0xC0, 0x1C, 0x71,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xC2, 0x18, 0x43, 0x08, 0x20, 0x00, 0x40,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x20, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x10, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x00, 0x7C, 0x02,
  0x01, 0x01, 0x01, 0x03, 0x02, 0x0C, 0x30, 0x40, 0x40, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x0F, 0xC1, 0x82, 0x30, 0x32, 0x01, 0x60, 0x14, 0x19, 0x46,
  0x54, 0x42, 0x44, 0x2C, 0xC2, 0x88, 0x28, 0x82, 0x88, 0x68, 0xCC, 0x87,
  0x48, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xC0, 0x03, 0x00, 0xC0, 0x50,
  0x14, 0x05, 0x02, 0x60, 0x88, 0x42, 0x10, 0x88, 0x23, 0xF9, 0x82, 0x40,
  0x90, 0x28, 0x0E, 0x01, 0x1F, 0x82, 0x08, 0x40, 0x98, 0x12, 0x02, 0x40,
  0x88, 0x31, 0xFC, 0x21, 0x8C, 0x09, 0x01, 0x20, 0x24, 0x04, 0x81, 0x10,
  0x67, 0xF0, 0x1F, 0x8C, 0x32, 0x05, 0x01, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0xA0, 0x4C, 0x31, 0xF0, 0x1F, 0x82,
  0x18, 0x41, 0x98, 0x12, 0x02, 0x40, 0xC8, 0x11, 0x02, 0x20, 0x4C, 0x09,
  0x01, 0x20, 0x24, 0x08, 0x81, 0x10, 0xC7, 0xE0, 0x3F, 0xE4, 0x00, 0x80,
  0x10, 0x06, 0x00, 0x80, 0x10, 0x03, 0xFC, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x07, 0xF8, 0x3F, 0xE4, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x03, 0xFC, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x1F, 0x8C, 0x32, 0x05, 0x01, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x4F, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x4C, 0x31, 0xF0,
  0x10, 0x22, 0x04, 0x40, 0x98, 0x12, 0x02, 0x40, 0x88, 0x11, 0xFE, 0x20,
  0x4C, 0x09, 0x01, 0x20, 0x64, 0x08, 0x81, 0x10, 0x26, 0x04, 0x3F, 0xC1,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x03, 0xFC, 0x03, 0xE0, 0x04, 0x00, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x48, 0x09,
  0x01, 0x10, 0x43, 0xF0, 0x10, 0x11, 0x02, 0x10, 0x63, 0x04, 0x20, 0x82,
  0x18, 0x21, 0x03, 0xE0, 0x23, 0x06, 0x10, 0x41, 0x04, 0x10, 0x40, 0x84,
  0x08, 0x40, 0x8C, 0x04, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x10, 0x32,
  0x85, 0x28, 0x62, 0x8A, 0x28, 0xA2, 0x92, 0x25, 0x24, 0x66, 0x46, 0x44,
  0x04, 0x40, 0x44, 0x04, 0x40, 0x4C, 0x04, 0x80, 0x88, 0x08, 0x18, 0x23,
  0x04, 0x60, 0x94, 0x12, 0x42, 0x48, 0x89, 0x11, 0x22, 0x22, 0x4C, 0x49,
  0x09, 0x21, 0x64, 0x28, 0x83, 0x10, 0x66, 0x0C, 0x1F, 0x8C, 0x32, 0x05,
  0x01, 0x40, 0x50, 0x34, 0x09, 0x02, 0x40, 0xA0, 0x28, 0x0A, 0x02, 0x81,
  0x20, 0x4C, 0x21, 0xF0, 0x1F, 0xC1, 0x02, 0x10, 0x33, 0x01, 0x20, 0x12,
  0x02, 0x20, 0x22, 0x0C, 0x3F, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0x1F, 0x8C, 0x32, 0x05, 0x01, 0x40, 0x50, 0x34,
  0x09, 0x02, 0x40, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x20, 0x4C, 0x21, 0xF0,
  0x04, 0x01, 0x00, 0x20, 0x0C, 0x1F, 0xC1, 0x06, 0x10, 0x23, 0x03, 0x20,
  0x22, 0x02, 0x20, 0x62, 0x0C, 0x3F, 0x06, 0x20, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x08, 0x40, 0x8C, 0x0C, 0x0F, 0xC3, 0x0C, 0x40, 0x90, 0x12, 0x00,
  0x60, 0x04, 0x00, 0x70, 0x01, 0x80, 0x18, 0x01, 0x00, 0x2C, 0x04, 0x81,
  0x90, 0x61, 0xF8, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x48, 0x12, 0x05, 0x01, 0x40, 0x50, 0x34, 0x09, 0x02, 0x40, 0xB0, 0x28,
  0x0A, 0x06, 0x81, 0x20, 0x4C, 0x21, 0xF0, 0x80, 0x60, 0x38, 0x0B, 0x02,
  0x41, 0x10, 0x44, 0x21, 0x08, 0x46, 0x11, 0x04, 0x41, 0x20, 0x28, 0x0C,
  0x03, 0x00, 0xC0, 0x86, 0x18, 0x62, 0x86, 0x28, 0xA2, 0x8A, 0x28, 0xA4,
  0x92, 0x49, 0x24, 0x92, 0x89, 0x28, 0xA2, 0x8A, 0x28, 0xA3, 0x0C, 0x30,
  0xC3, 0x0C, 0x20, 0x10, 0x08, 0x40, 0x82, 0x08, 0x08, 0xC0, 0x44, 0x02,
  0x40, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x28, 0x02, 0x20, 0x31, 0x01, 0x04,
  0x10, 0x21, 0x81, 0x18, 0x04, 0x80, 0x70, 0x19, 0x02, 0x20, 0x84, 0x30,
  0x44, 0x09, 0x01, 0x20, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x3F, 0xE0, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x30, 0x07,
  0xFC, 0x0F, 0x8C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x1F, 0x80,
  0x83, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x83, 0x04, 0x10, 0x41, 0x02,
  0x08, 0x20, 0x83, 0x1F, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0xF8, 0x06,
  0x03, 0x02, 0xC3, 0x21, 0x11, 0x88, 0x86, 0x81, 0xC0, 0x80, 0xFF, 0xE0,
  0xCC, 0x80, 0x1F, 0x48, 0x24, 0x09, 0x02, 0x40, 0xA0, 0x28, 0x0A, 0x06,
  0x81, 0x20, 0x4C, 0x31, 0xF4, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x2F, 0x8C,
  0x12, 0x04, 0x81, 0x20, 0x58, 0x14, 0x05, 0x01, 0x40, 0x90, 0x26, 0x13,
  0x78, 0x1F, 0x08, 0x24, 0x09, 0x02, 0x40, 0x20, 0x08, 0x02, 0x00, 0x81,
  0xA0, 0x4C, 0x31, 0xF0, 0x00, 0x40, 0x10, 0x04, 0x01, 0x1F, 0x48, 0x24,
  0x09, 0x02, 0x40, 0xA0, 0x28, 0x0A, 0x06, 0x81, 0x20, 0x4C, 0x31, 0xF4,
  0x1F, 0x10, 0x50, 0x28, 0x14, 0x0F, 0xFE, 0x01, 0x00, 0x80, 0x40, 0xB0,
  0xCF, 0x80, 0x00, 0x7C, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x7F,
  0xE0, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x3E,
  0x00, 0x1F, 0x48, 0x24, 0x09, 0x02, 0x40, 0xA0, 0x28, 0x0A, 0x06, 0x81,
  0x10, 0xC7, 0xD0, 0x04, 0x01, 0x00, 0x80, 0x63, 0xF0, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x2F, 0x8C, 0x12, 0x04, 0x81, 0x20, 0x58, 0x14, 0x05, 0x03,
  0x40, 0x90, 0x24, 0x0B, 0x02, 0x03, 0x00, 0xE0, 0x10, 0x00, 0x00, 0x0F,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x10, 0xFF, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x0F, 0xC0, 0x20, 0x04, 0x00, 0x80,
  0x30, 0x14, 0x04, 0x81, 0x10, 0x42, 0x10, 0x46, 0x0F, 0x82, 0x10, 0x42,
  0x08, 0x21, 0x04, 0x20, 0x44, 0x0C, 0xF8, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x30, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x60, 0x60, 0x3F, 0x3D, 0xEC,
  0x45, 0x08, 0xA3, 0x14, 0x42, 0x88, 0xD1, 0x16, 0x22, 0x84, 0x50, 0x8A,
  0x21, 0x44, 0x60, 0x2F, 0x8C, 0x12, 0x04, 0x81, 0x20, 0x58, 0x14, 0x05,
  0x03, 0x40, 0x90, 0x24, 0x0B, 0x02, 0x1F, 0x10, 0x50, 0x28, 0x14, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0x40, 0xB0, 0x8F, 0x80, 0x2F, 0x8C, 0x12, 0x04,
  0x81, 0x20, 0x58, 0x14, 0x05, 0x01, 0x40, 0x90, 0x26, 0x11, 0x78, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x1F, 0x48, 0x24, 0x09, 0x02, 0x40, 0xA0, 0x28,
  0x0A, 0x06, 0x81, 0x20, 0x4C, 0x31, 0xF4, 0x01, 0x00, 0xC0, 0x20, 0x08,
  0x2F, 0x9C, 0x26, 0x0D, 0x01, 0x40, 0xD0, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x1F, 0xC6, 0x08, 0x81, 0x90, 0x02, 0x00, 0x3C, 0x00,
  0x60, 0x06, 0x00, 0x48, 0x19, 0x02, 0x1F, 0x80, 0x0C, 0x02, 0x00, 0x83,
  0xFF, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x04, 0x01, 0xF0, 0x40, 0x50, 0x34, 0x09, 0x02, 0x40, 0xB0, 0x28, 0x0A,
  0x06, 0x81, 0x20, 0x4C, 0x21, 0xF0, 0x80, 0xC0, 0xE0, 0x50, 0x64, 0x22,
  0x31, 0x10, 0x88, 0x48, 0x24, 0x0C, 0x06, 0x00, 0x84, 0x31, 0x8E, 0x31,
  0x46, 0x29, 0x4D, 0x29, 0x25, 0x25, 0x24, 0xA5, 0x14, 0xA3, 0x0C, 0x61,
  0x00, 0x20, 0x62, 0x08, 0x42, 0x04, 0x80, 0xA0, 0x0C, 0x03, 0x80, 0x50,
  0x11, 0x04, 0x21, 0x02, 0x40, 0x60, 0x40, 0xD0, 0x24, 0x09, 0x02, 0xC0,
  0xA0, 0x28, 0x1A, 0x04, 0x81, 0x30, 0xC7, 0xD0, 0x04, 0x03, 0x00, 0x80,
  0x63, 0xF0, 0x3F, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00,
  0xC0, 0x10, 0x04, 0x01, 0x00, 0x7F, 0xC0, 0x01, 0xE0, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x01, 0x83, 0xE0, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x07, 0x80, 0x11,
  0x12, 0x22, 0x22, 0x26, 0x44, 0x44, 0x4C, 0x88, 0x88, 0x1E, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x80, 0x7C, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x03, 0xC0, 0x70, 0x72,
  0x18, 0xCE, 0x1E,
};

const GFXglyph JetBrainsMono_ThinItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 16, 13, 5, -16 },
  { 9, 7, 7, 13, 4, -16 },
  { 16, 12, 16, 13, 1, -16 },
  { 40, 11, 22, 13, 1, -19 },
  { 71, 15, 16, 13, -1, -16 },
  { 101, 11, 16, 13, 1, -16 },
  { 123, 2, 7, 13, 7, -16 },
  { 125, 9, 22, 13, 4, -19 },
  { 150, 9, 22, 13, 1, -19 },
  { 175, 12, 11, 13, 1, -13 },
  { 192, 10, 10, 13, 2, -12 },
  { 205, 4, 7, 13, 3, -3 },
  { 209, 7, 1, 13, 3, -8 },
  { 210, 4, 3, 13, 4, -3 },
  { 212, 12, 20, 13, 1, -18 },
  { 242, 10, 16, 13, 2, -16 },
  { 262, 10, 16, 13, 1, -16 },
  { 282, 11, 16, 13, 1, -16 },
  { 304, 11, 16, 13, 1, -16 },
  { 326, 9, 16, 13, 2, -16 },
  { 344, 10, 16, 13, 2, -16 },
  { 364, 10, 16, 13, 1, -16 },
  { 384, 10, 16, 13, 3, -16 },
  { 404, 11, 16, 13, 1, -16 },
  { 426, 10, 16, 13, 2, -16 },
  { 446, 5, 12, 13, 4, -12 },
  { 454, 6, 16, 13, 3, -12 },
  { 466, 10, 11, 13, 2, -13 },
  { 480, 10, 6, 13, 2, -10 },
  { 488, 10, 11, 13, 1, -13 },
  { 502, 8, 16, 13, 4, -16 },
  { 518, 12, 20, 13, 1, -16 },
  { 548, 10, 16, 13, 1, -16 },
  { 568, 11, 16, 13, 1, -16 },
  { 590, 10, 16, 13, 2, -16 },
  { 610, 11, 16, 13, 1, -16 },
  { 632, 11, 16, 13, 2, -16 },
  { 654, 11, 16, 13, 2, -16 },
  { 676, 10, 16, 13, 2, -16 },
  { 696, 11, 16, 13, 1, -16 },
  { 718, 10, 16, 13, 2, -16 },
  { 738, 11, 16, 13, 1, -16 },
  { 760, 12, 16, 13, 1, -16 },
  { 784, 9, 16, 13, 2, -16 },
  { 802, 12, 16, 13, 1, -16 },
  { 826, 11, 16, 13, 1, -16 },
  { 848, 10, 16, 13, 2, -16 },
  { 868, 12, 16, 13, 1, -16 },
  { 892, 10, 20, 13, 2, -16 },
  { 917, 12, 16, 13, 1, -16 },
  { 941, 11, 16, 13, 1, -16 },
  { 963, 10, 16, 13, 3, -16 },
  { 983, 10, 16, 13, 2, -16 },
  { 1003, 10, 16, 13, 3, -16 },
  { 1023, 12, 16, 13, 2, -16 },
  { 1047, 13, 16, 13, 0, -16 },
  { 1073, 11, 16, 13, 3, -16 },
  { 1095, 11, 16, 13, 1, -16 },
  { 1117, 9, 20, 13, 3, -18 },
  { 1140, 6, 20, 13, 4, -18 },
  { 1155, 8, 20, 13, 2, -18 },
  { 1175, 9, 9, 13, 2, -16 },
  { 1186, 11, 1, 13, 0, 1 },
  { 1188, 3, 3, 13, 6, -17 },
  { 1190, 10, 12, 13, 2, -12 },
  { 1205, 10, 16, 13, 1, -16 },
  { 1225, 10, 12, 13, 2, -12 },
  { 1240, 10, 16, 13, 2, -16 },
  { 1260, 9, 12, 13, 2, -12 },
  { 1274, 14, 20, 13, -1, -16 },
  { 1309, 10, 16, 13, 2, -12 },
  { 1329, 10, 16, 13, 1, -16 },
  { 1349, 10, 17, 13, 1, -17 },
  { 1371, 11, 21, 13, 0, -17 },
  { 1400, 11, 16, 13, 2, -16 },
  { 1422, 8, 16, 13, 3, -16 },
  { 1438, 11, 12, 13, 1, -12 },
  { 1455, 10, 12, 13, 1, -12 },
  { 1470, 9, 12, 13, 2, -12 },
  { 1484, 10, 16, 13, 1, -12 },
  { 1504, 10, 16, 13, 2, -12 },
  { 1524, 10, 12, 13, 2, -12 },
  { 1539, 11, 12, 13, 1, -12 },
  { 1556, 10, 15, 13, 2, -15 },
  { 1575, 10, 12, 13, 2, -12 },
  { 1590, 9, 12, 13, 3, -12 },
  { 1604, 11, 12, 13, 2, -12 },
  { 1621, 11, 12, 13, 1, -12 },
  { 1638, 10, 16, 13, 2, -12 },
  { 1658, 11, 12, 13, 1, -12 },
  { 1675, 11, 20, 13, 2, -18 },
  { 1703, 4, 20, 13, 5, -18 },
  { 1713, 10, 20, 13, 1, -18 },
  { 1738, 10, 4, 13, 2, -10 },
};

const GFXfont JetBrainsMono_ThinItalic22pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic22pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _JETBRAINSMONO_THINITALIC22PT7B_H_
