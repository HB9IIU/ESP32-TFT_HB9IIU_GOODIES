#ifndef _JETBRAINSMONO_THINITALIC33PT7B_H_
#define _JETBRAINSMONO_THINITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x18, 0x61, 0x04, 0x10, 0xC3,
  0x08, 0x20, 0x00, 0x00, 0x03, 0xCF, 0x38, 0x61, 0xD8, 0x6E, 0x1B, 0x06,
  0xC1, 0xB0, 0x6C, 0x13, 0x0C, 0x83, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x18,
  0x18, 0x03, 0x02, 0x00, 0x40, 0xC0, 0x18, 0x18, 0x03, 0x02, 0x00, 0x40,
  0xC1, 0xFF, 0xFF, 0x03, 0x02, 0x00, 0x40, 0xC0, 0x18, 0x18, 0x03, 0x06,
  0x00, 0xC0, 0xC0, 0x18, 0x10, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0xFF, 0xFF,
  0x02, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x10, 0x02, 0x06, 0x00, 0xC0, 0xC0,
  0x18, 0x10, 0x06, 0x06, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x1F, 0xE0, 0x1D, 0xB8, 0x18, 0xC6, 0x08, 0x63,
  0x0C, 0x21, 0x86, 0x10, 0xC3, 0x08, 0x01, 0x84, 0x00, 0xC6, 0x00, 0x33,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x26, 0x00, 0x31, 0x80,
  0x18, 0x40, 0x08, 0x30, 0x04, 0x19, 0x82, 0x08, 0xC1, 0x0C, 0x61, 0x86,
  0x18, 0xC6, 0x0F, 0x6E, 0x01, 0xFE, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x0E, 0x0C, 0x60, 0x10,
  0x30, 0x40, 0x40, 0x40, 0x81, 0x00, 0x81, 0x06, 0x01, 0x06, 0x18, 0x06,
  0x0C, 0x60, 0x0C, 0x19, 0x80, 0x18, 0x66, 0x00, 0x1F, 0x88, 0x00, 0x1E,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x78, 0x00, 0x33,
  0xF8, 0x00, 0xC4, 0x10, 0x01, 0x18, 0x20, 0x04, 0x20, 0x40, 0x18, 0x40,
  0x80, 0x60, 0x83, 0x01, 0x83, 0x06, 0x06, 0x02, 0x08, 0x18, 0x06, 0x30,
  0x60, 0x07, 0xC0, 0x01, 0xFC, 0x01, 0xC7, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0x40, 0x30, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x03, 0xC0, 0x03, 0xB0, 0x03, 0x18, 0x09, 0x06, 0x0D, 0x81, 0x0C, 0xC0,
  0xCC, 0x60, 0x34, 0x20, 0x1E, 0x10, 0x06, 0x18, 0x03, 0x0C, 0x03, 0xC3,
  0x03, 0x31, 0xC7, 0x18, 0x7E, 0x06, 0x6D, 0xBF, 0xB6, 0xD8, 0x00, 0x08,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x60, 0x04, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x0C, 0x03, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x02, 0x06, 0x0F, 0xE2, 0x3E, 0x7D, 0x7C, 0x07,
  0xF0, 0x00, 0xC0, 0x00, 0xB0, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0xC1, 0x80,
  0xC0, 0xC0, 0xE0, 0x30, 0x20, 0x10, 0x00, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xFE,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x38, 0x70, 0xC3, 0x86, 0x1C, 0x30, 0x41, 0x80, 0xFF, 0xFF,
  0xF8, 0x13, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFC, 0x07, 0x0E, 0x0C,
  0x07, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30,
  0x03, 0x30, 0x03, 0x30, 0x82, 0x21, 0xC6, 0x61, 0xC6, 0x60, 0x86, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x0C, 0x40, 0x0C, 0x60,
  0x18, 0x60, 0x38, 0x3C, 0xF0, 0x1F, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x3B,
  0x01, 0x8C, 0x1C, 0x20, 0x40, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x3F,
  0xFF, 0x03, 0xFC, 0x03, 0x07, 0x03, 0x00, 0xC3, 0x00, 0x61, 0x00, 0x11,
  0x80, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0x40, 0x18, 0x60, 0x30,
  0x70, 0xE0, 0x1F, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0xC6,
  0x03, 0x30, 0x08, 0x80, 0x26, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0xFF, 0xE0,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x11, 0xF0, 0x17, 0xF8, 0x1C, 0x0C, 0x38, 0x0C, 0x30, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x40, 0x0C, 0x60, 0x18, 0x60, 0x30, 0x38, 0x60, 0x1F, 0xC0, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x18, 0x80, 0x6F, 0xE0, 0xE0, 0xE3, 0x00, 0xC6, 0x00,
  0xD8, 0x01, 0xA0, 0x03, 0x40, 0x07, 0x80, 0x0F, 0x00, 0x16, 0x00, 0x64,
  0x01, 0x8C, 0x07, 0x0E, 0x1C, 0x0F, 0xE0, 0x7F, 0xFF, 0x7F, 0xFE, 0x60,
  0x06, 0x40, 0x04, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x01, 0xFC, 0x07, 0x0E, 0x0C,
  0x03, 0x08, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x02, 0x08,
  0x04, 0x0C, 0x18, 0x07, 0x70, 0x01, 0xC0, 0x07, 0x70, 0x1C, 0x38, 0x30,
  0x0C, 0x60, 0x0C, 0x60, 0x04, 0x40, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0xC0,
  0x0C, 0x60, 0x18, 0x70, 0x70, 0x1F, 0xC0, 0x07, 0xF0, 0x38, 0x70, 0xC0,
  0x33, 0x00, 0x66, 0x00, 0x58, 0x00, 0xB0, 0x01, 0x60, 0x06, 0xC0, 0x0D,
  0x80, 0x1B, 0x00, 0x67, 0x01, 0xC7, 0x07, 0x07, 0xF4, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0x70, 0x07, 0x81,
  0xF0, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x10, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0C, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0xFF, 0xF8, 0x30, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x60, 0x00, 0x1F, 0xC0, 0x0F, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x18, 0x07, 0x81, 0xF0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0xFF, 0x00, 0x70, 0x70, 0x18, 0x06, 0x06, 0x00, 0x60, 0x80, 0x0C, 0x30,
  0x00, 0x84, 0x00, 0x11, 0x80, 0x06, 0x30, 0x3E, 0xC6, 0x0F, 0xF8, 0x83,
  0x07, 0x10, 0x40, 0x66, 0x18, 0x08, 0xC3, 0x01, 0x18, 0x60, 0x63, 0x0C,
  0x0C, 0x61, 0x01, 0x88, 0x20, 0x31, 0x04, 0x04, 0x60, 0xC1, 0x8C, 0x1C,
  0xD1, 0x81, 0xF6, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xE0, 0x02, 0xC0, 0x0D, 0x80, 0x13, 0x00, 0x62,
  0x00, 0xC4, 0x01, 0x08, 0x06, 0x10, 0x08, 0x30, 0x30, 0x60, 0x40, 0xC1,
  0x81, 0x83, 0x03, 0x0C, 0x02, 0x1F, 0xFC, 0x20, 0x08, 0xC0, 0x11, 0x00,
  0x36, 0x00, 0x6C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x0F, 0xF8, 0x08, 0x3E,
  0x08, 0x06, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x02,
  0x10, 0x06, 0x30, 0x0C, 0x30, 0x18, 0x3F, 0xF0, 0x30, 0x78, 0x20, 0x0C,
  0x20, 0x04, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x04, 0x60, 0x0C,
  0x40, 0x08, 0x40, 0x38, 0xFF, 0xF0, 0xFF, 0xC0, 0x03, 0xF8, 0x1C, 0x38,
  0x60, 0x18, 0x80, 0x33, 0x00, 0x26, 0x00, 0x48, 0x01, 0x90, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x13, 0x00, 0x26, 0x00, 0xCC, 0x01, 0x18,
  0x06, 0x1C, 0x38, 0x1F, 0xC0, 0x0F, 0xF0, 0x08, 0x7C, 0x08, 0x0E, 0x18,
  0x06, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x10, 0x02, 0x30,
  0x02, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x20, 0x06, 0x20, 0x04, 0x20,
  0x04, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x40, 0x18, 0x40,
  0x70, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xFF, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x7F, 0xF8, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0xC3, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xF8, 0x1C, 0x38, 0x60, 0x18, 0x80, 0x33, 0x00, 0x26, 0x00, 0x48, 0x01,
  0x90, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x1F, 0xC8,
  0x3F, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x13, 0x00, 0x26, 0x00,
  0xCC, 0x01, 0x18, 0x06, 0x1C, 0x38, 0x1F, 0xC0, 0x0C, 0x01, 0x84, 0x00,
  0x82, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x20,
  0x04, 0x10, 0x02, 0x18, 0x03, 0x0C, 0x01, 0x87, 0xFF, 0xC3, 0x00, 0x61,
  0x00, 0x20, 0x80, 0x10, 0x40, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03,
  0x0C, 0x01, 0x04, 0x00, 0x82, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0x1F,
  0xFE, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x30, 0x02, 0x10, 0x01,
  0x0C, 0x01, 0x86, 0x00, 0x83, 0x00, 0xC0, 0xE1, 0xC0, 0x3F, 0x80, 0x0C,
  0x00, 0xC2, 0x00, 0x60, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x06, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x10, 0x30, 0x0C, 0x0C, 0x03, 0x06, 0x00,
  0xFF, 0x00, 0x30, 0x60, 0x08, 0x18, 0x02, 0x02, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x01, 0x81, 0x80, 0x60, 0x40, 0x18, 0x10, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0x1C, 0x03, 0x8E, 0x01,
  0xC5, 0x01, 0xE2, 0xC0, 0xB1, 0x60, 0xD0, 0x90, 0x48, 0xC8, 0x6C, 0x64,
  0x26, 0x33, 0x33, 0x19, 0x91, 0x88, 0x50, 0x84, 0x28, 0x46, 0x18, 0x23,
  0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x20, 0x02, 0x30, 0x01,
  0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x62, 0x00, 0x31, 0x00, 0x10, 0x0C,
  0x01, 0x87, 0x00, 0x83, 0x80, 0x43, 0x40, 0x61, 0xA0, 0x30, 0xD8, 0x18,
  0x6C, 0x0C, 0x22, 0x04, 0x11, 0x02, 0x18, 0xC3, 0x0C, 0x61, 0x86, 0x10,
  0xC3, 0x08, 0x61, 0x04, 0x20, 0x83, 0x10, 0x41, 0x98, 0x60, 0x4C, 0x30,
  0x26, 0x18, 0x1B, 0x08, 0x0D, 0x04, 0x02, 0x82, 0x01, 0x43, 0x00, 0xE1,
  0x80, 0x70, 0x03, 0xF8, 0x1C, 0x38, 0x60, 0x30, 0x80, 0x33, 0x00, 0x66,
  0x00, 0xC8, 0x01, 0x90, 0x03, 0x60, 0x04, 0xC0, 0x09, 0x80, 0x33, 0x00,
  0x66, 0x00, 0xC8, 0x01, 0xB0, 0x02, 0x60, 0x04, 0xC0, 0x19, 0x80, 0x33,
  0x00, 0x66, 0x00, 0x8C, 0x03, 0x18, 0x0C, 0x1C, 0x30, 0x1F, 0xC0, 0x0F,
  0xFC, 0x04, 0x0F, 0x82, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C,
  0x60, 0x06, 0x20, 0x03, 0x10, 0x01, 0x18, 0x01, 0x8C, 0x01, 0x86, 0x03,
  0x83, 0xFF, 0x81, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xF8, 0x1C, 0x38, 0x60, 0x30, 0x80, 0x33, 0x00, 0x66,
  0x00, 0xC8, 0x01, 0x90, 0x03, 0x60, 0x04, 0xC0, 0x09, 0x80, 0x33, 0x00,
  0x66, 0x00, 0xC8, 0x01, 0xB0, 0x02, 0x60, 0x04, 0xC0, 0x19, 0x80, 0x33,
  0x00, 0x66, 0x00, 0x8C, 0x03, 0x18, 0x0C, 0x1C, 0x30, 0x1F, 0xC0, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0F,
  0xFC, 0x04, 0x0F, 0x02, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C,
  0x60, 0x06, 0x20, 0x02, 0x10, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x86, 0x07,
  0x83, 0xFF, 0x01, 0x06, 0x00, 0x81, 0x80, 0x40, 0xC0, 0x60, 0x20, 0x30,
  0x18, 0x18, 0x0C, 0x0C, 0x02, 0x04, 0x01, 0x82, 0x00, 0xC3, 0x00, 0x21,
  0x80, 0x18, 0x03, 0xFC, 0x03, 0x87, 0x03, 0x00, 0xC1, 0x00, 0x61, 0x80,
  0x30, 0xC0, 0x18, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x03, 0x30, 0x01, 0x18, 0x01, 0x8C, 0x00, 0xC3, 0x00,
  0xC1, 0xE1, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x03, 0x10, 0x02, 0x10, 0x02, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x20, 0x04, 0x20, 0x04, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x08, 0x40, 0x08, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0xC0,
  0x60, 0x70, 0xC0, 0x3F, 0x80, 0x80, 0x07, 0x00, 0x0B, 0x00, 0x36, 0x00,
  0x4C, 0x01, 0x98, 0x03, 0x30, 0x0C, 0x60, 0x18, 0x40, 0x20, 0x80, 0xC1,
  0x01, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x30, 0x18, 0x60, 0x31, 0x80, 0x23,
  0x00, 0x44, 0x00, 0x98, 0x01, 0x20, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x40, 0xC0, 0xD0, 0x30, 0x24, 0x1C, 0x09, 0x05, 0x06, 0x41,
  0x41, 0xB0, 0x50, 0x4C, 0x34, 0x33, 0x09, 0x0C, 0xC2, 0x42, 0x31, 0x90,
  0x8C, 0x44, 0x63, 0x11, 0x18, 0xCC, 0x44, 0x32, 0x11, 0x0C, 0x84, 0xC3,
  0x21, 0x20, 0xD0, 0x48, 0x34, 0x16, 0x0D, 0x05, 0x82, 0xC1, 0x40, 0xA0,
  0x50, 0x28, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0x06, 0x00, 0x30, 0x60,
  0x06, 0x02, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x01, 0x80, 0x18, 0x30, 0x01,
  0x86, 0x00, 0x08, 0x40, 0x00, 0xCC, 0x00, 0x05, 0x80, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x0D, 0x00, 0x01, 0x98, 0x00, 0x30, 0x80,
  0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x04, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x00, 0x30, 0x60, 0x03, 0x0E, 0x00, 0x18, 0xC0, 0x03, 0xA0, 0x01,
  0x18, 0x01, 0x8C, 0x01, 0x82, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0x20,
  0x60, 0x18, 0x60, 0x0C, 0x60, 0x02, 0x30, 0x01, 0xB0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xF1,
  0xFF, 0xF0, 0x07, 0xF8, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x00,
  0x80, 0x40, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x08, 0x06, 0x07, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0x80, 0x1E, 0x00, 0xF0, 0x0C, 0x80, 0x66, 0x06,
  0x30, 0x61, 0x83, 0x04, 0x30, 0x31, 0x81, 0x98, 0x0D, 0x80, 0x2C, 0x01,
  0x80, 0xFF, 0xFF, 0xE3, 0x0C, 0x21, 0x80, 0x0F, 0xE6, 0x38, 0x68, 0xC0,
  0x71, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x90, 0x03, 0x20, 0x04, 0x40, 0x09,
  0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x02, 0x30, 0x0C, 0x60,
  0x38, 0x60, 0xF0, 0x7E, 0x60, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0xFE, 0x0B, 0x06, 0x18, 0x04, 0x70, 0x0C,
  0xC0, 0x19, 0x80, 0x33, 0x00, 0x64, 0x00, 0xC8, 0x01, 0x10, 0x02, 0x60,
  0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x46, 0x01, 0x8C, 0x06, 0x36, 0x1C,
  0x67, 0xE0, 0x07, 0xF0, 0x70, 0xE3, 0x00, 0xCC, 0x03, 0x60, 0x0D, 0x80,
  0x34, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x1B, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0x70, 0xE0, 0xFE, 0x00, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x0F, 0xE6,
  0x1C, 0x34, 0x30, 0x1C, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C,
  0x40, 0x08, 0x40, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x70, 0x60, 0xF0, 0x3F, 0x30, 0x07, 0xF0,
  0x70, 0xE3, 0x00, 0x88, 0x03, 0x60, 0x0D, 0x80, 0x34, 0x00, 0xD0, 0x03,
  0xFF, 0xFB, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x2C, 0x03,
  0x30, 0x18, 0x70, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE6, 0x38, 0x68, 0xC0, 0x51, 0x00, 0x66, 0x00, 0xCC, 0x01,
  0x90, 0x03, 0x20, 0x04, 0x40, 0x09, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC,
  0x01, 0x98, 0x06, 0x18, 0x14, 0x1F, 0xD8, 0x0C, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x1C, 0x1F, 0xF0, 0x7F, 0x80, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0xFE, 0x0B,
  0x0E, 0x18, 0x0C, 0x70, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x64, 0x00,
  0x88, 0x01, 0x10, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x64,
  0x00, 0x88, 0x01, 0x30, 0x06, 0x60, 0x0C, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x30, 0x0C, 0x10, 0x0E,
  0x08, 0x06, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x06, 0x01, 0x86, 0x00, 0xFE,
  0x00, 0x41, 0x80, 0x60, 0xC0, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x04,
  0x03, 0x02, 0x00, 0xC1, 0x00, 0x61, 0x80, 0x18, 0xFE, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x78, 0x21, 0xFE, 0x17,
  0xCF, 0x0C, 0x68, 0xC6, 0x18, 0x66, 0x0C, 0x33, 0x04, 0x19, 0x82, 0x0C,
  0xC3, 0x06, 0x41, 0x82, 0x20, 0xC1, 0x30, 0x61, 0x98, 0x20, 0xCC, 0x10,
  0x66, 0x08, 0x32, 0x0C, 0x11, 0x06, 0x08, 0x83, 0x04, 0xC1, 0x06, 0x60,
  0x83, 0x00, 0x1B, 0xF8, 0x2C, 0x38, 0x60, 0x31, 0xC0, 0x33, 0x00, 0x66,
  0x00, 0xCC, 0x01, 0x90, 0x02, 0x20, 0x04, 0x40, 0x19, 0x80, 0x33, 0x00,
  0x66, 0x00, 0xCC, 0x01, 0x90, 0x02, 0x20, 0x04, 0xC0, 0x19, 0x80, 0x30,
  0x07, 0xF0, 0x70, 0xE3, 0x00, 0x88, 0x03, 0x60, 0x0D, 0x80, 0x34, 0x00,
  0xD0, 0x03, 0xC0, 0x0B, 0x00, 0x2C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00,
  0x4C, 0x03, 0x30, 0x18, 0x70, 0xC0, 0xFE, 0x00, 0x0D, 0xFC, 0x0B, 0x06,
  0x0C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03,
  0x10, 0x02, 0x30, 0x02, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x04,
  0x30, 0x0C, 0x30, 0x18, 0x6C, 0x38, 0x67, 0xE0, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0F, 0xE6, 0x38, 0x68,
  0xC0, 0x71, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x90, 0x03, 0x20, 0x04, 0xC0,
  0x09, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x02, 0x30, 0x0C,
  0x60, 0x38, 0x60, 0xF0, 0x7E, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x33, 0xF8, 0x68, 0x38, 0xE0, 0x31, 0x80,
  0x33, 0x00, 0x64, 0x00, 0xC8, 0x01, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x00, 0x07, 0xFC, 0x18, 0x1C, 0x60, 0x19, 0x80, 0x13, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xB0, 0x03, 0x30, 0x0C, 0x70, 0x38, 0x7F,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x0F, 0xFF,
  0xE0, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x30, 0x06, 0x40,
  0x08, 0x80, 0x13, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x20, 0x04,
  0x40, 0x09, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x02, 0x30,
  0x0C, 0x60, 0x30, 0x70, 0xC0, 0x7F, 0x00, 0xC0, 0x07, 0x80, 0x1B, 0x00,
  0x22, 0x00, 0xC4, 0x01, 0x0C, 0x06, 0x18, 0x08, 0x30, 0x30, 0x20, 0x40,
  0x41, 0x80, 0x82, 0x01, 0x8C, 0x03, 0x10, 0x02, 0x60, 0x04, 0x80, 0x0B,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xC1, 0x81, 0xE0, 0xC1, 0xB0, 0x60, 0xD8,
  0x50, 0x4C, 0x28, 0x66, 0x34, 0x33, 0x12, 0x11, 0x89, 0x18, 0xCC, 0x8C,
  0x64, 0x64, 0x32, 0x32, 0x1B, 0x1B, 0x0D, 0x0D, 0x06, 0x86, 0x83, 0xC3,
  0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x00, 0x18, 0x01, 0x86, 0x01,
  0x81, 0x81, 0x80, 0xC1, 0x80, 0x30, 0x80, 0x18, 0xC0, 0x06, 0xC0, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0x44, 0x00, 0x63, 0x00,
  0x60, 0x80, 0x60, 0x60, 0x60, 0x18, 0x60, 0x0C, 0x60, 0x03, 0x00, 0x20,
  0x05, 0x80, 0x36, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x80, 0x24, 0x00, 0x90,
  0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x00, 0xC6,
  0x0F, 0x1F, 0xEC, 0x0C, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xFE, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFC, 0x00,
  0x78, 0x00, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60,
  0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x02, 0x0C, 0x18, 0x30, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x18, 0x06, 0xFC, 0x0D,
  0x0C, 0x1E, 0x18, 0x2C, 0x18, 0xD0, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 24, 20, 7, -24 },
  { 19, 10, 10, 20, 7, -24 },
  { 32, 19, 24, 20, 1, -24 },
  { 89, 17, 34, 20, 2, -29 },
  { 162, 23, 24, 20, -1, -24 },
  { 231, 17, 24, 20, 1, -24 },
  { 282, 3, 10, 20, 10, -24 },
  { 286, 13, 32, 20, 6, -28 },
  { 338, 13, 32, 20, 2, -28 },
  { 390, 17, 17, 20, 2, -20 },
  { 427, 15, 16, 20, 3, -19 },
  { 457, 7, 10, 20, 4, -5 },
  { 466, 11, 2, 20, 5, -12 },
  { 469, 5, 5, 20, 6, -5 },
  { 473, 19, 31, 20, 1, -27 },
  { 547, 16, 24, 20, 2, -24 },
  { 595, 14, 24, 20, 2, -24 },
  { 637, 17, 24, 20, 2, -24 },
  { 688, 16, 24, 20, 2, -24 },
  { 736, 14, 24, 20, 3, -24 },
  { 778, 16, 24, 20, 2, -24 },
  { 826, 15, 24, 20, 2, -24 },
  { 871, 16, 24, 20, 4, -24 },
  { 919, 16, 24, 20, 2, -24 },
  { 967, 15, 24, 20, 4, -24 },
  { 1012, 8, 18, 20, 6, -18 },
  { 1030, 10, 23, 20, 4, -18 },
  { 1059, 15, 16, 20, 3, -19 },
  { 1089, 15, 9, 20, 3, -15 },
  { 1106, 15, 16, 20, 2, -19 },
  { 1136, 13, 24, 20, 5, -24 },
  { 1175, 19, 30, 20, 1, -24 },
  { 1247, 15, 24, 20, 1, -24 },
  { 1292, 16, 24, 20, 2, -24 },
  { 1340, 15, 24, 20, 3, -24 },
  { 1385, 16, 24, 20, 2, -24 },
  { 1433, 16, 24, 20, 3, -24 },
  { 1481, 18, 24, 20, 2, -24 },
  { 1535, 15, 24, 20, 3, -24 },
  { 1580, 17, 24, 20, 2, -24 },
  { 1631, 15, 24, 20, 3, -24 },
  { 1676, 17, 24, 20, 1, -24 },
  { 1727, 18, 24, 20, 2, -24 },
  { 1781, 13, 24, 20, 3, -24 },
  { 1820, 17, 24, 20, 2, -24 },
  { 1871, 17, 24, 20, 2, -24 },
  { 1922, 15, 24, 20, 3, -24 },
  { 1967, 17, 24, 20, 2, -24 },
  { 2018, 15, 30, 20, 3, -24 },
  { 2075, 17, 24, 20, 2, -24 },
  { 2126, 17, 24, 20, 2, -24 },
  { 2177, 16, 24, 20, 4, -24 },
  { 2225, 16, 24, 20, 3, -24 },
  { 2273, 15, 24, 20, 5, -24 },
  { 2318, 18, 24, 20, 3, -24 },
  { 2372, 20, 24, 20, 0, -24 },
  { 2432, 17, 24, 20, 4, -24 },
  { 2483, 17, 24, 20, 2, -24 },
  { 2534, 13, 31, 20, 5, -27 },
  { 2585, 9, 31, 20, 6, -27 },
  { 2620, 12, 31, 20, 3, -27 },
  { 2667, 13, 13, 20, 4, -24 },
  { 2689, 16, 1, 20, 0, 1 },
  { 2691, 5, 5, 20, 9, -26 },
  { 2695, 15, 18, 20, 3, -18 },
  { 2729, 15, 24, 20, 2, -24 },
  { 2774, 14, 18, 20, 3, -18 },
  { 2806, 16, 24, 20, 3, -24 },
  { 2854, 14, 18, 20, 3, -18 },
  { 2886, 21, 30, 20, -1, -24 },
  { 2965, 15, 24, 20, 3, -18 },
  { 3010, 15, 24, 20, 2, -24 },
  { 3055, 14, 25, 20, 2, -25 },
  { 3099, 16, 31, 20, 1, -25 },
  { 3161, 17, 24, 20, 2, -24 },
  { 3212, 13, 24, 20, 4, -24 },
  { 3251, 17, 18, 20, 1, -18 },
  { 3290, 15, 18, 20, 2, -18 },
  { 3324, 14, 18, 20, 3, -18 },
  { 3356, 16, 24, 20, 1, -18 },
  { 3404, 15, 24, 20, 3, -18 },
  { 3449, 15, 18, 20, 3, -18 },
  { 3483, 15, 18, 20, 2, -18 },
  { 3517, 15, 23, 20, 3, -23 },
  { 3561, 15, 18, 20, 3, -18 },
  { 3595, 15, 18, 20, 4, -18 },
  { 3629, 17, 18, 20, 3, -18 },
  { 3668, 17, 18, 20, 1, -18 },
  { 3707, 14, 24, 20, 3, -18 },
  { 3749, 15, 18, 20, 2, -18 },
  { 3783, 15, 31, 20, 4, -27 },
  { 3842, 7, 31, 20, 7, -27 },
  { 3870, 16, 31, 20, 1, -27 },
  { 3932, 15, 6, 20, 3, -15 },
};

const GFXfont JetBrainsMono_ThinItalic33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_THINITALIC33PT7B_H_
