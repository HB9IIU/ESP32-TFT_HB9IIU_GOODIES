#ifndef _JETBRAINSMONO_THINITALIC42PT7B_H_
#define _JETBRAINSMONO_THINITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C,
  0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x20,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0xF8, 0xF8, 0xF0, 0x38, 0x39, 0xC1, 0xCC,
  0x0E, 0x60, 0x77, 0x03, 0xB8, 0x19, 0xC0, 0xCE, 0x0E, 0x60, 0x73, 0x03,
  0x98, 0x18, 0xC0, 0xCE, 0x06, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x18, 0x06,
  0x00, 0x18, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x70, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x38, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x00, 0xC0, 0x70, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60,
  0x01, 0x80, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x80,
  0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x0C, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x0E, 0x00,
  0x38, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x18, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xF8, 0x01, 0xC4, 0x70, 0x0E, 0x30, 0xE0, 0x70, 0xC1, 0x81, 0x83, 0x06,
  0x0E, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC0, 0x80, 0x03, 0x02, 0x00, 0x0E,
  0x18, 0x00, 0x18, 0x60, 0x00, 0x71, 0x80, 0x00, 0xF6, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0C, 0xF0, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x80, 0x02, 0x06, 0x00, 0x08, 0x18, 0x00, 0x60, 0x61, 0x81,
  0x81, 0x86, 0x06, 0x06, 0x18, 0x18, 0x30, 0x60, 0x60, 0xC1, 0xC1, 0x06,
  0x03, 0x84, 0x38, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x30, 0x1F, 0xC0, 0x06, 0x03, 0x06, 0x00,
  0xE0, 0x60, 0x60, 0x0C, 0x06, 0x06, 0x01, 0x80, 0x40, 0x60, 0x30, 0x0C,
  0x06, 0x06, 0x00, 0xC0, 0x60, 0xC0, 0x0C, 0x06, 0x18, 0x00, 0xC0, 0x63,
  0x80, 0x0C, 0x0C, 0x30, 0x00, 0xC0, 0xC6, 0x00, 0x07, 0xF8, 0xC0, 0x00,
  0x3F, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x18, 0xFE, 0x00, 0x03, 0x18, 0x30,
  0x00, 0x63, 0x03, 0x00, 0x0C, 0x30, 0x30, 0x01, 0x83, 0x03, 0x00, 0x38,
  0x20, 0x30, 0x03, 0x06, 0x03, 0x00, 0x60, 0x60, 0x30, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x60, 0x60, 0x30, 0x06, 0x06, 0x06, 0x00, 0x3F, 0xC0, 0xC0,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0x83, 0x80,
  0x0E, 0x03, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0x38,
  0x01, 0x18, 0x30, 0x0C, 0x70, 0x70, 0x30, 0xC0, 0x60, 0x61, 0x80, 0x61,
  0x83, 0x00, 0xE6, 0x0E, 0x00, 0xDC, 0x18, 0x01, 0xF0, 0x30, 0x01, 0xC0,
  0x60, 0x03, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x1B, 0x03, 0x00, 0x67, 0x07,
  0x03, 0x86, 0x07, 0xFE, 0x06, 0x07, 0xF0, 0x0E, 0x00, 0x77, 0x77, 0x6E,
  0xEE, 0xEC, 0xCC, 0xC0, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x1C, 0x06, 0x03, 0xF8, 0x30, 0xFB, 0xF1, 0x3F, 0x83, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0xD8, 0x00, 0x0E, 0xE0, 0x00, 0xE3, 0x00,
  0x0E, 0x1C, 0x00, 0x60, 0x70, 0x07, 0x03, 0x80, 0x70, 0x0E, 0x07, 0x00,
  0x70, 0x10, 0x01, 0x00, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x83, 0x83, 0xC1, 0xC1, 0xE0,
  0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x39, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03,
  0xC1, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0xC0, 0x03, 0x1C, 0x00, 0x31,
  0x80, 0x03, 0x18, 0x00, 0x33, 0x80, 0x03, 0x38, 0x00, 0x73, 0x00, 0x07,
  0x30, 0x00, 0x63, 0x02, 0x06, 0x30, 0xF0, 0x67, 0x0F, 0x06, 0x70, 0xF0,
  0xE7, 0x06, 0x0E, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00,
  0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0,
  0x03, 0x07, 0x00, 0x70, 0x78, 0x0E, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xEC, 0x00, 0x7B, 0x80, 0x1C, 0x60,
  0x0F, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3C, 0x07, 0x01, 0xC0,
  0x0E, 0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x87, 0x00, 0x06,
  0x18, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x06,
  0x00, 0x60, 0x70, 0x0C, 0x03, 0xEF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x01, 0x81, 0xC0, 0x30, 0x70, 0x06,
  0x0C, 0x00, 0xC3, 0x00, 0x18, 0xE0, 0x07, 0x38, 0x00, 0xC6, 0x00, 0x18,
  0xC0, 0x03, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x8F, 0xE0, 0x19, 0xFF, 0x01, 0xA0, 0x38, 0x1C,
  0x01, 0xC3, 0x80, 0x0C, 0x38, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0xE0, 0x01, 0x8E, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x70, 0x70, 0x0E,
  0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1B, 0xFC, 0x06, 0xE3, 0xE0, 0xE0, 0x1C, 0x38, 0x01, 0xC6, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0x6E, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00,
  0x36, 0x00, 0x06, 0xC0, 0x01, 0xD8, 0x00, 0x33, 0x80, 0x0E, 0x30, 0x03,
  0x87, 0x00, 0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x70, 0x00, 0x76, 0x00, 0x06, 0x60, 0x00, 0xE6, 0x00, 0x0C, 0x60,
  0x01, 0xCE, 0x00, 0x18, 0xE0, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0x80, 0xE0, 0x70, 0x06,
  0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00,
  0x31, 0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xE0, 0x1C, 0x07, 0x03, 0x80, 0x38,
  0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0x9C, 0x00, 0xE0, 0x70, 0x1C,
  0x03, 0x83, 0x00, 0x18, 0x70, 0x01, 0xC6, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8E, 0x00, 0x30,
  0x70, 0x0E, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x38, 0x1E, 0x0E, 0x00, 0xC3, 0x00, 0x0C, 0xE0, 0x01, 0x98, 0x00,
  0x33, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00,
  0x6C, 0x00, 0x19, 0x80, 0x03, 0x38, 0x00, 0xC3, 0x80, 0x38, 0x78, 0x1E,
  0x03, 0xFF, 0xC0, 0x1E, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x07,
  0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x0F, 0x8F, 0xC7, 0xE3, 0xF0,
  0xF0, 0x00, 0x40, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x78, 0x0F, 0xE0, 0x0F, 0x80, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x3C, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18,
  0x07, 0xE6, 0x18, 0x0F, 0xF6, 0x18, 0x1C, 0x1E, 0x38, 0x38, 0x0E, 0x30,
  0x30, 0x0E, 0x30, 0x30, 0x0C, 0x30, 0x30, 0x0C, 0x30, 0x70, 0x0C, 0x30,
  0x60, 0x0C, 0x30, 0x60, 0x0C, 0x60, 0x60, 0x1C, 0x60, 0x60, 0x18, 0x60,
  0x60, 0x18, 0x60, 0x60, 0x18, 0x60, 0x60, 0x38, 0x60, 0x78, 0xD8, 0xE0,
  0x3F, 0x98, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x09, 0x00,
  0x01, 0x98, 0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x06, 0x18,
  0x00, 0x61, 0x80, 0x0E, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0x80,
  0xC0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x00, 0xC0, 0x60,
  0x0C, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0C, 0x00, 0xE1, 0x80, 0x06, 0x18,
  0x00, 0x63, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x66,
  0x00, 0x06, 0xC0, 0x00, 0x70, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0C, 0x03,
  0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x60, 0xC0, 0x07, 0x0C, 0x00, 0x31, 0xC0,
  0x03, 0x18, 0x00, 0x31, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x0E, 0x18,
  0x01, 0xC1, 0x80, 0x38, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x30, 0x0F, 0x03,
  0x00, 0x38, 0x30, 0x01, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x0C,
  0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0xE0, 0x03,
  0x8C, 0x00, 0x70, 0xC0, 0x1E, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0xE0, 0x03,
  0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0xE0, 0x0E,
  0x03, 0x80, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xF0, 0x0C, 0x07, 0x80, 0xC0, 0x1C, 0x0C, 0x00, 0xE0, 0xC0, 0x06,
  0x0C, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00,
  0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0xE3, 0x00,
  0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x70,
  0x00, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03, 0x86,
  0x00, 0x30, 0xE0, 0x07, 0x0C, 0x00, 0xE0, 0xC0, 0x3C, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xE0, 0x38, 0x0E,
  0x00, 0xE0, 0xE0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x06,
  0x18, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x7F, 0xE1,
  0x83, 0xFF, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18,
  0x00, 0xE0, 0xE0, 0x0E, 0x03, 0x80, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x06, 0x00, 0x38, 0x70, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x80, 0x0C, 0x18, 0x00,
  0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C,
  0x00, 0x70, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x30, 0x00, 0xC1, 0x80, 0x06,
  0x0C, 0x00, 0x30, 0x60, 0x03, 0x87, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x38, 0x00, 0xC1,
  0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x00, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x80, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x38, 0x00, 0xC0, 0xC0, 0x0E, 0x07, 0x00, 0xE0, 0x1F, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x70, 0xC0, 0x03, 0x83,
  0x00, 0x0C, 0x0C, 0x00, 0x70, 0x30, 0x03, 0x80, 0xC0, 0x0C, 0x07, 0x00,
  0x70, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x06, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0x60, 0x70, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x70, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x70, 0x0C,
  0x01, 0x80, 0x38, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x07, 0x01,
  0x80, 0x0C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xE0, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x0C, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x50, 0x03, 0xC3,
  0x60, 0x0B, 0x0D, 0x80, 0x6C, 0x36, 0x03, 0x30, 0xC8, 0x0D, 0x83, 0x20,
  0x66, 0x0C, 0xC1, 0x98, 0x63, 0x0C, 0x61, 0x8C, 0x31, 0x86, 0x11, 0x86,
  0x18, 0x46, 0x30, 0x61, 0xB0, 0xC1, 0x86, 0xC3, 0x0E, 0x1E, 0x0C, 0x30,
  0x30, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE1,
  0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x18, 0x78, 0x01, 0x83, 0xC0,
  0x0C, 0x1E, 0x00, 0x60, 0xD0, 0x03, 0x06, 0xC0, 0x18, 0x36, 0x00, 0xC3,
  0xB0, 0x0C, 0x18, 0x80, 0x60, 0xC6, 0x03, 0x06, 0x30, 0x18, 0x31, 0x80,
  0xC1, 0x84, 0x06, 0x0C, 0x30, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x81, 0x86, 0x0C, 0x0C, 0x30, 0x60, 0x61, 0x86, 0x03, 0x18,
  0x30, 0x0C, 0xC1, 0x80, 0x66, 0x0C, 0x03, 0x30, 0x60, 0x19, 0x83, 0x00,
  0x4C, 0x38, 0x03, 0xC1, 0x80, 0x1E, 0x0C, 0x00, 0xF0, 0x60, 0x03, 0x83,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0x81, 0xC0, 0x70,
  0x06, 0x0E, 0x00, 0x60, 0xC0, 0x07, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18,
  0x00, 0x71, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x38, 0x00, 0x63,
  0x00, 0x06, 0x30, 0x00, 0xE3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C,
  0x30, 0x00, 0xC7, 0x00, 0x0C, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x01,
  0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00,
  0x60, 0x30, 0x0E, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0xC0, 0x1F, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00,
  0x61, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0x83,
  0x80, 0x1C, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xFC, 0x03, 0x81, 0xC0, 0x70, 0x06, 0x0E, 0x00, 0x60,
  0xC0, 0x07, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x71, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x38, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00,
  0xE3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC7, 0x00,
  0x0C, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60,
  0x01, 0x86, 0x00, 0x38, 0x60, 0x03, 0x07, 0x00, 0x60, 0x30, 0x0E, 0x03,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0x00, 0xF8, 0x18, 0x00, 0xE0,
  0xC0, 0x03, 0x06, 0x00, 0x1C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00,
  0x18, 0xC0, 0x01, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x06, 0x0C,
  0x00, 0x70, 0xC0, 0x0F, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0x81, 0x80,
  0x0C, 0x06, 0x00, 0x60, 0x30, 0x07, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x38, 0x01, 0xC1,
  0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0xC3, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1C, 0x07, 0x00, 0xC0, 0x0E, 0x06, 0x00,
  0x18, 0x18, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00,
  0x0C, 0x1C, 0x00, 0x60, 0x38, 0x03, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03,
  0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0x60, 0xC0,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x1C, 0x00, 0x70,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00,
  0x30, 0xE0, 0x01, 0x86, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C,
  0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xE0, 0x0C,
  0x03, 0x80, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x1D, 0xC0, 0x03, 0x18,
  0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30,
  0x07, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x30, 0x06, 0x06, 0x00, 0xC1, 0xC0, 0x18, 0x30, 0x03, 0x06, 0x00, 0x61,
  0x80, 0x0C, 0x30, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x38, 0x0E, 0xC0, 0x70, 0x19, 0x00, 0xE0, 0x32, 0x03, 0xC0, 0x64, 0x07,
  0x81, 0x88, 0x0B, 0x03, 0x30, 0x36, 0x06, 0x60, 0x6C, 0x0C, 0xC0, 0xD8,
  0x31, 0x81, 0x30, 0x63, 0x06, 0x60, 0xC6, 0x0C, 0xC3, 0x0C, 0x11, 0x86,
  0x18, 0x63, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x0C, 0x60, 0xC6, 0x18, 0xC1,
  0x8C, 0x31, 0x83, 0x10, 0x66, 0x06, 0x20, 0xCC, 0x0C, 0xC1, 0x98, 0x19,
  0x83, 0x30, 0x32, 0x06, 0xC0, 0x6C, 0x09, 0x80, 0xD8, 0x13, 0x01, 0xA0,
  0x24, 0x03, 0xC0, 0x58, 0x07, 0x80, 0xB0, 0x0E, 0x01, 0x60, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x00, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x01, 0xC0,
  0x60, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xE0,
  0x03, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18, 0x70,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x0E,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x06, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x03, 0x00, 0x06, 0x03, 0x80, 0x03, 0x03,
  0x80, 0x01, 0xC3, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x1B, 0x00, 0x01, 0x98,
  0x00, 0x1C, 0xC0, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x06,
  0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x18,
  0x18, 0x00, 0xC1, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0xC0, 0x18, 0x03,
  0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x07, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFF, 0xC0, 0xFF, 0x80,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xD8, 0x01, 0x98, 0x03, 0x98,
  0x03, 0x1C, 0x07, 0x0C, 0x06, 0x0C, 0x0C, 0x0C, 0x1C, 0x0E, 0x18, 0x06,
  0x38, 0x06, 0x30, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE1, 0x87, 0x0C, 0x18, 0x70, 0x00, 0x30, 0x00,
  0x3F, 0xCC, 0x1F, 0x3D, 0x87, 0x00, 0xB0, 0xC0, 0x1E, 0x30, 0x01, 0xC6,
  0x00, 0x39, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0x67, 0x00, 0x1C, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x01, 0x8C, 0x00, 0x31, 0x80, 0x0E, 0x30, 0x01, 0x86, 0x00, 0x70, 0x60,
  0x1E, 0x0F, 0x9E, 0xC0, 0xFF, 0x18, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x40, 0x18, 0xFF, 0x03, 0x78, 0xF0, 0x68, 0x07, 0x0E, 0x00, 0x61, 0x80,
  0x0C, 0x30, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00,
  0x18, 0xC0, 0x03, 0x18, 0x00, 0x67, 0x00, 0x0C, 0xC0, 0x03, 0x18, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x73, 0x80, 0x0C, 0x78, 0x03,
  0x8D, 0x80, 0xE1, 0xBC, 0xF8, 0x33, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x3F,
  0xE0, 0x0F, 0xBE, 0x07, 0x00, 0xE0, 0xC0, 0x0C, 0x30, 0x01, 0xC6, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0x87, 0x00, 0x70, 0x70, 0x1C,
  0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x06, 0x0C, 0x01, 0xFE, 0x60, 0x3E, 0x7B, 0x03, 0x80, 0x58, 0x18, 0x01,
  0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xE0, 0x03, 0x86, 0x00, 0x18,
  0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00,
  0x1C, 0x18, 0x00, 0xC0, 0xC0, 0x0E, 0x03, 0x00, 0xF0, 0x1F, 0x3D, 0x80,
  0x7F, 0x8C, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x1F, 0x3E, 0x07, 0x00,
  0xE0, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x18, 0xC0, 0x03, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x06,
  0x30, 0x01, 0x87, 0x00, 0x70, 0x60, 0x1C, 0x0F, 0xDF, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x30,
  0xF9, 0xEC, 0x70, 0x0B, 0x18, 0x03, 0xCC, 0x00, 0x73, 0x00, 0x1D, 0x80,
  0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0xE0, 0x03,
  0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0xCE,
  0x00, 0xF1, 0xC0, 0x78, 0x3F, 0xF6, 0x07, 0xF1, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x0F, 0xFE, 0x03, 0xF8, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x40, 0x18, 0xFF, 0x03, 0x38, 0xF0, 0x68, 0x07, 0x0E, 0x00, 0x61,
  0x80, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x67, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x80, 0x0E, 0x60,
  0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x38, 0xC0, 0x03,
  0x86, 0x00, 0x38, 0x30, 0x03, 0x81, 0x80, 0x38, 0x0C, 0x03, 0x80, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0x30, 0x1C, 0x01, 0x81, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0x03, 0x00, 0x38, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x70, 0x18, 0x01, 0x81, 0xC0, 0x0E, 0x0C,
  0x00, 0x30, 0x60, 0x01, 0xC3, 0x00, 0x06, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x20,
  0x20, 0x37, 0xE7, 0xE0, 0xF3, 0x91, 0xC3, 0x87, 0x83, 0x0C, 0x0C, 0x0C,
  0x70, 0x30, 0x31, 0x81, 0xC0, 0xC6, 0x06, 0x03, 0x18, 0x18, 0x18, 0x60,
  0x60, 0x61, 0x81, 0x81, 0x8E, 0x06, 0x06, 0x30, 0x18, 0x18, 0xC0, 0xC0,
  0x63, 0x03, 0x03, 0x8C, 0x0C, 0x0C, 0x30, 0x30, 0x31, 0xC0, 0xC0, 0xC6,
  0x03, 0x03, 0x18, 0x18, 0x0C, 0x60, 0x60, 0x31, 0x81, 0x81, 0x86, 0x06,
  0x06, 0x38, 0x18, 0x18, 0x00, 0x08, 0x03, 0x9F, 0xE0, 0x67, 0x1E, 0x0D,
  0x00, 0xE1, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31, 0xC0, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0xE0,
  0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80,
  0x06, 0x70, 0x01, 0xCC, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x0F, 0x3E, 0x07, 0x00, 0xE0, 0xC0,
  0x0C, 0x30, 0x01, 0x86, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00,
  0x18, 0xC0, 0x03, 0x18, 0x00, 0x67, 0x00, 0x0C, 0xC0, 0x03, 0x98, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0E, 0x30, 0x01,
  0x86, 0x00, 0x60, 0x60, 0x1C, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x04,
  0x00, 0xE7, 0xF8, 0x0D, 0xE3, 0xC0, 0xD0, 0x0E, 0x0E, 0x00, 0x60, 0xC0,
  0x06, 0x0C, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18,
  0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x63, 0x80, 0x0E, 0x30, 0x00, 0xC3,
  0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0xC7, 0x00, 0x18,
  0x78, 0x03, 0x86, 0xC0, 0x70, 0x6F, 0x3E, 0x06, 0x7F, 0x80, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xCC, 0x1F,
  0x3D, 0x87, 0x00, 0xB0, 0xC0, 0x0E, 0x30, 0x01, 0xC6, 0x00, 0x39, 0x80,
  0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x66, 0x00,
  0x1C, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x31, 0x80, 0x0E, 0x30, 0x01, 0x87, 0x00, 0x70, 0x60, 0x1E, 0x0F, 0xBE,
  0xC0, 0xFF, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x08,
  0x00, 0xCF, 0xF8, 0x0D, 0xE7, 0xC0, 0xF0, 0x0E, 0x0E, 0x00, 0xE1, 0xC0,
  0x06, 0x1C, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x7F, 0xF0, 0x1E, 0x1F, 0x07, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00,
  0xCE, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x3B, 0x00, 0x06, 0x60, 0x00, 0xCE, 0x00, 0x38,
  0xE0, 0x0E, 0x1F, 0x8F, 0x80, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xE0, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C,
  0x00, 0x31, 0x80, 0x06, 0x70, 0x01, 0xCC, 0x00, 0x31, 0x80, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x66, 0x00, 0x1C, 0xC0,
  0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x61, 0x80,
  0x0C, 0x38, 0x03, 0x03, 0x80, 0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0xC0,
  0x00, 0xF8, 0x00, 0x19, 0x80, 0x07, 0x30, 0x00, 0xC6, 0x00, 0x30, 0xC0,
  0x06, 0x18, 0x01, 0x83, 0x00, 0x30, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x60, 0x18, 0x0C, 0x03, 0x03, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0xC3,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x26, 0x00, 0x06, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x1E, 0x03, 0x81, 0xB0,
  0x3C, 0x0D, 0x81, 0xE0, 0x6C, 0x0B, 0x06, 0x60, 0xD8, 0x33, 0x06, 0xC1,
  0x98, 0x26, 0x18, 0xC3, 0x30, 0xC6, 0x19, 0x86, 0x30, 0x8C, 0x61, 0x8C,
  0x63, 0x0C, 0x63, 0x18, 0x66, 0x19, 0x83, 0x30, 0xCC, 0x19, 0x86, 0x60,
  0xD8, 0x36, 0x06, 0xC1, 0xB0, 0x34, 0x0D, 0x81, 0xE0, 0x68, 0x0F, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x60, 0x30, 0x03, 0x00, 0xE0, 0x18, 0x01, 0x80, 0xE0, 0x07, 0x07, 0x00,
  0x0C, 0x38, 0x00, 0x18, 0xC0, 0x00, 0x66, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xB0, 0x00, 0x0C, 0xE0,
  0x00, 0x61, 0x80, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0x60, 0x38, 0x00, 0xC0, 0xC0, 0x03, 0x0E, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x9C, 0x00, 0x73, 0x00, 0x0C, 0x60,
  0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x39, 0x80,
  0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x1C, 0x60, 0x03, 0x0E, 0x00, 0xE0, 0xE0, 0x2C, 0x1F, 0xF9, 0x80, 0xFE,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x07, 0x80, 0xFF, 0xE0, 0x1F, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0x80, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60,
  0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x31, 0xF8, 0x03, 0x31, 0xC0, 0x26, 0x0E, 0x06, 0x60, 0x70, 0x66,
  0x03, 0x0E, 0x60, 0x1F, 0xCE, 0x00, 0xF8,
};

const GFXglyph JetBrainsMono_ThinItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 8, 31, 25, 9, -31 },
  { 32, 13, 13, 25, 8, -31 },
  { 54, 24, 31, 25, 1, -31 },
  { 147, 22, 43, 25, 2, -37 },
  { 266, 28, 31, 25, -1, -31 },
  { 375, 23, 31, 25, 1, -31 },
  { 465, 4, 13, 25, 13, -31 },
  { 472, 17, 40, 25, 7, -35 },
  { 557, 17, 40, 25, 2, -35 },
  { 642, 21, 22, 25, 3, -26 },
  { 700, 20, 20, 25, 3, -24 },
  { 750, 9, 13, 25, 5, -6 },
  { 765, 14, 2, 25, 6, -15 },
  { 769, 6, 6, 25, 8, -6 },
  { 774, 24, 40, 25, 1, -35 },
  { 894, 20, 31, 25, 3, -31 },
  { 972, 19, 31, 25, 2, -31 },
  { 1046, 22, 31, 25, 2, -31 },
  { 1132, 20, 31, 25, 3, -31 },
  { 1210, 19, 31, 25, 3, -31 },
  { 1284, 20, 31, 25, 3, -31 },
  { 1362, 19, 31, 25, 3, -31 },
  { 1436, 20, 31, 25, 5, -31 },
  { 1514, 20, 31, 25, 3, -31 },
  { 1592, 19, 31, 25, 5, -31 },
  { 1666, 9, 24, 25, 8, -24 },
  { 1693, 12, 31, 25, 5, -24 },
  { 1740, 19, 21, 25, 4, -24 },
  { 1790, 19, 12, 25, 3, -20 },
  { 1819, 20, 21, 25, 2, -24 },
  { 1872, 16, 31, 25, 7, -31 },
  { 1934, 24, 39, 25, 1, -31 },
  { 2051, 20, 31, 25, 1, -31 },
  { 2129, 20, 31, 25, 3, -31 },
  { 2207, 21, 31, 25, 3, -31 },
  { 2289, 20, 31, 25, 3, -31 },
  { 2367, 21, 31, 25, 3, -31 },
  { 2449, 22, 31, 25, 3, -31 },
  { 2535, 21, 31, 25, 3, -31 },
  { 2617, 21, 31, 25, 3, -31 },
  { 2699, 20, 31, 25, 3, -31 },
  { 2777, 21, 31, 25, 2, -31 },
  { 2859, 22, 31, 25, 3, -31 },
  { 2945, 18, 31, 25, 3, -31 },
  { 3015, 22, 31, 25, 2, -31 },
  { 3101, 21, 31, 25, 3, -31 },
  { 3183, 20, 31, 25, 3, -31 },
  { 3261, 22, 31, 25, 3, -31 },
  { 3347, 20, 39, 25, 3, -31 },
  { 3445, 21, 31, 25, 3, -31 },
  { 3527, 22, 31, 25, 2, -31 },
  { 3613, 21, 31, 25, 5, -31 },
  { 3695, 21, 31, 25, 3, -31 },
  { 3777, 19, 31, 25, 6, -31 },
  { 3851, 23, 31, 25, 4, -31 },
  { 3941, 25, 31, 25, 0, -31 },
  { 4038, 21, 31, 25, 5, -31 },
  { 4120, 22, 31, 25, 2, -31 },
  { 4206, 15, 40, 25, 7, -35 },
  { 4281, 11, 40, 25, 8, -35 },
  { 4336, 16, 40, 25, 4, -35 },
  { 4416, 16, 17, 25, 5, -31 },
  { 4450, 21, 2, 25, 0, 1 },
  { 4456, 6, 6, 25, 12, -33 },
  { 4461, 19, 24, 25, 3, -24 },
  { 4518, 19, 31, 25, 3, -31 },
  { 4592, 19, 24, 25, 3, -24 },
  { 4649, 21, 31, 25, 3, -31 },
  { 4731, 19, 24, 25, 3, -24 },
  { 4788, 26, 39, 25, -1, -31 },
  { 4915, 18, 32, 25, 4, -24 },
  { 4987, 19, 31, 25, 3, -31 },
  { 5061, 19, 32, 25, 2, -32 },
  { 5137, 21, 40, 25, 1, -32 },
  { 5242, 21, 31, 25, 3, -31 },
  { 5324, 16, 31, 25, 5, -31 },
  { 5386, 22, 24, 25, 1, -24 },
  { 5452, 19, 24, 25, 3, -24 },
  { 5509, 19, 24, 25, 3, -24 },
  { 5566, 20, 32, 25, 2, -24 },
  { 5646, 19, 32, 25, 3, -24 },
  { 5722, 20, 24, 25, 3, -24 },
  { 5782, 19, 24, 25, 3, -24 },
  { 5839, 19, 29, 25, 4, -29 },
  { 5908, 19, 23, 25, 3, -23 },
  { 5963, 19, 23, 25, 5, -23 },
  { 6018, 21, 23, 25, 4, -23 },
  { 6079, 22, 23, 25, 1, -23 },
  { 6143, 19, 31, 25, 3, -23 },
  { 6217, 20, 23, 25, 2, -23 },
  { 6275, 20, 40, 25, 5, -35 },
  { 6375, 8, 40, 25, 9, -35 },
  { 6415, 20, 40, 25, 2, -35 },
  { 6515, 20, 8, 25, 3, -19 },
};

const GFXfont JetBrainsMono_ThinItalic42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_THINITALIC42PT7B_H_
