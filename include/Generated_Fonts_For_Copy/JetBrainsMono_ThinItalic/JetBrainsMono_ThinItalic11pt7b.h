#ifndef _JETBRAINSMONO_THINITALIC11PT7B_H_
#define _JETBRAINSMONO_THINITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x53, 0x9A, 0xA0, 0x14, 0x29, 0xF9, 0x44, 0x9F, 0x94, 0x48,
  0x10, 0x9F, 0x5A, 0x30, 0xC5, 0xAF, 0x90, 0x80, 0x72, 0xA9, 0x63, 0x81,
  0xC6, 0x95, 0x4E, 0x38, 0x92, 0x08, 0x56, 0x68, 0x9D, 0xE0, 0x34, 0x48,
  0x88, 0x88, 0x86, 0x61, 0x11, 0x11, 0x22, 0x2C, 0x21, 0x3E, 0x45, 0x48,
  0x21, 0x3E, 0x42, 0x00, 0x29, 0x40, 0xE0, 0x70, 0x06, 0x08, 0x20, 0x41,
  0x02, 0x08, 0x10, 0x41, 0x80, 0x7C, 0x63, 0x5A, 0xC6, 0x5E, 0x35, 0x12,
  0x22, 0x2F, 0x7C, 0x42, 0x11, 0x11, 0x1E, 0x78, 0x88, 0x20, 0x86, 0x5C,
  0x18, 0x88, 0x98, 0xF8, 0x42, 0x7A, 0x29, 0xA0, 0x86, 0x5E, 0x11, 0x10,
  0xE8, 0xC6, 0x5E, 0x7E, 0x20, 0x84, 0x10, 0x84, 0x10, 0x7A, 0x62, 0xE5,
  0x46, 0x3E, 0x7C, 0x63, 0x17, 0x08, 0x88, 0x40, 0x01, 0x80, 0x30, 0x00,
  0x24, 0x48, 0x1B, 0x20, 0xC1, 0x00, 0xF8, 0x3C, 0xC1, 0x86, 0xC8, 0x00,
  0x61, 0x12, 0xC8, 0x08, 0x3C, 0x85, 0x2A, 0xA5, 0x54, 0xA9, 0x4C, 0x80,
  0xE0, 0x10, 0xCA, 0x52, 0xBD, 0x31, 0x7A, 0x63, 0xE9, 0x46, 0x3E, 0x7A,
  0x61, 0x08, 0x42, 0x5E, 0x72, 0x63, 0x18, 0xC6, 0x5C, 0x7A, 0x21, 0xE8,
  0x42, 0x1E, 0x7D, 0x08, 0x3E, 0x82, 0x08, 0x20, 0x7A, 0x61, 0x0B, 0xC6,
  0x5E, 0x4A, 0x63, 0xF8, 0xC6, 0x52, 0x79, 0x08, 0x42, 0x10, 0x9E, 0x1C,
  0x10, 0x41, 0x04, 0x28, 0x9C, 0x4D, 0x29, 0x3C, 0x92, 0x49, 0x24, 0x44,
  0x88, 0x88, 0x8F, 0x4A, 0xF7, 0x58, 0xC6, 0x32, 0x4A, 0x6B, 0x5A, 0xD6,
  0x52, 0x7A, 0x63, 0x18, 0xC6, 0x5E, 0x7A, 0x63, 0x1F, 0x42, 0x10, 0x7A,
  0x63, 0x18, 0xC6, 0x5A, 0x20, 0x80, 0x7A, 0x63, 0x3E, 0x4A, 0x52, 0x7C,
  0x60, 0xC1, 0x06, 0x3E, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x10, 0x4A, 0x63,
  0x18, 0xC6, 0x5C, 0x8C, 0xA5, 0x4A, 0x63, 0x10, 0xA6, 0x9A, 0xB6, 0xDA,
  0x49, 0x24, 0x26, 0x48, 0xA0, 0x83, 0x05, 0x12, 0x42, 0x85, 0x25, 0x14,
  0x20, 0x82, 0x10, 0x78, 0x44, 0x42, 0x22, 0x1E, 0x74, 0x44, 0x88, 0x88,
  0x8C, 0x92, 0x24, 0x92, 0x24, 0x31, 0x11, 0x12, 0x22, 0x2E, 0x11, 0x95,
  0x10, 0xF8, 0x90, 0x7C, 0x63, 0x19, 0x78, 0x42, 0x1D, 0x18, 0xC6, 0x5E,
  0x74, 0x61, 0x09, 0x78, 0x08, 0x5F, 0x18, 0xC6, 0x5E, 0x74, 0x7F, 0x08,
  0x78, 0x0E, 0x21, 0xF0, 0x82, 0x04, 0x08, 0x10, 0x21, 0x80, 0x7C, 0x63,
  0x19, 0x38, 0x5C, 0x42, 0x1D, 0x18, 0xC6, 0x52, 0x10, 0x62, 0x22, 0x2F,
  0x0C, 0x03, 0x82, 0x08, 0x20, 0x84, 0x13, 0x80, 0x42, 0x23, 0x2E, 0x52,
  0x52, 0xE1, 0x08, 0x84, 0x21, 0x0F, 0x7D, 0x55, 0x55, 0x96, 0x90, 0x74,
  0x63, 0x19, 0x48, 0x74, 0x63, 0x19, 0x78, 0x39, 0x14, 0x51, 0x49, 0xE8,
  0x20, 0x7C, 0x63, 0x19, 0x78, 0x42, 0x7C, 0x61, 0x08, 0x40, 0x7C, 0x18,
  0x20, 0xF8, 0x21, 0x3E, 0x44, 0x21, 0x0E, 0x8C, 0x63, 0x19, 0x70, 0x8C,
  0x54, 0xA6, 0x20, 0xA6, 0xAE, 0xBA, 0xB2, 0x40, 0x64, 0xA1, 0x0C, 0x4B,
  0x20, 0x8C, 0x63, 0x29, 0x38, 0x5C, 0x78, 0x88, 0x88, 0x78, 0x18, 0x84,
  0x22, 0x70, 0x84, 0x21, 0x80, 0x29, 0x24, 0x92, 0x90, 0x30, 0x41, 0x04,
  0x10, 0x72, 0x08, 0x23, 0x80, 0xCD, 0xC0,
};

const GFXglyph JetBrainsMono_ThinItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 4, 3, 7, 2, -8 },
  { 5, 7, 8, 7, 0, -8 },
  { 12, 5, 12, 7, 1, -10 },
  { 20, 7, 8, 7, 0, -8 },
  { 27, 6, 8, 7, 0, -8 },
  { 33, 1, 3, 7, 3, -8 },
  { 34, 4, 10, 7, 2, -9 },
  { 39, 4, 10, 7, 1, -9 },
  { 44, 5, 6, 7, 1, -7 },
  { 48, 5, 5, 7, 1, -6 },
  { 52, 3, 4, 7, 1, -2 },
  { 54, 3, 1, 7, 2, -4 },
  { 55, 2, 2, 7, 2, -2 },
  { 56, 7, 10, 7, 0, -9 },
  { 65, 5, 8, 7, 1, -8 },
  { 70, 4, 8, 7, 1, -8 },
  { 74, 5, 8, 7, 1, -8 },
  { 79, 5, 8, 7, 1, -8 },
  { 84, 5, 8, 7, 1, -8 },
  { 89, 5, 8, 7, 1, -8 },
  { 94, 5, 8, 7, 1, -8 },
  { 99, 6, 8, 7, 1, -8 },
  { 105, 5, 8, 7, 1, -8 },
  { 110, 5, 8, 7, 1, -8 },
  { 115, 3, 6, 7, 2, -6 },
  { 118, 4, 8, 7, 1, -6 },
  { 122, 5, 5, 7, 1, -6 },
  { 126, 5, 3, 7, 1, -5 },
  { 128, 5, 5, 7, 1, -6 },
  { 132, 4, 8, 7, 2, -8 },
  { 136, 7, 10, 7, 0, -8 },
  { 145, 5, 8, 7, 0, -8 },
  { 150, 5, 8, 7, 1, -8 },
  { 155, 5, 8, 7, 1, -8 },
  { 160, 5, 8, 7, 1, -8 },
  { 165, 5, 8, 7, 1, -8 },
  { 170, 6, 8, 7, 1, -8 },
  { 176, 5, 8, 7, 1, -8 },
  { 181, 5, 8, 7, 1, -8 },
  { 186, 5, 8, 7, 1, -8 },
  { 191, 6, 8, 7, 0, -8 },
  { 197, 6, 8, 7, 1, -8 },
  { 203, 4, 8, 7, 1, -8 },
  { 207, 5, 8, 7, 1, -8 },
  { 212, 5, 8, 7, 1, -8 },
  { 217, 5, 8, 7, 1, -8 },
  { 222, 5, 8, 7, 1, -8 },
  { 227, 5, 10, 7, 1, -8 },
  { 234, 5, 8, 7, 1, -8 },
  { 239, 5, 8, 7, 1, -8 },
  { 244, 6, 8, 7, 1, -8 },
  { 250, 5, 8, 7, 1, -8 },
  { 255, 5, 8, 7, 2, -8 },
  { 260, 6, 8, 7, 1, -8 },
  { 266, 7, 8, 7, 0, -8 },
  { 273, 6, 8, 7, 1, -8 },
  { 279, 5, 8, 7, 1, -8 },
  { 284, 4, 10, 7, 2, -9 },
  { 289, 3, 10, 7, 2, -9 },
  { 293, 4, 10, 7, 1, -9 },
  { 298, 5, 4, 7, 1, -8 },
  { 301, 5, 1, 7, 0, 0 },
  { 302, 2, 2, 7, 3, -9 },
  { 303, 5, 6, 7, 1, -6 },
  { 307, 5, 8, 7, 1, -8 },
  { 312, 5, 6, 7, 1, -6 },
  { 316, 5, 8, 7, 1, -8 },
  { 321, 5, 6, 7, 1, -6 },
  { 325, 7, 10, 7, 0, -8 },
  { 334, 5, 8, 7, 1, -6 },
  { 339, 5, 8, 7, 1, -8 },
  { 344, 4, 8, 7, 1, -8 },
  { 348, 6, 10, 7, 0, -8 },
  { 356, 5, 8, 7, 1, -8 },
  { 361, 5, 8, 7, 1, -8 },
  { 366, 6, 6, 7, 0, -6 },
  { 371, 5, 6, 7, 1, -6 },
  { 375, 5, 6, 7, 1, -6 },
  { 379, 6, 8, 7, 0, -6 },
  { 385, 5, 8, 7, 1, -6 },
  { 390, 5, 6, 7, 1, -6 },
  { 394, 5, 6, 7, 1, -6 },
  { 398, 5, 8, 7, 1, -8 },
  { 403, 5, 6, 7, 1, -6 },
  { 407, 5, 6, 7, 1, -6 },
  { 411, 6, 6, 7, 1, -6 },
  { 416, 6, 6, 7, 0, -6 },
  { 421, 5, 8, 7, 1, -6 },
  { 426, 5, 6, 7, 1, -6 },
  { 430, 5, 10, 7, 1, -9 },
  { 437, 3, 10, 7, 2, -9 },
  { 441, 6, 10, 7, 0, -9 },
  { 449, 5, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_ThinItalic11pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic11pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _JETBRAINSMONO_THINITALIC11PT7B_H_
