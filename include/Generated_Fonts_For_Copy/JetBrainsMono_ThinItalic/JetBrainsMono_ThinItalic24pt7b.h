#ifndef _JETBRAINSMONO_THINITALIC24PT7B_H_
#define _JETBRAINSMONO_THINITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC4, 0x21, 0x18, 0xC4, 0x21, 0x08, 0x44, 0x00, 0x08, 0xE7,
  0x00, 0x42, 0x8F, 0x1E, 0x3C, 0x50, 0xA1, 0x42, 0x02, 0x08, 0x10, 0xC1,
  0x84, 0x08, 0x20, 0x43, 0x06, 0x11, 0xFF, 0xE1, 0x0C, 0x18, 0x40, 0x82,
  0x04, 0x20, 0x61, 0x0F, 0xFF, 0x10, 0x81, 0x84, 0x08, 0x60, 0x42, 0x04,
  0x10, 0x00, 0x00, 0x80, 0x08, 0x00, 0x80, 0x3C, 0x0F, 0x61, 0x91, 0x11,
  0x11, 0x11, 0x11, 0x01, 0x10, 0x1A, 0x00, 0xE0, 0x03, 0x80, 0x24, 0x02,
  0x60, 0x22, 0x04, 0x24, 0x42, 0x44, 0x46, 0x4C, 0x3F, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x02, 0x01, 0x86, 0xC0, 0x84, 0x20, 0x82, 0x10, 0x81, 0x08,
  0x80, 0x84, 0x80, 0x44, 0x80, 0x3E, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x4E, 0x00, 0x48, 0x80, 0x48, 0x40, 0x44, 0x20, 0x62, 0x10, 0x21, 0x08,
  0x20, 0x88, 0x60, 0x3C, 0x00, 0x03, 0x80, 0xEC, 0x08, 0x21, 0x02, 0x10,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x3C, 0x06, 0x41, 0x42, 0x34, 0x32, 0xC1,
  0x48, 0x1C, 0x80, 0x88, 0x14, 0xC2, 0x67, 0xC2, 0x6D, 0x2D, 0xB4, 0x00,
  0xC0, 0xC0, 0x40, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x03, 0x00, 0x80, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x00, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x04, 0x21, 0xFD, 0x78, 0x3E, 0x00, 0xC0, 0x0D, 0x00,
  0xCC, 0x0C, 0x20, 0xC1, 0x82, 0x08, 0x00, 0x02, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x41, 0xFF, 0xFF, 0xF8, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x19, 0xCC, 0x46, 0x23, 0x10, 0xFF, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x00, 0x07, 0x83,
  0xB8, 0xC1, 0x90, 0x16, 0x02, 0x80, 0x50, 0x0A, 0x03, 0x46, 0x79, 0xCB,
  0x01, 0x60, 0x28, 0x05, 0x01, 0xA0, 0x36, 0x04, 0xC3, 0x0F, 0xC0, 0x00,
  0x80, 0x70, 0x12, 0x0C, 0x41, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x1F, 0xFC,
  0x03, 0xC0, 0xC6, 0x18, 0x33, 0x01, 0x20, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x40, 0x0F, 0xFE, 0x3F, 0xE7, 0xFC, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x78, 0x01, 0x80, 0x18, 0x01, 0x00, 0x20, 0x0D, 0x01, 0x20, 0x24,
  0x0C, 0xC3, 0x0F, 0xC0, 0x00, 0x40, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80,
  0xC0, 0x20, 0x10, 0x48, 0x16, 0x07, 0x03, 0x80, 0xBF, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x60, 0x1F, 0xE7, 0xFC, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x83, 0xFC, 0x60, 0xC8, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0xA0, 0x24,
  0x04, 0xC1, 0x0F, 0xC0, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01,
  0x00, 0xC8, 0x3F, 0x98, 0x3C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x02,
  0xC1, 0x1F, 0x80, 0x7F, 0xEF, 0xFF, 0x01, 0xE0, 0x28, 0x0C, 0x01, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x20, 0x0C, 0x00, 0x03, 0xC0, 0xC6, 0x18, 0x11, 0x01, 0x10, 0x11,
  0x01, 0x10, 0x20, 0x84, 0x07, 0x80, 0xD8, 0x10, 0xC2, 0x06, 0x40, 0x24,
  0x02, 0x40, 0x64, 0x04, 0x60, 0xC3, 0xF0, 0x0F, 0x07, 0x31, 0x83, 0x20,
  0x28, 0x05, 0x00, 0xA0, 0x14, 0x06, 0x80, 0x8C, 0x70, 0xF4, 0x01, 0x00,
  0x60, 0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x00, 0x3B, 0xDC, 0x00, 0x00,
  0x00, 0x00, 0x39, 0xCE, 0x00, 0x1E, 0x3C, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0xE1, 0x82, 0x0C, 0x10, 0x60, 0x80, 0x00, 0x20, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x20, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x0C, 0x00, 0x38, 0x1F, 0x80, 0x60, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x02, 0x1E, 0x08, 0x04, 0x02, 0x02, 0x00, 0x00, 0x80, 0xE0, 0x70,
  0x00, 0x03, 0xC0, 0x73, 0x86, 0x04, 0x20, 0x32, 0x00, 0x90, 0x05, 0x83,
  0x28, 0x75, 0x46, 0x1A, 0x20, 0x91, 0x04, 0x88, 0x2C, 0x41, 0x42, 0x1A,
  0x10, 0xD0, 0xDC, 0x83, 0x84, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x1F,
  0x00, 0x01, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x68, 0x09, 0x01, 0x20, 0x44,
  0x08, 0xC2, 0x08, 0x41, 0x18, 0x23, 0xFC, 0x40, 0x90, 0x12, 0x02, 0x80,
  0x70, 0x0C, 0x3E, 0x07, 0xF8, 0x81, 0x90, 0x12, 0x02, 0x40, 0x58, 0x1A,
  0x06, 0x7F, 0x8F, 0xF1, 0x03, 0x20, 0x2C, 0x05, 0x80, 0xA0, 0x34, 0x04,
  0x83, 0x1F, 0xC0, 0x07, 0x83, 0x98, 0x40, 0x90, 0x12, 0x02, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0xA0, 0x36,
  0x04, 0x41, 0x07, 0xC0, 0x3C, 0x07, 0xF0, 0x81, 0x10, 0x32, 0x02, 0x40,
  0x58, 0x1A, 0x03, 0x40, 0x48, 0x09, 0x01, 0x20, 0x2C, 0x0D, 0x81, 0x20,
  0x24, 0x0C, 0x83, 0x1F, 0x80, 0x1F, 0xF3, 0xFF, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x7F, 0xC4, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x0F, 0xF8, 0x3F, 0xF3, 0xFF, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x07, 0xFC, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07,
  0x83, 0x98, 0x40, 0x90, 0x12, 0x02, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08,
  0xFD, 0x1F, 0x60, 0x2C, 0x05, 0x00, 0xA0, 0x36, 0x04, 0x41, 0x07, 0xC0,
  0x30, 0x24, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0xD8, 0x1A, 0x02, 0x7F,
  0xC8, 0x09, 0x01, 0x20, 0x2C, 0x0D, 0x81, 0x20, 0x24, 0x04, 0x80, 0x90,
  0x30, 0x1F, 0xE7, 0xFC, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x1F, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x4C, 0x04, 0xC0,
  0x4C, 0x08, 0x61, 0x83, 0xE0, 0x30, 0x12, 0x03, 0x20, 0x22, 0x06, 0x20,
  0xC2, 0x08, 0x61, 0x84, 0x10, 0x7E, 0x04, 0x20, 0x42, 0x04, 0x30, 0xC1,
  0x0C, 0x10, 0x81, 0x88, 0x08, 0x80, 0x88, 0x0C, 0x10, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0x18, 0x18, 0xC0, 0xC6, 0x0E,
  0x70, 0x62, 0x45, 0x12, 0x48, 0x92, 0x44, 0xA2, 0x25, 0x33, 0x11, 0x98,
  0x08, 0x80, 0x44, 0x02, 0x20, 0x11, 0x01, 0x88, 0x0C, 0xC0, 0x44, 0x02,
  0x00, 0x30, 0x26, 0x04, 0xC0, 0x94, 0x12, 0x82, 0x50, 0x5A, 0x1A, 0x22,
  0x44, 0x48, 0x89, 0x11, 0x21, 0x2C, 0x2D, 0x05, 0x20, 0xA4, 0x1C, 0x81,
  0x90, 0x30, 0x07, 0x83, 0x18, 0xC1, 0x90, 0x12, 0x02, 0xC0, 0x58, 0x1A,
  0x03, 0x40, 0x48, 0x09, 0x01, 0x60, 0x2C, 0x0D, 0x01, 0xA0, 0x24, 0x04,
  0x41, 0x07, 0xC0, 0x3F, 0x03, 0xFE, 0x20, 0x22, 0x03, 0x20, 0x12, 0x01,
  0x60, 0x24, 0x02, 0x40, 0x47, 0xF8, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07, 0x83, 0x98, 0xC1, 0x90, 0x12,
  0x02, 0xC0, 0x58, 0x1A, 0x03, 0x40, 0x48, 0x09, 0x01, 0x60, 0x2C, 0x0D,
  0x01, 0xA0, 0x26, 0x04, 0x41, 0x07, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x3E, 0x03, 0xFC, 0x20, 0x22, 0x03, 0x20, 0x32, 0x03, 0x60, 0x24,
  0x06, 0x40, 0xC7, 0xF8, 0x42, 0x04, 0x20, 0xC3, 0x0C, 0x10, 0x81, 0x08,
  0x18, 0x80, 0x88, 0x0C, 0x03, 0xC0, 0xC6, 0x18, 0x11, 0x01, 0x10, 0x11,
  0x00, 0x10, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x02, 0x40, 0x24, 0x04, 0x60, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x32,
  0x02, 0x20, 0x22, 0x02, 0x20, 0x22, 0x02, 0x60, 0x64, 0x04, 0x40, 0x44,
  0x04, 0x40, 0x44, 0x04, 0xC0, 0xC8, 0x08, 0x80, 0x8C, 0x08, 0x41, 0x03,
  0xE0, 0xC0, 0x3C, 0x02, 0x40, 0x64, 0x04, 0x40, 0x44, 0x08, 0x40, 0x84,
  0x10, 0x41, 0x06, 0x30, 0x22, 0x02, 0x60, 0x24, 0x02, 0x40, 0x28, 0x02,
  0x80, 0x38, 0x03, 0x00, 0x43, 0x0A, 0x18, 0x50, 0xC6, 0x8A, 0x24, 0x51,
  0x62, 0x8B, 0x24, 0x99, 0x24, 0x89, 0x24, 0x8B, 0x24, 0x51, 0x22, 0x89,
  0x14, 0x51, 0x42, 0x8A, 0x14, 0x50, 0xC2, 0x86, 0x18, 0x00, 0x18, 0x06,
  0x10, 0x18, 0x20, 0x20, 0x20, 0x80, 0x43, 0x00, 0xC4, 0x00, 0x90, 0x01,
  0x40, 0x01, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x24, 0x00, 0xC4, 0x03, 0x08,
  0x04, 0x18, 0x10, 0x10, 0x60, 0x21, 0x80, 0x20, 0x80, 0x18, 0x02, 0x40,
  0x64, 0x04, 0x40, 0x82, 0x18, 0x21, 0x02, 0x20, 0x16, 0x01, 0x40, 0x18,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x07, 0xFE, 0x00, 0x1F, 0x88, 0x04, 0x02, 0x01, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x30, 0x18, 0x08, 0x04, 0x03, 0xE0, 0xC0, 0x81, 0x02, 0x06, 0x04,
  0x08, 0x10, 0x20, 0x60, 0x40, 0x81, 0x03, 0x02, 0x04, 0x08, 0x18, 0x30,
  0x20, 0x40, 0x81, 0x80, 0x0F, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x23, 0xF0, 0x06, 0x03, 0x02, 0x83, 0x41, 0x31,
  0x88, 0x84, 0x83, 0xC0, 0xC0, 0x40, 0xFF, 0xF0, 0x89, 0x90, 0x1F, 0xE4,
  0x1D, 0x81, 0x20, 0x24, 0x04, 0x80, 0xB0, 0x16, 0x06, 0x80, 0x90, 0x12,
  0x06, 0x21, 0xC7, 0xD8, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x5F,
  0x1C, 0x33, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x2C, 0x0D, 0x81, 0xA0,
  0x26, 0x04, 0xC1, 0x17, 0xC0, 0x1F, 0x86, 0x09, 0x81, 0x20, 0x24, 0x00,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x50, 0x13, 0x02, 0x20, 0x83, 0xE0, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x3F, 0xCC, 0x3B, 0x02, 0x40, 0x48,
  0x09, 0x01, 0x60, 0x2C, 0x0D, 0x01, 0x20, 0x24, 0x0C, 0x43, 0x8F, 0xB0,
  0x1F, 0x8C, 0x36, 0x05, 0x01, 0x40, 0x50, 0x1F, 0xFF, 0x00, 0x80, 0x20,
  0x0C, 0x09, 0x04, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x07, 0xFF, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x1F,
  0xE4, 0x1D, 0x81, 0x20, 0x24, 0x04, 0x80, 0xB0, 0x16, 0x06, 0xC0, 0x98,
  0x11, 0x8A, 0x1E, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0xFE, 0x00, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0B, 0xE7, 0x0D, 0x81, 0x40, 0x50, 0x14,
  0x05, 0x01, 0xC0, 0xF0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x20, 0x01, 0xC0,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x1F, 0xFC, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x61, 0xF8, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x12, 0x02, 0x60, 0x46, 0x08, 0x41, 0x04, 0x30, 0x46, 0x07, 0xC0,
  0x46, 0x0C, 0x20, 0x81, 0x08, 0x10, 0x80, 0x88, 0x0C, 0xF8, 0x7C, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x30, 0x0F, 0xC0, 0x3E, 0xF2, 0x31, 0x62, 0x16, 0x21,
  0x42, 0x14, 0x23, 0x42, 0x24, 0x62, 0x44, 0x2C, 0x42, 0x84, 0x28, 0x46,
  0x84, 0x60, 0x2F, 0x9C, 0x36, 0x05, 0x01, 0x40, 0x50, 0x14, 0x07, 0x03,
  0xC0, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0x80, 0x1F, 0x8C, 0x36, 0x05, 0x01,
  0x40, 0x50, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x28, 0x09, 0x04, 0x3E, 0x00,
  0x17, 0xC3, 0x86, 0x30, 0x22, 0x02, 0x20, 0x22, 0x02, 0x20, 0x26, 0x06,
  0x60, 0x64, 0x04, 0x60, 0x46, 0x08, 0x5F, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x00, 0x1F, 0xE4, 0x1D, 0x81, 0x20, 0x24, 0x04, 0x80, 0xB0, 0x16,
  0x06, 0x80, 0x90, 0x12, 0x06, 0x21, 0xC7, 0xC8, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x2F, 0xC6, 0x08, 0x81, 0xB0, 0x36, 0x06, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x00, 0x1F, 0xC4, 0x09, 0x01,
  0xA0, 0x06, 0x00, 0x60, 0x03, 0xE0, 0x04, 0x00, 0xC0, 0x1A, 0x02, 0x60,
  0xC7, 0xF0, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC4, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x1F, 0x00,
  0x60, 0x2C, 0x0D, 0x01, 0x20, 0x24, 0x04, 0x80, 0x90, 0x16, 0x06, 0x80,
  0x90, 0x13, 0x06, 0x21, 0x87, 0xE0, 0x80, 0x70, 0x1B, 0x02, 0x20, 0xC4,
  0x10, 0x86, 0x10, 0x82, 0x30, 0x24, 0x05, 0x80, 0xA0, 0x14, 0x03, 0x00,
  0x86, 0x18, 0x61, 0x86, 0x28, 0xA2, 0x8A, 0x28, 0xA4, 0x92, 0x49, 0x24,
  0x92, 0x8A, 0x28, 0xA2, 0x8C, 0x30, 0xC3, 0x00, 0x30, 0x31, 0x06, 0x08,
  0x40, 0x88, 0x05, 0x00, 0x70, 0x06, 0x00, 0xF0, 0x09, 0x01, 0x18, 0x20,
  0x84, 0x0C, 0xC0, 0x60, 0x60, 0x68, 0x09, 0x01, 0x20, 0x24, 0x04, 0x80,
  0xB0, 0x34, 0x04, 0x80, 0x98, 0x31, 0x0A, 0x1E, 0x40, 0x18, 0x02, 0x00,
  0x40, 0x18, 0xFE, 0x00, 0x1F, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xC0,
  0x00, 0xE0, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x7C, 0x00, 0x80, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x38, 0x00, 0xC0, 0x08, 0xC6, 0x21, 0x08,
  0x46, 0x31, 0x08, 0x42, 0x11, 0x88, 0x42, 0x10, 0x8C, 0x62, 0x00, 0x1E,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x08, 0x01, 0xF0, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x60, 0x30, 0x00, 0x30, 0x2D, 0x06, 0x10, 0xC1,
  0x28, 0x18,
};

const GFXglyph JetBrainsMono_ThinItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 18, 14, 5, -18 },
  { 13, 7, 8, 14, 5, -18 },
  { 20, 13, 18, 14, 1, -18 },
  { 50, 12, 24, 14, 1, -21 },
  { 86, 17, 18, 14, -1, -18 },
  { 125, 12, 18, 14, 1, -18 },
  { 152, 3, 8, 14, 7, -18 },
  { 155, 10, 23, 14, 4, -20 },
  { 184, 10, 23, 14, 1, -20 },
  { 213, 13, 13, 14, 1, -15 },
  { 235, 11, 12, 14, 2, -14 },
  { 252, 5, 8, 14, 3, -4 },
  { 257, 8, 1, 14, 3, -8 },
  { 258, 3, 3, 14, 5, -3 },
  { 260, 13, 23, 14, 1, -20 },
  { 298, 11, 18, 14, 2, -18 },
  { 323, 11, 18, 14, 1, -18 },
  { 348, 12, 18, 14, 1, -18 },
  { 375, 11, 18, 14, 2, -18 },
  { 400, 10, 18, 14, 2, -18 },
  { 423, 11, 18, 14, 2, -18 },
  { 448, 10, 18, 14, 2, -18 },
  { 471, 11, 18, 14, 3, -18 },
  { 496, 12, 18, 14, 1, -18 },
  { 523, 11, 18, 14, 3, -18 },
  { 548, 5, 13, 14, 5, -13 },
  { 557, 7, 17, 14, 3, -13 },
  { 572, 11, 12, 14, 2, -14 },
  { 589, 11, 6, 14, 2, -11 },
  { 598, 12, 12, 14, 1, -14 },
  { 616, 9, 18, 14, 4, -18 },
  { 637, 13, 22, 14, 1, -18 },
  { 673, 11, 18, 14, 1, -18 },
  { 698, 11, 18, 14, 2, -18 },
  { 723, 11, 18, 14, 2, -18 },
  { 748, 11, 18, 14, 2, -18 },
  { 773, 12, 18, 14, 2, -18 },
  { 800, 12, 18, 14, 2, -18 },
  { 827, 11, 18, 14, 2, -18 },
  { 852, 11, 18, 14, 2, -18 },
  { 877, 11, 18, 14, 2, -18 },
  { 902, 12, 18, 14, 1, -18 },
  { 929, 12, 18, 14, 2, -18 },
  { 956, 10, 18, 14, 2, -18 },
  { 979, 13, 18, 14, 1, -18 },
  { 1009, 11, 18, 14, 2, -18 },
  { 1034, 11, 18, 14, 2, -18 },
  { 1059, 12, 18, 14, 2, -18 },
  { 1086, 11, 22, 14, 2, -18 },
  { 1117, 12, 18, 14, 2, -18 },
  { 1144, 12, 18, 14, 1, -18 },
  { 1171, 12, 18, 14, 3, -18 },
  { 1198, 12, 18, 14, 2, -18 },
  { 1225, 12, 18, 14, 3, -18 },
  { 1252, 13, 18, 14, 2, -18 },
  { 1282, 15, 18, 14, 0, -18 },
  { 1316, 12, 18, 14, 3, -18 },
  { 1343, 13, 18, 14, 1, -18 },
  { 1373, 9, 23, 14, 4, -20 },
  { 1399, 7, 23, 14, 4, -20 },
  { 1420, 9, 23, 14, 2, -20 },
  { 1446, 9, 10, 14, 3, -18 },
  { 1458, 12, 1, 14, 0, 1 },
  { 1460, 3, 4, 14, 7, -19 },
  { 1462, 11, 13, 14, 2, -13 },
  { 1480, 11, 18, 14, 2, -18 },
  { 1505, 11, 13, 14, 2, -13 },
  { 1523, 11, 18, 14, 2, -18 },
  { 1548, 10, 13, 14, 2, -13 },
  { 1565, 15, 22, 14, -1, -18 },
  { 1607, 11, 17, 14, 2, -13 },
  { 1631, 10, 18, 14, 2, -18 },
  { 1654, 11, 18, 14, 1, -18 },
  { 1679, 11, 22, 14, 1, -18 },
  { 1710, 12, 18, 14, 2, -18 },
  { 1737, 9, 18, 14, 3, -18 },
  { 1758, 12, 13, 14, 1, -13 },
  { 1778, 10, 13, 14, 2, -13 },
  { 1795, 10, 13, 14, 2, -13 },
  { 1812, 12, 17, 14, 1, -13 },
  { 1838, 11, 17, 14, 2, -13 },
  { 1862, 11, 13, 14, 2, -13 },
  { 1880, 11, 13, 14, 2, -13 },
  { 1898, 10, 17, 14, 3, -17 },
  { 1920, 11, 13, 14, 2, -13 },
  { 1938, 11, 13, 14, 3, -13 },
  { 1956, 12, 13, 14, 2, -13 },
  { 1976, 12, 13, 14, 1, -13 },
  { 1996, 11, 17, 14, 2, -13 },
  { 2020, 12, 13, 14, 1, -13 },
  { 2040, 11, 23, 14, 3, -20 },
  { 2072, 5, 23, 14, 5, -20 },
  { 2087, 11, 23, 14, 1, -20 },
  { 2119, 11, 5, 14, 2, -11 },
};

const GFXfont JetBrainsMono_ThinItalic24pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic24pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _JETBRAINSMONO_THINITALIC24PT7B_H_
