#ifndef _JETBRAINSMONO_THINITALIC65PT7B_H_
#define _JETBRAINSMONO_THINITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x03, 0xE7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07,
  0x8E, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xF1,
  0x8F, 0xC0, 0x03, 0xE0, 0xC1, 0xF0, 0x03, 0xC0, 0xE0, 0x78, 0x01, 0xC0,
  0x70, 0x1C, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0,
  0x0C, 0x03, 0xC0, 0x70, 0x06, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xF0, 0x1C,
  0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00,
  0x7C, 0x1C, 0x00, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0x07, 0xC7, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x39, 0xF8,
  0x00, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0x06, 0x03,
  0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0,
  0x3C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x30,
  0x07, 0x87, 0x80, 0x38, 0x03, 0x83, 0xC0, 0x1C, 0x01, 0xC1, 0xE0, 0x0E,
  0x00, 0xE0, 0xF0, 0x07, 0x00, 0xF0, 0x38, 0x03, 0x00, 0x70, 0x1E, 0x01,
  0x80, 0x78, 0x0F, 0x00, 0xC0, 0x78, 0x03, 0xC0, 0xE0, 0x78, 0x01, 0xF8,
  0x70, 0xF8, 0x00, 0x7F, 0xBB, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xE0, 0x03, 0xC1,
  0xE0, 0x00, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x07, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x70, 0x07, 0x80,
  0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0xC0, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0,
  0x0E, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0x1C,
  0x1E, 0x00, 0x00, 0x1C, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x38,
  0x00, 0x00, 0x0F, 0xFF, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x81, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x0F,
  0x8F, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x3C, 0x00, 0x00, 0x1C, 0x1C, 0x01,
  0xC0, 0x00, 0x03, 0x83, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x00,
  0x3C, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x01, 0xC0, 0x00, 0x70,
  0x07, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xE0,
  0x01, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x07, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x71, 0xE0, 0x1E, 0x00, 0x38,
  0x70, 0x03, 0xC0, 0x1C, 0x1C, 0x00, 0xF0, 0x0F, 0x0F, 0x00, 0x1E, 0x03,
  0x83, 0x80, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0xF0, 0xF0, 0x38, 0x00, 0x1E,
  0x38, 0x0E, 0x00, 0x07, 0x9C, 0x07, 0x80, 0x00, 0xFF, 0x01, 0xE0, 0x00,
  0x1F, 0x80, 0x70, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x7C, 0x01, 0xC0, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x0E, 0xE0, 0x1C,
  0x00, 0x07, 0xBC, 0x07, 0x80, 0x03, 0xC7, 0x01, 0xE0, 0x03, 0xE1, 0xE0,
  0x3C, 0x01, 0xF0, 0x3C, 0x0F, 0xC3, 0xF0, 0x07, 0x01, 0xFF, 0xF8, 0x01,
  0xE0, 0x3F, 0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0xF3,
  0xDF, 0x7D, 0xE7, 0x9E, 0x7B, 0xEF, 0xBC, 0xF3, 0xCF, 0x38, 0xE3, 0x8E,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x04, 0x00, 0x0E,
  0x00, 0x09, 0xE0, 0x07, 0x80, 0x1E, 0x7F, 0x01, 0xE0, 0x3F, 0xBF, 0xF0,
  0x70, 0x7F, 0xF3, 0xFF, 0x0C, 0x7F, 0xE0, 0x1F, 0xF3, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x0F, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFE, 0x7F, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x03, 0x87, 0x80, 0x78, 0x07, 0x0F, 0x01, 0xF8, 0x0E, 0x1E, 0x07,
  0xF0, 0x3C, 0x38, 0x0F, 0xE0, 0x78, 0x70, 0x0F, 0xC0, 0xF0, 0xE0, 0x1F,
  0x01, 0xC3, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xF0, 0xE0,
  0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0x1C, 0x00, 0x38,
  0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x07, 0xFC, 0x00, 0x1E, 0x3F, 0xFE, 0x00, 0x38, 0xFF, 0xFE, 0x00, 0x73,
  0x80, 0x7E, 0x00, 0xEC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x02, 0x00, 0x00, 0x79, 0xFF, 0xC0, 0x03, 0xDF, 0xFF, 0x80, 0x0E, 0xF0,
  0x7F, 0x00, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF1, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x07, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7E, 0x01,
  0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0x70, 0x01, 0xFF, 0xF3, 0x80, 0x01, 0xFF, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01,
  0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x80, 0xF0, 0xE0, 0x00, 0xFF, 0x8E, 0x0E, 0x00,
  0x3F, 0xFC, 0xE0, 0xE0, 0x07, 0xFB, 0xEE, 0x0E, 0x00, 0x78, 0x06, 0xE0,
  0xE0, 0x0F, 0x00, 0x3E, 0x1E, 0x01, 0xE0, 0x01, 0xE1, 0xC0, 0x1C, 0x00,
  0x1C, 0x1C, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x1C, 0x00, 0x1C, 0x1C, 0x03,
  0xC0, 0x01, 0xC1, 0xC0, 0x3C, 0x00, 0x1C, 0x3C, 0x03, 0x80, 0x03, 0xC3,
  0xC0, 0x38, 0x00, 0x3C, 0x38, 0x03, 0x80, 0x03, 0x83, 0x80, 0x38, 0x00,
  0x38, 0x38, 0x07, 0x80, 0x03, 0x83, 0x80, 0x78, 0x00, 0x38, 0x78, 0x07,
  0x00, 0x07, 0x87, 0x80, 0x70, 0x00, 0x78, 0x70, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x70, 0x00, 0xF0, 0x70, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x78, 0x01,
  0xF0, 0x70, 0x03, 0xC0, 0x37, 0x0F, 0x00, 0x3F, 0xFE, 0x70, 0xF0, 0x01,
  0xFF, 0xCE, 0x0E, 0x00, 0x0F, 0xF8, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1E,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x0F, 0xC0, 0x0E, 0x00, 0x03, 0xE0,
  0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x7E, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0E, 0x00,
  0x0F, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x0F, 0x80, 0x70, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF8, 0x03, 0x80, 0x0F, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x07, 0xFF, 0xF0, 0xF0, 0x0F, 0xFF, 0xE1, 0xC0, 0x1F, 0xFF, 0xC3,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0xE0, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x74, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xEC, 0x00,
  0x06, 0xE0, 0x1D, 0x80, 0x01, 0xDC, 0x03, 0xB8, 0x00, 0x33, 0x80, 0x77,
  0x00, 0x0E, 0x70, 0x1C, 0xE0, 0x01, 0x9C, 0x03, 0x8C, 0x00, 0x73, 0x80,
  0x71, 0x80, 0x0C, 0x70, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0x61,
  0xC0, 0x38, 0x60, 0x1C, 0x78, 0x0F, 0x0C, 0x07, 0x0E, 0x01, 0xC1, 0x80,
  0xE1, 0xC0, 0x38, 0x38, 0x38, 0x38, 0x07, 0x07, 0x07, 0x07, 0x00, 0xE0,
  0x61, 0xC0, 0xE0, 0x1C, 0x0C, 0x38, 0x3C, 0x07, 0x81, 0x8E, 0x07, 0x80,
  0xF0, 0x39, 0xC0, 0xE0, 0x1C, 0x07, 0x70, 0x1C, 0x03, 0x80, 0x6C, 0x03,
  0x80, 0x70, 0x0F, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0x80, 0x7E, 0x00, 0x01, 0xC0, 0x3F,
  0x00, 0x00, 0xE0, 0x1D, 0x80, 0x00, 0x70, 0x0E, 0xE0, 0x00, 0x78, 0x07,
  0x70, 0x00, 0x38, 0x03, 0xB8, 0x00, 0x1C, 0x03, 0x9C, 0x00, 0x0E, 0x01,
  0xC7, 0x00, 0x07, 0x00, 0xE3, 0x80, 0x03, 0x80, 0x71, 0xC0, 0x03, 0xC0,
  0x38, 0xE0, 0x01, 0xC0, 0x1C, 0x38, 0x00, 0xE0, 0x1E, 0x1C, 0x00, 0x70,
  0x0E, 0x0E, 0x00, 0x38, 0x07, 0x07, 0x00, 0x1C, 0x03, 0x81, 0xC0, 0x0E,
  0x01, 0xC0, 0xE0, 0x0F, 0x00, 0xE0, 0x70, 0x07, 0x00, 0xF0, 0x38, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x38,
  0x1C, 0x03, 0xC0, 0x1C, 0x0E, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0xE0, 0x07,
  0x03, 0x80, 0x70, 0x01, 0xC3, 0xC0, 0x38, 0x00, 0xE1, 0xC0, 0x1C, 0x00,
  0x70, 0xE0, 0x1E, 0x00, 0x38, 0x70, 0x0E, 0x00, 0x0E, 0x38, 0x07, 0x00,
  0x07, 0x1C, 0x03, 0x80, 0x03, 0x8E, 0x01, 0xC0, 0x01, 0xCF, 0x00, 0xE0,
  0x00, 0x77, 0x00, 0xF0, 0x00, 0x3B, 0x80, 0x70, 0x00, 0x1D, 0xC0, 0x38,
  0x00, 0x0E, 0xE0, 0x1C, 0x00, 0x07, 0xF0, 0x0E, 0x00, 0x01, 0xF8, 0x07,
  0x00, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1C, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0x00, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x3F, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x7F, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x78, 0x03, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x1E,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xEE, 0x00, 0x1E,
  0x00, 0x3D, 0xC0, 0x07, 0xC0, 0x07, 0x38, 0x00, 0xF8, 0x00, 0xE7, 0x00,
  0x1B, 0x00, 0x1C, 0xE0, 0x07, 0x60, 0x07, 0x1C, 0x00, 0xEC, 0x00, 0xE3,
  0x80, 0x19, 0x80, 0x1C, 0x70, 0x07, 0x30, 0x07, 0x8E, 0x00, 0xE6, 0x00,
  0xE1, 0xC0, 0x18, 0xC0, 0x1C, 0x38, 0x03, 0x18, 0x03, 0x87, 0x00, 0xE3,
  0x00, 0xE0, 0xE0, 0x1C, 0x60, 0x1C, 0x1C, 0x03, 0x0C, 0x03, 0x83, 0x80,
  0xE1, 0x80, 0x70, 0x70, 0x1C, 0x30, 0x1C, 0x0E, 0x03, 0x06, 0x03, 0x81,
  0xC0, 0xE0, 0xC0, 0x70, 0x30, 0x1C, 0x18, 0x1C, 0x06, 0x03, 0x07, 0x03,
  0x81, 0xC0, 0x60, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x03,
  0x83, 0x80, 0xE0, 0x60, 0x70, 0x70, 0x1C, 0x1C, 0x0E, 0x0E, 0x03, 0x83,
  0x01, 0xC1, 0x80, 0x70, 0x60, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x0E, 0x01,
  0xC3, 0x80, 0xE1, 0xC0, 0x38, 0x60, 0x1C, 0x70, 0x07, 0x0C, 0x03, 0x8E,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x1C, 0x60, 0x0E, 0x30, 0x03, 0x8C, 0x01,
  0xCE, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x0E, 0x60, 0x07, 0x38, 0x01, 0xCC,
  0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x07, 0x60, 0x03, 0x38, 0x00,
  0xEC, 0x00, 0x66, 0x00, 0x1D, 0x80, 0x0D, 0xC0, 0x03, 0xF0, 0x01, 0xB8,
  0x00, 0x7C, 0x00, 0x37, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x70, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x0E, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xE0,
  0x1E, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x39, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x3C, 0x00, 0xFF, 0xF8,
  0xE0, 0x0F, 0xE3, 0xF3, 0x80, 0x7C, 0x01, 0xEE, 0x03, 0xC0, 0x01, 0xB8,
  0x1E, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x0E,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0xF8, 0x0F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x77, 0x80, 0x7E, 0x07, 0x9C,
  0x00, 0xFF, 0xFC, 0x70, 0x01, 0xFF, 0xC1, 0xC0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xC0, 0x03, 0x8F, 0xFF,
  0xC0, 0x0E, 0x7E, 0x7F, 0x80, 0x7B, 0x80, 0x1F, 0x01, 0xFC, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x1C, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0x81, 0xF0, 0x00,
  0x1E, 0x07, 0x60, 0x00, 0xF0, 0x1D, 0xC0, 0x07, 0x80, 0x73, 0xC0, 0xFC,
  0x01, 0xC7, 0xFF, 0xE0, 0x0F, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x00,
  0xFE, 0x1F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0xF8, 0x3C, 0x00, 0x3F, 0xFE, 0x38, 0x00, 0xFE, 0x3F, 0x38, 0x01,
  0xF0, 0x07, 0xB8, 0x03, 0xC0, 0x01, 0xB8, 0x07, 0x80, 0x01, 0xF8, 0x07,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x77, 0x80, 0x1F,
  0x81, 0xE7, 0x00, 0x0F, 0xFF, 0xC7, 0x00, 0x07, 0xFF, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xCF, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x1E, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x3E,
  0x00, 0x3C, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x78, 0x03, 0xFF, 0xE3, 0x80, 0x7F, 0x1F, 0x9C, 0x07, 0xC0, 0x1E, 0xE0,
  0x78, 0x00, 0x37, 0x07, 0x80, 0x01, 0xB8, 0x38, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x3E, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x38, 0x78, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x7C, 0x1C, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x3E, 0x07, 0x80, 0x03, 0x70, 0x1F, 0x00, 0x7B, 0x80, 0x7F, 0x1F,
  0x1C, 0x01, 0xFF, 0xF1, 0xE0, 0x07, 0xFE, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xC0,
  0x03, 0x8F, 0xFF, 0xC0, 0x0E, 0x7E, 0x7F, 0x80, 0x7B, 0x80, 0x1F, 0x01,
  0xFC, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x78, 0x03, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x07,
  0x80, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x08, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0x8F, 0xE0, 0xFE, 0x00, 0xEF, 0xFC,
  0x7F, 0xC0, 0x37, 0x9F, 0x3D, 0xF8, 0x1D, 0x81, 0xE8, 0x1E, 0x07, 0xC0,
  0x7C, 0x03, 0xC1, 0xE0, 0x1F, 0x00, 0xF0, 0x70, 0x03, 0x80, 0x3C, 0x1C,
  0x00, 0xE0, 0x0E, 0x07, 0x00, 0x78, 0x03, 0x83, 0xC0, 0x1C, 0x00, 0xE0,
  0xE0, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x03,
  0x83, 0x80, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x00, 0x70, 0x38, 0x03, 0x80,
  0x1C, 0x1E, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0x0E,
  0x00, 0x70, 0x70, 0x03, 0x80, 0x3C, 0x1C, 0x00, 0xE0, 0x0E, 0x07, 0x00,
  0x78, 0x03, 0x83, 0xC0, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x38,
  0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x07, 0x83, 0x80, 0x1C, 0x01, 0xE0,
  0xE0, 0x0F, 0x00, 0x70, 0x78, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x07,
  0x07, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x80,
  0x3C, 0x1C, 0x01, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x03, 0x83, 0xC0, 0x1C,
  0x00, 0xE0, 0x03, 0x83, 0xFF, 0x00, 0x0E, 0x3F, 0xFF, 0x00, 0x39, 0xF9,
  0xFE, 0x01, 0xEE, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0xF0, 0x1D, 0x80, 0x01,
  0xE0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xC0, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xC0,
  0x00, 0xE3, 0xFF, 0xF0, 0x00, 0xE7, 0xE7, 0xF8, 0x01, 0xEE, 0x00, 0x7C,
  0x01, 0xFC, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x70,
  0x1F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x01, 0xE0,
  0x1D, 0x80, 0x03, 0xC0, 0x1D, 0xC0, 0x07, 0x80, 0x1C, 0xF0, 0x3F, 0x00,
  0x3C, 0x7F, 0xFE, 0x00, 0x3C, 0x3F, 0xF8, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3C,
  0x00, 0xFF, 0xF8, 0xE0, 0x0F, 0xE3, 0xF3, 0x80, 0x7C, 0x01, 0xEE, 0x03,
  0xC0, 0x01, 0xB8, 0x1E, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x77, 0x80,
  0x7E, 0x07, 0x9C, 0x00, 0xFF, 0xFC, 0x70, 0x01, 0xFF, 0xC1, 0xC0, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x03, 0x83, 0xFF, 0x00,
  0x0E, 0x3F, 0xFF, 0x00, 0x39, 0xF8, 0xFE, 0x00, 0xEE, 0x00, 0x7C, 0x07,
  0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x7C,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x07, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0x0F, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xE0, 0x1C,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0xE0, 0x1E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xB8, 0x00, 0xF0, 0x01, 0xDC,
  0x00, 0xF8, 0x01, 0xCE, 0x00, 0x6C, 0x00, 0xE7, 0x00, 0x36, 0x00, 0x73,
  0x80, 0x3B, 0x00, 0x79, 0xC0, 0x19, 0x80, 0x38, 0xE0, 0x0C, 0xC0, 0x1C,
  0x70, 0x0E, 0x60, 0x1E, 0x38, 0x06, 0x30, 0x0E, 0x1C, 0x03, 0x18, 0x07,
  0x0E, 0x03, 0x8C, 0x07, 0x87, 0x01, 0x86, 0x03, 0x83, 0x80, 0xC3, 0x01,
  0xC1, 0xC0, 0xE1, 0x81, 0xE0, 0xE0, 0x60, 0xE0, 0xE0, 0x70, 0x70, 0x70,
  0x70, 0x38, 0x38, 0x38, 0x78, 0x1C, 0x18, 0x1C, 0x38, 0x0E, 0x1C, 0x0E,
  0x1C, 0x07, 0x0E, 0x07, 0x0E, 0x03, 0x86, 0x03, 0x8E, 0x01, 0xC7, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0xE3, 0x80, 0x71, 0x80, 0x73, 0x80, 0x39, 0xC0,
  0x39, 0xC0, 0x1C, 0xE0, 0x1C, 0xE0, 0x0E, 0x60, 0x0E, 0xE0, 0x07, 0x70,
  0x07, 0x70, 0x03, 0xB8, 0x03, 0xB8, 0x01, 0xD8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x37, 0x03, 0xC0, 0x03, 0xF8, 0x1F, 0x00,
  0x3B, 0xC0, 0x7F, 0x9F, 0x9C, 0x01, 0xFF, 0xF8, 0xE0, 0x03, 0xFF, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1C,
  0x3F, 0xE0, 0x00, 0x71, 0xFF, 0xE0, 0x01, 0xCF, 0x07, 0x80, 0x07, 0x38,
  0x0F, 0x00, 0x1C, 0xE0, 0x1E, 0x00, 0xE7, 0x00, 0x38, 0x03, 0x9C, 0x00,
  0x70, 0x0E, 0x70, 0x01, 0xE0, 0x71, 0xC0, 0x03, 0xFF, 0xC7, 0x00, 0x07,
  0xFE, 0x38, 0x00, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_ThinItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 13, 47, 39, 13, -47 },
  { 78, 20, 19, 39, 13, -47 },
  { 126, 37, 47, 39, 2, -47 },
  { 344, 33, 66, 39, 4, -57 },
  { 617, 44, 48, 39, -2, -48 },
  { 881, 34, 49, 39, 2, -48 },
  { 1090, 6, 19, 39, 20, -47 },
  { 1105, 26, 63, 39, 11, -55 },
  { 1310, 26, 63, 39, 3, -55 },
  { 1515, 34, 33, 39, 4, -40 },
  { 1656, 30, 31, 39, 5, -37 },
  { 1773, 14, 20, 39, 8, -10 },
  { 1808, 22, 3, 39, 9, -23 },
  { 1817, 10, 10, 39, 12, -9 },
  { 1830, 36, 61, 39, 2, -54 },
  { 2105, 31, 49, 39, 5, -48 },
  { 2295, 28, 47, 39, 4, -47 },
  { 2460, 33, 48, 39, 3, -48 },
  { 2658, 32, 48, 39, 4, -47 },
  { 2850, 29, 47, 39, 5, -47 },
  { 3021, 31, 48, 39, 5, -47 },
  { 3207, 30, 48, 39, 4, -47 },
  { 3387, 31, 47, 39, 8, -47 },
  { 3570, 32, 49, 39, 4, -48 },
  { 3766, 30, 48, 39, 7, -48 },
  { 3946, 15, 37, 39, 12, -36 },
  { 4016, 19, 46, 39, 8, -36 },
  { 4126, 30, 33, 39, 6, -38 },
  { 4250, 30, 17, 39, 5, -30 },
  { 4314, 30, 33, 39, 4, -38 },
  { 4438, 25, 47, 39, 11, -47 },
  { 4585, 36, 60, 39, 2, -48 },
  { 4855, 30, 47, 39, 2, -47 },
  { 5032, 32, 47, 39, 4, -47 },
  { 5220, 31, 49, 39, 5, -48 },
  { 5410, 31, 47, 39, 4, -47 },
  { 5593, 33, 47, 39, 5, -47 },
  { 5787, 34, 47, 39, 5, -47 },
  { 5987, 31, 49, 39, 5, -48 },
  { 6177, 33, 47, 39, 4, -47 },
  { 6371, 31, 48, 39, 5, -48 },
  { 6557, 33, 48, 39, 3, -47 },
  { 6755, 35, 48, 39, 4, -48 },
  { 6965, 27, 47, 39, 5, -47 },
  { 7124, 35, 47, 39, 3, -47 },
  { 7330, 33, 47, 39, 4, -47 },
  { 7524, 31, 49, 39, 5, -48 },
  { 7714, 34, 47, 39, 4, -47 },
  { 7914, 31, 60, 39, 5, -48 },
  { 8147, 33, 47, 39, 4, -47 },
  { 8341, 33, 49, 39, 4, -48 },
  { 8544, 32, 47, 39, 8, -47 },
  { 8732, 32, 48, 39, 5, -47 },
  { 8924, 30, 47, 39, 9, -47 },
  { 9101, 35, 47, 39, 6, -47 },
  { 9307, 38, 47, 39, 1, -47 },
  { 9531, 32, 47, 39, 8, -47 },
  { 9719, 34, 47, 39, 3, -47 },
  { 9919, 25, 61, 39, 10, -54 },
  { 10110, 17, 61, 39, 12, -54 },
  { 10240, 24, 61, 39, 6, -54 },
  { 10423, 26, 25, 39, 7, -47 },
  { 10505, 32, 3, 39, 0, 2 },
  { 10517, 10, 9, 39, 18, -51 },
  { 10529, 30, 37, 39, 5, -36 },
  { 10668, 30, 48, 39, 4, -47 },
  { 10848, 29, 37, 39, 5, -36 },
  { 10983, 32, 48, 39, 5, -47 },
  { 11175, 29, 37, 39, 5, -36 },
  { 11310, 41, 59, 39, -2, -47 },
  { 11613, 29, 48, 39, 6, -36 },
  { 11787, 30, 47, 39, 4, -47 },
  { 11964, 29, 50, 39, 3, -50 },
  { 12146, 33, 62, 39, 1, -50 },
  { 12402, 33, 47, 39, 4, -47 },
  { 12596, 26, 47, 39, 7, -47 },
  { 12749, 34, 36, 39, 2, -36 },
  { 12902, 30, 36, 39, 4, -36 },
  { 13037, 29, 37, 39, 5, -36 },
  { 13172, 32, 48, 39, 2, -36 },
  { 13364, 30, 48, 39, 5, -36 },
  { 13544, 30, 36, 39, 5, -36 },
  { 13679, 30, 37, 39, 4, -36 },
  { 13818, 29, 46, 39, 7, -46 },
  { 13985, 30, 37, 39, 5, -36 },
  { 14124, 29, 36, 39, 8, -36 },
  { 14255, 33, 36, 39, 6, -36 },
  { 14404, 34, 36, 39, 2, -36 },
  { 14557, 29, 48, 39, 5, -36 },
  { 14731, 30, 36, 39, 4, -36 },
  { 14866, 31, 61, 39, 7, -54 },
  { 15103, 13, 61, 39, 14, -54 },
  { 15203, 31, 61, 39, 3, -54 },
  { 15440, 30, 12, 39, 5, -29 },
};

const GFXfont JetBrainsMono_ThinItalic65pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic65pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic65pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _JETBRAINSMONO_THINITALIC65PT7B_H_
