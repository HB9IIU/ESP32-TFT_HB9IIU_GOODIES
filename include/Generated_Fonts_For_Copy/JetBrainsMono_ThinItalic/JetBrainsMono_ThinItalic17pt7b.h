#ifndef _JETBRAINSMONO_THINITALIC17PT7B_H_
#define _JETBRAINSMONO_THINITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x22, 0x22, 0x22, 0x40, 0x64, 0x4D, 0x24, 0xA2, 0x88, 0x04,
  0x42, 0x20, 0x88, 0xFF, 0x11, 0x04, 0x41, 0x10, 0x88, 0xFF, 0x89, 0x04,
  0x41, 0x10, 0x04, 0x02, 0x03, 0x82, 0xA2, 0x52, 0x49, 0x20, 0x50, 0x18,
  0x07, 0x02, 0x82, 0x29, 0x24, 0x91, 0xF0, 0x20, 0x10, 0x00, 0x18, 0x24,
  0x89, 0x11, 0x22, 0x44, 0x50, 0xF4, 0x01, 0x00, 0x48, 0x16, 0x82, 0x88,
  0x92, 0x22, 0x48, 0x70, 0x0C, 0x09, 0x08, 0x44, 0x02, 0x01, 0x01, 0xC3,
  0x12, 0x8A, 0x43, 0x21, 0x11, 0x4F, 0x10, 0x7A, 0x80, 0x06, 0x30, 0x81,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x08, 0x18, 0x08, 0x30,
  0x10, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x82, 0x08,
  0x60, 0x08, 0x04, 0x22, 0x2F, 0xE0, 0x80, 0xC0, 0x90, 0x8C, 0x08, 0x08,
  0x08, 0x08, 0xFF, 0x08, 0x10, 0x10, 0x32, 0x64, 0x48, 0xFC, 0xFC, 0x00,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x04, 0x02, 0x02, 0x01, 0x00, 0x0C, 0x33, 0x21, 0x41, 0x41, 0x41, 0x49,
  0x49, 0x81, 0x82, 0x82, 0x42, 0x7C, 0x0C, 0x69, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x27, 0xF0, 0x0C, 0x19, 0x88, 0x48, 0x20, 0x10, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0F, 0xE0, 0x3F, 0x02, 0x04, 0x08,
  0x1C, 0x02, 0x02, 0x02, 0x02, 0x82, 0x84, 0x78, 0x03, 0x04, 0x04, 0x08,
  0x10, 0x21, 0x42, 0x42, 0xFE, 0x02, 0x02, 0x02, 0x3F, 0x20, 0x20, 0x20,
  0x5E, 0x62, 0x01, 0x01, 0x02, 0x82, 0x82, 0x7C, 0x06, 0x08, 0x08, 0x10,
  0x28, 0x76, 0x41, 0x81, 0x81, 0x82, 0x82, 0x7C, 0xFF, 0x82, 0x82, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x0C, 0x13, 0x21, 0x21,
  0x21, 0x22, 0x1C, 0x26, 0x42, 0x82, 0x82, 0x82, 0x7C, 0x18, 0x26, 0x42,
  0x81, 0x82, 0x82, 0x86, 0x7C, 0x08, 0x08, 0x10, 0x20, 0x40, 0x27, 0x30,
  0x00, 0x00, 0xEE, 0x11, 0xC6, 0x00, 0x00, 0x06, 0x23, 0x10, 0x88, 0x00,
  0x02, 0x08, 0x63, 0x08, 0x08, 0x0C, 0x06, 0x02, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x40, 0x30, 0x08, 0x06, 0x01, 0x0E, 0x30, 0x40, 0x80, 0x7C, 0x10,
  0x41, 0x04, 0x66, 0x10, 0x40, 0x0C, 0x30, 0x07, 0x02, 0x21, 0x04, 0x81,
  0x20, 0x51, 0xF4, 0x85, 0x22, 0x48, 0x92, 0x24, 0x89, 0x3E, 0x80, 0x10,
  0x04, 0x00, 0xF0, 0x06, 0x06, 0x0A, 0x0A, 0x09, 0x11, 0x11, 0x21, 0x3F,
  0x41, 0x41, 0xC1, 0x3F, 0x21, 0x21, 0x41, 0x42, 0x7C, 0x42, 0x41, 0x41,
  0x82, 0x82, 0xFC, 0x0C, 0x09, 0x88, 0x48, 0x24, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x88, 0x47, 0xC0, 0x3E, 0x21, 0x21, 0x41, 0x41, 0x41,
  0x41, 0x42, 0x42, 0x82, 0x84, 0xF8, 0x3F, 0x90, 0x08, 0x04, 0x04, 0x03,
  0xF1, 0x00, 0x80, 0x40, 0x20, 0x20, 0x1F, 0xC0, 0x3F, 0x90, 0x08, 0x08,
  0x04, 0x03, 0xF9, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x00, 0x0C, 0x09,
  0x88, 0x48, 0x24, 0x02, 0x01, 0x00, 0x9E, 0x41, 0x20, 0xA0, 0x88, 0x47,
  0xC0, 0x21, 0x90, 0x88, 0x48, 0x24, 0x13, 0xF9, 0x04, 0x84, 0x42, 0x41,
  0x20, 0x90, 0x40, 0x3F, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0xFE, 0x0F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02,
  0x82, 0x84, 0x78, 0x20, 0x90, 0x88, 0x88, 0x44, 0x43, 0xC1, 0x10, 0x88,
  0x44, 0x41, 0x20, 0x90, 0x40, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x07, 0xF0, 0x21, 0xA9, 0x54, 0xCA, 0xA5, 0x52, 0x49, 0x05,
  0x02, 0x81, 0x41, 0x20, 0x90, 0x40, 0x21, 0x98, 0x8C, 0x4A, 0x24, 0x92,
  0x49, 0x24, 0x94, 0x4A, 0x43, 0x21, 0x90, 0xC0, 0x0C, 0x13, 0x21, 0x41,
  0x41, 0x41, 0x41, 0x41, 0x42, 0x42, 0x82, 0x42, 0x7C, 0x3F, 0x10, 0x48,
  0x28, 0x14, 0x12, 0x11, 0xF0, 0x80, 0x40, 0x40, 0x20, 0x10, 0x00, 0x0C,
  0x13, 0x21, 0x41, 0x41, 0x41, 0x41, 0x41, 0x42, 0x42, 0x82, 0x42, 0x7C,
  0x08, 0x04, 0x04, 0x3F, 0x10, 0x48, 0x28, 0x14, 0x12, 0x31, 0xE0, 0x88,
  0x44, 0x42, 0x20, 0x90, 0x40, 0x0E, 0x08, 0x88, 0x48, 0x24, 0x01, 0x00,
  0x70, 0x04, 0x02, 0x00, 0xA0, 0x90, 0x47, 0xC0, 0xFF, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x90, 0x88, 0x48,
  0x24, 0x12, 0x09, 0x04, 0x84, 0x42, 0x41, 0x10, 0x8F, 0x80, 0x81, 0x42,
  0x42, 0x42, 0x44, 0x44, 0x48, 0x48, 0x50, 0x50, 0x30, 0x20, 0x44, 0x53,
  0x24, 0xC9, 0x52, 0x55, 0x15, 0x45, 0x52, 0x94, 0xA6, 0x29, 0x8C, 0x63,
  0x10, 0x30, 0x44, 0x20, 0x90, 0x28, 0x0A, 0x01, 0x00, 0xC0, 0x48, 0x12,
  0x08, 0x44, 0x12, 0x06, 0x81, 0xA1, 0x10, 0x88, 0x82, 0x81, 0x40, 0xC0,
  0x20, 0x20, 0x10, 0x08, 0x04, 0x00, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x40, 0x20, 0x20, 0x20, 0x20, 0x1F, 0xC0, 0x3C, 0x82, 0x08, 0x41,
  0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x3C, 0x84, 0x10, 0x84, 0x20,
  0x84, 0x21, 0x08, 0x21, 0x08, 0x41, 0x3C, 0x10, 0x42, 0x08, 0x20, 0x82,
  0x08, 0x41, 0x04, 0x10, 0x41, 0x38, 0x18, 0x30, 0x91, 0x24, 0x50, 0xC0,
  0xFF, 0x90, 0x0C, 0x33, 0x41, 0x41, 0x41, 0x42, 0x42, 0x82, 0x46, 0x7A,
  0x20, 0x20, 0x2C, 0x52, 0x61, 0x41, 0x41, 0x42, 0x42, 0x82, 0xC2, 0xBC,
  0x0C, 0x32, 0x41, 0x41, 0x40, 0x40, 0x40, 0x82, 0x42, 0x7C, 0x01, 0x80,
  0x83, 0x46, 0x64, 0x12, 0x09, 0x04, 0x84, 0x42, 0x41, 0x11, 0x8F, 0x40,
  0x0C, 0x32, 0x41, 0x41, 0x41, 0x7E, 0x40, 0x80, 0x42, 0x7C, 0x07, 0xC1,
  0x00, 0x40, 0xDE, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x0E, 0x00, 0x0C, 0x33, 0x41, 0x41, 0x41, 0x42, 0x42,
  0x42, 0x7E, 0x02, 0x02, 0x04, 0x78, 0x20, 0x20, 0x2C, 0x52, 0x61, 0x41,
  0x41, 0x42, 0x42, 0x82, 0x82, 0x82, 0x04, 0x08, 0x00, 0x03, 0xC1, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x8F, 0xE0, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xF0,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x11, 0xF0,
  0x20, 0x10, 0x08, 0x28, 0x24, 0x22, 0x21, 0x20, 0xF0, 0x48, 0x42, 0x20,
  0x90, 0x40, 0xF0, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x01,
  0xF0, 0x12, 0x6D, 0x49, 0x49, 0x89, 0x89, 0x91, 0x91, 0x92, 0x92, 0x0C,
  0x52, 0x61, 0x41, 0x41, 0x42, 0x42, 0x82, 0x82, 0x82, 0x0C, 0x32, 0x41,
  0x41, 0x41, 0x42, 0x42, 0x82, 0x42, 0x7C, 0x0C, 0x52, 0x61, 0x41, 0x41,
  0x42, 0x42, 0x82, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x0C, 0x33, 0x41, 0x41,
  0x41, 0x42, 0x42, 0x82, 0x46, 0x7A, 0x02, 0x04, 0x04, 0x0C, 0x33, 0x21,
  0x41, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x0C, 0x33, 0x41, 0x40, 0x60,
  0x1E, 0x02, 0x02, 0x82, 0x7C, 0x10, 0x20, 0x47, 0x72, 0x04, 0x08, 0x10,
  0x20, 0x81, 0x01, 0xE0, 0x41, 0x41, 0x41, 0x41, 0x42, 0x42, 0x82, 0x44,
  0x7C, 0x83, 0x82, 0x84, 0x44, 0x48, 0x48, 0x50, 0x50, 0x20, 0x91, 0x91,
  0xAA, 0xAA, 0xAA, 0xCC, 0xCC, 0x88, 0x88, 0x61, 0x22, 0x14, 0x18, 0x18,
  0x28, 0x24, 0x44, 0x82, 0x41, 0x41, 0x41, 0x42, 0x42, 0x82, 0x42, 0x7E,
  0x02, 0x04, 0x04, 0x78, 0x3F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40,
  0xFE, 0x07, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xF0, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x1C, 0x24, 0x94, 0x92, 0x4A, 0x49, 0x24, 0x38,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x0F, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0xC0, 0x21, 0x51, 0x89, 0x86,
};

const GFXglyph JetBrainsMono_ThinItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 6, 5, 10, 3, -12 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 9, 17, 10, 1, -15 },
  { 46, 11, 13, 10, 0, -13 },
  { 64, 9, 13, 10, 1, -13 },
  { 79, 2, 5, 10, 5, -12 },
  { 81, 7, 16, 10, 3, -14 },
  { 95, 7, 16, 10, 1, -14 },
  { 109, 9, 8, 10, 1, -10 },
  { 118, 8, 8, 10, 1, -10 },
  { 126, 4, 6, 10, 2, -3 },
  { 129, 6, 1, 10, 2, -6 },
  { 130, 3, 2, 10, 3, -2 },
  { 131, 9, 16, 10, 1, -14 },
  { 149, 8, 13, 10, 1, -13 },
  { 162, 7, 12, 10, 1, -12 },
  { 173, 9, 13, 10, 1, -13 },
  { 188, 8, 12, 10, 1, -12 },
  { 200, 8, 12, 10, 1, -12 },
  { 212, 8, 12, 10, 1, -12 },
  { 224, 8, 12, 10, 1, -12 },
  { 236, 8, 12, 10, 2, -12 },
  { 248, 8, 13, 10, 1, -13 },
  { 261, 8, 13, 10, 2, -13 },
  { 274, 4, 10, 10, 3, -10 },
  { 279, 5, 13, 10, 2, -10 },
  { 288, 7, 9, 10, 2, -10 },
  { 296, 8, 5, 10, 1, -8 },
  { 301, 8, 9, 10, 1, -10 },
  { 310, 6, 12, 10, 3, -12 },
  { 319, 10, 16, 10, 0, -13 },
  { 339, 8, 12, 10, 0, -12 },
  { 351, 8, 12, 10, 1, -12 },
  { 363, 9, 13, 10, 1, -13 },
  { 378, 8, 12, 10, 1, -12 },
  { 390, 9, 12, 10, 1, -12 },
  { 404, 9, 12, 10, 1, -12 },
  { 418, 9, 13, 10, 1, -13 },
  { 433, 9, 12, 10, 1, -12 },
  { 447, 8, 12, 10, 1, -12 },
  { 459, 8, 12, 10, 1, -12 },
  { 471, 9, 12, 10, 1, -12 },
  { 485, 7, 12, 10, 1, -12 },
  { 496, 9, 12, 10, 1, -12 },
  { 510, 9, 12, 10, 1, -12 },
  { 524, 8, 13, 10, 1, -13 },
  { 537, 9, 12, 10, 1, -12 },
  { 551, 8, 16, 10, 1, -13 },
  { 567, 9, 12, 10, 1, -12 },
  { 581, 9, 13, 10, 1, -13 },
  { 596, 8, 12, 10, 2, -12 },
  { 608, 9, 12, 10, 1, -12 },
  { 622, 8, 12, 10, 2, -12 },
  { 634, 10, 12, 10, 1, -12 },
  { 649, 10, 12, 10, 0, -12 },
  { 664, 9, 12, 10, 2, -12 },
  { 678, 9, 12, 10, 1, -12 },
  { 692, 6, 16, 10, 3, -14 },
  { 704, 5, 16, 10, 3, -14 },
  { 714, 6, 16, 10, 2, -14 },
  { 726, 7, 6, 10, 2, -12 },
  { 732, 8, 1, 10, 0, 0 },
  { 733, 2, 2, 10, 5, -13 },
  { 734, 8, 10, 10, 1, -10 },
  { 744, 8, 12, 10, 1, -12 },
  { 756, 8, 10, 10, 1, -10 },
  { 766, 9, 12, 10, 1, -12 },
  { 780, 8, 10, 10, 1, -10 },
  { 790, 10, 15, 10, 0, -12 },
  { 809, 8, 13, 10, 1, -10 },
  { 822, 8, 12, 10, 1, -12 },
  { 834, 7, 13, 10, 1, -13 },
  { 846, 9, 16, 10, 0, -13 },
  { 864, 9, 12, 10, 1, -12 },
  { 878, 7, 12, 10, 2, -12 },
  { 889, 8, 10, 10, 1, -10 },
  { 899, 8, 10, 10, 1, -10 },
  { 909, 8, 10, 10, 1, -10 },
  { 919, 8, 13, 10, 1, -10 },
  { 932, 8, 13, 10, 1, -10 },
  { 945, 8, 10, 10, 1, -10 },
  { 955, 8, 10, 10, 1, -10 },
  { 965, 7, 12, 10, 2, -12 },
  { 976, 8, 9, 10, 1, -9 },
  { 985, 8, 9, 10, 2, -9 },
  { 994, 8, 9, 10, 2, -9 },
  { 1003, 8, 9, 10, 1, -9 },
  { 1012, 8, 12, 10, 1, -9 },
  { 1024, 8, 9, 10, 1, -9 },
  { 1033, 8, 16, 10, 2, -14 },
  { 1049, 3, 16, 10, 4, -14 },
  { 1055, 8, 16, 10, 1, -14 },
  { 1071, 8, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_ThinItalic17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_THINITALIC17PT7B_H_
