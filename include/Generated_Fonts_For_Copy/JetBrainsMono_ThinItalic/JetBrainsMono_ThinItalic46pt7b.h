#ifndef _JETBRAINSMONO_THINITALIC46PT7B_H_
#define _JETBRAINSMONO_THINITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x00, 0x38, 0x1C, 0xE0, 0x73,
  0x81, 0xDE, 0x07, 0x70, 0x1D, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39,
  0x80, 0xE6, 0x03, 0x18, 0x0C, 0xE0, 0x33, 0x81, 0xC0, 0x00, 0x06, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x01,
  0xC0, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF0, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x0E, 0x00,
  0x06, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0x80, 0x01, 0x80, 0x30,
  0x00, 0x30, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x0E, 0x00, 0x0E, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0E, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xF8, 0x01, 0xE6, 0x78, 0x07, 0x0C, 0x78, 0x1C, 0x18, 0x70,
  0x30, 0x20, 0x60, 0xE0, 0xC0, 0xC1, 0x81, 0x81, 0x83, 0x03, 0x03, 0x06,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x38, 0x60, 0x00, 0x38,
  0xC0, 0x00, 0x79, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x17, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x83,
  0x80, 0x03, 0x07, 0x00, 0x06, 0x06, 0x00, 0x08, 0x0C, 0x70, 0x30, 0x18,
  0xC0, 0x60, 0x71, 0x80, 0xC0, 0xE3, 0x81, 0x81, 0x87, 0x03, 0x07, 0x07,
  0x06, 0x1C, 0x0F, 0x18, 0x70, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x06, 0x01, 0xFC, 0x00,
  0x18, 0x07, 0x1C, 0x00, 0x60, 0x18, 0x1C, 0x01, 0x80, 0x60, 0x18, 0x07,
  0x00, 0xC0, 0x30, 0x1C, 0x01, 0x80, 0xE0, 0x70, 0x03, 0x01, 0x80, 0xC0,
  0x06, 0x03, 0x03, 0x00, 0x18, 0x06, 0x0C, 0x00, 0x30, 0x0C, 0x30, 0x00,
  0x60, 0x30, 0xC0, 0x00, 0xE0, 0x63, 0x80, 0x00, 0xF3, 0x8E, 0x00, 0x00,
  0xFE, 0x18, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x71, 0xFC, 0x00, 0x01,
  0xC7, 0xFC, 0x00, 0x03, 0x1C, 0x18, 0x00, 0x0C, 0x30, 0x38, 0x00, 0x30,
  0xC0, 0x30, 0x00, 0xC1, 0x80, 0xE0, 0x03, 0x03, 0x01, 0x80, 0x0E, 0x06,
  0x03, 0x00, 0x38, 0x1C, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x00, 0xC1, 0xC0, 0x60, 0x01, 0xFF,
  0x01, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0xF0, 0xF0, 0x01, 0xC0, 0x38, 0x01, 0x80, 0x38, 0x03, 0x80, 0x18, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x70, 0x00, 0x18, 0x70, 0x07, 0x30,
  0x38, 0x06, 0x70, 0x18, 0x0C, 0x60, 0x1C, 0x1C, 0x60, 0x0C, 0x18, 0x60,
  0x0E, 0x30, 0x60, 0x07, 0x70, 0xE0, 0x03, 0x60, 0xE0, 0x03, 0xC0, 0xC0,
  0x01, 0x80, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xE0, 0xC0, 0x06, 0x60, 0xE0,
  0x1C, 0x70, 0xF0, 0x38, 0x30, 0x7F, 0xF0, 0x38, 0x3F, 0xC0, 0x1C, 0x3B,
  0x9C, 0xE7, 0x39, 0xDE, 0xE7, 0x39, 0xCC, 0x60, 0x00, 0x00, 0x40, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x07, 0xC0, 0x01, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x40, 0x18, 0x02, 0xF8, 0x18, 0x1E, 0xFF,
  0x18, 0xFF, 0x1F, 0x93, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x8E, 0x00, 0x07,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xE0, 0x38,
  0x1C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x7D,
  0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xE0, 0x07, 0xC3, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x03, 0x06, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00,
  0x18, 0x70, 0x00, 0x70, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC7, 0x00, 0x03,
  0x8E, 0x00, 0x06, 0x1C, 0x1C, 0x0C, 0x38, 0x7C, 0x18, 0x60, 0xF8, 0x70,
  0xC0, 0xE0, 0xE1, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x1C,
  0x00, 0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xE1, 0x80,
  0x01, 0x83, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1E, 0x00,
  0xE0, 0x1E, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xB0, 0x01, 0xE3, 0x00, 0x38,
  0x30, 0x0F, 0x07, 0x00, 0xC0, 0x70, 0x08, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x1E, 0x03,
  0x00, 0x0E, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x63, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x30, 0xE0, 0x00,
  0xC1, 0x80, 0x06, 0x07, 0x00, 0x38, 0x0E, 0x03, 0xC0, 0x3F, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x06,
  0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0xE0, 0x00,
  0xCE, 0x00, 0x0C, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x3F, 0x00, 0x33, 0xFF, 0x01, 0xD8, 0x1E, 0x07, 0x80, 0x3C,
  0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0x80, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x00, 0xC1,
  0x80, 0x07, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x1F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x19, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0xE0,
  0x07, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0x67, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x00, 0xCC, 0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00,
  0x1D, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0xE1, 0xC0, 0x0E, 0x07,
  0x00, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x70, 0x00, 0x3B,
  0x80, 0x01, 0x9C, 0x00, 0x1C, 0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0x81, 0xE0, 0x1C,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x60, 0x70, 0x01,
  0xC0, 0x60, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x0E, 0x1E, 0x00, 0x78, 0x0E, 0x01,
  0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x60,
  0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x0E, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x3C, 0x03, 0xC0, 0x3F, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x01, 0xE0, 0x78,
  0x1C, 0x01, 0xC1, 0xC0, 0x07, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xCE, 0x00,
  0x07, 0x60, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x0D, 0xC0, 0x00, 0x6E,
  0x00, 0x03, 0x70, 0x00, 0x39, 0x80, 0x01, 0x8C, 0x00, 0x1C, 0x70, 0x01,
  0xC1, 0xC0, 0x1E, 0x0F, 0xC7, 0x60, 0x1F, 0xF6, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x03,
  0xE1, 0xFC, 0x7F, 0x1F, 0x87, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x3F, 0x0F, 0xE3, 0xF8, 0xFC, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC0, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0x81,
  0xF0, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x30,
  0x00, 0x1C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70,
  0xC0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x1C, 0x03, 0xF9, 0x87, 0x01, 0xFF,
  0x61, 0x80, 0xE0, 0x78, 0x60, 0x30, 0x0E, 0x18, 0x1C, 0x03, 0x86, 0x06,
  0x00, 0xE3, 0x81, 0x80, 0x38, 0xE0, 0x60, 0x0C, 0x30, 0x38, 0x03, 0x0C,
  0x0E, 0x00, 0xC3, 0x03, 0x00, 0x30, 0xC0, 0xC0, 0x1C, 0x70, 0x30, 0x07,
  0x1C, 0x0C, 0x01, 0x86, 0x03, 0x00, 0x61, 0x80, 0xC0, 0x38, 0x60, 0x38,
  0x16, 0x18, 0x0F, 0xFD, 0x86, 0x01, 0xFE, 0xE1, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x07, 0x60,
  0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x00, 0xC7, 0x00, 0x0E,
  0x18, 0x00, 0x60, 0xC0, 0x07, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80,
  0x18, 0x0C, 0x00, 0xC0, 0x60, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00,
  0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0E,
  0x00, 0x30, 0x60, 0x01, 0x87, 0x00, 0x0E, 0x30, 0x00, 0x73, 0x80, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x60, 0x00, 0x1F, 0x00,
  0x00, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0x80,
  0x0E, 0x06, 0x00, 0x18, 0x18, 0x00, 0x70, 0xE0, 0x00, 0xC3, 0x80, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC3, 0x00, 0x06, 0x1C,
  0x00, 0x38, 0x70, 0x01, 0xC1, 0x80, 0x0E, 0x06, 0x01, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x70,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0xC0,
  0x00, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE1, 0x80, 0x03,
  0x06, 0x00, 0x38, 0x38, 0x03, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3C, 0x0F, 0x01, 0xC0, 0x1C, 0x06,
  0x00, 0x38, 0x30, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x60, 0x00, 0x61, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x03, 0x8C,
  0x00, 0x0E, 0x30, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x06, 0x07, 0x00,
  0x30, 0x1E, 0x03, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0x80, 0x3C, 0x06, 0x00, 0x38,
  0x18, 0x00, 0xE0, 0xE0, 0x01, 0x83, 0x80, 0x07, 0x0C, 0x00, 0x1C, 0x30,
  0x00, 0x70, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x70, 0x00,
  0x61, 0x80, 0x01, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x60, 0x00, 0xC3,
  0x80, 0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x00,
  0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61, 0xC0, 0x01, 0x87, 0x00, 0x0E,
  0x18, 0x00, 0x30, 0x60, 0x01, 0xC1, 0x80, 0x0E, 0x06, 0x00, 0x70, 0x38,
  0x0F, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x3C, 0x0F, 0x01, 0xC0, 0x1C, 0x06, 0x00, 0x38, 0x30, 0x00,
  0x61, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x03, 0xFF,
  0x18, 0x1F, 0xFC, 0x60, 0x00, 0x71, 0x80, 0x01, 0x86, 0x00, 0x06, 0x38,
  0x00, 0x18, 0xE0, 0x00, 0x63, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x30, 0x00,
  0x30, 0xE0, 0x01, 0xC3, 0x80, 0x06, 0x07, 0x00, 0x30, 0x1E, 0x03, 0xC0,
  0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x1C,
  0x18, 0x00, 0x38, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x83,
  0x80, 0x03, 0x07, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x60, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x07, 0x06, 0x00,
  0x0E, 0x0C, 0x00, 0x18, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xE0, 0x00,
  0xC1, 0xC0, 0x03, 0x83, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0xC0, 0x03, 0x83,
  0x00, 0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x70,
  0x00, 0x60, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x80, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x40, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x87,
  0x00, 0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0xC0,
  0x30, 0x00, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x70, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x38,
  0x00, 0xE0, 0x18, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x06,
  0x00, 0x1C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0x60, 0x60, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xA0,
  0x03, 0xC0, 0xD8, 0x01, 0x60, 0x6C, 0x01, 0xB0, 0x36, 0x00, 0x98, 0x1B,
  0x00, 0xCC, 0x1C, 0x80, 0xCE, 0x0C, 0x60, 0x66, 0x06, 0x30, 0x63, 0x03,
  0x18, 0x31, 0x81, 0x8C, 0x30, 0xC0, 0xC2, 0x18, 0xE0, 0xE1, 0x98, 0x70,
  0x70, 0xCC, 0x30, 0x30, 0x6C, 0x18, 0x18, 0x36, 0x0C, 0x0C, 0x0E, 0x06,
  0x06, 0x07, 0x03, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x06, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x38,
  0x3C, 0x00, 0x60, 0x78, 0x00, 0xC0, 0xD8, 0x01, 0x83, 0xB0, 0x03, 0x06,
  0x60, 0x06, 0x0C, 0xC0, 0x1C, 0x18, 0xC0, 0x30, 0x31, 0x80, 0x60, 0x63,
  0x00, 0xC1, 0xC6, 0x01, 0x83, 0x86, 0x03, 0x06, 0x0C, 0x0E, 0x0C, 0x18,
  0x18, 0x18, 0x30, 0x30, 0x30, 0x70, 0x60, 0xE0, 0x60, 0xC1, 0xC0, 0xC1,
  0x83, 0x01, 0x87, 0x06, 0x03, 0x8E, 0x0C, 0x03, 0x18, 0x18, 0x06, 0x30,
  0x30, 0x0C, 0x60, 0xE0, 0x18, 0xC1, 0x80, 0x1B, 0x83, 0x00, 0x37, 0x06,
  0x00, 0x6C, 0x0C, 0x00, 0xD8, 0x18, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xC0,
  0x03, 0xC1, 0x80, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xF0,
  0x38, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x06, 0x00, 0x1C, 0x70, 0x00, 0xE3,
  0x00, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x01, 0xC6, 0x00, 0x0C, 0x70, 0x00,
  0x63, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x30,
  0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x71, 0x80, 0x03, 0x9C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x70, 0x01, 0xC1,
  0x80, 0x1C, 0x0E, 0x01, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x06, 0x00, 0x1C, 0x06,
  0x00, 0x0E, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x0C,
  0x00, 0x07, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x18,
  0x00, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xF0,
  0x38, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x06, 0x00, 0x1C, 0x70, 0x00, 0xE3,
  0x00, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x01, 0xC6, 0x00, 0x0C, 0x70, 0x00,
  0x63, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x30,
  0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x71, 0x80, 0x03, 0x9C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x70, 0x01, 0xC1,
  0x80, 0x1C, 0x0F, 0x01, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x30, 0x01, 0xE0, 0x60, 0x00, 0xC0, 0xC0,
  0x01, 0xC3, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x71, 0xC0, 0x00, 0xC3, 0x80, 0x03,
  0x86, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x18, 0x03, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xF8, 0x01, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x06, 0x01, 0xC0,
  0x0E, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x18, 0x00,
  0x70, 0x70, 0x00, 0x60, 0xE0, 0x00, 0xE1, 0x80, 0x00, 0xC0, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x01, 0xE0, 0x70, 0x01,
  0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x70, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60,
  0x00, 0xE1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xE0, 0x00,
  0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x87,
  0x00, 0x06, 0x1C, 0x00, 0x18, 0x60, 0x00, 0xE1, 0x80, 0x03, 0x86, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x1C,
  0x38, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x80, 0x0E, 0x07, 0x00, 0x70, 0x1E,
  0x03, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xE0, 0x00, 0x1D, 0x80,
  0x00, 0x66, 0x00, 0x03, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x01,
  0xC6, 0x00, 0x06, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xC1, 0xC0, 0x07, 0x03,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x00,
  0x70, 0x0C, 0x01, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x30, 0x01, 0x80, 0xC0,
  0x06, 0x07, 0x00, 0x18, 0x18, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x00, 0x06,
  0x1C, 0x00, 0x18, 0x60, 0x00, 0x71, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x30,
  0x00, 0x0D, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x0E, 0x01, 0xB0, 0x0F, 0x01,
  0xD8, 0x07, 0x80, 0xEC, 0x03, 0xC0, 0x66, 0x03, 0x60, 0x33, 0x01, 0xB0,
  0x39, 0x80, 0xD8, 0x18, 0xC0, 0x48, 0x0C, 0x60, 0x64, 0x06, 0x30, 0x32,
  0x07, 0x18, 0x11, 0x03, 0x0C, 0x18, 0x81, 0x86, 0x0C, 0x41, 0xC3, 0x06,
  0x20, 0xC1, 0x86, 0x10, 0x60, 0xC3, 0x08, 0x30, 0x61, 0x84, 0x38, 0x30,
  0x82, 0x18, 0x38, 0xC1, 0x0C, 0x1C, 0x60, 0x86, 0x0E, 0x20, 0x46, 0x06,
  0x30, 0x63, 0x03, 0x18, 0x31, 0x81, 0x88, 0x19, 0xC0, 0xCC, 0x0C, 0xC0,
  0x66, 0x06, 0x60, 0x33, 0x03, 0x30, 0x19, 0x01, 0xB0, 0x0D, 0x80, 0xD8,
  0x06, 0xC0, 0x6C, 0x03, 0x40, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x06,
  0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x30, 0x1C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x07, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0xC0,
  0x01, 0x80, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x80, 0x00,
  0x63, 0x00, 0x01, 0xC6, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x38,
  0x18, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x1C, 0x00,
  0xE0, 0x30, 0x00, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x86, 0x00, 0x03,
  0x1C, 0x00, 0x06, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x6E, 0x00, 0x33, 0x80, 0x1C,
  0x60, 0x06, 0x18, 0x03, 0x87, 0x01, 0xC0, 0xC0, 0x70, 0x30, 0x38, 0x0E,
  0x0C, 0x03, 0x87, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x07, 0x70, 0x01, 0xF8,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0xE0, 0xC1, 0xC1,
  0x81, 0xC0, 0x00, 0x7C, 0x08, 0x1F, 0xF9, 0x81, 0xF1, 0xEC, 0x1C, 0x03,
  0x61, 0xC0, 0x0F, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0xC6, 0x00, 0x0C, 0x30,
  0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x01, 0xC6, 0x00, 0x0E,
  0x30, 0x00, 0x71, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x70, 0x01, 0xC1,
  0x80, 0x1E, 0x0E, 0x01, 0xB0, 0x3F, 0xFB, 0x80, 0xFF, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x0F, 0x00, 0x63,
  0xFE, 0x03, 0x78, 0xF8, 0x1E, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x18,
  0x70, 0x00, 0xC3, 0x00, 0x07, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x8E, 0x00,
  0x0C, 0x70, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x01, 0xC6,
  0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xE0, 0x01,
  0xC7, 0x00, 0x0C, 0x38, 0x00, 0xE1, 0xE0, 0x0E, 0x1F, 0x80, 0xE0, 0xEF,
  0xFE, 0x06, 0x3F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xEF,
  0xC0, 0xE0, 0x0E, 0x1C, 0x00, 0x61, 0x80, 0x07, 0x38, 0x00, 0x73, 0x00,
  0x07, 0x30, 0x00, 0x77, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x38,
  0x70, 0x07, 0x07, 0x80, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x7C, 0x38, 0x0F,
  0xFC, 0xC0, 0x7C, 0x7B, 0x03, 0x80, 0x6C, 0x1C, 0x00, 0xF0, 0x60, 0x01,
  0xC3, 0x80, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61, 0xC0, 0x01, 0x87,
  0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x00, 0xE1, 0x80, 0x03, 0x86, 0x00,
  0x0C, 0x38, 0x00, 0x30, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x1C,
  0x30, 0x00, 0x70, 0xC0, 0x01, 0x83, 0x80, 0x0E, 0x06, 0x00, 0x78, 0x1C,
  0x03, 0x60, 0x3F, 0xFB, 0x80, 0x7F, 0x8E, 0x00, 0x00, 0x3C, 0x00, 0x1F,
  0xF8, 0x07, 0xC7, 0xC0, 0xE0, 0x1E, 0x1C, 0x00, 0xE1, 0x80, 0x06, 0x38,
  0x00, 0x63, 0x00, 0x07, 0x30, 0x00, 0x67, 0x00, 0x06, 0x70, 0x00, 0x66,
  0x00, 0x06, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x04, 0xC0, 0x01,
  0x8E, 0x00, 0x38, 0x60, 0x07, 0x07, 0x00, 0xE0, 0x3F, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x40,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x08, 0x1F, 0xF9, 0x81, 0xF1, 0xEC,
  0x1C, 0x03, 0x61, 0xC0, 0x0F, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0xC6, 0x00,
  0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x0E, 0x30, 0x00, 0x71, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xE0, 0x00,
  0xC7, 0x00, 0x0E, 0x38, 0x00, 0x70, 0xC0, 0x07, 0x87, 0x00, 0x78, 0x1C,
  0x06, 0xC0, 0x7F, 0xE6, 0x01, 0xFC, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x0F, 0x00, 0x63, 0xFE,
  0x03, 0x78, 0xF8, 0x1E, 0x01, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x18, 0x70,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x8E, 0x00, 0x0C,
  0x70, 0x00, 0x63, 0x00, 0x07, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x38, 0xC0, 0x01, 0xC6,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xE0, 0x00,
  0xC6, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x70,
  0x60, 0x01, 0xC0, 0xC0, 0x07, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0E, 0x00, 0x60, 0x38, 0x01, 0xC0,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0E,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38,
  0x06, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x18, 0x00, 0x70, 0x30, 0x00, 0xE0,
  0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0xF0, 0x38, 0x1D, 0xF8, 0xFC, 0x1B, 0x1D, 0x8E, 0x1C, 0x1E, 0x0E, 0x1C,
  0x0E, 0x06, 0x18, 0x0C, 0x06, 0x18, 0x0C, 0x06, 0x18, 0x0C, 0x06, 0x38,
  0x1C, 0x0E, 0x30, 0x1C, 0x0E, 0x30, 0x18, 0x0C, 0x30, 0x18, 0x0C, 0x30,
  0x18, 0x0C, 0x30, 0x18, 0x0C, 0x70, 0x38, 0x1C, 0x70, 0x38, 0x1C, 0x60,
  0x30, 0x18, 0x60, 0x30, 0x18, 0x60, 0x30, 0x18, 0x60, 0x30, 0x18, 0xE0,
  0x30, 0x18, 0xE0, 0x70, 0x38, 0xC0, 0x60, 0x38, 0xC0, 0x60, 0x30, 0xC0,
  0x60, 0x30, 0xC0, 0x60, 0x30, 0x00, 0x1F, 0x00, 0x63, 0xFE, 0x03, 0x78,
  0xF8, 0x1A, 0x01, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x18, 0x70, 0x00, 0xC3,
  0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x70, 0x00,
  0x63, 0x00, 0x07, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x38, 0xC0, 0x01, 0xC6, 0x00, 0x0C,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00,
  0x0E, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xC7, 0xC0, 0xE0, 0x1E,
  0x1C, 0x00, 0xE1, 0x80, 0x06, 0x38, 0x00, 0x63, 0x00, 0x07, 0x30, 0x00,
  0x67, 0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x0E, 0x60, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8E, 0x00, 0x38, 0x60, 0x07, 0x07,
  0x00, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x18, 0xFF,
  0x80, 0x6F, 0x1F, 0x01, 0xE0, 0x0E, 0x0F, 0x00, 0x38, 0x38, 0x00, 0x60,
  0xE0, 0x01, 0x83, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61, 0xC0,
  0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE1, 0x80, 0x03,
  0x86, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC3, 0x80, 0x03, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x60, 0xE0, 0x03, 0x83, 0xC0, 0x1C, 0x1F, 0x80,
  0xE0, 0x77, 0xFF, 0x01, 0x8F, 0xF0, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x08, 0x1F, 0xF9, 0x81, 0xF1,
  0xEC, 0x1C, 0x03, 0x61, 0xC0, 0x0F, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0xC6,
  0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x01,
  0xC6, 0x00, 0x0E, 0x30, 0x00, 0x71, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xE0,
  0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x18,
  0x70, 0x01, 0xC1, 0x80, 0x1E, 0x0E, 0x01, 0xB0, 0x3F, 0xFB, 0x80, 0xFF,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1E, 0x00, 0x67, 0xFE, 0x03, 0x78, 0xF8, 0x3E, 0x01, 0xE1, 0xE0, 0x07,
  0x0E, 0x00, 0x18, 0x70, 0x00, 0xE3, 0x00, 0x07, 0x18, 0x00, 0x39, 0xC0,
  0x01, 0x8E, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFF, 0x01, 0xF0, 0x7C, 0x1E, 0x00, 0xF0, 0xC0, 0x03, 0x8E, 0x00, 0x0C,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xCE, 0x00, 0x06, 0x70, 0x00, 0x71, 0x80, 0x03, 0x0F, 0x00, 0x78, 0x3F,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x70, 0x00, 0x63,
  0x80, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x01, 0xC6, 0x00, 0x0C, 0x30, 0x00,
  0x63, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xC7, 0x00, 0x0E,
  0x38, 0x00, 0x61, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x38, 0x03, 0x81, 0xE0,
  0x38, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xE0, 0x00, 0x3B, 0x00, 0x01,
  0x98, 0x00, 0x1C, 0xC0, 0x00, 0xC7, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0,
  0x07, 0x06, 0x00, 0x30, 0x30, 0x03, 0x81, 0xC0, 0x18, 0x06, 0x01, 0xC0,
  0x30, 0x0C, 0x01, 0x80, 0xE0, 0x0C, 0x06, 0x00, 0x60, 0x70, 0x01, 0x83,
  0x00, 0x0C, 0x38, 0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00,
  0xEE, 0x00, 0x03, 0x60, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x1F, 0x00, 0xA0, 0x36, 0x03, 0x40,
  0x6C, 0x06, 0x81, 0xD8, 0x09, 0x03, 0x30, 0x32, 0x06, 0x60, 0x64, 0x0C,
  0xC1, 0x88, 0x31, 0x83, 0x10, 0x63, 0x06, 0x20, 0xC6, 0x18, 0x43, 0x0C,
  0x30, 0x86, 0x18, 0x61, 0x0C, 0x31, 0x82, 0x30, 0x73, 0x06, 0x60, 0xE6,
  0x0C, 0xC1, 0xD8, 0x1B, 0x03, 0xB0, 0x36, 0x07, 0x40, 0x6C, 0x07, 0x80,
  0xF0, 0x0B, 0x01, 0xE0, 0x14, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x81, 0x80, 0x07, 0x00, 0xE0, 0x03, 0x00, 0x38,
  0x03, 0x00, 0x0C, 0x03, 0x80, 0x07, 0x03, 0x80, 0x01, 0x83, 0x80, 0x00,
  0xE3, 0x80, 0x00, 0x31, 0x80, 0x00, 0x1D, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0xE0, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x01,
  0xC0, 0x60, 0x00, 0x60, 0xF0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x33, 0x80,
  0x03, 0x30, 0x00, 0x73, 0x00, 0x07, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30,
  0x00, 0x67, 0x00, 0x06, 0x70, 0x00, 0xE6, 0x00, 0x0E, 0x60, 0x00, 0xE6,
  0x00, 0x0C, 0x60, 0x00, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x1C,
  0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x58, 0x78, 0x1D,
  0x83, 0xFF, 0x38, 0x0F, 0xE3, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x19, 0xFE, 0x00, 0xD8, 0x38, 0x0C, 0xC0, 0xC0, 0x6E, 0x03,
  0x03, 0x60, 0x1C, 0x3B, 0x00, 0x7F, 0x98, 0x00, 0xF0,
};

const GFXglyph JetBrainsMono_ThinItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 10, 34, 28, 9, -34 },
  { 44, 14, 14, 28, 9, -34 },
  { 69, 27, 34, 28, 1, -34 },
  { 184, 23, 46, 28, 3, -40 },
  { 317, 31, 34, 28, -1, -34 },
  { 449, 24, 34, 28, 2, -34 },
  { 551, 5, 14, 28, 14, -34 },
  { 560, 18, 45, 28, 8, -39 },
  { 662, 18, 45, 28, 2, -39 },
  { 764, 24, 23, 28, 3, -28 },
  { 833, 21, 21, 28, 4, -26 },
  { 889, 10, 14, 28, 6, -7 },
  { 907, 15, 2, 28, 7, -16 },
  { 911, 7, 6, 28, 9, -6 },
  { 917, 25, 43, 28, 2, -38 },
  { 1052, 23, 34, 28, 3, -34 },
  { 1150, 20, 34, 28, 3, -34 },
  { 1235, 24, 34, 28, 2, -34 },
  { 1337, 22, 34, 28, 3, -34 },
  { 1431, 20, 34, 28, 4, -34 },
  { 1516, 22, 34, 28, 3, -34 },
  { 1610, 21, 34, 28, 3, -34 },
  { 1700, 21, 34, 28, 6, -34 },
  { 1790, 23, 34, 28, 3, -34 },
  { 1888, 21, 34, 28, 5, -34 },
  { 1978, 10, 26, 28, 9, -26 },
  { 2011, 13, 33, 28, 6, -26 },
  { 2065, 22, 23, 28, 4, -27 },
  { 2129, 21, 12, 28, 4, -21 },
  { 2161, 21, 23, 28, 3, -27 },
  { 2222, 17, 34, 28, 8, -34 },
  { 2295, 26, 42, 28, 1, -34 },
  { 2432, 21, 34, 28, 1, -34 },
  { 2522, 22, 34, 28, 3, -34 },
  { 2616, 22, 34, 28, 4, -34 },
  { 2710, 22, 34, 28, 3, -34 },
  { 2804, 24, 34, 28, 3, -34 },
  { 2906, 24, 34, 28, 3, -34 },
  { 3008, 22, 34, 28, 4, -34 },
  { 3102, 23, 34, 28, 3, -34 },
  { 3200, 22, 34, 28, 3, -34 },
  { 3294, 23, 34, 28, 2, -34 },
  { 3392, 25, 34, 28, 3, -34 },
  { 3499, 19, 34, 28, 3, -34 },
  { 3580, 25, 34, 28, 2, -34 },
  { 3687, 23, 34, 28, 3, -34 },
  { 3785, 21, 34, 28, 4, -34 },
  { 3875, 24, 34, 28, 3, -34 },
  { 3977, 21, 42, 28, 4, -34 },
  { 4088, 23, 34, 28, 3, -34 },
  { 4186, 23, 34, 28, 3, -34 },
  { 4284, 22, 34, 28, 6, -34 },
  { 4378, 22, 34, 28, 4, -34 },
  { 4472, 22, 34, 28, 6, -34 },
  { 4566, 25, 34, 28, 4, -34 },
  { 4673, 28, 34, 28, 0, -34 },
  { 4792, 23, 34, 28, 6, -34 },
  { 4890, 24, 34, 28, 2, -34 },
  { 4992, 17, 43, 28, 7, -38 },
  { 5084, 12, 43, 28, 8, -38 },
  { 5149, 17, 43, 28, 4, -38 },
  { 5241, 18, 18, 28, 5, -34 },
  { 5282, 23, 2, 28, 0, 1 },
  { 5288, 7, 6, 28, 13, -36 },
  { 5294, 21, 26, 28, 4, -26 },
  { 5363, 21, 34, 28, 3, -34 },
  { 5453, 20, 26, 28, 4, -26 },
  { 5518, 22, 34, 28, 4, -34 },
  { 5612, 20, 26, 28, 4, -26 },
  { 5677, 28, 42, 28, -1, -34 },
  { 5824, 21, 34, 28, 4, -26 },
  { 5914, 21, 34, 28, 3, -34 },
  { 6004, 21, 35, 28, 2, -35 },
  { 6096, 23, 43, 28, 1, -35 },
  { 6220, 23, 34, 28, 3, -34 },
  { 6318, 18, 34, 28, 5, -34 },
  { 6395, 24, 26, 28, 2, -26 },
  { 6473, 21, 26, 28, 3, -26 },
  { 6542, 20, 26, 28, 4, -26 },
  { 6607, 22, 34, 28, 2, -26 },
  { 6701, 21, 34, 28, 4, -26 },
  { 6791, 21, 26, 28, 4, -26 },
  { 6860, 21, 26, 28, 3, -26 },
  { 6929, 20, 32, 28, 5, -32 },
  { 7009, 21, 25, 28, 4, -25 },
  { 7075, 21, 25, 28, 5, -25 },
  { 7141, 23, 25, 28, 4, -25 },
  { 7213, 25, 25, 28, 1, -25 },
  { 7292, 20, 33, 28, 4, -25 },
  { 7375, 21, 25, 28, 3, -25 },
  { 7441, 22, 43, 28, 5, -38 },
  { 7560, 9, 43, 28, 10, -38 },
  { 7609, 22, 43, 28, 2, -38 },
  { 7728, 21, 8, 28, 4, -20 },
};

const GFXfont JetBrainsMono_ThinItalic46pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic46pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _JETBRAINSMONO_THINITALIC46PT7B_H_
