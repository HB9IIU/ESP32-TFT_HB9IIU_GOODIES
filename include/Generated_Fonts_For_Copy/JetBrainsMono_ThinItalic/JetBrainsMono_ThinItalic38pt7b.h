#ifndef _JETBRAINSMONO_THINITALIC38PT7B_H_
#define _JETBRAINSMONO_THINITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x70, 0xC1,
  0x83, 0x06, 0x08, 0x10, 0x20, 0x41, 0x80, 0x00, 0x00, 0x00, 0x71, 0xE3,
  0xC7, 0x80, 0x70, 0x6C, 0x1D, 0x83, 0xB0, 0x7E, 0x0D, 0xC1, 0xB0, 0x36,
  0x06, 0xC0, 0xD8, 0x33, 0x06, 0x40, 0xC0, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x60, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x81, 0x80,
  0x0C, 0x06, 0x00, 0x30, 0x18, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x18,
  0x0C, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x30,
  0x01, 0x80, 0xC0, 0x06, 0x02, 0x00, 0x30, 0x18, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x06,
  0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x18, 0xCE, 0x06, 0x18, 0xE1, 0x82, 0x0C,
  0x30, 0x41, 0x86, 0x08, 0x30, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0x61, 0x00, 0x06, 0x20, 0x00, 0xF4, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x06, 0xE0, 0x00, 0xC6, 0x00, 0x10, 0xE0, 0x02, 0x0C, 0x00, 0xC1, 0x80,
  0x18, 0x31, 0x83, 0x06, 0x20, 0x60, 0xC6, 0x08, 0x30, 0xC1, 0x06, 0x1C,
  0x23, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0xFE,
  0x00, 0x60, 0x60, 0xC0, 0x30, 0x10, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x03,
  0x03, 0x06, 0x00, 0xC0, 0xC1, 0x00, 0x30, 0x20, 0xC0, 0x08, 0x08, 0x60,
  0x02, 0x06, 0x30, 0x00, 0xC3, 0x18, 0x00, 0x1F, 0x8C, 0x00, 0x03, 0xC6,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x31, 0xF8, 0x00, 0x18, 0xC7, 0x00, 0x0C, 0x60, 0xC0, 0x06, 0x10, 0x30,
  0x01, 0x0C, 0x0C, 0x00, 0xC3, 0x03, 0x00, 0x60, 0xC0, 0xC0, 0x30, 0x30,
  0x30, 0x18, 0x0C, 0x08, 0x0C, 0x03, 0x06, 0x06, 0x00, 0xF7, 0x03, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x01, 0xC1, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x01, 0xEC,
  0x00, 0x18, 0xE0, 0x33, 0x06, 0x02, 0x30, 0x30, 0x66, 0x03, 0x0C, 0x60,
  0x19, 0x86, 0x01, 0xD8, 0x60, 0x0F, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06,
  0x00, 0xF0, 0x60, 0x1B, 0x86, 0x03, 0x18, 0x79, 0xE0, 0xC3, 0xF8, 0x0E,
  0x33, 0x37, 0x77, 0x66, 0x66, 0x4C, 0x00, 0x06, 0x00, 0x7C, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x08, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x08,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x70, 0x60, 0x7F, 0xC6, 0x3F, 0x1F, 0x6F,
  0x80, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x0A, 0x00, 0x03, 0xB0, 0x00, 0x31,
  0x80, 0x06, 0x18, 0x00, 0xC1, 0xC0, 0x18, 0x0C, 0x03, 0x80, 0x60, 0x10,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0x80, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x0E, 0x1E, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60,
  0x60, 0xC0, 0xC0, 0xFF, 0xF0, 0x79, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x38, 0x30, 0x06, 0x18, 0x01, 0xC6,
  0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x73, 0x00,
  0x19, 0xC0, 0x06, 0x60, 0xC1, 0x98, 0x78, 0x66, 0x1E, 0x19, 0x83, 0x0E,
  0x60, 0x03, 0x38, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x01, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xE0, 0x0C, 0x1C, 0x06, 0x03, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3B, 0x00, 0x39, 0x80,
  0x70, 0xC0, 0x70, 0x40, 0x20, 0x60, 0x20, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1C, 0x07, 0x07, 0x00,
  0x70, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x07,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0x63, 0x00, 0x30, 0xC0, 0x0C, 0x38, 0x0E, 0x07, 0xCF, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x30, 0x60, 0x18, 0x70, 0x0C, 0x30, 0x06, 0x30,
  0x03, 0x30, 0x01, 0x18, 0x01, 0x98, 0x00, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x1F, 0xC0, 0xDE, 0xF8, 0x3C, 0x06, 0x0E, 0x00, 0xC3, 0x00, 0x30, 0xC0,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x18, 0x06, 0x07,
  0xCF, 0x00, 0x7F, 0x80, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x19, 0xE0, 0x0D, 0xFE, 0x07, 0x81, 0xC1,
  0xC0, 0x38, 0xE0, 0x06, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80,
  0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06,
  0x0C, 0x03, 0x01, 0xE7, 0x80, 0x3F, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF6,
  0x00, 0x1B, 0x80, 0x06, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x0C, 0x07, 0x03, 0x00, 0x70, 0xC0, 0x06, 0x18, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x10, 0x18, 0x0E,
  0x03, 0x83, 0x80, 0x1D, 0xC0, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x38, 0x70,
  0x1C, 0x07, 0x07, 0x00, 0x60, 0xC0, 0x0E, 0x30, 0x00, 0xC6, 0x00, 0x18,
  0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x60, 0x07, 0x0E, 0x01, 0xC0,
  0xF9, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0x01, 0xC3,
  0x00, 0x63, 0x00, 0x19, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01,
  0xA0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x73, 0x80, 0x30, 0xE0,
  0x78, 0x7F, 0xF8, 0x0F, 0xD8, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x3E, 0x3F, 0x1F, 0x87, 0x80, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0x00,
  0x3F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0,
  0x10, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0x03, 0xF0, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x70, 0x1C, 0x06, 0x00, 0x60, 0x60,
  0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xC4, 0x07, 0xF6, 0x60, 0x71, 0xB3, 0x07, 0x03, 0x98, 0x30,
  0x18, 0xC1, 0x80, 0xC6, 0x0C, 0x06, 0x30, 0xC0, 0x33, 0x06, 0x01, 0x98,
  0x30, 0x0C, 0xC1, 0x80, 0xC6, 0x0C, 0x06, 0x30, 0x60, 0x31, 0x83, 0x03,
  0x98, 0x1C, 0x3C, 0xC0, 0x7F, 0x66, 0x01, 0xE2, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x58, 0x00, 0x36, 0x00, 0x09, 0x80, 0x06, 0x60,
  0x01, 0x98, 0x00, 0xC2, 0x00, 0x30, 0x80, 0x18, 0x30, 0x06, 0x0C, 0x01,
  0x83, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x00,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x18, 0x01, 0x86, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x03, 0x0F,
  0xF8, 0x03, 0xFF, 0x80, 0x80, 0x78, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x30,
  0xC0, 0x1C, 0x30, 0x0E, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0x80, 0x38, 0x60,
  0x07, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x07, 0x0F, 0xFF, 0x03,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x70, 0x38, 0x30, 0x07, 0x0C,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x03, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0x60, 0x0C, 0x1C, 0x07,
  0x03, 0xCF, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x80, 0xF0,
  0x60, 0x0C, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18,
  0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0x43, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x0C, 0x60, 0x06, 0x10, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x30, 0xC0,
  0x18, 0x30, 0x1C, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x7F, 0xFE, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xF8,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x70, 0x38, 0x30, 0x07, 0x0C, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x03, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x0F, 0xF9, 0x83,
  0xFE, 0x60, 0x01, 0x98, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x03,
  0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0x60, 0x0C, 0x1C, 0x07, 0x03,
  0xCF, 0x80, 0x7F, 0x80, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C, 0x60,
  0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01,
  0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x0F, 0xFF, 0xC3,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x21, 0x80,
  0x18, 0x60, 0x06, 0x10, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x31,
  0x80, 0x06, 0x30, 0x01, 0x86, 0x00, 0x30, 0xE0, 0x0C, 0x0C, 0x03, 0x80,
  0xF3, 0xC0, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x08, 0x00,
  0xC1, 0x80, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x30, 0x18, 0x03, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x03, 0x80, 0x30,
  0x30, 0x03, 0xFE, 0x00, 0x30, 0x70, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06,
  0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x00, 0xC0,
  0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06,
  0x0C, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xB0, 0x1B, 0x0B, 0x01, 0xA1,
  0x90, 0x36, 0x19, 0x02, 0x61, 0x90, 0x66, 0x19, 0x84, 0x61, 0x98, 0xC6,
  0x10, 0x88, 0x43, 0x09, 0x8C, 0x30, 0xD0, 0xC3, 0x0F, 0x0C, 0x30, 0xE0,
  0xC3, 0x06, 0x0C, 0x30, 0x00, 0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00,
  0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x84, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0xC3,
  0x80, 0x30, 0xE0, 0x0C, 0x68, 0x03, 0x1A, 0x00, 0xC6, 0xC0, 0x31, 0xB0,
  0x08, 0x64, 0x06, 0x11, 0x01, 0x8C, 0x60, 0x63, 0x18, 0x18, 0xC6, 0x06,
  0x30, 0x81, 0x0C, 0x30, 0xC2, 0x0C, 0x31, 0x83, 0x0C, 0x60, 0x43, 0x18,
  0x18, 0xC6, 0x06, 0x21, 0x81, 0x98, 0x60, 0x26, 0x10, 0x0D, 0x8C, 0x03,
  0x63, 0x00, 0xD8, 0xC0, 0x16, 0x30, 0x07, 0x0C, 0x01, 0xC2, 0x00, 0x70,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x60, 0x38, 0x30, 0x06, 0x08, 0x01, 0x86,
  0x00, 0x31, 0x80, 0x0C, 0x40, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x46, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x06, 0x30,
  0x01, 0x8C, 0x00, 0x63, 0x00, 0x30, 0x60, 0x0C, 0x18, 0x06, 0x03, 0xCF,
  0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x20, 0x0F, 0x0C, 0x00,
  0x61, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00,
  0x66, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x38, 0x60, 0x0E,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x70, 0x38, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x00, 0x31,
  0x80, 0x0C, 0x40, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x06, 0x30, 0x01, 0x8C, 0x00, 0x46, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0x63, 0x00, 0x30, 0x60, 0x0C, 0x18, 0x06, 0x03, 0xCF, 0x00, 0x7F,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x20, 0x0E,
  0x0C, 0x00, 0xE1, 0x80, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x30,
  0x60, 0x3C, 0x0F, 0xFF, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x80, 0x30, 0x30, 0x06, 0x06,
  0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x18, 0x60, 0x03, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0C, 0x07, 0x03, 0x00, 0x70, 0xC0, 0x06,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x0E,
  0x01, 0xC0, 0xF9, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0xC3, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x08, 0x60, 0x06, 0x10, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x06, 0x30, 0x01, 0x8C, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x18, 0x60, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0x63, 0x80, 0x30, 0x60, 0x0C, 0x1C, 0x06, 0x03, 0xCF, 0x00, 0x7F,
  0x80, 0xC0, 0x00, 0xF0, 0x00, 0x64, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x18, 0x60, 0x0C, 0x18, 0x03, 0x06,
  0x00, 0xC0, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC1,
  0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0x43, 0x00, 0x19, 0x80,
  0x06, 0x60, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1A, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x60, 0x30, 0x1B, 0x01, 0x80, 0xD8, 0x1C, 0x04,
  0xC0, 0xA0, 0x66, 0x05, 0x03, 0x30, 0x68, 0x19, 0x83, 0x41, 0x8C, 0x12,
  0x0C, 0x61, 0x90, 0x63, 0x0C, 0x82, 0x18, 0x44, 0x30, 0xC2, 0x21, 0x86,
  0x31, 0x0C, 0x31, 0x08, 0x41, 0x08, 0x46, 0x08, 0xC2, 0x30, 0x44, 0x11,
  0x02, 0x20, 0x98, 0x13, 0x04, 0xC0, 0x98, 0x26, 0x04, 0x81, 0x20, 0x64,
  0x0B, 0x03, 0x60, 0x58, 0x1A, 0x06, 0x80, 0xD0, 0x3C, 0x07, 0x81, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x00, 0x06, 0x06, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x10, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x00,
  0x98, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x64, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x81, 0xC0, 0x03, 0x07,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x06, 0x30, 0x01,
  0xC6, 0x00, 0x30, 0xC0, 0x0C, 0x0C, 0x03, 0x81, 0x80, 0x60, 0x30, 0x18,
  0x03, 0x07, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x19, 0x80,
  0x03, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0x1F, 0xF0,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0xC0,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x60, 0x01, 0xE0, 0x03, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x63, 0x01, 0xC6,
  0x03, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x60, 0x31, 0xC0, 0x63, 0x00, 0x6C,
  0x00, 0xF8, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC3, 0x18, 0x61,
  0x80, 0x03, 0xF9, 0x83, 0xCE, 0xC3, 0x01, 0xE3, 0x00, 0x73, 0x00, 0x39,
  0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0x46, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0,
  0x0E, 0x30, 0x07, 0x18, 0x07, 0x07, 0x1D, 0x81, 0xFC, 0xC0, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x33, 0xF8, 0x1B, 0x9E, 0x1A, 0x03, 0x8E, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x46, 0x00, 0x62, 0x00, 0x33, 0x00, 0x19, 0xC0,
  0x1C, 0xE0, 0x0C, 0x78, 0x0C, 0x37, 0x1C, 0x11, 0xFC, 0x00, 0x03, 0xFC,
  0x03, 0xFF, 0x03, 0x01, 0xC3, 0x00, 0x63, 0x00, 0x19, 0x80, 0x0C, 0xC0,
  0x06, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x30, 0x06,
  0x1C, 0x07, 0x07, 0x9E, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x0F,
  0xE6, 0x07, 0x9D, 0x83, 0x01, 0xE1, 0x80, 0x38, 0xC0, 0x0E, 0x30, 0x03,
  0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6,
  0x00, 0x21, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00,
  0x38, 0x60, 0x0E, 0x18, 0x07, 0x03, 0x8E, 0xC0, 0x7F, 0x30, 0x03, 0xFC,
  0x03, 0xDF, 0x03, 0x01, 0xC3, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x3F, 0xFF, 0x9F, 0xFF, 0xCC, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x30, 0x06,
  0x18, 0x06, 0x07, 0x8E, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF9, 0x83, 0xCE, 0xC3, 0x01, 0xE3, 0x00,
  0x73, 0x00, 0x39, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30,
  0x01, 0x98, 0x00, 0xCC, 0x00, 0x46, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18,
  0xC0, 0x1C, 0x70, 0x16, 0x1C, 0x3B, 0x07, 0xF3, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x38, 0x1F,
  0xF8, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x33, 0xF8, 0x13, 0x9E, 0x1A,
  0x03, 0x8E, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C,
  0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xC6, 0x00,
  0x62, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x02, 0x30,
  0x03, 0x10, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x07, 0x18, 0x01, 0x82, 0x00, 0x70, 0xC0, 0x1C, 0x18, 0x07,
  0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x01, 0x83, 0x80, 0x30, 0x30, 0x06, 0x07, 0x00, 0xC0, 0x60,
  0x30, 0x0E, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x18,
  0x60, 0x03, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x09, 0xE3, 0xE1, 0xA7,
  0x6E, 0x1C, 0x38, 0x31, 0x83, 0x83, 0x18, 0x30, 0x31, 0x83, 0x03, 0x10,
  0x30, 0x23, 0x03, 0x06, 0x30, 0x30, 0x63, 0x02, 0x06, 0x30, 0x60, 0x63,
  0x06, 0x06, 0x30, 0x60, 0x46, 0x06, 0x0C, 0x60, 0x60, 0xC6, 0x06, 0x0C,
  0x60, 0x40, 0xC6, 0x0C, 0x0C, 0x60, 0xC0, 0xC4, 0x0C, 0x18, 0xC0, 0xC1,
  0x80, 0x19, 0xFC, 0x0D, 0xCF, 0x0D, 0x01, 0xC7, 0x00, 0x63, 0x00, 0x31,
  0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0x66, 0x00, 0x63, 0x00, 0x31, 0x00, 0x19, 0x80, 0x0C, 0xC0,
  0x06, 0x60, 0x03, 0x30, 0x01, 0x18, 0x01, 0x88, 0x00, 0xC0, 0x03, 0xFC,
  0x03, 0xDF, 0x03, 0x01, 0xC3, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66,
  0x00, 0x26, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x0C, 0x30, 0x06,
  0x18, 0x06, 0x07, 0x9E, 0x01, 0xFE, 0x00, 0x06, 0x7F, 0x00, 0xDC, 0xF0,
  0x34, 0x07, 0x07, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61,
  0x80, 0x08, 0x30, 0x03, 0x04, 0x00, 0x61, 0x80, 0x0C, 0x38, 0x03, 0x87,
  0x00, 0x60, 0xF0, 0x18, 0x1B, 0x8E, 0x02, 0x3F, 0x80, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x03, 0xF9, 0x83, 0xCE, 0xC3, 0x01, 0xE3, 0x00, 0x73, 0x00,
  0x39, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98,
  0x00, 0xCC, 0x00, 0x46, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C,
  0xC0, 0x0E, 0x30, 0x07, 0x18, 0x07, 0x07, 0x1D, 0x81, 0xFC, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x18, 0xFE, 0x06, 0xF7, 0xC1, 0xE0, 0x38, 0x70, 0x06, 0x18,
  0x01, 0x86, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x07, 0xCF, 0x87, 0x00, 0xC7, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0xC0, 0x06, 0x60, 0x03, 0x38, 0x03, 0x0F, 0x07, 0x83, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x18, 0x01, 0x98,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x08, 0xC0, 0x0C,
  0x40, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00,
  0x63, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x0C, 0x30, 0x06, 0x1C,
  0x06, 0x07, 0x9E, 0x01, 0xFE, 0x00, 0x80, 0x03, 0xE0, 0x01, 0xB0, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0xC2, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x30, 0x60,
  0x30, 0x30, 0x18, 0x08, 0x18, 0x04, 0x0C, 0x03, 0x0C, 0x01, 0x86, 0x00,
  0xC6, 0x00, 0x63, 0x00, 0x13, 0x00, 0x0D, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0x80, 0xC0, 0x70, 0x18, 0x1A, 0x07, 0x03, 0x40, 0xA0,
  0x48, 0x34, 0x19, 0x06, 0x83, 0x20, 0x90, 0x44, 0x32, 0x18, 0x86, 0x43,
  0x10, 0x88, 0x42, 0x31, 0x18, 0x46, 0x23, 0x08, 0x84, 0x41, 0x30, 0x98,
  0x26, 0x1B, 0x04, 0x83, 0x40, 0xB0, 0x78, 0x14, 0x0F, 0x02, 0x81, 0xC0,
  0x70, 0x38, 0x0C, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00,
  0xC0, 0x30, 0x18, 0x03, 0x03, 0x00, 0x18, 0x70, 0x01, 0x86, 0x00, 0x0C,
  0xC0, 0x00, 0xD8, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01,
  0xD8, 0x00, 0x19, 0x80, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x03, 0x07, 0x00, 0x30, 0xE0, 0x01, 0x80, 0x30, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x23, 0x00, 0x31, 0x80, 0x19, 0x80,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x00, 0xCC,
  0x00, 0x66, 0x00, 0x33, 0x00, 0x38, 0xC0, 0x1C, 0x60, 0x1C, 0x1C, 0x36,
  0x07, 0xF3, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x38, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xC0, 0x03, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0x03, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x03, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0xCF,
  0xC0, 0x26, 0x18, 0x19, 0x83, 0x06, 0x40, 0xE1, 0xB0, 0x1F, 0xCC, 0x03,
  0xE0,
};

const GFXglyph JetBrainsMono_ThinItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 28, 23, 8, -28 },
  { 26, 11, 12, 23, 8, -28 },
  { 43, 22, 28, 23, 1, -28 },
  { 120, 19, 38, 23, 2, -33 },
  { 211, 26, 28, 23, -1, -28 },
  { 302, 20, 28, 23, 1, -28 },
  { 372, 4, 12, 23, 11, -28 },
  { 378, 15, 37, 23, 7, -32 },
  { 448, 15, 37, 23, 2, -32 },
  { 518, 20, 19, 23, 2, -23 },
  { 566, 17, 17, 23, 3, -21 },
  { 603, 8, 12, 23, 5, -6 },
  { 615, 12, 1, 23, 6, -13 },
  { 617, 6, 5, 23, 7, -5 },
  { 621, 22, 36, 23, 1, -32 },
  { 720, 18, 28, 23, 3, -28 },
  { 783, 17, 28, 23, 2, -28 },
  { 843, 19, 28, 23, 2, -28 },
  { 910, 18, 28, 23, 3, -28 },
  { 973, 17, 28, 23, 3, -28 },
  { 1033, 18, 28, 23, 3, -28 },
  { 1096, 18, 28, 23, 2, -28 },
  { 1159, 18, 28, 23, 5, -28 },
  { 1222, 19, 28, 23, 2, -28 },
  { 1289, 17, 28, 23, 4, -28 },
  { 1349, 9, 21, 23, 7, -21 },
  { 1373, 11, 27, 23, 5, -21 },
  { 1411, 17, 19, 23, 4, -22 },
  { 1452, 17, 11, 23, 3, -18 },
  { 1476, 18, 19, 23, 2, -22 },
  { 1519, 15, 28, 23, 6, -28 },
  { 1572, 21, 35, 23, 1, -28 },
  { 1664, 18, 28, 23, 1, -28 },
  { 1727, 18, 28, 23, 3, -28 },
  { 1790, 18, 28, 23, 3, -28 },
  { 1853, 18, 28, 23, 3, -28 },
  { 1916, 19, 28, 23, 3, -28 },
  { 1983, 20, 28, 23, 3, -28 },
  { 2053, 18, 28, 23, 3, -28 },
  { 2116, 18, 28, 23, 3, -28 },
  { 2179, 18, 28, 23, 3, -28 },
  { 2242, 19, 28, 23, 2, -28 },
  { 2309, 20, 28, 23, 3, -28 },
  { 2379, 16, 28, 23, 3, -28 },
  { 2435, 20, 28, 23, 2, -28 },
  { 2505, 18, 28, 23, 3, -28 },
  { 2568, 18, 28, 23, 3, -28 },
  { 2631, 19, 28, 23, 3, -28 },
  { 2698, 18, 35, 23, 3, -28 },
  { 2777, 19, 28, 23, 3, -28 },
  { 2844, 19, 28, 23, 2, -28 },
  { 2911, 18, 28, 23, 5, -28 },
  { 2974, 18, 28, 23, 3, -28 },
  { 3037, 18, 28, 23, 5, -28 },
  { 3100, 21, 28, 23, 3, -28 },
  { 3174, 23, 28, 23, 0, -28 },
  { 3255, 19, 28, 23, 5, -28 },
  { 3322, 20, 28, 23, 2, -28 },
  { 3392, 14, 36, 23, 6, -32 },
  { 3455, 10, 36, 23, 7, -32 },
  { 3500, 14, 36, 23, 4, -32 },
  { 3563, 15, 15, 23, 4, -28 },
  { 3592, 19, 2, 23, 0, 1 },
  { 3597, 5, 5, 23, 11, -30 },
  { 3601, 17, 21, 23, 3, -21 },
  { 3646, 17, 28, 23, 3, -28 },
  { 3706, 17, 21, 23, 3, -21 },
  { 3751, 18, 28, 23, 3, -28 },
  { 3814, 17, 21, 23, 3, -21 },
  { 3859, 24, 35, 23, -1, -28 },
  { 3964, 17, 28, 23, 3, -21 },
  { 4024, 17, 28, 23, 3, -28 },
  { 4084, 17, 29, 23, 2, -29 },
  { 4146, 19, 36, 23, 1, -29 },
  { 4232, 19, 28, 23, 3, -28 },
  { 4299, 15, 28, 23, 4, -28 },
  { 4352, 20, 21, 23, 1, -21 },
  { 4405, 17, 21, 23, 3, -21 },
  { 4450, 17, 21, 23, 3, -21 },
  { 4495, 19, 28, 23, 1, -21 },
  { 4562, 17, 28, 23, 3, -21 },
  { 4622, 18, 21, 23, 3, -21 },
  { 4670, 17, 21, 23, 3, -21 },
  { 4715, 17, 27, 23, 4, -27 },
  { 4773, 17, 21, 23, 3, -21 },
  { 4818, 17, 21, 23, 5, -21 },
  { 4863, 19, 21, 23, 4, -21 },
  { 4913, 20, 21, 23, 1, -21 },
  { 4966, 17, 28, 23, 3, -21 },
  { 5026, 18, 21, 23, 2, -21 },
  { 5074, 18, 36, 23, 4, -32 },
  { 5155, 8, 36, 23, 8, -32 },
  { 5191, 19, 36, 23, 1, -32 },
  { 5277, 18, 7, 23, 3, -17 },
};

const GFXfont JetBrainsMono_ThinItalic38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_THINITALIC38PT7B_H_
