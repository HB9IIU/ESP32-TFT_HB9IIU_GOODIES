#ifndef _JETBRAINSMONO_THINITALIC64PT7B_H_
#define _JETBRAINSMONO_THINITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0,
  0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3E, 0xF8, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00,
  0x78, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00,
  0xE3, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3E, 0x38, 0xFC, 0x00, 0x78,
  0x38, 0x3C, 0x00, 0xF0, 0x38, 0x1E, 0x01, 0xE0, 0x30, 0x1E, 0x01, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0x30, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x07, 0x80, 0x60, 0x00, 0x07, 0x80,
  0x60, 0x00, 0x07, 0x80, 0x60, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xF0,
  0xC0, 0x00, 0x00, 0xFC, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0x9F, 0x80, 0x00, 0x01, 0x87, 0xC0, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x70, 0xF0, 0x07, 0x00, 0x70, 0xF0, 0x07, 0x00, 0x70, 0xF0, 0x07,
  0x00, 0xF0, 0xF0, 0x06, 0x00, 0xE0, 0xF0, 0x06, 0x01, 0xE0, 0x70, 0x0E,
  0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x3C, 0x0E, 0x07, 0x80, 0x3E, 0x0E,
  0x1F, 0x00, 0x1F, 0xCC, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x0E, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x00, 0x38,
  0x00, 0x70, 0x0F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0x00, 0x18, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x80, 0x0E, 0x0F, 0x00,
  0x00, 0x1C, 0x01, 0xC1, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x00,
  0x1C, 0x03, 0x83, 0x80, 0x00, 0x01, 0xF9, 0xF0, 0x70, 0x00, 0x00, 0x0F,
  0xFE, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x1E, 0x07, 0x80, 0x00,
  0x01, 0xC1, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x00, 0x07,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x70, 0x03, 0x80, 0x00, 0x78, 0x07, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0xE7, 0xC0, 0x03, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC7, 0x80, 0x70, 0x00, 0xE1,
  0xC0, 0x1E, 0x00, 0x70, 0x70, 0x03, 0xC0, 0x38, 0x3C, 0x00, 0xF0, 0x1E,
  0x0E, 0x00, 0x1E, 0x07, 0x03, 0x80, 0x03, 0x83, 0x80, 0xE0, 0x00, 0xF1,
  0xE0, 0x38, 0x00, 0x1E, 0x70, 0x1E, 0x00, 0x07, 0xB8, 0x07, 0x80, 0x00,
  0xFE, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0x70,
  0x00, 0x1C, 0xE0, 0x1E, 0x00, 0x1E, 0x3C, 0x07, 0x80, 0x0F, 0x87, 0x01,
  0xF0, 0x07, 0x80, 0xE0, 0x3F, 0x0F, 0xC0, 0x3C, 0x07, 0xFF, 0xE0, 0x07,
  0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x7C, 0xF9,
  0xE3, 0xC7, 0x8F, 0x1E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0xF1,
  0xE3, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xCF,
  0x80, 0x38, 0x03, 0xFF, 0xF8, 0x1C, 0x0F, 0xFB, 0xFF, 0x0E, 0x1F, 0xF8,
  0x3F, 0xE6, 0x3F, 0xE0, 0x07, 0xFB, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x0F,
  0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x7F, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0,
  0x38, 0x07, 0x87, 0x80, 0xF8, 0x0F, 0x0F, 0x03, 0xF0, 0x1E, 0x1C, 0x07,
  0xE0, 0x38, 0x38, 0x0F, 0xC0, 0x70, 0x70, 0x0F, 0x81, 0xE1, 0xE0, 0x0C,
  0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E,
  0xE0, 0x00, 0x07, 0xCE, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3E, 0x1C, 0x00,
  0x0F, 0x81, 0xC0, 0x01, 0xF0, 0x1C, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0x80,
  0x1C, 0x00, 0x20, 0x03, 0xC0, 0x04, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x08, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0xE0, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x1C, 0x78, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xC7,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x01, 0xF0, 0x00, 0x38, 0x3F, 0xF8, 0x00, 0xE3, 0xFF, 0xF0,
  0x03, 0x9E, 0x07, 0xE0, 0x0E, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x38, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC7,
  0xF8, 0x00, 0x1C, 0xFF, 0xF0, 0x01, 0xDF, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F,
  0x00, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x78, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x70, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x00, 0xFF,
  0x1F, 0xF0, 0x01, 0xFF, 0xF3, 0x80, 0x07, 0xFE, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x3F, 0x81, 0xFE, 0x07,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x18, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0xF0, 0xE0, 0xE0, 0x01, 0xFF, 0xCE, 0x0E, 0x00,
  0x7F, 0xFC, 0xE0, 0xE0, 0x07, 0xC0, 0xFC, 0x0E, 0x00, 0xF0, 0x07, 0xC1,
  0xE0, 0x1E, 0x00, 0x3C, 0x1C, 0x01, 0xC0, 0x03, 0xC1, 0xC0, 0x1C, 0x00,
  0x3C, 0x1C, 0x03, 0xC0, 0x03, 0xC1, 0xC0, 0x38, 0x00, 0x38, 0x1C, 0x03,
  0x80, 0x03, 0x83, 0xC0, 0x38, 0x00, 0x38, 0x38, 0x03, 0x80, 0x03, 0x83,
  0x80, 0x38, 0x00, 0x38, 0x38, 0x07, 0x80, 0x07, 0x83, 0x80, 0x78, 0x00,
  0x78, 0x38, 0x07, 0x00, 0x07, 0x07, 0x80, 0x70, 0x00, 0x70, 0x78, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x70, 0x07, 0x00, 0x0F, 0x07,
  0x00, 0x70, 0x00, 0xF0, 0x70, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x7C, 0x03,
  0xE0, 0xF0, 0x03, 0xFB, 0xEE, 0x0E, 0x00, 0x3F, 0xFC, 0xE0, 0xE0, 0x00,
  0xFF, 0x8E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x07,
  0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x0E, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xC0,
  0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x7F, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x7C, 0x03,
  0x80, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x7F, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x70, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xF0, 0x03, 0x80, 0x0F, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0xF0,
  0x78, 0x07, 0xFF, 0xE0, 0xE0, 0x0F, 0xFF, 0xC1, 0xC0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07,
  0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x37, 0x01, 0xD8, 0x00, 0x1D, 0x80, 0x76, 0x00, 0x06, 0xE0, 0x39,
  0x80, 0x03, 0xB8, 0x0E, 0x70, 0x01, 0xCE, 0x03, 0x9C, 0x00, 0x73, 0x80,
  0xE3, 0x00, 0x38, 0xE0, 0x38, 0xC0, 0x0E, 0x78, 0x0E, 0x30, 0x07, 0x1C,
  0x03, 0x8E, 0x01, 0xC7, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0x60, 0x30,
  0x70, 0x1C, 0x18, 0x1C, 0x1C, 0x07, 0x06, 0x06, 0x0F, 0x01, 0xC1, 0xC3,
  0x83, 0x80, 0x70, 0x70, 0xC0, 0xE0, 0x3C, 0x0C, 0x70, 0x38, 0x0E, 0x03,
  0x18, 0x0E, 0x03, 0x80, 0xCE, 0x03, 0x80, 0xE0, 0x3B, 0x01, 0xE0, 0x38,
  0x0F, 0xC0, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x07, 0x80, 0x78, 0x07, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x01, 0xF0, 0x00,
  0x07, 0x01, 0xF0, 0x00, 0x07, 0x01, 0xF8, 0x00, 0x0E, 0x01, 0xF8, 0x00,
  0x0E, 0x01, 0xF8, 0x00, 0x0E, 0x01, 0xD8, 0x00, 0x0E, 0x03, 0xDC, 0x00,
  0x0E, 0x03, 0x9C, 0x00, 0x0E, 0x03, 0x9C, 0x00, 0x1E, 0x03, 0x8C, 0x00,
  0x1C, 0x03, 0x8E, 0x00, 0x1C, 0x03, 0x8E, 0x00, 0x1C, 0x03, 0x8E, 0x00,
  0x1C, 0x07, 0x06, 0x00, 0x1C, 0x07, 0x07, 0x00, 0x3C, 0x07, 0x07, 0x00,
  0x38, 0x07, 0x07, 0x00, 0x38, 0x07, 0x07, 0x00, 0x38, 0x07, 0x03, 0x80,
  0x38, 0x0F, 0x03, 0x80, 0x38, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x70, 0x1E, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0xC0, 0x70, 0x1C, 0x00, 0xE0,
  0xF0, 0x1C, 0x00, 0xE0, 0xE0, 0x1C, 0x00, 0xE0, 0xE0, 0x1C, 0x00, 0x60,
  0xE0, 0x1C, 0x00, 0x70, 0xE0, 0x38, 0x00, 0x70, 0xE0, 0x38, 0x00, 0x71,
  0xE0, 0x38, 0x00, 0x71, 0xC0, 0x38, 0x00, 0x39, 0xC0, 0x38, 0x00, 0x39,
  0xC0, 0x38, 0x00, 0x39, 0xC0, 0x78, 0x00, 0x39, 0xC0, 0x70, 0x00, 0x1D,
  0xC0, 0x70, 0x00, 0x1D, 0x80, 0x70, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x1F,
  0x80, 0x70, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x38, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x03, 0xE0, 0x0E, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x0F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x38, 0x00,
  0x3F, 0x80, 0x1C, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3C, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x07, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x70, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE7, 0x00, 0x1F,
  0x00, 0x1C, 0xE0, 0x03, 0xE0, 0x03, 0x9C, 0x00, 0x6C, 0x00, 0xF3, 0x80,
  0x0D, 0x80, 0x1C, 0x70, 0x03, 0xF0, 0x03, 0x8E, 0x00, 0x6E, 0x00, 0x71,
  0xC0, 0x0D, 0xC0, 0x1C, 0x38, 0x03, 0xB8, 0x03, 0x87, 0x00, 0x77, 0x00,
  0x70, 0xE0, 0x0C, 0xE0, 0x1E, 0x1C, 0x03, 0x9C, 0x03, 0x83, 0x80, 0x73,
  0x80, 0x70, 0x70, 0x0C, 0x70, 0x0E, 0x0E, 0x01, 0x8E, 0x03, 0x81, 0x80,
  0x71, 0xC0, 0x70, 0x30, 0x0C, 0x38, 0x0E, 0x06, 0x01, 0x87, 0x01, 0xC0,
  0xC0, 0x70, 0xE0, 0x70, 0x38, 0x0E, 0x1C, 0x0E, 0x07, 0x01, 0x83, 0x01,
  0xC0, 0xE0, 0x70, 0x60, 0x70, 0x1C, 0x0E, 0x0C, 0x0E, 0x03, 0x81, 0x81,
  0x81, 0xC0, 0x70, 0x30, 0x30, 0x38, 0x0E, 0x0E, 0x06, 0x0E, 0x01, 0xC1,
  0x80, 0xC1, 0xC0, 0x38, 0x30, 0x18, 0x38, 0x07, 0x0E, 0x03, 0x06, 0x00,
  0xE1, 0x80, 0x61, 0xC0, 0x1C, 0x30, 0x0C, 0x38, 0x03, 0x8E, 0x01, 0x87,
  0x00, 0x71, 0x80, 0x31, 0xC0, 0x0E, 0x30, 0x06, 0x38, 0x01, 0xCE, 0x00,
  0xC7, 0x00, 0x39, 0xC0, 0x18, 0xC0, 0x07, 0x30, 0x03, 0x38, 0x00, 0xE6,
  0x00, 0x67, 0x00, 0x1D, 0xC0, 0x0C, 0xE0, 0x03, 0xB0, 0x01, 0xB8, 0x00,
  0x76, 0x00, 0x37, 0x00, 0x0F, 0xC0, 0x06, 0xE0, 0x01, 0xF0, 0x00, 0xD8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x06, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83,
  0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0x80,
  0xF0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x3C, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF,
  0xE1, 0xC0, 0x1F, 0xFF, 0x8E, 0x03, 0xF0, 0x1E, 0xF0, 0x3E, 0x00, 0x3F,
  0x81, 0xC0, 0x00, 0xF8, 0x1C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x07, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x77, 0x00, 0xFC, 0x0F, 0x38, 0x03, 0xFF, 0xF1,
  0xC0, 0x0F, 0xFE, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x01, 0xF8, 0x00, 0x38, 0x7F, 0xF0, 0x01, 0xCF, 0xFF, 0xE0,
  0x1E, 0xF0, 0x1F, 0x80, 0xEE, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0xF0, 0x3E,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0x7C, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x38, 0x1F, 0x80, 0x03, 0xC0, 0xEE, 0x00, 0x7C,
  0x07, 0x3C, 0x0F, 0xC0, 0x79, 0xFF, 0xF8, 0x03, 0xC3, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x1E, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x3E,
  0x00, 0x7C, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x3F, 0x01, 0xC0, 0x03, 0xFF, 0xC3, 0x80, 0x0F, 0xFF, 0xC7,
  0x00, 0x7E, 0x03, 0xDE, 0x01, 0xF0, 0x01, 0xFC, 0x03, 0x80, 0x01, 0xF0,
  0x0E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E,
  0x00, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xB8, 0x01, 0xF8, 0x1E, 0x70,
  0x01, 0xFF, 0xF8, 0xE0, 0x01, 0xFF, 0xC3, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0x80, 0xFC, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x3F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x70, 0x78, 0x00, 0x0F,
  0x03, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x3F, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xE1,
  0xC0, 0x1F, 0xFF, 0x8E, 0x03, 0xF0, 0x1E, 0xF0, 0x3E, 0x00, 0x37, 0x81,
  0xC0, 0x00, 0xF8, 0x1C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1F, 0x03, 0xC0,
  0x01, 0xB8, 0x0F, 0x00, 0x3B, 0xC0, 0x7F, 0x0F, 0x9C, 0x00, 0xFF, 0xF8,
  0xE0, 0x03, 0xFF, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x01, 0xF8, 0x00, 0x38, 0x7F, 0xF0, 0x01, 0xCF,
  0xFF, 0xE0, 0x1E, 0xF0, 0x1F, 0x80, 0xEE, 0x00, 0x3C, 0x07, 0x60, 0x00,
  0xF0, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x03, 0xC0,
  0x07, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xE0,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x7C, 0x00, 0xE7, 0xF8, 0x7F, 0x80,
  0x33, 0xFF, 0x3F, 0xF0, 0x1D, 0x83, 0xC8, 0x3E, 0x07, 0xC0, 0x74, 0x07,
  0x81, 0xE0, 0x1D, 0x00, 0xE0, 0x70, 0x07, 0x80, 0x38, 0x1C, 0x01, 0xE0,
  0x0E, 0x07, 0x00, 0x70, 0x03, 0x83, 0xC0, 0x1C, 0x00, 0xE0, 0xE0, 0x07,
  0x00, 0x78, 0x38, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x07, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0x70, 0x78, 0x03, 0x80, 0x1C, 0x1C,
  0x00, 0xE0, 0x0F, 0x07, 0x00, 0x38, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0xE0,
  0x70, 0x07, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x70, 0x03,
  0x83, 0xC0, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x78, 0x38, 0x01, 0xC0,
  0x1C, 0x0E, 0x00, 0xF0, 0x07, 0x03, 0x80, 0x38, 0x01, 0xC0, 0xE0, 0x0E,
  0x00, 0x70, 0x78, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x0F, 0x07, 0x00,
  0x38, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x00, 0x38, 0x1C,
  0x01, 0xC0, 0x0E, 0x0F, 0x00, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x01, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x1C, 0x3F, 0xF8, 0x00, 0xE7, 0xFF, 0xF0, 0x0F,
  0x78, 0x0F, 0xC0, 0x77, 0x00, 0x1E, 0x03, 0xB0, 0x00, 0x78, 0x1F, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x80,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0,
  0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x03,
  0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xC3, 0xFF, 0x80, 0x03, 0x9F, 0xFF, 0xC0, 0x0F, 0x78, 0x0F,
  0xC0, 0x1D, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x0E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x70, 0x0F, 0xC0, 0x01,
  0xE0, 0x1D, 0xC0, 0x0F, 0x80, 0x39, 0xE0, 0x7E, 0x00, 0xF3, 0xFF, 0xF0,
  0x01, 0xE1, 0xFF, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xE1, 0xC0, 0x1F,
  0xFF, 0x8E, 0x03, 0xF0, 0x1E, 0xF0, 0x3E, 0x00, 0x3F, 0x81, 0xC0, 0x00,
  0xF8, 0x1C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x07, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x77, 0x00, 0xFC, 0x0F, 0x38, 0x03, 0xFF, 0xF1, 0xC0, 0x0F, 0xFE,
  0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x0E, 0x1F, 0xFE, 0x00, 0x39, 0xFF, 0xFC, 0x01, 0xEF, 0x01, 0xF8,
  0x07, 0xF0, 0x01, 0xF0, 0x1D, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x0F, 0x80, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x78, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xE8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1E, 0x03, 0x80,
  0x01, 0xC0, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x1C,
  0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x0E, 0xE0, 0x07, 0xC0, 0x0E, 0xE0,
  0x06, 0xC0, 0x0E, 0xE0, 0x06, 0xC0, 0x1C, 0xE0, 0x0E, 0xC0, 0x1C, 0xE0,
  0x0C, 0xC0, 0x1C, 0xE0, 0x0C, 0xC0, 0x38, 0xE0, 0x1C, 0xC0, 0x38, 0xE0,
  0x18, 0xC0, 0x38, 0xE0, 0x38, 0xC0, 0x70, 0xE0, 0x38, 0xC0, 0x70, 0xE0,
  0x30, 0xC0, 0x70, 0xE0, 0x70, 0xC0, 0xE0, 0xE0, 0x70, 0xC0, 0xE0, 0xE0,
  0x60, 0xC0, 0xE0, 0xE0, 0xE0, 0xC1, 0xC0, 0xE0, 0xE0, 0xC1, 0xC0, 0xE0,
  0xC0, 0xC1, 0xC0, 0xE1, 0xC0, 0xC3, 0x80, 0xE1, 0xC0, 0xC3, 0x80, 0xE1,
  0x80, 0xC3, 0x80, 0xE3, 0x80, 0xC7, 0x00, 0xE3, 0x80, 0xC7, 0x00, 0xE3,
  0x00, 0xC7, 0x00, 0xE7, 0x00, 0xE7, 0x00, 0xE6, 0x00, 0xEE, 0x00, 0xE6,
  0x00, 0xEE, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0xEC, 0x00, 0xFC, 0x00, 0xEC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x7C, 0x1E, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x6E, 0x03, 0xE0, 0x07, 0x70, 0x0F, 0xE1, 0xF3,
  0x80, 0x3F, 0xFE, 0x1C, 0x00, 0x7F, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1C, 0x3F,
  0xF0, 0x00, 0xE1, 0xE3, 0xE0, 0x03, 0x8E, 0x03, 0x80, 0x0E, 0x38, 0x07,
  0x00, 0x39, 0xC0, 0x1E, 0x00, 0xE7, 0x00, 0x3C, 0x07, 0x1C, 0x00, 0x78,
  0x1C, 0x70, 0x01, 0xF9, 0xE1, 0xC0, 0x03, 0xFF, 0x0E, 0x00, 0x03, 0xF8,
  0x00,
};

const GFXglyph JetBrainsMono_ThinItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 13, 47, 38, 13, -47 },
  { 78, 19, 19, 38, 13, -47 },
  { 124, 37, 47, 38, 2, -47 },
  { 342, 32, 65, 38, 4, -56 },
  { 602, 44, 47, 38, -2, -47 },
  { 861, 34, 48, 38, 2, -47 },
  { 1065, 7, 19, 38, 19, -47 },
  { 1082, 26, 62, 38, 11, -54 },
  { 1284, 25, 62, 38, 3, -54 },
  { 1478, 33, 32, 38, 4, -39 },
  { 1610, 29, 30, 38, 5, -36 },
  { 1719, 14, 20, 38, 8, -10 },
  { 1754, 21, 3, 38, 9, -23 },
  { 1762, 10, 10, 38, 12, -9 },
  { 1775, 36, 60, 38, 2, -53 },
  { 2045, 31, 48, 38, 5, -47 },
  { 2231, 28, 47, 38, 4, -47 },
  { 2396, 33, 47, 38, 3, -47 },
  { 2590, 31, 48, 38, 4, -47 },
  { 2776, 28, 47, 38, 5, -47 },
  { 2941, 30, 48, 38, 5, -47 },
  { 3121, 29, 48, 38, 4, -47 },
  { 3295, 30, 47, 38, 8, -47 },
  { 3472, 32, 48, 38, 4, -47 },
  { 3664, 29, 47, 38, 7, -47 },
  { 3835, 14, 37, 38, 12, -36 },
  { 3900, 19, 46, 38, 8, -36 },
  { 4010, 30, 32, 38, 6, -37 },
  { 4130, 29, 18, 38, 5, -30 },
  { 4196, 29, 32, 38, 4, -37 },
  { 4312, 24, 47, 38, 11, -47 },
  { 4453, 36, 58, 38, 2, -47 },
  { 4714, 29, 47, 38, 2, -47 },
  { 4885, 31, 47, 38, 4, -47 },
  { 5068, 31, 48, 38, 5, -47 },
  { 5254, 31, 47, 38, 4, -47 },
  { 5437, 32, 47, 38, 5, -47 },
  { 5625, 33, 47, 38, 5, -47 },
  { 5819, 31, 48, 38, 5, -47 },
  { 6005, 32, 47, 38, 4, -47 },
  { 6193, 30, 47, 38, 5, -47 },
  { 6370, 32, 48, 38, 3, -47 },
  { 6562, 35, 47, 38, 4, -47 },
  { 6768, 26, 47, 38, 5, -47 },
  { 6921, 34, 47, 38, 3, -47 },
  { 7121, 32, 47, 38, 4, -47 },
  { 7309, 30, 48, 38, 5, -47 },
  { 7489, 33, 47, 38, 4, -47 },
  { 7683, 30, 59, 38, 5, -47 },
  { 7905, 33, 47, 38, 4, -47 },
  { 8099, 32, 48, 38, 4, -47 },
  { 8291, 31, 47, 38, 8, -47 },
  { 8474, 31, 48, 38, 5, -47 },
  { 8660, 30, 47, 38, 9, -47 },
  { 8837, 35, 47, 38, 5, -47 },
  { 9043, 38, 47, 38, 1, -47 },
  { 9267, 32, 47, 38, 8, -47 },
  { 9455, 33, 47, 38, 3, -47 },
  { 9649, 24, 60, 38, 10, -53 },
  { 9829, 16, 60, 38, 12, -53 },
  { 9949, 24, 60, 38, 6, -53 },
  { 10129, 26, 25, 38, 7, -47 },
  { 10211, 31, 2, 38, 0, 2 },
  { 10219, 9, 9, 38, 18, -50 },
  { 10230, 29, 37, 38, 5, -36 },
  { 10365, 29, 48, 38, 4, -47 },
  { 10539, 29, 37, 38, 5, -36 },
  { 10674, 31, 48, 38, 5, -47 },
  { 10860, 28, 37, 38, 5, -36 },
  { 10990, 40, 59, 38, -2, -47 },
  { 11285, 29, 48, 38, 5, -36 },
  { 11459, 29, 47, 38, 4, -47 },
  { 11630, 29, 49, 38, 3, -49 },
  { 11808, 32, 61, 38, 1, -49 },
  { 12052, 32, 47, 38, 4, -47 },
  { 12240, 25, 47, 38, 7, -47 },
  { 12387, 34, 36, 38, 2, -36 },
  { 12540, 29, 36, 38, 4, -36 },
  { 12671, 28, 37, 38, 5, -36 },
  { 12801, 31, 48, 38, 2, -36 },
  { 12987, 29, 48, 38, 5, -36 },
  { 13161, 30, 36, 38, 5, -36 },
  { 13296, 30, 37, 38, 4, -36 },
  { 13435, 28, 45, 38, 7, -45 },
  { 13593, 29, 36, 38, 5, -35 },
  { 13724, 28, 35, 38, 8, -35 },
  { 13847, 32, 35, 38, 6, -35 },
  { 13987, 34, 35, 38, 2, -35 },
  { 14136, 29, 47, 38, 5, -35 },
  { 14307, 30, 35, 38, 4, -35 },
  { 14439, 31, 60, 38, 7, -53 },
  { 14672, 12, 60, 38, 14, -53 },
  { 14762, 31, 60, 38, 2, -53 },
  { 14995, 30, 11, 38, 5, -28 },
};

const GFXfont JetBrainsMono_ThinItalic64pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic64pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _JETBRAINSMONO_THINITALIC64PT7B_H_
