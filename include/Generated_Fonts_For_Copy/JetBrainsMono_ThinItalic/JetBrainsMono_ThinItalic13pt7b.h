#ifndef _JETBRAINSMONO_THINITALIC13PT7B_H_
#define _JETBRAINSMONO_THINITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x60, 0x80, 0xBA, 0xA0, 0x1B, 0x12, 0x7F, 0x24, 0x24, 0xB6,
  0x48, 0x48, 0x48, 0x08, 0xE5, 0x55, 0x51, 0xC1, 0x89, 0x26, 0xAF, 0x08,
  0x20, 0x30, 0x49, 0x4A, 0x54, 0x68, 0x10, 0x1E, 0x2A, 0x4A, 0x8E, 0x0C,
  0x64, 0x89, 0x02, 0x0A, 0x52, 0xC2, 0x8C, 0xE4, 0xE0, 0x08, 0x88, 0x84,
  0x21, 0x10, 0x84, 0x10, 0xC1, 0x00, 0x20, 0x82, 0x10, 0x84, 0x42, 0x10,
  0x88, 0x88, 0x00, 0x10, 0x23, 0x59, 0xC3, 0x09, 0x22, 0x00, 0x10, 0x4F,
  0xC8, 0x20, 0x80, 0x5A, 0xF0, 0x70, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x40, 0xC0, 0x19, 0x94, 0x51, 0x86, 0xD8, 0x61,
  0x89, 0xC0, 0x3A, 0x84, 0x21, 0x08, 0x44, 0xF8, 0x39, 0x14, 0x41, 0x04,
  0x21, 0x08, 0x43, 0xE0, 0x7C, 0x21, 0x0E, 0x08, 0x10, 0xA2, 0xF0, 0x0C,
  0x41, 0x08, 0x46, 0x2F, 0x82, 0x08, 0x7D, 0x04, 0x1E, 0x84, 0x10, 0xA2,
  0x70, 0x18, 0x42, 0x1E, 0x46, 0x18, 0x62, 0x70, 0xFE, 0x20, 0x84, 0x20,
  0x84, 0x10, 0x80, 0x19, 0x94, 0x51, 0x29, 0xC8, 0xA1, 0x8B, 0xC0, 0x19,
  0x94, 0x61, 0x85, 0xE0, 0x84, 0x21, 0x00, 0x64, 0x00, 0xB0, 0x64, 0x00,
  0x94, 0x80, 0x04, 0x23, 0x30, 0x60, 0x40, 0x80, 0x7C, 0x0F, 0x80, 0x81,
  0x81, 0x03, 0x19, 0x88, 0x00, 0x78, 0x42, 0x36, 0x20, 0x00, 0xC0, 0x0C,
  0x32, 0x21, 0x45, 0x4A, 0x52, 0x52, 0x92, 0x9E, 0x80, 0x80, 0x70, 0x08,
  0x51, 0x45, 0x24, 0xF4, 0x51, 0x84, 0x7D, 0x14, 0x52, 0xBA, 0x18, 0x62,
  0xF0, 0x19, 0x94, 0x50, 0x82, 0x08, 0x21, 0x89, 0xC0, 0x7D, 0x14, 0x51,
  0x86, 0x18, 0xA2, 0xF0, 0x7E, 0x81, 0x02, 0x07, 0x90, 0x20, 0x40, 0xF8,
  0x7E, 0x81, 0x02, 0x0F, 0xD0, 0x20, 0x40, 0x80, 0x19, 0x94, 0x50, 0x82,
  0x78, 0x61, 0x89, 0xC0, 0x45, 0x14, 0x51, 0xBE, 0x18, 0xA2, 0x88, 0x7C,
  0x41, 0x04, 0x10, 0x42, 0x08, 0x23, 0xE0, 0x1C, 0x10, 0x41, 0x04, 0x28,
  0xA2, 0xF0, 0x42, 0x89, 0x12, 0x45, 0x16, 0x24, 0x44, 0x89, 0x10, 0x42,
  0x10, 0x84, 0x42, 0x10, 0xF8, 0x46, 0x9A, 0xB5, 0xA9, 0x50, 0xA1, 0x44,
  0x88, 0x45, 0x96, 0x59, 0x96, 0x59, 0xA2, 0x88, 0x19, 0x94, 0x51, 0x86,
  0x18, 0x62, 0x89, 0xC0, 0x7C, 0x85, 0x0A, 0x27, 0x90, 0x20, 0x40, 0x80,
  0x19, 0x94, 0x51, 0x86, 0x18, 0x62, 0x89, 0xC1, 0x06, 0x7D, 0x14, 0x51,
  0x7A, 0x48, 0xA2, 0x88, 0x39, 0x14, 0x50, 0x60, 0x60, 0x41, 0x8B, 0xC0,
  0xFC, 0x82, 0x08, 0x21, 0x04, 0x10, 0x40, 0x45, 0x14, 0x51, 0x86, 0x18,
  0xA2, 0x70, 0x86, 0x28, 0xA4, 0x92, 0x8A, 0x10, 0x40, 0x93, 0x26, 0xCD,
  0xAB, 0x5A, 0xB6, 0x44, 0x88, 0x23, 0x22, 0x14, 0x08, 0x18, 0x18, 0x24,
  0x44, 0x86, 0x86, 0x29, 0x14, 0x61, 0x04, 0x10, 0x40, 0x7C, 0x20, 0x84,
  0x20, 0x84, 0x20, 0xF8, 0x39, 0x10, 0x84, 0x21, 0x08, 0x44, 0x21, 0xC0,
  0x88, 0x44, 0x44, 0x22, 0x22, 0x21, 0x38, 0x42, 0x10, 0x88, 0x42, 0x10,
  0x85, 0xC0, 0x10, 0xA2, 0x92, 0x84, 0xFC, 0x90, 0x7D, 0x18, 0x61, 0x8A,
  0x27, 0x80, 0x41, 0x07, 0x91, 0x86, 0x18, 0xA2, 0xF0, 0x79, 0x18, 0x20,
  0x82, 0x27, 0x00, 0x04, 0x17, 0xD1, 0x86, 0x18, 0xA2, 0x78, 0x79, 0x18,
  0x7E, 0x82, 0x27, 0x00, 0x0F, 0x08, 0x7E, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0xE0, 0x7D, 0x18, 0x61, 0x8A, 0x66, 0x82, 0xF0, 0x41, 0x07,
  0x91, 0x86, 0x18, 0xA2, 0x88, 0x18, 0x00, 0xE1, 0x08, 0x44, 0x27, 0xC0,
  0x06, 0x00, 0x01, 0xE0, 0x40, 0x81, 0x02, 0x08, 0x10, 0x27, 0x80, 0x41,
  0x04, 0x52, 0x93, 0x89, 0x22, 0x88, 0xF0, 0x82, 0x08, 0x20, 0x82, 0x10,
  0x3C, 0x7E, 0x95, 0x2A, 0x95, 0x2A, 0x65, 0x00, 0x79, 0x18, 0x61, 0x8A,
  0x28, 0x80, 0x79, 0x18, 0x61, 0x8A, 0x27, 0x00, 0x3C, 0x45, 0x0A, 0x14,
  0x48, 0x9E, 0x20, 0x80, 0x7D, 0x18, 0x61, 0x8A, 0x27, 0x82, 0x08, 0x7D,
  0x14, 0x60, 0x82, 0x08, 0x00, 0x7D, 0x04, 0x0E, 0x0A, 0x2F, 0x80, 0x10,
  0x8F, 0xC8, 0x20, 0x82, 0x10, 0x38, 0x45, 0x18, 0x61, 0x8A, 0x27, 0x00,
  0x8C, 0x65, 0x2A, 0x51, 0x00, 0x93, 0x2A, 0xD5, 0xAD, 0x9B, 0x26, 0x00,
  0x22, 0x48, 0x60, 0x82, 0x84, 0xB1, 0x00, 0x46, 0x18, 0x62, 0x8A, 0x66,
  0x82, 0xF0, 0x7C, 0x21, 0x08, 0x41, 0x0F, 0x80, 0x06, 0x10, 0x40, 0x81,
  0x02, 0x38, 0x08, 0x10, 0x40, 0x81, 0xC0, 0x55, 0x56, 0xAA, 0x30, 0x10,
  0x20, 0x41, 0x02, 0x03, 0x88, 0x10, 0x20, 0x47, 0x00, 0x66, 0x58, 0x80,
};

const GFXglyph JetBrainsMono_ThinItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 3, 8, 3, -9 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 6, 13, 8, 1, -11 },
  { 25, 8, 10, 8, 0, -10 },
  { 35, 7, 10, 8, 0, -10 },
  { 44, 1, 3, 8, 4, -9 },
  { 45, 5, 13, 8, 2, -11 },
  { 54, 5, 13, 8, 1, -11 },
  { 63, 7, 7, 8, 1, -8 },
  { 70, 6, 6, 8, 1, -7 },
  { 75, 2, 4, 8, 2, -2 },
  { 76, 4, 1, 8, 2, -5 },
  { 77, 2, 2, 8, 2, -2 },
  { 78, 8, 12, 8, 0, -11 },
  { 90, 6, 10, 8, 1, -10 },
  { 98, 5, 9, 8, 1, -9 },
  { 104, 6, 10, 8, 1, -10 },
  { 112, 6, 9, 8, 1, -9 },
  { 119, 6, 9, 8, 1, -9 },
  { 126, 6, 9, 8, 1, -9 },
  { 133, 6, 9, 8, 1, -9 },
  { 140, 6, 9, 8, 2, -9 },
  { 147, 6, 10, 8, 1, -10 },
  { 155, 6, 10, 8, 1, -10 },
  { 163, 3, 7, 8, 2, -7 },
  { 166, 3, 9, 8, 2, -7 },
  { 170, 6, 7, 8, 1, -8 },
  { 176, 6, 3, 8, 1, -6 },
  { 179, 6, 7, 8, 1, -8 },
  { 185, 5, 9, 8, 2, -9 },
  { 191, 8, 12, 8, 0, -10 },
  { 203, 6, 9, 8, 0, -9 },
  { 210, 6, 9, 8, 1, -9 },
  { 217, 6, 10, 8, 1, -10 },
  { 225, 6, 9, 8, 1, -9 },
  { 232, 7, 9, 8, 1, -9 },
  { 240, 7, 9, 8, 1, -9 },
  { 248, 6, 10, 8, 1, -10 },
  { 256, 6, 9, 8, 1, -9 },
  { 263, 6, 10, 8, 1, -10 },
  { 271, 6, 9, 8, 1, -9 },
  { 278, 7, 10, 8, 1, -10 },
  { 287, 5, 9, 8, 1, -9 },
  { 293, 7, 9, 8, 1, -9 },
  { 301, 6, 9, 8, 1, -9 },
  { 308, 6, 10, 8, 1, -10 },
  { 316, 7, 9, 8, 1, -9 },
  { 324, 6, 12, 8, 1, -10 },
  { 333, 6, 9, 8, 1, -9 },
  { 340, 6, 10, 8, 1, -10 },
  { 348, 6, 9, 8, 2, -9 },
  { 355, 6, 9, 8, 1, -9 },
  { 362, 6, 9, 8, 2, -9 },
  { 369, 7, 9, 8, 1, -9 },
  { 377, 8, 9, 8, 0, -9 },
  { 386, 6, 9, 8, 2, -9 },
  { 393, 6, 9, 8, 1, -9 },
  { 400, 5, 12, 8, 2, -11 },
  { 408, 4, 12, 8, 2, -11 },
  { 414, 5, 12, 8, 1, -11 },
  { 422, 6, 5, 8, 1, -9 },
  { 426, 6, 1, 8, 0, 0 },
  { 427, 2, 2, 8, 4, -10 },
  { 428, 6, 7, 8, 1, -7 },
  { 434, 6, 9, 8, 1, -9 },
  { 441, 6, 7, 8, 1, -7 },
  { 447, 6, 9, 8, 1, -9 },
  { 454, 6, 7, 8, 1, -7 },
  { 460, 8, 11, 8, 0, -9 },
  { 471, 6, 9, 8, 1, -7 },
  { 478, 6, 9, 8, 1, -9 },
  { 485, 5, 10, 8, 1, -10 },
  { 492, 7, 12, 8, 0, -10 },
  { 503, 6, 9, 8, 1, -9 },
  { 510, 6, 9, 8, 1, -9 },
  { 517, 7, 7, 8, 0, -7 },
  { 524, 6, 7, 8, 1, -7 },
  { 530, 6, 7, 8, 1, -7 },
  { 536, 7, 9, 8, 0, -7 },
  { 544, 6, 9, 8, 1, -7 },
  { 551, 6, 7, 8, 1, -7 },
  { 557, 6, 7, 8, 1, -7 },
  { 563, 6, 9, 8, 1, -9 },
  { 570, 6, 7, 8, 1, -7 },
  { 576, 5, 7, 8, 2, -7 },
  { 581, 7, 7, 8, 1, -7 },
  { 588, 7, 7, 8, 0, -7 },
  { 595, 6, 9, 8, 1, -7 },
  { 602, 6, 7, 8, 1, -7 },
  { 608, 7, 12, 8, 1, -11 },
  { 619, 2, 12, 8, 3, -11 },
  { 622, 7, 12, 8, 0, -11 },
  { 633, 6, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_ThinItalic13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_THINITALIC13PT7B_H_
