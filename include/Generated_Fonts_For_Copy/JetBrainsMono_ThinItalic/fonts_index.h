#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &JetBrainsMono_ThinItalic6pt7b, 6, "JetBrainsMono_ThinItalic6pt7b" },
  { &JetBrainsMono_ThinItalic7pt7b, 7, "JetBrainsMono_ThinItalic7pt7b" },
  { &JetBrainsMono_ThinItalic8pt7b, 8, "JetBrainsMono_ThinItalic8pt7b" },
  { &JetBrainsMono_ThinItalic9pt7b, 9, "JetBrainsMono_ThinItalic9pt7b" },
  { &JetBrainsMono_ThinItalic10pt7b, 10, "JetBrainsMono_ThinItalic10pt7b" },
  { &JetBrainsMono_ThinItalic11pt7b, 11, "JetBrainsMono_ThinItalic11pt7b" },
  { &JetBrainsMono_ThinItalic12pt7b, 12, "JetBrainsMono_ThinItalic12pt7b" },
  { &JetBrainsMono_ThinItalic13pt7b, 13, "JetBrainsMono_ThinItalic13pt7b" },
  { &JetBrainsMono_ThinItalic14pt7b, 14, "JetBrainsMono_ThinItalic14pt7b" },
  { &JetBrainsMono_ThinItalic15pt7b, 15, "JetBrainsMono_ThinItalic15pt7b" },
  { &JetBrainsMono_ThinItalic16pt7b, 16, "JetBrainsMono_ThinItalic16pt7b" },
  { &JetBrainsMono_ThinItalic17pt7b, 17, "JetBrainsMono_ThinItalic17pt7b" },
  { &JetBrainsMono_ThinItalic18pt7b, 18, "JetBrainsMono_ThinItalic18pt7b" },
  { &JetBrainsMono_ThinItalic19pt7b, 19, "JetBrainsMono_ThinItalic19pt7b" },
  { &JetBrainsMono_ThinItalic20pt7b, 20, "JetBrainsMono_ThinItalic20pt7b" },
  { &JetBrainsMono_ThinItalic21pt7b, 21, "JetBrainsMono_ThinItalic21pt7b" },
  { &JetBrainsMono_ThinItalic22pt7b, 22, "JetBrainsMono_ThinItalic22pt7b" },
  { &JetBrainsMono_ThinItalic23pt7b, 23, "JetBrainsMono_ThinItalic23pt7b" },
  { &JetBrainsMono_ThinItalic24pt7b, 24, "JetBrainsMono_ThinItalic24pt7b" },
  { &JetBrainsMono_ThinItalic25pt7b, 25, "JetBrainsMono_ThinItalic25pt7b" },
  { &JetBrainsMono_ThinItalic26pt7b, 26, "JetBrainsMono_ThinItalic26pt7b" },
  { &JetBrainsMono_ThinItalic27pt7b, 27, "JetBrainsMono_ThinItalic27pt7b" },
  { &JetBrainsMono_ThinItalic28pt7b, 28, "JetBrainsMono_ThinItalic28pt7b" },
  { &JetBrainsMono_ThinItalic29pt7b, 29, "JetBrainsMono_ThinItalic29pt7b" },
  { &JetBrainsMono_ThinItalic30pt7b, 30, "JetBrainsMono_ThinItalic30pt7b" },
  { &JetBrainsMono_ThinItalic31pt7b, 31, "JetBrainsMono_ThinItalic31pt7b" },
  { &JetBrainsMono_ThinItalic32pt7b, 32, "JetBrainsMono_ThinItalic32pt7b" },
  { &JetBrainsMono_ThinItalic33pt7b, 33, "JetBrainsMono_ThinItalic33pt7b" },
  { &JetBrainsMono_ThinItalic34pt7b, 34, "JetBrainsMono_ThinItalic34pt7b" },
  { &JetBrainsMono_ThinItalic35pt7b, 35, "JetBrainsMono_ThinItalic35pt7b" },
  { &JetBrainsMono_ThinItalic36pt7b, 36, "JetBrainsMono_ThinItalic36pt7b" },
  { &JetBrainsMono_ThinItalic37pt7b, 37, "JetBrainsMono_ThinItalic37pt7b" },
  { &JetBrainsMono_ThinItalic38pt7b, 38, "JetBrainsMono_ThinItalic38pt7b" },
  { &JetBrainsMono_ThinItalic39pt7b, 39, "JetBrainsMono_ThinItalic39pt7b" },
  { &JetBrainsMono_ThinItalic40pt7b, 40, "JetBrainsMono_ThinItalic40pt7b" },
  { &JetBrainsMono_ThinItalic41pt7b, 41, "JetBrainsMono_ThinItalic41pt7b" },
  { &JetBrainsMono_ThinItalic42pt7b, 42, "JetBrainsMono_ThinItalic42pt7b" },
  { &JetBrainsMono_ThinItalic43pt7b, 43, "JetBrainsMono_ThinItalic43pt7b" },
  { &JetBrainsMono_ThinItalic44pt7b, 44, "JetBrainsMono_ThinItalic44pt7b" },
  { &JetBrainsMono_ThinItalic45pt7b, 45, "JetBrainsMono_ThinItalic45pt7b" },
  { &JetBrainsMono_ThinItalic46pt7b, 46, "JetBrainsMono_ThinItalic46pt7b" },
  { &JetBrainsMono_ThinItalic47pt7b, 47, "JetBrainsMono_ThinItalic47pt7b" },
  { &JetBrainsMono_ThinItalic48pt7b, 48, "JetBrainsMono_ThinItalic48pt7b" },
  { &JetBrainsMono_ThinItalic49pt7b, 49, "JetBrainsMono_ThinItalic49pt7b" },
  { &JetBrainsMono_ThinItalic50pt7b, 50, "JetBrainsMono_ThinItalic50pt7b" },
  { &JetBrainsMono_ThinItalic51pt7b, 51, "JetBrainsMono_ThinItalic51pt7b" },
  { &JetBrainsMono_ThinItalic52pt7b, 52, "JetBrainsMono_ThinItalic52pt7b" },
  { &JetBrainsMono_ThinItalic53pt7b, 53, "JetBrainsMono_ThinItalic53pt7b" },
  { &JetBrainsMono_ThinItalic54pt7b, 54, "JetBrainsMono_ThinItalic54pt7b" },
  { &JetBrainsMono_ThinItalic55pt7b, 55, "JetBrainsMono_ThinItalic55pt7b" },
  { &JetBrainsMono_ThinItalic56pt7b, 56, "JetBrainsMono_ThinItalic56pt7b" },
  { &JetBrainsMono_ThinItalic57pt7b, 57, "JetBrainsMono_ThinItalic57pt7b" },
  { &JetBrainsMono_ThinItalic58pt7b, 58, "JetBrainsMono_ThinItalic58pt7b" },
  { &JetBrainsMono_ThinItalic59pt7b, 59, "JetBrainsMono_ThinItalic59pt7b" },
  { &JetBrainsMono_ThinItalic60pt7b, 60, "JetBrainsMono_ThinItalic60pt7b" },
  { &JetBrainsMono_ThinItalic61pt7b, 61, "JetBrainsMono_ThinItalic61pt7b" },
  { &JetBrainsMono_ThinItalic62pt7b, 62, "JetBrainsMono_ThinItalic62pt7b" },
  { &JetBrainsMono_ThinItalic63pt7b, 63, "JetBrainsMono_ThinItalic63pt7b" },
  { &JetBrainsMono_ThinItalic64pt7b, 64, "JetBrainsMono_ThinItalic64pt7b" },
  { &JetBrainsMono_ThinItalic65pt7b, 65, "JetBrainsMono_ThinItalic65pt7b" },
  { &JetBrainsMono_ThinItalic66pt7b, 66, "JetBrainsMono_ThinItalic66pt7b" },
  { &JetBrainsMono_ThinItalic67pt7b, 67, "JetBrainsMono_ThinItalic67pt7b" },
  { &JetBrainsMono_ThinItalic68pt7b, 68, "JetBrainsMono_ThinItalic68pt7b" },
  { &JetBrainsMono_ThinItalic69pt7b, 69, "JetBrainsMono_ThinItalic69pt7b" },
  { &JetBrainsMono_ThinItalic70pt7b, 70, "JetBrainsMono_ThinItalic70pt7b" },
  { &JetBrainsMono_ThinItalic71pt7b, 71, "JetBrainsMono_ThinItalic71pt7b" },
  { &JetBrainsMono_ThinItalic72pt7b, 72, "JetBrainsMono_ThinItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
