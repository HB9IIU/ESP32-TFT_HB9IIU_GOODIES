#ifndef _JETBRAINSMONO_THINITALIC70PT7B_H_
#define _JETBRAINSMONO_THINITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x79, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8E, 0x00,
  0x38, 0x70, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8E,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x6F, 0xF0, 0x00, 0x3E, 0x1C, 0x3F, 0x00, 0x0F, 0x03, 0x81, 0xE0,
  0x03, 0xC0, 0x70, 0x3E, 0x00, 0xF0, 0x0E, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0x30, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0xF0, 0x1C, 0x01,
  0xC0, 0x1E, 0x03, 0x80, 0x38, 0x03, 0xC0, 0xF0, 0x07, 0x00, 0x70, 0x1E,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x03, 0xE0, 0x70, 0x00, 0x00, 0x3E, 0x0C, 0x00, 0x00, 0x03, 0xF1,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xCF, 0xE0, 0x00, 0x00, 0x38, 0x7E, 0x00, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x7C, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70,
  0x70, 0x01, 0xC0, 0x1E, 0x0E, 0x00, 0x38, 0x03, 0xC1, 0xC0, 0x06, 0x00,
  0x78, 0x38, 0x01, 0xC0, 0x0E, 0x07, 0x80, 0x38, 0x03, 0xC0, 0xF0, 0x07,
  0x00, 0x70, 0x1E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x07, 0x80, 0x3E,
  0x03, 0x03, 0xE0, 0x03, 0xF0, 0xE0, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x38, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x70, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0E, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x3C, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1C, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x78, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x70, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0x00,
  0x03, 0x81, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x0E, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x80, 0x00,
  0x3C, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF0, 0xF0, 0x0F, 0x00,
  0x07, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x78, 0x01, 0xF0, 0x07, 0x83, 0x80,
  0x07, 0x80, 0x78, 0x1C, 0x00, 0x1E, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x3C,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x78, 0x00, 0x1F, 0x1C, 0x03, 0x80, 0x00,
  0x79, 0xC0, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0x80,
  0x00, 0x7B, 0xC0, 0x3C, 0x00, 0x07, 0x8E, 0x01, 0xE0, 0x00, 0x78, 0x78,
  0x07, 0x80, 0x0F, 0x81, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x00, 0xFF, 0x7F,
  0x80, 0x3C, 0x07, 0xFF, 0xF0, 0x00, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x1E,
  0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x8E, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x00, 0x07, 0x80, 0x03, 0x7C, 0x00, 0x78, 0x01, 0xF7, 0xF8,
  0x07, 0x00, 0xFF, 0xFF, 0xE0, 0x70, 0x3F, 0xF1, 0xFF, 0x87, 0x1F, 0xFC,
  0x07, 0xFE, 0x67, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x06,
  0x03, 0xF8, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0xCF,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0xF0, 0x78, 0x07, 0xC0, 0x3C, 0x1E, 0x03, 0xF0, 0x0F, 0x07,
  0x00, 0xFE, 0x03, 0xC3, 0xC0, 0x3F, 0x80, 0xE0, 0xF0, 0x0F, 0xC0, 0x78,
  0x3C, 0x03, 0xF0, 0x1E, 0x0F, 0x00, 0x38, 0x07, 0x83, 0xC0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0x1F, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xDC, 0x00, 0x00, 0x3F, 0x38, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x07,
  0xE1, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xFC, 0x07, 0x80, 0x03, 0xE0,
  0x0F, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x10, 0x00,
  0xF0, 0x00, 0x40, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x02, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x10, 0x07, 0x80, 0x03,
  0x80, 0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x1F, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x38, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x78, 0x3F, 0xF8, 0x00, 0x1E, 0x3F, 0xFF, 0x80, 0x07,
  0x3F, 0xFF, 0xF0, 0x01, 0xDE, 0x00, 0xFE, 0x00, 0x76, 0x00, 0x0F, 0x80,
  0x3F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x0F, 0xC0,
  0x00, 0x3C, 0xFF, 0xF0, 0x00, 0xF7, 0xFF, 0xF8, 0x01, 0xDF, 0x07, 0xF8,
  0x07, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x78, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0xFB, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x38, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFE,
  0x01, 0xFF, 0x1F, 0xB8, 0x00, 0xFF, 0xFE, 0xF0, 0x00, 0xFF, 0xF3, 0xC0,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x07, 0xF0, 0x70, 0x38, 0x00, 0x3F, 0xF8, 0xE0,
  0xF0, 0x00, 0xFF, 0xF9, 0xC1, 0xE0, 0x03, 0xF0, 0xFB, 0x83, 0xC0, 0x0F,
  0x80, 0x37, 0x07, 0x00, 0x3C, 0x00, 0x3E, 0x0E, 0x00, 0x78, 0x00, 0x78,
  0x1C, 0x01, 0xE0, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x07,
  0x00, 0x03, 0xC1, 0xE0, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x1C, 0x00, 0x0F,
  0x07, 0x00, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x1C, 0x01,
  0xE0, 0x00, 0x70, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x07, 0x00, 0x03,
  0xC1, 0xE0, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x3C, 0x00, 0x0F, 0x07, 0x00,
  0x78, 0x00, 0x1C, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0x00,
  0xF0, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0x07, 0xC1, 0xC0,
  0x0F, 0x00, 0x0F, 0x83, 0x80, 0x0F, 0x00, 0x3E, 0x07, 0x00, 0x1F, 0x81,
  0xDC, 0x1E, 0x00, 0x1F, 0xFF, 0x38, 0x3C, 0x00, 0x1F, 0xFC, 0x70, 0x78,
  0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0x3E,
  0x00, 0x70, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xFE, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x03, 0xC0,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x7F, 0x00,
  0x1C, 0x00, 0x0F, 0xC0, 0x0E, 0x00, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xC3, 0xC0, 0x1F, 0xFF, 0xC1,
  0xC0, 0x0F, 0xFF, 0xE0, 0xE0, 0x08, 0x00, 0x70, 0x70, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x3B, 0x00, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x03, 0xB8, 0x00, 0x1D, 0xE0, 0x1E, 0xE0, 0x00, 0x77, 0x80, 0x73, 0x80,
  0x03, 0x9C, 0x01, 0xC6, 0x00, 0x0E, 0x70, 0x07, 0x1C, 0x00, 0x71, 0xC0,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x0E, 0x3C, 0x03, 0xC7, 0x00,
  0x38, 0xF0, 0x0F, 0x0C, 0x01, 0xC3, 0x80, 0x3C, 0x38, 0x07, 0x0E, 0x00,
  0xE0, 0xE0, 0x38, 0x38, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x0E, 0x0E, 0x07,
  0x07, 0x80, 0x38, 0x18, 0x18, 0x1E, 0x01, 0xE0, 0x70, 0xE0, 0x78, 0x07,
  0x81, 0xC3, 0x01, 0xC0, 0x1C, 0x07, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x60,
  0x1C, 0x01, 0xC0, 0x33, 0x80, 0xF0, 0x07, 0x00, 0xEC, 0x03, 0xC0, 0x3C,
  0x03, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x7E, 0x00, 0x00, 0x70,
  0x1F, 0x80, 0x00, 0x1C, 0x07, 0xE0, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x03,
  0xC0, 0x77, 0x00, 0x00, 0xE0, 0x1D, 0xC0, 0x00, 0x38, 0x07, 0x70, 0x00,
  0x0E, 0x03, 0xDE, 0x00, 0x03, 0x80, 0xF3, 0x80, 0x01, 0xE0, 0x38, 0xE0,
  0x00, 0x78, 0x0E, 0x38, 0x00, 0x1E, 0x03, 0x8E, 0x00, 0x07, 0x00, 0xE1,
  0xC0, 0x01, 0xC0, 0x78, 0x70, 0x00, 0x70, 0x1E, 0x1C, 0x00, 0x3C, 0x07,
  0x07, 0x00, 0x0F, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0x70, 0x38, 0x00, 0xE0,
  0x1C, 0x0E, 0x00, 0x38, 0x0F, 0x03, 0x80, 0x0E, 0x03, 0xC0, 0x70, 0x03,
  0x80, 0xF0, 0x1C, 0x01, 0xE0, 0x38, 0x07, 0x00, 0x78, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x78, 0x07, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x78, 0x03,
  0x80, 0x70, 0x1E, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0x3C, 0x0F, 0x01, 0xC0,
  0x07, 0x03, 0x80, 0x70, 0x01, 0xC0, 0xE0, 0x1C, 0x00, 0x70, 0x38, 0x0F,
  0x00, 0x1C, 0x0E, 0x03, 0xC0, 0x03, 0x87, 0x80, 0xE0, 0x00, 0xE1, 0xE0,
  0x38, 0x00, 0x38, 0x78, 0x0E, 0x00, 0x0E, 0x1C, 0x03, 0x80, 0x01, 0xC7,
  0x01, 0xE0, 0x00, 0x71, 0xC0, 0x78, 0x00, 0x1C, 0x70, 0x1E, 0x00, 0x07,
  0x3C, 0x07, 0x00, 0x01, 0xEF, 0x01, 0xC0, 0x00, 0x3B, 0x80, 0x70, 0x00,
  0x0E, 0xE0, 0x3C, 0x00, 0x03, 0xB8, 0x0F, 0x00, 0x00, 0xFE, 0x03, 0xC0,
  0x00, 0x1F, 0x80, 0xE0, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x01, 0xF0, 0x0E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x1C,
  0x00, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xE0,
  0x0E, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xF0, 0x00, 0x3F, 0x80, 0x1C, 0x00, 0x01, 0xF8, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x70, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x3C, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0x80, 0xF8,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3C, 0x70, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0xE0, 0x01, 0xF0, 0x00, 0xF3, 0x80, 0x07, 0xC0, 0x03,
  0xCE, 0x00, 0x1F, 0x00, 0x0E, 0x38, 0x00, 0xEC, 0x00, 0x38, 0xE0, 0x03,
  0xB0, 0x01, 0xE3, 0x80, 0x0E, 0xC0, 0x07, 0x0E, 0x00, 0x33, 0x00, 0x1C,
  0x38, 0x01, 0xCC, 0x00, 0xF1, 0xE0, 0x07, 0x30, 0x03, 0xC7, 0x80, 0x18,
  0xC0, 0x0E, 0x1E, 0x00, 0xE3, 0x00, 0x38, 0x78, 0x03, 0x8C, 0x01, 0xE1,
  0xC0, 0x0E, 0x70, 0x07, 0x07, 0x00, 0x71, 0xC0, 0x1C, 0x1C, 0x01, 0xC7,
  0x00, 0x70, 0x70, 0x07, 0x1C, 0x03, 0xC1, 0xC0, 0x18, 0x70, 0x0E, 0x07,
  0x00, 0xE1, 0xC0, 0x38, 0x1C, 0x03, 0x87, 0x01, 0xE0, 0x70, 0x0C, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x70, 0x1C, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x1C,
  0x06, 0x07, 0x03, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x70,
  0x38, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x1C, 0x0C, 0x07, 0x07, 0x00, 0x70,
  0x70, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x07, 0x06, 0x01, 0xC3,
  0xC0, 0x1C, 0x38, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x1C, 0x38, 0x01, 0xC3,
  0x00, 0x70, 0xE0, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x07, 0x1C,
  0x00, 0x71, 0x80, 0x1C, 0x70, 0x03, 0xC6, 0x00, 0x71, 0xC0, 0x0F, 0x38,
  0x01, 0xCE, 0x00, 0x3C, 0xC0, 0x07, 0x38, 0x00, 0xF3, 0x00, 0x18, 0xE0,
  0x03, 0xDC, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x01, 0x9C, 0x00, 0x39, 0x80,
  0x06, 0x70, 0x00, 0xEE, 0x00, 0x1B, 0xC0, 0x03, 0xB8, 0x00, 0x6E, 0x00,
  0x0E, 0xC0, 0x01, 0xB8, 0x00, 0x3B, 0x00, 0x06, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x3C, 0x00, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E,
  0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x03,
  0x80, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xFE, 0x07, 0x00,
  0x1F, 0xFF, 0x87, 0x00, 0x3F, 0xFF, 0xCF, 0x00, 0x7C, 0x03, 0xEF, 0x00,
  0xF0, 0x00, 0xEF, 0x01, 0xE0, 0x00, 0x7F, 0x03, 0xC0, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x3D, 0xE0, 0x0F, 0xE1, 0xF9, 0xE0, 0x07,
  0xFF, 0xF1, 0xC0, 0x03, 0xFF, 0xC1, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x81, 0xFF, 0x00, 0x03, 0x87, 0xFF, 0xC0, 0x07, 0x8F, 0xFF, 0xF0, 0x07,
  0xBE, 0x01, 0xF8, 0x07, 0xF8, 0x00, 0x78, 0x07, 0x60, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0xFC,
  0x00, 0x03, 0xC0, 0xFE, 0x00, 0x0F, 0x80, 0xF7, 0x80, 0x1F, 0x00, 0xF3,
  0xE0, 0xFE, 0x00, 0xE1, 0xFF, 0xF8, 0x00, 0xE0, 0xFF, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFE, 0x07, 0x00, 0x07, 0xFF,
  0xE1, 0xC0, 0x03, 0xFF, 0xFC, 0xF0, 0x01, 0xF0, 0x0F, 0xBC, 0x00, 0xF0,
  0x00, 0xEF, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0xF7, 0x80, 0x0F, 0xE1, 0xF9, 0xE0, 0x01, 0xFF, 0xFC, 0x70, 0x00, 0x3F,
  0xFC, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xE0,
  0x01, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xE7,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x0E, 0x00, 0x7F, 0xFE,
  0x1C, 0x01, 0xFF, 0xFE, 0x78, 0x07, 0xC0, 0x3E, 0xF0, 0x1E, 0x00, 0x1D,
  0xE0, 0x78, 0x00, 0x1F, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E,
  0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0xFC, 0x0F, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x0E, 0xE0, 0x1F, 0x80, 0x79,
  0xC0, 0x1F, 0xFF, 0xE3, 0x80, 0x1F, 0xFF, 0x0F, 0x00, 0x0F, 0xF8, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x1F, 0xF0, 0x00, 0x70, 0xFF, 0xFC, 0x01, 0xE3, 0xFF,
  0xFC, 0x03, 0xCF, 0x00, 0xFC, 0x07, 0xB8, 0x00, 0xF8, 0x0E, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x07, 0x87, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x00, 0x38, 0x00, 0xF8, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xC7, 0xF0, 0x1F, 0x80, 0x1C, 0x7F, 0xC3, 0xFF, 0x00, 0xE7,
  0xFF, 0x3F, 0xF8, 0x07, 0x60, 0xF9, 0x83, 0xE0, 0x3E, 0x03, 0xD8, 0x0F,
  0x01, 0xE0, 0x0F, 0x80, 0x38, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0xF0, 0x03,
  0xC0, 0x0E, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x03, 0x81,
  0xC0, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x70, 0x03, 0xC0,
  0x0F, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x03, 0x81, 0xE0,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0x0F,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x03, 0x81, 0xE0, 0x07,
  0x80, 0x1C, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x07, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x07, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0x1E,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0x1E, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0x03, 0x81, 0xFF, 0x00, 0x07, 0x0F, 0xFF, 0xC0, 0x1E, 0x3F,
  0xFF, 0xC0, 0x3C, 0xF0, 0x0F, 0xC0, 0x7B, 0x80, 0x0F, 0x80, 0xEC, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x7F, 0xC0, 0x00, 0x38, 0x7F, 0xFC,
  0x00, 0x1E, 0x3F, 0xFF, 0xC0, 0x07, 0xBE, 0x01, 0xF8, 0x01, 0xFE, 0x00,
  0x1E, 0x00, 0x76, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x1C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF0,
  0x0F, 0xC0, 0x00, 0x3C, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0xF7, 0x80, 0x1F,
  0x00, 0x3C, 0xF8, 0x3F, 0x80, 0x0E, 0x1F, 0xFF, 0x80, 0x03, 0x83, 0xFF,
  0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x07, 0x00, 0x1F, 0xFF, 0x87, 0x00, 0x3F, 0xFF, 0xCF, 0x00, 0xFC, 0x03,
  0xEF, 0x01, 0xF0, 0x00, 0xEF, 0x01, 0xE0, 0x00, 0x7F, 0x03, 0xC0, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x3D, 0xE0, 0x0F, 0xE1, 0xF9,
  0xE0, 0x07, 0xFF, 0xF1, 0xC0, 0x03, 0xFF, 0xC1, 0xC0, 0x00, 0x3E, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x03, 0x81, 0xFF, 0x80, 0x03, 0x87, 0xFF, 0xE0, 0x03, 0x8F, 0xFF,
  0xF0, 0x07, 0x9E, 0x01, 0xF8, 0x07, 0xB8, 0x00, 0x7C, 0x07, 0xF0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x07,
  0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x00, 0x78, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x3B, 0x80,
  0x0F, 0x80, 0x0F, 0x70, 0x01, 0xF0, 0x01, 0xEE, 0x00, 0x36, 0x00, 0x39,
  0xC0, 0x0E, 0xC0, 0x07, 0x38, 0x01, 0xD8, 0x01, 0xE7, 0x00, 0x33, 0x00,
  0x38, 0xE0, 0x0E, 0x60, 0x07, 0x1C, 0x01, 0xCC, 0x01, 0xE3, 0x80, 0x31,
  0x80, 0x38, 0x70, 0x0E, 0x30, 0x07, 0x0E, 0x01, 0xC6, 0x01, 0xE1, 0xC0,
  0x30, 0xC0, 0x38, 0x38, 0x0E, 0x18, 0x07, 0x07, 0x01, 0xC3, 0x01, 0xE0,
  0xE0, 0x30, 0x60, 0x38, 0x1C, 0x0E, 0x0C, 0x07, 0x03, 0x81, 0xC1, 0x81,
  0xE0, 0x70, 0x70, 0x30, 0x38, 0x0E, 0x0E, 0x06, 0x07, 0x01, 0xC1, 0xC0,
  0xE1, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0x87, 0x00, 0xE1,
  0xC0, 0x71, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x39, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0x39, 0x80, 0x1D, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x00, 0xEE, 0x00,
  0x77, 0x00, 0x1D, 0x80, 0x0E, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0x70, 0x1F, 0x00, 0x1D, 0xE0, 0x3F, 0x00,
  0xF3, 0xC0, 0x3F, 0xFF, 0xC7, 0x80, 0x3F, 0xFF, 0x0E, 0x00, 0x0F, 0xF8,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x0F, 0xFC, 0x00, 0x0F, 0x1F, 0xFE, 0x00, 0x0E, 0x3C,
  0x1F, 0x00, 0x0E, 0x38, 0x07, 0x80, 0x0E, 0x78, 0x07, 0x80, 0x0E, 0x70,
  0x03, 0xC0, 0x0E, 0x70, 0x01, 0xE0, 0x1E, 0xF0, 0x01, 0xF0, 0x3C, 0xF0,
  0x00, 0xF8, 0x78, 0xE0, 0x00, 0x7F, 0xF8, 0xE0, 0x00, 0x3F, 0xE0, 0xE0,
  0x00, 0x0F, 0x80,
};

const GFXglyph JetBrainsMono_ThinItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 14, 51, 42, 14, -51 },
  { 91, 21, 21, 42, 14, -51 },
  { 147, 40, 51, 42, 2, -51 },
  { 402, 35, 71, 42, 4, -61 },
  { 713, 48, 51, 42, -2, -51 },
  { 1019, 37, 53, 42, 2, -52 },
  { 1265, 7, 21, 42, 21, -51 },
  { 1284, 28, 68, 42, 12, -59 },
  { 1522, 27, 68, 42, 4, -59 },
  { 1752, 36, 36, 42, 4, -43 },
  { 1914, 32, 33, 42, 6, -40 },
  { 2046, 16, 22, 42, 8, -11 },
  { 2090, 23, 3, 42, 10, -25 },
  { 2099, 11, 11, 42, 13, -10 },
  { 2115, 39, 66, 42, 2, -58 },
  { 2437, 34, 53, 42, 5, -52 },
  { 2663, 31, 51, 42, 4, -51 },
  { 2861, 35, 52, 42, 4, -52 },
  { 3089, 34, 52, 42, 5, -51 },
  { 3310, 30, 51, 42, 6, -51 },
  { 3502, 34, 52, 42, 5, -51 },
  { 3723, 31, 52, 42, 5, -51 },
  { 3925, 33, 51, 42, 9, -51 },
  { 4136, 35, 53, 42, 4, -52 },
  { 4368, 31, 52, 42, 8, -52 },
  { 4570, 16, 40, 42, 13, -39 },
  { 4650, 21, 50, 42, 8, -39 },
  { 4782, 32, 35, 42, 7, -41 },
  { 4922, 31, 19, 42, 6, -33 },
  { 4996, 33, 35, 42, 4, -41 },
  { 5141, 27, 51, 42, 12, -51 },
  { 5314, 39, 65, 42, 2, -52 },
  { 5631, 32, 51, 42, 2, -51 },
  { 5835, 34, 51, 42, 5, -51 },
  { 6052, 33, 53, 42, 6, -52 },
  { 6271, 33, 51, 42, 5, -51 },
  { 6482, 36, 51, 42, 5, -51 },
  { 6712, 37, 51, 42, 5, -51 },
  { 6948, 33, 53, 42, 6, -52 },
  { 7167, 34, 51, 42, 5, -51 },
  { 7384, 34, 51, 42, 5, -51 },
  { 7601, 36, 52, 42, 3, -51 },
  { 7835, 37, 51, 42, 5, -51 },
  { 8071, 29, 51, 42, 5, -51 },
  { 8256, 38, 51, 42, 3, -51 },
  { 8499, 34, 51, 42, 5, -51 },
  { 8716, 32, 53, 42, 6, -52 },
  { 8928, 36, 51, 42, 5, -51 },
  { 9158, 32, 65, 42, 6, -52 },
  { 9418, 35, 51, 42, 5, -51 },
  { 9642, 35, 53, 42, 4, -52 },
  { 9874, 34, 51, 42, 9, -51 },
  { 10091, 33, 52, 42, 6, -51 },
  { 10306, 32, 51, 42, 10, -51 },
  { 10510, 38, 51, 42, 6, -51 },
  { 10753, 41, 51, 42, 1, -51 },
  { 11015, 35, 51, 42, 9, -51 },
  { 11239, 37, 51, 42, 3, -51 },
  { 11475, 26, 66, 42, 11, -58 },
  { 11690, 18, 66, 42, 13, -58 },
  { 11839, 26, 66, 42, 7, -58 },
  { 12054, 28, 27, 42, 8, -51 },
  { 12149, 34, 3, 42, 0, 2 },
  { 12162, 10, 10, 42, 20, -55 },
  { 12175, 32, 40, 42, 5, -39 },
  { 12335, 32, 52, 42, 5, -51 },
  { 12543, 31, 40, 42, 6, -39 },
  { 12698, 34, 52, 42, 5, -51 },
  { 12919, 30, 40, 42, 6, -39 },
  { 13069, 44, 64, 42, -2, -51 },
  { 13421, 31, 52, 42, 6, -39 },
  { 13623, 31, 51, 42, 5, -51 },
  { 13821, 31, 54, 42, 4, -54 },
  { 14031, 34, 67, 42, 2, -54 },
  { 14316, 35, 51, 42, 5, -51 },
  { 14540, 27, 51, 42, 8, -51 },
  { 14713, 37, 39, 42, 2, -39 },
  { 14894, 31, 39, 42, 5, -39 },
  { 15046, 30, 40, 42, 6, -39 },
  { 15196, 34, 52, 42, 3, -39 },
  { 15417, 32, 52, 42, 5, -39 },
  { 15625, 32, 39, 42, 6, -39 },
  { 15781, 32, 40, 42, 5, -39 },
  { 15941, 31, 49, 42, 7, -49 },
  { 16131, 31, 40, 42, 6, -39 },
  { 16286, 32, 39, 42, 8, -39 },
  { 16442, 35, 39, 42, 7, -39 },
  { 16613, 37, 39, 42, 2, -39 },
  { 16794, 31, 52, 42, 6, -39 },
  { 16996, 33, 39, 42, 4, -39 },
  { 17157, 33, 66, 42, 8, -58 },
  { 17430, 14, 66, 42, 15, -58 },
  { 17546, 33, 66, 42, 3, -58 },
  { 17819, 32, 13, 42, 6, -31 },
};

const GFXfont JetBrainsMono_ThinItalic70pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic70pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _JETBRAINSMONO_THINITALIC70PT7B_H_
