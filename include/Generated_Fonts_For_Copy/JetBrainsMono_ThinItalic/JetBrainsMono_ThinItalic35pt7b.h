#ifndef _JETBRAINSMONO_THINITALIC35PT7B_H_
#define _JETBRAINSMONO_THINITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x60, 0xC1,
  0x83, 0x04, 0x08, 0x10, 0x20, 0x40, 0x00, 0x00, 0x0C, 0x38, 0xF0, 0xE0,
  0x70, 0xEE, 0x1D, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x36, 0x0C, 0xC1,
  0x98, 0x33, 0x06, 0x00, 0x00, 0x20, 0x30, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x0C, 0x04, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x18,
  0x1F, 0xFF, 0xF0, 0x30, 0x30, 0x03, 0x03, 0x00, 0x20, 0x30, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x04, 0x04, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x81, 0x81, 0x80, 0x30, 0x10, 0x03, 0x03, 0x00, 0x30,
  0x30, 0x06, 0x02, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x73,
  0x38, 0x30, 0x86, 0x0C, 0x21, 0x86, 0x08, 0x61, 0x82, 0x18, 0x61, 0x80,
  0x18, 0x60, 0x07, 0x10, 0x00, 0xC4, 0x00, 0x1D, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x0D, 0xC0, 0x03, 0x38, 0x00, 0x86, 0x00, 0x20, 0x80, 0x08,
  0x30, 0x06, 0x0C, 0xC1, 0x82, 0x30, 0x61, 0x86, 0x10, 0x61, 0x84, 0x30,
  0x3D, 0x78, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x03, 0x03, 0xF0, 0x06, 0x06, 0x18,
  0x0C, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x10, 0x08, 0x18, 0x20, 0x08, 0x18,
  0x60, 0x08, 0x10, 0xC0, 0x18, 0x11, 0x80, 0x08, 0x33, 0x00, 0x0E, 0xE6,
  0x00, 0x07, 0xC4, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x67, 0xF0, 0x00, 0xC4, 0x30, 0x01, 0x8C, 0x10, 0x01, 0x08,
  0x10, 0x02, 0x18, 0x10, 0x06, 0x18, 0x10, 0x0C, 0x18, 0x30, 0x18, 0x18,
  0x30, 0x30, 0x18, 0x20, 0x60, 0x1C, 0xE0, 0xC0, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x3F, 0xC0, 0x0E, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x03, 0xC0, 0x01, 0xF8, 0x00, 0x71, 0x80, 0xCC, 0x30, 0x33, 0x03, 0x0C,
  0x60, 0x71, 0x0C, 0x06, 0x61, 0x80, 0x78, 0x30, 0x0E, 0x04, 0x00, 0xC1,
  0x80, 0x38, 0x30, 0x0D, 0x83, 0x03, 0x18, 0x71, 0xC3, 0x07, 0xF0, 0x30,
  0x6D, 0xFF, 0xB6, 0xDA, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0x80, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x04, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0xF0, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x10, 0x30, 0x3F, 0x8C, 0x7C, 0xF9, 0x7C, 0x07, 0xF8, 0x00, 0x30, 0x00,
  0x14, 0x00, 0x0D, 0x80, 0x06, 0x30, 0x03, 0x0C, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0x70, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x0F, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x60, 0x60, 0x40,
  0xC0, 0xFF, 0xF0, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x70,
  0x70, 0x38, 0x06, 0x0C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06,
  0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC1, 0x06, 0x31, 0xE3, 0x0C,
  0x78, 0xC2, 0x0C, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0xC1, 0xC0, 0x60,
  0x3E, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x03, 0x60, 0x1C,
  0xC0, 0x61, 0x03, 0x86, 0x04, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x60,
  0x30, 0x30, 0x06, 0x18, 0x01, 0x86, 0x00, 0x23, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x88, 0x00, 0xC4,
  0x00, 0x42, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x38, 0x70, 0x0F, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x30,
  0xC0, 0x63, 0x00, 0x8C, 0x03, 0x30, 0x06, 0xE0, 0x0D, 0x80, 0x1B, 0xFF,
  0xF7, 0xFF, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x0F, 0xFF, 0x0F, 0xFF, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x31, 0xE0, 0x37, 0xF8,
  0x3C, 0x1C, 0x30, 0x0C, 0x70, 0x06, 0x60, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18,
  0xE0, 0x30, 0x70, 0xE0, 0x3F, 0xC0, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0D, 0xF8, 0x1E, 0x1E, 0x38, 0x06, 0x30, 0x07,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0x40, 0x02, 0x40, 0x06,
  0x40, 0x06, 0x60, 0x0C, 0x70, 0x18, 0x3C, 0x70, 0x1F, 0xE0, 0x7F, 0xFF,
  0xBF, 0xFF, 0xD8, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x63, 0x00, 0x31, 0x00,
  0x31, 0x80, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xC0,
  0xC1, 0x80, 0x30, 0xC0, 0x18, 0x40, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18,
  0x03, 0x06, 0x01, 0x81, 0x83, 0x80, 0x67, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x38, 0x60, 0x30, 0x18, 0x30, 0x06, 0x30, 0x03, 0x18, 0x00, 0x88, 0x00,
  0x4C, 0x00, 0x66, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x38, 0x38, 0x78, 0x0F,
  0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x1C, 0x0C, 0x30, 0x06, 0x20, 0x06,
  0x60, 0x02, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x0C, 0x60, 0x1C, 0x70, 0x38, 0x3F, 0xD0, 0x0F, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x04, 0x3C, 0xF9, 0xF3, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xF9, 0xF3, 0xE7, 0x80,
  0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0E, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0C, 0x06, 0x01, 0x80, 0x40, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x10, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x1C, 0x0F,
  0xC0, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0xF8, 0x03, 0x81, 0xC0, 0x60, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06,
  0x18, 0x00, 0x21, 0x80, 0x02, 0x10, 0x00, 0x23, 0x01, 0xF6, 0x30, 0x3F,
  0xE3, 0x06, 0x0E, 0x30, 0xC0, 0x62, 0x0C, 0x06, 0x20, 0xC0, 0x46, 0x08,
  0x0C, 0x60, 0x80, 0xC6, 0x18, 0x0C, 0x61, 0x80, 0xC6, 0x18, 0x0C, 0x41,
  0x81, 0x8C, 0x18, 0x28, 0xC0, 0xFF, 0x8C, 0x07, 0xD8, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x28, 0x00, 0x6C, 0x00, 0x4C, 0x00, 0xCC, 0x00, 0xCC, 0x01, 0x8C, 0x01,
  0x84, 0x01, 0x04, 0x03, 0x04, 0x02, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C,
  0x06, 0x0C, 0x06, 0x0F, 0xFE, 0x1F, 0xFE, 0x10, 0x02, 0x30, 0x02, 0x30,
  0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x0F, 0xE0, 0x07,
  0xFF, 0x03, 0x01, 0xC1, 0x80, 0x70, 0x80, 0x18, 0x40, 0x0C, 0x60, 0x06,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x86, 0x01, 0x82, 0x01, 0xC3, 0xFF,
  0x81, 0xFF, 0xE0, 0xC0, 0x38, 0x60, 0x0C, 0x30, 0x03, 0x10, 0x01, 0x98,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0x80, 0x30,
  0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x03, 0x81, 0x81,
  0x80, 0x61, 0x80, 0x30, 0x80, 0x08, 0xC0, 0x04, 0x60, 0x04, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x8C,
  0x00, 0xC6, 0x00, 0x63, 0x00, 0x60, 0xC0, 0x60, 0x78, 0xE0, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x07, 0xFE, 0x03, 0x03, 0x81, 0x80, 0x60, 0x80, 0x30,
  0x40, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x86, 0x00,
  0xC2, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x04, 0x30,
  0x02, 0x10, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x43, 0x00, 0x61,
  0x80, 0x60, 0x80, 0x60, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x87,
  0xFF, 0xC6, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF,
  0xC1, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x03,
  0x81, 0x81, 0x80, 0x61, 0x80, 0x30, 0x80, 0x08, 0xC0, 0x04, 0x60, 0x04,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x87, 0xF8, 0xC0, 0x0C, 0x40, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98,
  0x00, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x60, 0xC0, 0x60, 0x78, 0xE0,
  0x0F, 0xE0, 0x00, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x08, 0x30, 0x06,
  0x0C, 0x01, 0x82, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x06,
  0x00, 0xC1, 0x80, 0x30, 0x40, 0x0C, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0x00,
  0x20, 0xC0, 0x18, 0x30, 0x06, 0x08, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18,
  0x60, 0x06, 0x18, 0x01, 0x06, 0x00, 0xC1, 0x00, 0x30, 0x40, 0x0C, 0x30,
  0x03, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x21, 0x80, 0x08, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0xC1, 0xC0, 0x60,
  0x3C, 0x78, 0x07, 0xF8, 0x00, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x03,
  0x06, 0x00, 0xC0, 0x80, 0x30, 0x10, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x70,
  0x18, 0x0C, 0x03, 0x03, 0x00, 0x60, 0x60, 0x08, 0x18, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x04, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x02,
  0x00, 0x30, 0x40, 0x06, 0x18, 0x00, 0xC0, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0xC3, 0x80, 0x71, 0xE0, 0x1C,
  0x68, 0x0F, 0x1A, 0x02, 0xC6, 0x81, 0x31, 0x30, 0xC8, 0x4C, 0x26, 0x31,
  0x19, 0x8C, 0x44, 0x63, 0x13, 0x18, 0xC6, 0x86, 0x31, 0xE1, 0x08, 0x30,
  0xC6, 0x0C, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x21,
  0x00, 0x08, 0x40, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x04, 0x20, 0x01, 0x00, 0x0E, 0x00, 0xC3, 0x80, 0x30, 0xE0, 0x08, 0x38,
  0x06, 0x0B, 0x01, 0x82, 0xC0, 0x61, 0x90, 0x18, 0x64, 0x06, 0x19, 0x81,
  0x06, 0x60, 0x41, 0x08, 0x30, 0x42, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x04, 0x20, 0xC1, 0x08, 0x30, 0x66, 0x08, 0x19, 0x86, 0x06, 0x61, 0x80,
  0x98, 0x60, 0x36, 0x18, 0x0D, 0x06, 0x03, 0x41, 0x00, 0x70, 0x40, 0x1C,
  0x30, 0x07, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x06, 0x08, 0x03, 0x18,
  0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x02, 0x20,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x04, 0x40,
  0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0,
  0x18, 0x60, 0x30, 0x70, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xC0,
  0xC0, 0x38, 0x30, 0x07, 0x08, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x0C, 0x60,
  0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x18, 0x40, 0x0C, 0x30, 0x07,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x06,
  0x1C, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x02, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x04, 0x40, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x18, 0xC0, 0x18, 0x60, 0x30, 0x78, 0xE0, 0x3F, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x0F, 0xF8,
  0x03, 0xFF, 0xC0, 0xC0, 0x38, 0x30, 0x06, 0x08, 0x00, 0xC2, 0x00, 0x31,
  0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x18, 0x40,
  0x0C, 0x30, 0x0E, 0x0F, 0xFF, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x20,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x60, 0x18, 0x18, 0x06, 0x06,
  0x00, 0xC1, 0x00, 0x30, 0x40, 0x0C, 0x30, 0x01, 0x80, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x70, 0x38, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x00, 0x21, 0x80,
  0x18, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0xC0, 0x02, 0x30, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x30, 0x38, 0x78, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x43, 0x00,
  0x61, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x02, 0x18,
  0x01, 0x08, 0x01, 0x84, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18,
  0xC0, 0x08, 0x60, 0x0C, 0x20, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00,
  0x86, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x60, 0x78, 0xE0, 0x1F, 0xE0, 0x00,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C,
  0x40, 0x0C, 0x40, 0x18, 0x60, 0x18, 0x60, 0x30, 0x60, 0x30, 0x60, 0x20,
  0x60, 0x60, 0x60, 0x60, 0x20, 0xC0, 0x20, 0xC0, 0x21, 0x80, 0x31, 0x80,
  0x31, 0x00, 0x33, 0x00, 0x32, 0x00, 0x36, 0x00, 0x36, 0x00, 0x14, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x40, 0x60, 0x68, 0x0C, 0x0D, 0x03, 0x81, 0xA0,
  0x50, 0x24, 0x0A, 0x0C, 0x83, 0x41, 0x90, 0x48, 0x22, 0x09, 0x0C, 0x43,
  0x21, 0x88, 0x64, 0x31, 0x08, 0x84, 0x21, 0x11, 0x8C, 0x62, 0x31, 0x88,
  0x44, 0x31, 0x08, 0x86, 0x61, 0x30, 0xC8, 0x26, 0x19, 0x04, 0x83, 0x60,
  0xB0, 0x68, 0x36, 0x0D, 0x06, 0x81, 0xA0, 0xD0, 0x3C, 0x1E, 0x07, 0x03,
  0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0x06, 0x00, 0x18, 0x30, 0x01, 0x80,
  0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x10, 0x0C, 0x00, 0xC0, 0x40, 0x06, 0x06,
  0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x02, 0x20, 0x00, 0x1B, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x19, 0x00,
  0x01, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0xC0,
  0x20, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x00, 0x30, 0x60, 0x01, 0x87,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0xD0, 0x00, 0x66, 0x00, 0x11, 0x80, 0x0C,
  0x20, 0x06, 0x0C, 0x01, 0x03, 0x00, 0xC0, 0x40, 0x60, 0x18, 0x10, 0x06,
  0x0C, 0x00, 0x86, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x01, 0x60, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFC, 0x3F, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0x83, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x08, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00,
  0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x1E,
  0x00, 0xD8, 0x03, 0x60, 0x18, 0x80, 0xC3, 0x03, 0x0C, 0x18, 0x30, 0x60,
  0x63, 0x01, 0x9C, 0x06, 0x60, 0x1B, 0x00, 0x30, 0xFF, 0xFF, 0x80, 0xE3,
  0x0C, 0x70, 0x01, 0x80, 0x07, 0xF3, 0x0C, 0x1A, 0x18, 0x0E, 0x30, 0x06,
  0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x04, 0x60, 0x04, 0x40, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18,
  0x60, 0x38, 0x70, 0xD8, 0x3F, 0x98, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x20, 0x19, 0xFC, 0x1E, 0x0E,
  0x1C, 0x06, 0x18, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x02, 0x30, 0x02, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x0C, 0x60, 0x0C, 0x50, 0x18, 0x58, 0x70, 0xCF, 0xE0, 0x00, 0xE0,
  0x07, 0xF8, 0x0C, 0x1C, 0x18, 0x06, 0x30, 0x06, 0x20, 0x06, 0x60, 0x06,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0x60, 0x30, 0x78, 0xE0,
  0x3F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x06, 0x0C, 0x0F, 0xE6, 0x0C, 0x1A, 0x0C, 0x07, 0x0C,
  0x01, 0x84, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x10, 0xC0, 0x08,
  0x40, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0xC3, 0x00, 0x60, 0xC0, 0x70, 0x70, 0xD8, 0x1F, 0xCC, 0x00, 0x00, 0xC0,
  0x0F, 0xF0, 0x30, 0x70, 0xC0, 0x63, 0x00, 0x64, 0x00, 0xD8, 0x01, 0xB0,
  0x03, 0x60, 0x06, 0xFF, 0xF9, 0xFF, 0xF6, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x04, 0xC0, 0x18, 0xC0, 0x61, 0xC3, 0x81, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x08, 0x3F, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0x80, 0x07, 0xF3, 0x0C, 0x1A, 0x18, 0x0E,
  0x30, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x04, 0x60, 0x04,
  0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0x60, 0x28,
  0x70, 0x78, 0x3F, 0xD8, 0x04, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xE0, 0x7F, 0x80, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x20, 0x19, 0xFC,
  0x1A, 0x0E, 0x1C, 0x06, 0x18, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x30, 0x02, 0x30, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x0C,
  0x00, 0x30, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x20, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x81, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x07, 0x80, 0xFF,
  0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x07, 0x18, 0x03, 0x06, 0x01,
  0xC1, 0x80, 0x60, 0x40, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x03, 0x06, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0C, 0x18, 0x02, 0x06, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x30, 0x40, 0x0C, 0x30, 0x01,
  0x80, 0xFF, 0x03, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0F, 0xFC, 0x1F, 0xE0, 0x00,
  0x81, 0x06, 0xFB, 0xF1, 0xC6, 0x8C, 0x61, 0xC3, 0x10, 0x20, 0xCC, 0x18,
  0x33, 0x06, 0x0C, 0xC1, 0x83, 0x30, 0x60, 0xCC, 0x10, 0x22, 0x04, 0x18,
  0x83, 0x06, 0x60, 0xC1, 0x98, 0x30, 0x66, 0x0C, 0x19, 0x83, 0x04, 0x60,
  0x81, 0x10, 0x20, 0xCC, 0x18, 0x33, 0x06, 0x0C, 0x00, 0x20, 0x19, 0xFC,
  0x1A, 0x0E, 0x1C, 0x06, 0x18, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x30, 0x02, 0x30, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x0C,
  0x00, 0xC0, 0x0F, 0xF0, 0x30, 0x70, 0xC0, 0x63, 0x00, 0x64, 0x00, 0xD8,
  0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x09, 0x00, 0x16, 0x00, 0x6C, 0x00,
  0xD8, 0x01, 0xB0, 0x03, 0x60, 0x0C, 0xC0, 0x18, 0xC0, 0x61, 0xC3, 0x81,
  0xFE, 0x00, 0x00, 0x10, 0x06, 0x7F, 0x03, 0xC1, 0xC1, 0xC0, 0x60, 0xC0,
  0x18, 0x60, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x86,
  0x00, 0x42, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x0C,
  0x30, 0x06, 0x14, 0x06, 0x0B, 0x0E, 0x0C, 0xFE, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x07, 0xF3, 0x1C, 0x1A, 0x18, 0x0E, 0x30, 0x06, 0x20, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x04, 0x60, 0x04, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0x60, 0x38, 0x70, 0xD8,
  0x3F, 0x98, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x1B, 0xFC, 0x16, 0x0E, 0x18, 0x06, 0x38, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x20, 0x04, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x07, 0xFE, 0x0E, 0x07,
  0x18, 0x03, 0x18, 0x01, 0x10, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0xC0, 0x06, 0x40, 0x06, 0x60, 0x0C, 0x78, 0x38, 0x1F, 0xF0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x3F, 0xFF, 0x83,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x30, 0x03, 0x30,
  0x02, 0x30, 0x02, 0x20, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x04, 0x60, 0x0C, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x08, 0xC0, 0x18, 0xC0, 0x18, 0x60, 0x30, 0x78, 0xE0, 0x3F, 0xC0, 0xC0,
  0x03, 0x40, 0x06, 0x40, 0x04, 0x60, 0x0C, 0x60, 0x08, 0x60, 0x18, 0x60,
  0x10, 0x20, 0x30, 0x20, 0x20, 0x30, 0x60, 0x30, 0x40, 0x30, 0xC0, 0x10,
  0x80, 0x11, 0x80, 0x19, 0x00, 0x1B, 0x00, 0x1A, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0xC0, 0xC0, 0xF0, 0x70, 0x6C, 0x14, 0x1B, 0x05, 0x06, 0xC3, 0x41,
  0x30, 0x90, 0xCC, 0x24, 0x33, 0x19, 0x08, 0xC4, 0x46, 0x31, 0x11, 0x8C,
  0xC4, 0x43, 0x21, 0x30, 0xC8, 0x4C, 0x36, 0x12, 0x0D, 0x05, 0x83, 0x41,
  0x60, 0xF0, 0x50, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x0C, 0x00, 0xE1, 0x80,
  0x30, 0x18, 0x0C, 0x01, 0x03, 0x00, 0x30, 0xC0, 0x02, 0x18, 0x00, 0x66,
  0x00, 0x05, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0x98,
  0x00, 0x31, 0x00, 0x0C, 0x30, 0x03, 0x02, 0x00, 0xC0, 0x60, 0x30, 0x04,
  0x0C, 0x00, 0xC3, 0x80, 0x0C, 0x00, 0x30, 0x02, 0x60, 0x0C, 0x80, 0x1B,
  0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0x30, 0x06, 0x40, 0x0D, 0x80,
  0x1B, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x98, 0x03, 0x38, 0x0E, 0x38, 0x2C,
  0x3F, 0x98, 0x08, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x1C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x02, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x20, 0xC0, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x80,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x08, 0x03,
  0x3E, 0x03, 0x63, 0x03, 0xC1, 0x82, 0xC0, 0xC6, 0xC0, 0xFE, 0xC0, 0x38,
};

const GFXglyph JetBrainsMono_ThinItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 7, 26, 21, 7, -26 },
  { 24, 11, 11, 21, 7, -26 },
  { 40, 20, 26, 21, 1, -26 },
  { 105, 18, 35, 21, 2, -30 },
  { 184, 24, 26, 21, -1, -26 },
  { 262, 19, 26, 21, 1, -26 },
  { 324, 3, 11, 21, 11, -26 },
  { 329, 14, 34, 21, 6, -30 },
  { 389, 13, 34, 21, 2, -30 },
  { 445, 18, 17, 21, 2, -21 },
  { 484, 16, 17, 21, 3, -20 },
  { 518, 8, 11, 21, 4, -5 },
  { 529, 12, 1, 21, 5, -12 },
  { 531, 5, 5, 21, 7, -5 },
  { 535, 20, 33, 21, 1, -29 },
  { 618, 18, 26, 21, 2, -26 },
  { 677, 15, 26, 21, 2, -26 },
  { 726, 18, 26, 21, 2, -26 },
  { 785, 17, 26, 21, 2, -26 },
  { 841, 15, 26, 21, 3, -26 },
  { 890, 16, 26, 21, 3, -26 },
  { 942, 16, 26, 21, 2, -26 },
  { 994, 17, 26, 21, 4, -26 },
  { 1050, 17, 26, 21, 2, -26 },
  { 1106, 16, 26, 21, 4, -26 },
  { 1158, 7, 20, 21, 7, -20 },
  { 1176, 10, 26, 21, 4, -20 },
  { 1209, 17, 17, 21, 3, -20 },
  { 1246, 16, 9, 21, 3, -16 },
  { 1264, 16, 17, 21, 2, -20 },
  { 1298, 13, 26, 21, 6, -26 },
  { 1341, 20, 32, 21, 1, -26 },
  { 1421, 16, 26, 21, 1, -26 },
  { 1473, 17, 26, 21, 2, -26 },
  { 1529, 17, 26, 21, 3, -26 },
  { 1585, 17, 26, 21, 2, -26 },
  { 1641, 17, 26, 21, 3, -26 },
  { 1697, 19, 26, 21, 2, -26 },
  { 1759, 17, 26, 21, 3, -26 },
  { 1815, 18, 26, 21, 2, -26 },
  { 1874, 16, 26, 21, 3, -26 },
  { 1926, 18, 26, 21, 1, -26 },
  { 1985, 19, 26, 21, 2, -26 },
  { 2047, 14, 26, 21, 3, -26 },
  { 2093, 18, 26, 21, 2, -26 },
  { 2152, 18, 26, 21, 2, -26 },
  { 2211, 16, 26, 21, 3, -26 },
  { 2263, 18, 26, 21, 2, -26 },
  { 2322, 16, 32, 21, 3, -26 },
  { 2386, 18, 26, 21, 2, -26 },
  { 2445, 18, 26, 21, 2, -26 },
  { 2504, 17, 26, 21, 4, -26 },
  { 2560, 17, 26, 21, 3, -26 },
  { 2616, 16, 26, 21, 5, -26 },
  { 2668, 19, 26, 21, 3, -26 },
  { 2730, 21, 26, 21, 0, -26 },
  { 2799, 18, 26, 21, 4, -26 },
  { 2858, 18, 26, 21, 2, -26 },
  { 2917, 13, 33, 21, 6, -29 },
  { 2971, 10, 33, 21, 6, -29 },
  { 3013, 13, 33, 21, 3, -29 },
  { 3067, 14, 14, 21, 4, -26 },
  { 3092, 17, 1, 21, 0, 1 },
  { 3095, 5, 4, 21, 10, -27 },
  { 3098, 16, 20, 21, 3, -20 },
  { 3138, 16, 26, 21, 2, -26 },
  { 3190, 16, 20, 21, 3, -20 },
  { 3230, 17, 26, 21, 3, -26 },
  { 3286, 15, 20, 21, 3, -20 },
  { 3324, 22, 32, 21, -1, -26 },
  { 3412, 16, 26, 21, 3, -20 },
  { 3464, 16, 26, 21, 2, -26 },
  { 3516, 15, 27, 21, 2, -27 },
  { 3567, 17, 33, 21, 1, -27 },
  { 3638, 18, 26, 21, 2, -26 },
  { 3697, 14, 26, 21, 4, -26 },
  { 3743, 18, 20, 21, 1, -20 },
  { 3788, 16, 20, 21, 2, -20 },
  { 3828, 15, 20, 21, 3, -20 },
  { 3866, 17, 26, 21, 1, -20 },
  { 3922, 16, 26, 21, 3, -20 },
  { 3974, 16, 20, 21, 3, -20 },
  { 4014, 16, 20, 21, 2, -20 },
  { 4054, 15, 25, 21, 4, -25 },
  { 4101, 16, 19, 21, 3, -19 },
  { 4139, 16, 19, 21, 4, -19 },
  { 4177, 18, 19, 21, 3, -19 },
  { 4220, 19, 19, 21, 1, -19 },
  { 4266, 15, 25, 21, 3, -19 },
  { 4313, 16, 19, 21, 2, -19 },
  { 4351, 17, 33, 21, 4, -29 },
  { 4422, 7, 33, 21, 7, -29 },
  { 4451, 17, 33, 21, 1, -29 },
  { 4522, 16, 7, 21, 3, -16 },
};

const GFXfont JetBrainsMono_ThinItalic35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_THINITALIC35PT7B_H_
