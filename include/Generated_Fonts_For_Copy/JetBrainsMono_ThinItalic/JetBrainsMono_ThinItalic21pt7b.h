#ifndef _JETBRAINSMONO_THINITALIC21PT7B_H_
#define _JETBRAINSMONO_THINITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x32, 0x22, 0x22, 0x20, 0x06, 0xE0, 0x46, 0x89, 0x16,
  0x2C, 0x51, 0x80, 0x02, 0x10, 0x10, 0x81, 0x08, 0x08, 0x43, 0xFF, 0x84,
  0x20, 0x21, 0x01, 0x10, 0x10, 0x80, 0x84, 0x3F, 0xF8, 0x42, 0x02, 0x10,
  0x31, 0x01, 0x08, 0x00, 0x01, 0x00, 0x20, 0x0C, 0x07, 0x61, 0x24, 0x44,
  0xC8, 0x81, 0x10, 0x34, 0x03, 0x80, 0x1C, 0x02, 0x40, 0x48, 0x09, 0xB1,
  0x26, 0x44, 0x49, 0x87, 0xC0, 0x20, 0x04, 0x00, 0x80, 0x0F, 0x06, 0x22,
  0x10, 0x44, 0x40, 0x89, 0x02, 0x12, 0x02, 0x48, 0x03, 0x20, 0x00, 0x80,
  0x02, 0x70, 0x09, 0x10, 0x24, 0x20, 0x48, 0x41, 0x11, 0x04, 0x22, 0x30,
  0x38, 0x00, 0x02, 0x01, 0xB0, 0x42, 0x08, 0x63, 0x00, 0x20, 0x04, 0x01,
  0xC0, 0x48, 0x28, 0x8A, 0x1A, 0x41, 0x48, 0x11, 0x06, 0x21, 0x23, 0xC6,
  0x69, 0x2D, 0x00, 0x01, 0x06, 0x08, 0x10, 0x20, 0x20, 0x60, 0x40, 0x40,
  0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x38, 0x08,
  0x10, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x60, 0x80, 0x02, 0x00, 0x40,
  0x18, 0x42, 0x1F, 0x4E, 0x3E, 0x03, 0x00, 0xD0, 0x13, 0x04, 0x21, 0x06,
  0x00, 0x04, 0x02, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x10, 0x08,
  0x00, 0x36, 0x64, 0x88, 0xFE, 0x7F, 0x80, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x00, 0x03, 0x01,
  0xF8, 0x41, 0x10, 0x32, 0x06, 0x40, 0x88, 0x13, 0x22, 0x46, 0x48, 0x09,
  0x03, 0x20, 0x44, 0x08, 0x81, 0x18, 0x41, 0xF0, 0x07, 0x04, 0x8C, 0xC4,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x23,
  0xFE, 0x03, 0x03, 0x98, 0x41, 0x10, 0x12, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x07, 0xFC, 0x1F,
  0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x02, 0x60, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x20, 0x44, 0x18, 0x82, 0x0F, 0x80, 0x01, 0x81, 0x01, 0x80,
  0x80, 0x80, 0x80, 0xC2, 0x42, 0x41, 0x40, 0xBF, 0xC0, 0x20, 0x10, 0x18,
  0x08, 0x3F, 0xC8, 0x02, 0x01, 0x00, 0x40, 0x17, 0x86, 0x11, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x04, 0x81, 0x20, 0x87, 0xC0, 0x01, 0x80, 0x80, 0x40,
  0x10, 0x08, 0x04, 0x02, 0xF8, 0xC2, 0x40, 0xD0, 0x14, 0x05, 0x02, 0x40,
  0x90, 0x43, 0xE0, 0xFF, 0xE0, 0x28, 0x12, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x00, 0x03, 0x01,
  0x98, 0x41, 0x10, 0x32, 0x04, 0x40, 0x84, 0x20, 0x78, 0x0E, 0x06, 0x31,
  0x02, 0x20, 0x4C, 0x08, 0x81, 0x10, 0x41, 0xF0, 0x06, 0x06, 0x62, 0x09,
  0x01, 0x40, 0x50, 0x1C, 0x09, 0x02, 0x63, 0x0F, 0x40, 0x20, 0x10, 0x08,
  0x06, 0x01, 0x00, 0x80, 0x31, 0xDC, 0x00, 0x00, 0x00, 0x03, 0x39, 0xC0,
  0x18, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x18, 0x42, 0x08, 0x00,
  0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x20, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x30, 0x30, 0x30, 0x30, 0x30, 0x00, 0x3E, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x78, 0x20, 0x10, 0x08, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x03, 0x01, 0x98, 0x40, 0x90, 0x16, 0x02, 0x80, 0x50, 0xFA,
  0x23, 0x48, 0x39, 0x06, 0x21, 0x44, 0x28, 0x85, 0x11, 0xA1, 0xD4, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x0E, 0x00, 0x01, 0x80, 0xA0, 0x28, 0x1A, 0x04,
  0x81, 0x20, 0x88, 0x22, 0x10, 0x84, 0x13, 0xFC, 0x81, 0x20, 0x50, 0x1C,
  0x04, 0x1F, 0x82, 0x08, 0x81, 0x10, 0x22, 0x04, 0x41, 0x88, 0x61, 0xF8,
  0x40, 0x88, 0x09, 0x01, 0x20, 0x44, 0x08, 0x82, 0x3F, 0x80, 0x06, 0x06,
  0x62, 0x09, 0x01, 0x40, 0xD0, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x81, 0x20, 0x4C, 0x21, 0xF0, 0x1F, 0x84, 0x32, 0x04, 0x81, 0x20,
  0x48, 0x12, 0x04, 0x81, 0x40, 0xD0, 0x24, 0x09, 0x02, 0x41, 0x10, 0xCF,
  0xC0, 0x3F, 0xC8, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0xFC, 0x40,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xF0, 0x1F, 0xF1, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0xFC, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x06, 0x06, 0x62, 0x09, 0x01,
  0x40, 0xD0, 0x04, 0x01, 0x00, 0xC0, 0x23, 0xE8, 0x0A, 0x06, 0x81, 0x20,
  0x4C, 0x21, 0xF0, 0x10, 0x22, 0x0C, 0x81, 0x10, 0x22, 0x04, 0x40, 0x88,
  0x11, 0xFE, 0x40, 0x88, 0x11, 0x02, 0x20, 0x44, 0x08, 0x81, 0x30, 0x40,
  0x3F, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x0F, 0xE0, 0x07, 0xE0, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x40, 0x48,
  0x11, 0x86, 0x1F, 0x80, 0x10, 0x31, 0x04, 0x20, 0x42, 0x08, 0x21, 0x82,
  0x10, 0x22, 0x03, 0xE0, 0x42, 0x04, 0x30, 0x41, 0x04, 0x10, 0x41, 0x84,
  0x08, 0xC0, 0x80, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40,
  0xC0, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x30, 0x66, 0x0C, 0xA2, 0x94, 0x52,
  0x94, 0x54, 0x92, 0x92, 0x22, 0x40, 0x48, 0x09, 0x02, 0x20, 0x48, 0x09,
  0x01, 0x20, 0x20, 0x10, 0x23, 0x04, 0xA1, 0x14, 0x22, 0x84, 0x48, 0x89,
  0x11, 0x22, 0x44, 0x88, 0x51, 0x0A, 0x21, 0x44, 0x28, 0x83, 0x20, 0x40,
  0x06, 0x0C, 0xC8, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81, 0xC0, 0xC0, 0xA0,
  0x50, 0x28, 0x14, 0x0A, 0x08, 0xF8, 0x1F, 0xC2, 0x0C, 0x80, 0x90, 0x12,
  0x02, 0x40, 0xC8, 0x11, 0xFC, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x00, 0x06, 0x0C, 0xC8, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81,
  0xC0, 0xC0, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x08, 0xF8, 0x04, 0x02, 0x01,
  0x80, 0x40, 0x1F, 0xC2, 0x0C, 0x80, 0x90, 0x12, 0x02, 0x40, 0x88, 0x31,
  0xF8, 0x42, 0x08, 0x41, 0x0C, 0x20, 0x84, 0x10, 0x83, 0x30, 0x20, 0x03,
  0x01, 0x98, 0x41, 0x10, 0x32, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x07, 0x00,
  0x10, 0x02, 0x00, 0x6C, 0x09, 0x81, 0x10, 0x41, 0xF0, 0xFF, 0xC2, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x20, 0x58, 0x14, 0x09, 0x02, 0x40, 0x90, 0x24,
  0x09, 0x02, 0x81, 0x20, 0x48, 0x12, 0x04, 0x81, 0x30, 0x87, 0xC0, 0x80,
  0xE0, 0x28, 0x12, 0x04, 0xC1, 0x10, 0x84, 0x21, 0x10, 0x44, 0x12, 0x04,
  0x81, 0x20, 0x50, 0x14, 0x02, 0x00, 0x86, 0x30, 0x86, 0x29, 0x45, 0x28,
  0xA5, 0x28, 0xA5, 0x24, 0xA4, 0xA4, 0x94, 0x92, 0x94, 0x62, 0x8C, 0x51,
  0x8C, 0x21, 0x80, 0x10, 0x18, 0x41, 0x02, 0x18, 0x08, 0x80, 0x48, 0x02,
  0x80, 0x0C, 0x00, 0x40, 0x05, 0x00, 0x48, 0x06, 0x20, 0x21, 0x02, 0x0C,
  0x20, 0x23, 0x01, 0x80, 0x80, 0xE0, 0x24, 0x11, 0x0C, 0x42, 0x09, 0x02,
  0xC0, 0xA0, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x3F,
  0xE0, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x03,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x3F, 0xE0, 0x1F, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0xF8, 0x84, 0x30, 0x84, 0x21, 0x04, 0x21, 0x08, 0x61, 0x08,
  0x42, 0x08, 0x42, 0x1F, 0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0xF8, 0x06, 0x05,
  0x02, 0x82, 0x43, 0x11, 0x09, 0x05, 0x83, 0xFF, 0xC0, 0xCC, 0x1C, 0x91,
  0xD0, 0x68, 0x1C, 0x0C, 0x0A, 0x05, 0x02, 0x81, 0x41, 0xA0, 0xCF, 0xC0,
  0x10, 0x04, 0x02, 0x00, 0x9C, 0x38, 0x88, 0x32, 0x04, 0x81, 0x40, 0xD0,
  0x24, 0x09, 0x02, 0x40, 0x98, 0x4F, 0xE0, 0x0E, 0x18, 0x90, 0x28, 0x1C,
  0x04, 0x02, 0x01, 0x00, 0x81, 0x40, 0xB0, 0x8F, 0x80, 0x00, 0x40, 0x30,
  0x08, 0x72, 0x23, 0x90, 0x64, 0x0B, 0x02, 0x81, 0x20, 0x48, 0x12, 0x04,
  0x83, 0x20, 0xC7, 0xE0, 0x0E, 0x18, 0x90, 0x68, 0x1C, 0x0F, 0xFE, 0x01,
  0x00, 0x80, 0x40, 0xA0, 0x8F, 0x80, 0x00, 0xFC, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x7F, 0xE0, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x0F, 0x00, 0x00, 0x1C, 0x91, 0xD0, 0x68, 0x1C, 0x0C, 0x0A, 0x05,
  0x02, 0x81, 0x61, 0x9F, 0x40, 0x40, 0x20, 0x10, 0x11, 0xF0, 0x10, 0x04,
  0x02, 0x00, 0x9C, 0x38, 0x88, 0x32, 0x04, 0x81, 0x40, 0x90, 0x24, 0x09,
  0x02, 0x40, 0x90, 0x2C, 0x10, 0x03, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x10,
  0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x11, 0xFF, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x18, 0x7C, 0x00, 0x10, 0x02, 0x00, 0x80, 0x10, 0x12, 0x04, 0x41, 0x08,
  0x41, 0x10, 0x7E, 0x08, 0x81, 0x08, 0x21, 0x04, 0x10, 0x82, 0x30, 0x20,
  0xF8, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x01, 0x00, 0x7E, 0x3D, 0xCC, 0xC9, 0x11, 0xA2, 0x24, 0x44,
  0x88, 0x91, 0x14, 0x22, 0x88, 0x51, 0x12, 0x22, 0x44, 0x40, 0x27, 0x0E,
  0x22, 0x0C, 0x81, 0x20, 0x50, 0x24, 0x09, 0x02, 0x40, 0x90, 0x24, 0x0B,
  0x04, 0x0E, 0x18, 0x90, 0x68, 0x1C, 0x0C, 0x0E, 0x05, 0x02, 0x81, 0x40,
  0xA0, 0x8F, 0x80, 0x27, 0x0E, 0x22, 0x04, 0x81, 0x20, 0x50, 0x24, 0x09,
  0x02, 0x40, 0x90, 0x26, 0x13, 0xF8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x1C,
  0x91, 0xD0, 0x68, 0x1C, 0x0C, 0x0A, 0x05, 0x02, 0x81, 0x41, 0xA0, 0xCF,
  0xC0, 0x20, 0x10, 0x08, 0x04, 0x2E, 0x28, 0xD8, 0x28, 0x14, 0x0A, 0x01,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x00, 0x0F, 0x04, 0x32, 0x04, 0x80,
  0x20, 0x0E, 0x00, 0x70, 0x02, 0x00, 0xB0, 0x24, 0x19, 0xFC, 0x08, 0x02,
  0x00, 0x83, 0xFF, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x20, 0x0C, 0x01, 0xF0, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x0C, 0x0A,
  0x05, 0x02, 0x81, 0x41, 0xB0, 0x8F, 0x80, 0xC0, 0x50, 0x24, 0x09, 0x04,
  0x41, 0x10, 0x82, 0x20, 0x90, 0x24, 0x0A, 0x02, 0x80, 0x40, 0x84, 0x63,
  0x18, 0xC6, 0x52, 0x94, 0xA5, 0x2A, 0x52, 0x94, 0xA5, 0x31, 0x8C, 0x63,
  0x18, 0x20, 0x64, 0x08, 0x42, 0x08, 0x80, 0xA0, 0x18, 0x03, 0x00, 0x50,
  0x12, 0x04, 0x21, 0x04, 0x40, 0x40, 0x40, 0xA0, 0x50, 0x28, 0x18, 0x14,
  0x0A, 0x05, 0x02, 0x83, 0x62, 0x9E, 0x80, 0x40, 0x20, 0x10, 0x11, 0xF0,
  0x3F, 0xC0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x08,
  0x04, 0x03, 0xFE, 0x01, 0xC0, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x3C, 0x00, 0x80, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x06, 0x00, 0xE0, 0x18, 0x84, 0x21, 0x08, 0x44, 0x21, 0x08, 0x42, 0x21,
  0x08, 0x42, 0x30, 0x1C, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x00, 0xF0, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x04, 0x0E, 0x00, 0x70, 0xC4, 0x61, 0x70, 0x40,
};

const GFXglyph JetBrainsMono_ThinItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 15, 13, 4, -15 },
  { 9, 7, 6, 13, 4, -15 },
  { 15, 13, 15, 13, 0, -15 },
  { 40, 11, 21, 13, 1, -18 },
  { 69, 15, 15, 13, -1, -15 },
  { 98, 11, 16, 13, 1, -16 },
  { 120, 3, 6, 13, 6, -15 },
  { 123, 8, 21, 13, 4, -18 },
  { 144, 8, 21, 13, 1, -18 },
  { 165, 11, 11, 13, 1, -13 },
  { 181, 9, 10, 13, 2, -12 },
  { 193, 4, 6, 13, 3, -3 },
  { 196, 7, 1, 13, 3, -7 },
  { 197, 3, 3, 13, 4, -3 },
  { 199, 11, 19, 13, 1, -17 },
  { 226, 11, 16, 13, 1, -16 },
  { 248, 9, 15, 13, 1, -15 },
  { 265, 11, 16, 13, 1, -16 },
  { 287, 11, 15, 13, 1, -15 },
  { 308, 9, 15, 13, 2, -15 },
  { 325, 10, 15, 13, 2, -15 },
  { 344, 10, 15, 13, 1, -15 },
  { 363, 10, 15, 13, 3, -15 },
  { 382, 11, 16, 13, 1, -16 },
  { 404, 10, 16, 13, 2, -16 },
  { 424, 5, 12, 13, 4, -12 },
  { 432, 6, 15, 13, 3, -12 },
  { 444, 10, 10, 13, 2, -12 },
  { 457, 9, 6, 13, 2, -10 },
  { 464, 10, 10, 13, 1, -12 },
  { 477, 9, 15, 13, 3, -15 },
  { 494, 11, 20, 13, 1, -16 },
  { 522, 10, 15, 13, 0, -15 },
  { 541, 11, 15, 13, 1, -15 },
  { 562, 10, 16, 13, 2, -16 },
  { 582, 10, 15, 13, 1, -15 },
  { 601, 10, 15, 13, 2, -15 },
  { 620, 12, 15, 13, 1, -15 },
  { 643, 10, 16, 13, 2, -16 },
  { 663, 11, 15, 13, 1, -15 },
  { 684, 10, 15, 13, 2, -15 },
  { 703, 11, 15, 13, 1, -15 },
  { 724, 12, 15, 13, 1, -15 },
  { 747, 8, 15, 13, 2, -15 },
  { 762, 11, 15, 13, 1, -15 },
  { 783, 11, 15, 13, 1, -15 },
  { 804, 9, 16, 13, 2, -16 },
  { 822, 11, 15, 13, 1, -15 },
  { 843, 9, 20, 13, 2, -16 },
  { 866, 11, 15, 13, 1, -15 },
  { 887, 11, 16, 13, 1, -16 },
  { 909, 10, 15, 13, 3, -15 },
  { 928, 10, 15, 13, 2, -15 },
  { 947, 10, 15, 13, 3, -15 },
  { 966, 11, 15, 13, 2, -15 },
  { 987, 13, 15, 13, 0, -15 },
  { 1012, 10, 15, 13, 3, -15 },
  { 1031, 11, 15, 13, 1, -15 },
  { 1052, 8, 19, 13, 3, -17 },
  { 1071, 5, 19, 13, 4, -17 },
  { 1083, 8, 19, 13, 2, -17 },
  { 1102, 9, 8, 13, 2, -15 },
  { 1111, 10, 1, 13, 0, 0 },
  { 1113, 3, 2, 13, 6, -16 },
  { 1114, 9, 12, 13, 2, -12 },
  { 1128, 10, 15, 13, 1, -15 },
  { 1147, 9, 12, 13, 2, -12 },
  { 1161, 10, 15, 13, 2, -15 },
  { 1180, 9, 12, 13, 2, -12 },
  { 1194, 14, 19, 13, -1, -15 },
  { 1228, 9, 16, 13, 2, -12 },
  { 1246, 10, 15, 13, 1, -15 },
  { 1265, 9, 16, 13, 1, -16 },
  { 1283, 11, 20, 13, 0, -16 },
  { 1311, 11, 15, 13, 1, -15 },
  { 1332, 9, 15, 13, 2, -15 },
  { 1349, 11, 12, 13, 1, -12 },
  { 1366, 10, 12, 13, 1, -12 },
  { 1381, 9, 12, 13, 2, -12 },
  { 1395, 10, 16, 13, 1, -12 },
  { 1415, 9, 16, 13, 2, -12 },
  { 1433, 9, 12, 13, 2, -12 },
  { 1447, 10, 12, 13, 1, -12 },
  { 1462, 10, 15, 13, 2, -15 },
  { 1481, 9, 12, 13, 2, -12 },
  { 1495, 10, 12, 13, 2, -12 },
  { 1510, 10, 12, 13, 2, -12 },
  { 1525, 11, 12, 13, 1, -12 },
  { 1542, 9, 16, 13, 2, -12 },
  { 1560, 10, 12, 13, 1, -12 },
  { 1575, 10, 19, 13, 2, -17 },
  { 1599, 5, 19, 13, 4, -17 },
  { 1611, 10, 19, 13, 1, -17 },
  { 1635, 9, 4, 13, 2, -9 },
};

const GFXfont JetBrainsMono_ThinItalic21pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic21pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _JETBRAINSMONO_THINITALIC21PT7B_H_
