#ifndef _JETBRAINSMONO_THINITALIC9PT7B_H_
#define _JETBRAINSMONO_THINITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x88, 0xB7, 0x00, 0x29, 0x5E, 0xAF, 0xAA, 0x80, 0x26, 0xBA,
  0x65, 0xDE, 0x40, 0x66, 0xAB, 0x14, 0x39, 0xAB, 0x80, 0x32, 0x50, 0xCA,
  0xCB, 0xA0, 0xE0, 0x2A, 0x49, 0x24, 0xC0, 0x61, 0x11, 0x11, 0x12, 0xC0,
  0x2B, 0x4A, 0x24, 0xF4, 0x60, 0xE0, 0x80, 0x08, 0x44, 0x42, 0x21, 0x10,
  0x69, 0x9D, 0x99, 0xE0, 0x17, 0x11, 0x22, 0xF0, 0x32, 0x42, 0x11, 0x33,
  0xC0, 0x72, 0x26, 0x19, 0xE0, 0x12, 0x49, 0x96, 0x20, 0x78, 0xE9, 0x19,
  0xE0, 0x22, 0x4A, 0x99, 0xE0, 0xF9, 0x12, 0x24, 0xC0, 0x69, 0x96, 0x99,
  0xE0, 0x69, 0x99, 0x64, 0x40, 0xC0, 0x80, 0x60, 0x05, 0x00, 0x3C, 0xC2,
  0xFE, 0xC2, 0x3C, 0x61, 0x12, 0x40, 0x40, 0x32, 0x57, 0x5A, 0xD6, 0x50,
  0x60, 0x11, 0x35, 0x75, 0x90, 0x69, 0x9E, 0x99, 0xE0, 0x69, 0x88, 0x89,
  0xE0, 0x69, 0x99, 0x99, 0xE0, 0x78, 0x8E, 0x88, 0xE0, 0x78, 0x8F, 0x88,
  0x80, 0x69, 0x88, 0xB9, 0xE0, 0x99, 0x9F, 0x99, 0xA0, 0x72, 0x24, 0x44,
  0xE0, 0x18, 0x42, 0x10, 0xC9, 0xC0, 0x99, 0xAC, 0xAA, 0x90, 0x92, 0x49,
  0x38, 0x4A, 0x5E, 0xD4, 0xC6, 0x20, 0x99, 0xDD, 0xAA, 0xA0, 0x69, 0x99,
  0x99, 0xE0, 0x69, 0x9F, 0x88, 0x80, 0x69, 0x99, 0x99, 0xE2, 0x20, 0x69,
  0x9D, 0xAA, 0xA0, 0x32, 0x50, 0x60, 0xC5, 0xC0, 0xF9, 0x08, 0x84, 0x21,
  0x00, 0x99, 0x99, 0x99, 0xE0, 0x99, 0x9A, 0xA4, 0x40, 0xAD, 0x7D, 0x6B,
  0x52, 0x80, 0x4A, 0x4C, 0x42, 0x2A, 0x20, 0x8C, 0x98, 0xC4, 0x21, 0x00,
  0x78, 0x44, 0x42, 0x23, 0xC0, 0x74, 0x44, 0x44, 0x8E, 0xAA, 0x95, 0x64,
  0x92, 0x56, 0x26, 0x69, 0xF0, 0x80, 0xF9, 0x99, 0xE0, 0x88, 0xF9, 0x99,
  0xE0, 0x79, 0x89, 0xE0, 0x11, 0xF9, 0x99, 0xE0, 0x79, 0xE8, 0xE0, 0x19,
  0x1E, 0x42, 0x10, 0x88, 0x80, 0xF9, 0x9A, 0x62, 0xC0, 0x88, 0xF9, 0x99,
  0xA0, 0x10, 0x71, 0x22, 0xF0, 0x08, 0x1C, 0x21, 0x08, 0x42, 0xE0, 0x88,
  0x9A, 0xCA, 0xA0, 0xC4, 0x44, 0x44, 0x70, 0x7B, 0x6B, 0x5A, 0x80, 0xF9,
  0x99, 0xA0, 0x79, 0x99, 0xE0, 0x7A, 0x52, 0x97, 0x42, 0x00, 0xF9, 0x99,
  0xE2, 0x20, 0xF9, 0x88, 0x80, 0xF8, 0x61, 0xE0, 0x4F, 0x44, 0x46, 0x99,
  0x99, 0xE0, 0x99, 0xAA, 0x40, 0xDD, 0xBA, 0xA0, 0x49, 0x88, 0xA9, 0x00,
  0x99, 0x9A, 0xE2, 0xC0, 0xF2, 0x48, 0xE0, 0x32, 0x2C, 0x44, 0x46, 0x56,
  0xAA, 0x31, 0x08, 0x72, 0x10, 0x98, 0xDA,
};

const GFXglyph JetBrainsMono_ThinItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 7, 5, 2, -7 },
  { 3, 3, 3, 5, 2, -7 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 4, 9, 5, 1, -8 },
  { 15, 6, 7, 5, 0, -7 },
  { 21, 5, 7, 5, 0, -7 },
  { 26, 1, 3, 5, 3, -7 },
  { 27, 3, 9, 5, 2, -8 },
  { 31, 4, 9, 5, 0, -8 },
  { 36, 4, 4, 5, 1, -5 },
  { 38, 4, 4, 5, 1, -5 },
  { 40, 2, 2, 5, 1, -1 },
  { 41, 3, 1, 5, 1, -3 },
  { 42, 1, 1, 5, 2, -1 },
  { 43, 5, 8, 5, 0, -7 },
  { 48, 4, 7, 5, 1, -7 },
  { 52, 4, 7, 5, 0, -7 },
  { 56, 5, 7, 5, 0, -7 },
  { 61, 4, 7, 5, 1, -7 },
  { 65, 4, 7, 5, 1, -7 },
  { 69, 4, 7, 5, 1, -7 },
  { 73, 4, 7, 5, 1, -7 },
  { 77, 4, 7, 5, 1, -7 },
  { 81, 4, 7, 5, 1, -7 },
  { 85, 4, 7, 5, 1, -7 },
  { 89, 2, 5, 5, 2, -5 },
  { 91, 3, 6, 5, 1, -5 },
  { 94, 4, 4, 5, 1, -5 },
  { 96, 4, 2, 5, 1, -4 },
  { 97, 4, 4, 5, 1, -5 },
  { 99, 4, 7, 5, 1, -7 },
  { 103, 5, 9, 5, 0, -7 },
  { 109, 4, 7, 5, 0, -7 },
  { 113, 4, 7, 5, 1, -7 },
  { 117, 4, 7, 5, 1, -7 },
  { 121, 4, 7, 5, 1, -7 },
  { 125, 4, 7, 5, 1, -7 },
  { 129, 4, 7, 5, 1, -7 },
  { 133, 4, 7, 5, 1, -7 },
  { 137, 4, 7, 5, 1, -7 },
  { 141, 4, 7, 5, 1, -7 },
  { 145, 5, 7, 5, 0, -7 },
  { 150, 4, 7, 5, 1, -7 },
  { 154, 3, 7, 5, 1, -7 },
  { 157, 5, 7, 5, 0, -7 },
  { 162, 4, 7, 5, 1, -7 },
  { 166, 4, 7, 5, 1, -7 },
  { 170, 4, 7, 5, 1, -7 },
  { 174, 4, 9, 5, 1, -7 },
  { 179, 4, 7, 5, 1, -7 },
  { 183, 5, 7, 5, 0, -7 },
  { 188, 5, 7, 5, 1, -7 },
  { 193, 4, 7, 5, 1, -7 },
  { 197, 4, 7, 5, 1, -7 },
  { 201, 5, 7, 5, 1, -7 },
  { 206, 5, 7, 5, 0, -7 },
  { 211, 5, 7, 5, 1, -7 },
  { 216, 5, 7, 5, 0, -7 },
  { 221, 4, 8, 5, 1, -7 },
  { 225, 2, 8, 5, 2, -7 },
  { 227, 3, 8, 5, 1, -7 },
  { 230, 4, 4, 5, 1, -7 },
  { 232, 4, 1, 5, 0, 0 },
  { 233, 1, 1, 5, 3, -7 },
  { 234, 4, 5, 5, 1, -5 },
  { 237, 4, 7, 5, 1, -7 },
  { 241, 4, 5, 5, 1, -5 },
  { 244, 4, 7, 5, 1, -7 },
  { 248, 4, 5, 5, 1, -5 },
  { 251, 5, 9, 5, 0, -7 },
  { 257, 4, 7, 5, 1, -5 },
  { 261, 4, 7, 5, 1, -7 },
  { 265, 4, 7, 5, 0, -7 },
  { 269, 5, 9, 5, 0, -7 },
  { 275, 4, 7, 5, 1, -7 },
  { 279, 4, 7, 5, 1, -7 },
  { 283, 5, 5, 5, 0, -5 },
  { 287, 4, 5, 5, 1, -5 },
  { 290, 4, 5, 5, 1, -5 },
  { 293, 5, 7, 5, 0, -5 },
  { 298, 4, 7, 5, 1, -5 },
  { 302, 4, 5, 5, 1, -5 },
  { 305, 4, 5, 5, 1, -5 },
  { 308, 4, 6, 5, 1, -6 },
  { 311, 4, 5, 5, 1, -5 },
  { 314, 4, 5, 5, 1, -5 },
  { 317, 4, 5, 5, 1, -5 },
  { 320, 5, 5, 5, 0, -5 },
  { 324, 4, 7, 5, 1, -5 },
  { 328, 4, 5, 5, 1, -5 },
  { 331, 4, 8, 5, 1, -7 },
  { 335, 2, 8, 5, 2, -7 },
  { 337, 5, 8, 5, 0, -7 },
  { 342, 4, 2, 5, 1, -4 },
};

const GFXfont JetBrainsMono_ThinItalic9pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic9pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _JETBRAINSMONO_THINITALIC9PT7B_H_
