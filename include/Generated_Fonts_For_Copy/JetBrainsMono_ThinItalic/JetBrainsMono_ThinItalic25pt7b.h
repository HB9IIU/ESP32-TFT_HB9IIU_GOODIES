#ifndef _JETBRAINSMONO_THINITALIC25PT7B_H_
#define _JETBRAINSMONO_THINITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x21, 0x08, 0x46, 0x21, 0x08, 0x42, 0x00, 0x08, 0xE7,
  0x00, 0x63, 0x42, 0x42, 0xC6, 0xC6, 0xC6, 0x84, 0x03, 0x0C, 0x08, 0x20,
  0x21, 0x81, 0x04, 0x04, 0x10, 0xFF, 0xF0, 0x82, 0x02, 0x08, 0x18, 0x60,
  0x41, 0x01, 0x04, 0x0C, 0x20, 0xFF, 0xF0, 0x86, 0x06, 0x10, 0x10, 0x40,
  0x43, 0x03, 0x08, 0x00, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x7F,
  0x04, 0x48, 0x64, 0x62, 0x21, 0x11, 0x10, 0x88, 0x06, 0x40, 0x1A, 0x00,
  0x78, 0x01, 0x60, 0x09, 0x80, 0x44, 0x02, 0x32, 0x11, 0x10, 0x88, 0x88,
  0xC6, 0x4C, 0x1F, 0xC0, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x00, 0x0F,
  0x81, 0x84, 0x40, 0x84, 0x30, 0x82, 0x10, 0x81, 0x08, 0x80, 0x84, 0x80,
  0x46, 0xC0, 0x1C, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x4F, 0x00, 0x48,
  0x40, 0x44, 0x20, 0x66, 0x10, 0x62, 0x08, 0x21, 0x08, 0x20, 0xC4, 0x60,
  0x3C, 0x00, 0x01, 0x00, 0x3F, 0x03, 0x08, 0x30, 0x61, 0x03, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x01, 0xA0, 0x19, 0x86, 0x86, 0x24, 0x12, 0x60,
  0xF3, 0x03, 0x10, 0x18, 0x81, 0x46, 0x11, 0x1F, 0x0C, 0xFF, 0xA8, 0x00,
  0xC0, 0x60, 0x60, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x10, 0x06, 0x00, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x30, 0x18, 0x04, 0x06, 0x03, 0x03, 0x00, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0xE6, 0x77, 0xDE, 0x06, 0x00, 0xA0, 0x1B,
  0x03, 0x10, 0x61, 0x8C, 0x08, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x61,
  0xFF, 0xC1, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x18, 0xCC,
  0x66, 0x31, 0x10, 0xFF, 0xEE, 0xE0, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x01, 0x00, 0xFC, 0x18, 0x63, 0x03, 0x20, 0x36, 0x03, 0x60, 0x34, 0x02,
  0x40, 0x24, 0x62, 0x46, 0x2C, 0x06, 0xC0, 0x68, 0x04, 0x80, 0x48, 0x0C,
  0xC0, 0x86, 0x18, 0x3E, 0x00, 0x01, 0xC0, 0xD0, 0x32, 0x08, 0x42, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x1F, 0xFC, 0x00, 0x80, 0x3F, 0x82, 0x04, 0x20,
  0x33, 0x00, 0x90, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x3F,
  0xF8, 0x3F, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x78, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x48, 0x04, 0x80, 0xC8,
  0x08, 0xC1, 0x07, 0xE0, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08,
  0x03, 0x00, 0xC3, 0x10, 0x64, 0x09, 0x81, 0x60, 0x2C, 0x05, 0xFF, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x1F, 0xF3, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x2F, 0x87, 0x0C, 0x60, 0x46, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x80, 0xC8, 0x08, 0x41, 0x87, 0xE0, 0x01, 0x80, 0x20, 0x08,
  0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0xFC, 0x30, 0xCC, 0x0B, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xA0, 0x14, 0x06, 0x41, 0x87, 0xC0, 0x7F, 0xF4, 0x03,
  0xC0, 0x2C, 0x04, 0xC0, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x01, 0x00, 0xFC, 0x10, 0x23, 0x03, 0x20, 0x32, 0x03, 0x20, 0x23, 0x04,
  0x19, 0x80, 0x60, 0x19, 0x82, 0x0C, 0x40, 0x48, 0x04, 0x80, 0x48, 0x04,
  0x80, 0xCC, 0x18, 0x7F, 0x00, 0x02, 0x03, 0xF0, 0x81, 0x20, 0x34, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x58, 0x19, 0xCE, 0x1C, 0x80, 0x30, 0x0C,
  0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x00, 0x39, 0xDE, 0x60, 0x00,
  0x00, 0x00, 0x01, 0xCE, 0x70, 0x0E, 0x3C, 0x78, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0xC3, 0x06, 0x18, 0x30, 0x41, 0x00, 0x00, 0x10, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x40, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x20, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x00, 0x3F,
  0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x0E, 0x0E, 0x02,
  0x00, 0x80, 0x20, 0x00, 0x00, 0x01, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x80,
  0x1F, 0xC0, 0x81, 0x84, 0x02, 0x30, 0x0C, 0x80, 0x32, 0x00, 0xD8, 0x7A,
  0x43, 0x19, 0x08, 0x24, 0x60, 0x91, 0x06, 0x44, 0x1B, 0x10, 0x48, 0x41,
  0x21, 0x0C, 0x87, 0xD2, 0x04, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0xE0, 0x00, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x60, 0x6C, 0x08, 0x81,
  0x10, 0x42, 0x08, 0x43, 0x08, 0x41, 0x18, 0x23, 0xFE, 0x40, 0xD0, 0x0A,
  0x01, 0xC0, 0x30, 0x04, 0x3F, 0xC3, 0x06, 0x20, 0x22, 0x03, 0x20, 0x32,
  0x02, 0x60, 0x66, 0x0C, 0x7F, 0x04, 0x0C, 0x40, 0x44, 0x06, 0x40, 0x6C,
  0x04, 0x80, 0x48, 0x0C, 0x81, 0x8F, 0xE0, 0x01, 0x00, 0xFE, 0x18, 0x23,
  0x03, 0x20, 0x12, 0x03, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x48, 0x04, 0xC0, 0xC6, 0x18, 0x3E, 0x00,
  0x3F, 0xC3, 0x06, 0x20, 0x22, 0x02, 0x20, 0x22, 0x02, 0x60, 0x26, 0x02,
  0x40, 0x24, 0x06, 0x40, 0x44, 0x04, 0x40, 0x4C, 0x04, 0x80, 0xC8, 0x18,
  0x83, 0x0F, 0xC0, 0x1F, 0xF8, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x7F, 0xC3, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF9, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x7F, 0xE2,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x00, 0x01, 0x00, 0xFE, 0x18, 0x23, 0x03, 0x20, 0x12, 0x03,
  0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x47, 0xE4, 0x02, 0x40, 0x6C, 0x06,
  0xC0, 0x48, 0x04, 0xC0, 0xC6, 0x18, 0x3E, 0x00, 0x30, 0x13, 0x01, 0x20,
  0x32, 0x02, 0x20, 0x22, 0x02, 0x60, 0x26, 0x02, 0x7F, 0xE4, 0x06, 0x40,
  0x44, 0x04, 0x40, 0x4C, 0x04, 0x80, 0xC8, 0x0C, 0x80, 0x88, 0x08, 0x1F,
  0xF0, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x0F, 0xF8, 0x01, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x60,
  0x33, 0x01, 0x18, 0x18, 0x61, 0x81, 0xF8, 0x00, 0x30, 0x19, 0x81, 0x88,
  0x08, 0x40, 0xC2, 0x04, 0x10, 0x41, 0x86, 0x0C, 0x20, 0x7E, 0x02, 0x18,
  0x10, 0x40, 0x82, 0x04, 0x18, 0x60, 0x42, 0x02, 0x10, 0x18, 0x80, 0x44,
  0x02, 0x00, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x3F,
  0xF0, 0x18, 0x1C, 0x60, 0x61, 0x82, 0x8D, 0x0A, 0x34, 0x48, 0x91, 0x62,
  0x49, 0x08, 0xA4, 0x23, 0x10, 0x8C, 0x46, 0x01, 0x10, 0x0C, 0x40, 0x21,
  0x00, 0x84, 0x02, 0x10, 0x08, 0xC0, 0x23, 0x01, 0x80, 0x30, 0x12, 0x81,
  0x28, 0x32, 0x82, 0x28, 0x22, 0xC2, 0x64, 0x26, 0x42, 0x44, 0x64, 0x66,
  0x42, 0x44, 0x24, 0x42, 0x4C, 0x34, 0x81, 0x48, 0x1C, 0x81, 0x88, 0x18,
  0x01, 0x00, 0xFC, 0x18, 0x23, 0x02, 0x20, 0x32, 0x02, 0x20, 0x26, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x64, 0x04, 0x40, 0x4C, 0x04, 0xC0, 0x48, 0x0C,
  0xC0, 0x84, 0x18, 0x3E, 0x00, 0x3F, 0xE1, 0x81, 0x88, 0x04, 0x40, 0x22,
  0x01, 0x10, 0x09, 0x80, 0x4C, 0x04, 0x40, 0xC3, 0xFC, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x00, 0x01,
  0x00, 0xFC, 0x18, 0x23, 0x02, 0x20, 0x32, 0x02, 0x20, 0x26, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x64, 0x04, 0x40, 0x4C, 0x04, 0xC0, 0x48, 0x0C, 0xC0,
  0x84, 0x18, 0x3E, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x08, 0x3F,
  0xE3, 0x03, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x60, 0x36, 0x06, 0x41,
  0xC7, 0xF0, 0x42, 0x04, 0x30, 0x41, 0x0C, 0x10, 0x81, 0x88, 0x08, 0x80,
  0xC8, 0x04, 0x00, 0x80, 0x3F, 0x82, 0x04, 0x20, 0x31, 0x01, 0x88, 0x00,
  0x40, 0x02, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x19, 0x00, 0xC8, 0x04, 0x40, 0x63, 0x06, 0x0F, 0xE0, 0xFF, 0xF0, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x12, 0x01, 0x20, 0x32, 0x03, 0x20, 0x22, 0x02, 0x60, 0x26, 0x02,
  0x40, 0x64, 0x06, 0x40, 0x44, 0x04, 0xC0, 0x4C, 0x04, 0xC0, 0xCC, 0x08,
  0x61, 0x03, 0xE0, 0xC0, 0x34, 0x02, 0x40, 0x24, 0x04, 0x40, 0x44, 0x0C,
  0x60, 0x86, 0x18, 0x61, 0x02, 0x10, 0x22, 0x02, 0x20, 0x26, 0x02, 0x40,
  0x2C, 0x02, 0x80, 0x38, 0x01, 0x00, 0x43, 0x0D, 0x0C, 0x24, 0x30, 0x91,
  0x42, 0x45, 0x11, 0x14, 0x44, 0x91, 0x12, 0x4C, 0xC9, 0x23, 0x24, 0x8D,
  0x12, 0x34, 0x50, 0x91, 0x42, 0x85, 0x0A, 0x14, 0x28, 0x60, 0xC1, 0x83,
  0x06, 0x00, 0x18, 0x06, 0x18, 0x18, 0x10, 0x20, 0x20, 0x80, 0x23, 0x00,
  0x44, 0x00, 0xD0, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x22,
  0x00, 0xC4, 0x03, 0x04, 0x04, 0x08, 0x10, 0x18, 0x60, 0x11, 0x80, 0x30,
  0xC0, 0x1A, 0x01, 0x10, 0x18, 0xC0, 0x82, 0x08, 0x10, 0xC0, 0xC4, 0x02,
  0x40, 0x16, 0x00, 0xE0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00,
  0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x07, 0xFF, 0x00,
  0x0F, 0x8C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x06,
  0x02, 0x01, 0xF8, 0x82, 0x08, 0x30, 0xC1, 0x04, 0x10, 0x60, 0x82, 0x08,
  0x30, 0x41, 0x04, 0x10, 0x60, 0x82, 0x08, 0x30, 0x41, 0x0F, 0xC0, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01,
  0x00, 0x43, 0xF0, 0x06, 0x01, 0xC0, 0x90, 0x64, 0x11, 0x0C, 0x62, 0x09,
  0x02, 0xC0, 0xA0, 0x30, 0xFF, 0xF0, 0xC4, 0x63, 0x0F, 0x23, 0x14, 0x81,
  0xB0, 0x34, 0x06, 0x80, 0xD0, 0x12, 0x02, 0xC0, 0x58, 0x0A, 0x03, 0x60,
  0x64, 0x18, 0x7D, 0x00, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x78, 0x71,
  0x98, 0x1B, 0x03, 0x40, 0x68, 0x0D, 0x01, 0x20, 0x24, 0x05, 0x80, 0xB0,
  0x36, 0x04, 0xC1, 0x97, 0xC0, 0x0F, 0x83, 0x18, 0x81, 0xB0, 0x14, 0x02,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x0A, 0x01, 0x60, 0x46, 0x18, 0x7C,
  0x00, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x0F, 0x21, 0x8A, 0x20, 0x66,
  0x06, 0x40, 0x64, 0x06, 0x40, 0x44, 0x04, 0xC0, 0x4C, 0x04, 0x80, 0xCC,
  0x0C, 0x41, 0x83, 0xE8, 0x0F, 0x83, 0x18, 0x81, 0xB0, 0x34, 0x06, 0x80,
  0xDF, 0xF2, 0x00, 0xC0, 0x18, 0x02, 0x01, 0x60, 0x44, 0x18, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x1F, 0xFE, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x0F, 0x23,
  0x14, 0x81, 0xB0, 0x34, 0x06, 0x80, 0xD0, 0x12, 0x02, 0xC0, 0x58, 0x19,
  0x03, 0x30, 0xE3, 0xE8, 0x01, 0x00, 0x20, 0x04, 0x01, 0x0F, 0xC1, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x78, 0x71, 0x98, 0x1B, 0x03,
  0x40, 0x68, 0x0D, 0x01, 0x20, 0x24, 0x05, 0x80, 0xA0, 0x34, 0x06, 0x80,
  0x90, 0x10, 0x01, 0xC0, 0x38, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x43, 0xFF, 0x80, 0x00, 0x70, 0x07, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x20, 0xFC, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x32, 0x02, 0x20, 0x46, 0x08, 0x41, 0x84, 0x30, 0x7E, 0x04, 0x60, 0x42,
  0x0C, 0x30, 0xC1, 0x08, 0x18, 0x80, 0x88, 0x0C, 0xFC, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x30, 0x07, 0xF0, 0x2E, 0x71, 0x9C, 0xC8, 0x46,
  0x46, 0x36, 0x31, 0x21, 0x09, 0x08, 0x48, 0x42, 0x42, 0x12, 0x31, 0xB1,
  0x89, 0x88, 0x48, 0x42, 0x42, 0x10, 0x27, 0x87, 0x19, 0x81, 0xB0, 0x34,
  0x06, 0x80, 0xD0, 0x12, 0x02, 0x40, 0x58, 0x0A, 0x03, 0x40, 0x68, 0x09,
  0x01, 0x00, 0x0F, 0x83, 0x18, 0x81, 0xB0, 0x34, 0x06, 0x80, 0xD0, 0x12,
  0x02, 0xC0, 0x58, 0x0A, 0x03, 0x60, 0x44, 0x18, 0x7C, 0x00, 0x13, 0xC1,
  0xC6, 0x30, 0x33, 0x03, 0x20, 0x32, 0x03, 0x20, 0x22, 0x02, 0x60, 0x26,
  0x02, 0x60, 0x66, 0x04, 0x60, 0xC5, 0xF0, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x00, 0x0F, 0x23, 0x14, 0x81, 0xB0, 0x34, 0x06, 0x80, 0xD0,
  0x12, 0x02, 0xC0, 0x58, 0x0A, 0x03, 0x60, 0x64, 0x18, 0x7D, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x37, 0xC2, 0x86, 0x30, 0x22, 0x02,
  0x20, 0x26, 0x02, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x0F, 0xC6, 0x0C, 0x80, 0xB0, 0x04, 0x00, 0xC0, 0x0F,
  0x80, 0x3C, 0x00, 0xC0, 0x08, 0x01, 0x40, 0x2C, 0x08, 0xFE, 0x00, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x0F, 0xFE, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x30, 0x03, 0xE0,
  0x20, 0x24, 0x05, 0x80, 0xB0, 0x14, 0x06, 0x80, 0xD0, 0x12, 0x02, 0xC0,
  0x58, 0x0B, 0x03, 0x60, 0x46, 0x10, 0x7C, 0x00, 0x80, 0x30, 0x0F, 0x01,
  0x20, 0x64, 0x08, 0x83, 0x10, 0x43, 0x10, 0x22, 0x04, 0x80, 0x90, 0x14,
  0x02, 0x80, 0x20, 0x00, 0x82, 0x0C, 0x30, 0xA1, 0x85, 0x0C, 0x28, 0xA2,
  0x65, 0x13, 0x28, 0x9A, 0x48, 0xD1, 0x46, 0x8A, 0x38, 0x61, 0xC3, 0x0E,
  0x18, 0x60, 0x80, 0x30, 0x18, 0x81, 0x86, 0x08, 0x10, 0x80, 0x48, 0x02,
  0x80, 0x0C, 0x00, 0xE0, 0x0D, 0x00, 0x4C, 0x04, 0x20, 0x41, 0x86, 0x04,
  0x60, 0x30, 0x20, 0x2C, 0x05, 0x00, 0xA0, 0x34, 0x04, 0x80, 0x90, 0x16,
  0x02, 0xC0, 0x58, 0x1B, 0x03, 0x31, 0xC3, 0xC8, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x0F, 0xC3, 0xC0, 0x00, 0x1F, 0xF0, 0x03, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x2F, 0xFC, 0x00, 0x70, 0x18, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x0F, 0xC0, 0xF8, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x08, 0x42, 0x11, 0x88, 0x42, 0x10, 0x8C, 0x62, 0x10, 0x84,
  0x63, 0x10, 0x84, 0x21, 0x18, 0x0C, 0x01, 0x30, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x3F, 0x03,
  0xF0, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x38, 0x0E, 0x00, 0x38, 0x34, 0x42, 0xC6, 0x28, 0x3E, 0x80,
  0x80,
};

const GFXglyph JetBrainsMono_ThinItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 18, 15, 5, -18 },
  { 13, 8, 7, 15, 5, -18 },
  { 20, 14, 18, 15, 1, -18 },
  { 52, 13, 26, 15, 1, -22 },
  { 95, 17, 18, 15, -1, -18 },
  { 134, 13, 19, 15, 1, -19 },
  { 165, 2, 7, 15, 8, -18 },
  { 167, 10, 24, 15, 4, -21 },
  { 197, 10, 24, 15, 1, -21 },
  { 227, 12, 12, 15, 2, -15 },
  { 245, 11, 12, 15, 2, -14 },
  { 262, 5, 8, 15, 3, -4 },
  { 267, 8, 1, 15, 4, -9 },
  { 268, 4, 3, 15, 5, -3 },
  { 270, 14, 24, 15, 1, -21 },
  { 312, 12, 19, 15, 2, -19 },
  { 341, 11, 18, 15, 1, -18 },
  { 366, 13, 19, 15, 1, -19 },
  { 397, 12, 18, 15, 2, -18 },
  { 424, 11, 18, 15, 2, -18 },
  { 449, 12, 18, 15, 2, -18 },
  { 476, 11, 18, 15, 2, -18 },
  { 501, 12, 18, 15, 3, -18 },
  { 528, 12, 19, 15, 2, -19 },
  { 557, 11, 19, 15, 3, -19 },
  { 584, 5, 14, 15, 5, -14 },
  { 593, 7, 18, 15, 3, -14 },
  { 609, 12, 13, 15, 2, -15 },
  { 629, 11, 7, 15, 2, -12 },
  { 639, 12, 13, 15, 1, -15 },
  { 659, 10, 18, 15, 4, -18 },
  { 682, 14, 23, 15, 1, -19 },
  { 723, 11, 18, 15, 1, -18 },
  { 748, 12, 18, 15, 2, -18 },
  { 775, 12, 19, 15, 2, -19 },
  { 804, 12, 18, 15, 2, -18 },
  { 831, 13, 18, 15, 2, -18 },
  { 861, 13, 18, 15, 2, -18 },
  { 891, 12, 19, 15, 2, -19 },
  { 920, 12, 18, 15, 2, -18 },
  { 947, 12, 18, 15, 2, -18 },
  { 974, 13, 18, 15, 1, -18 },
  { 1004, 13, 18, 15, 2, -18 },
  { 1034, 10, 18, 15, 2, -18 },
  { 1057, 14, 18, 15, 1, -18 },
  { 1089, 12, 18, 15, 2, -18 },
  { 1116, 12, 19, 15, 2, -19 },
  { 1145, 13, 18, 15, 2, -18 },
  { 1175, 12, 24, 15, 2, -19 },
  { 1211, 12, 18, 15, 2, -18 },
  { 1238, 13, 19, 15, 1, -19 },
  { 1269, 12, 18, 15, 3, -18 },
  { 1296, 12, 18, 15, 2, -18 },
  { 1323, 12, 18, 15, 3, -18 },
  { 1350, 14, 18, 15, 2, -18 },
  { 1382, 15, 18, 15, 0, -18 },
  { 1416, 13, 18, 15, 3, -18 },
  { 1446, 13, 18, 15, 1, -18 },
  { 1476, 9, 24, 15, 4, -21 },
  { 1503, 6, 24, 15, 5, -21 },
  { 1521, 10, 24, 15, 2, -21 },
  { 1551, 10, 10, 15, 3, -18 },
  { 1564, 12, 1, 15, 0, 1 },
  { 1566, 4, 4, 15, 7, -20 },
  { 1568, 11, 14, 15, 2, -14 },
  { 1588, 11, 18, 15, 2, -18 },
  { 1613, 11, 14, 15, 2, -14 },
  { 1633, 12, 18, 15, 2, -18 },
  { 1660, 11, 14, 15, 2, -14 },
  { 1680, 16, 23, 15, -1, -18 },
  { 1726, 11, 19, 15, 2, -14 },
  { 1753, 11, 18, 15, 2, -18 },
  { 1778, 11, 19, 15, 1, -19 },
  { 1805, 12, 24, 15, 1, -19 },
  { 1841, 12, 18, 15, 2, -18 },
  { 1868, 10, 18, 15, 3, -18 },
  { 1891, 13, 14, 15, 1, -14 },
  { 1914, 11, 14, 15, 2, -14 },
  { 1934, 11, 14, 15, 2, -14 },
  { 1954, 12, 19, 15, 1, -14 },
  { 1983, 11, 19, 15, 2, -14 },
  { 2010, 12, 14, 15, 2, -14 },
  { 2031, 11, 14, 15, 2, -14 },
  { 2051, 11, 18, 15, 3, -18 },
  { 2076, 11, 14, 15, 2, -14 },
  { 2096, 11, 14, 15, 3, -14 },
  { 2116, 13, 14, 15, 2, -14 },
  { 2139, 13, 14, 15, 1, -14 },
  { 2162, 11, 19, 15, 2, -14 },
  { 2189, 12, 14, 15, 1, -14 },
  { 2210, 12, 24, 15, 3, -21 },
  { 2246, 5, 24, 15, 5, -21 },
  { 2261, 12, 24, 15, 1, -21 },
  { 2297, 12, 5, 15, 2, -11 },
};

const GFXfont JetBrainsMono_ThinItalic25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_THINITALIC25PT7B_H_
