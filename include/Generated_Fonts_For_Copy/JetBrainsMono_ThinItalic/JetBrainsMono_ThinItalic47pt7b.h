#ifndef _JETBRAINSMONO_THINITALIC47PT7B_H_
#define _JETBRAINSMONO_THINITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xE1,
  0xF0, 0xF8, 0x78, 0x00, 0x38, 0x1E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE7,
  0x81, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0x71, 0x80,
  0xE3, 0x01, 0xC6, 0x03, 0x1C, 0x06, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x38, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x30,
  0x06, 0x00, 0x06, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x06, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x06, 0x00, 0x06, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x01,
  0xC0, 0x30, 0x00, 0x30, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0xFE, 0xF8, 0x07, 0x8C, 0x78, 0x0C, 0x18, 0x30, 0x38, 0x30,
  0x70, 0x60, 0x60, 0xE1, 0xC0, 0xC1, 0xC3, 0x03, 0x03, 0x86, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x78, 0x60, 0x00,
  0x70, 0x80, 0x00, 0x7B, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x37, 0xC0, 0x00, 0x63, 0x80, 0x01, 0x83, 0x80, 0x03,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x1C, 0xE0, 0x30,
  0x31, 0xC0, 0x40, 0x63, 0x81, 0x80, 0xC7, 0x03, 0x03, 0x86, 0x06, 0x0E,
  0x0E, 0x0C, 0x38, 0x0E, 0x18, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0xFE, 0x00, 0x06, 0x01, 0xEF, 0x00, 0x0C, 0x03, 0x83, 0x80, 0x18,
  0x03, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x70, 0x06, 0x01, 0x80, 0xE0,
  0x06, 0x01, 0x81, 0xC0, 0x06, 0x03, 0x81, 0x80, 0x06, 0x03, 0x03, 0x00,
  0x0E, 0x03, 0x06, 0x00, 0x0C, 0x03, 0x0C, 0x00, 0x0E, 0x07, 0x1C, 0x00,
  0x06, 0x0E, 0x38, 0x00, 0x07, 0xFC, 0x70, 0x00, 0x03, 0xF8, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x0E, 0x3F, 0xC0, 0x00, 0x1C, 0x7F, 0xC0,
  0x00, 0x18, 0xE0, 0xE0, 0x00, 0x30, 0xC0, 0x60, 0x00, 0x61, 0xC0, 0x60,
  0x00, 0xC1, 0x80, 0x60, 0x01, 0x81, 0x80, 0x60, 0x03, 0x81, 0x80, 0x60,
  0x07, 0x01, 0x80, 0xE0, 0x06, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x80, 0xC0,
  0x18, 0x01, 0x80, 0xC0, 0x30, 0x01, 0x81, 0x80, 0x60, 0x01, 0xFF, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x1C, 0x03, 0x80,
  0x1C, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x38, 0x38,
  0x03, 0x30, 0x38, 0x06, 0x70, 0x1C, 0x0E, 0x70, 0x0C, 0x0C, 0x60, 0x0E,
  0x18, 0x60, 0x07, 0x38, 0x60, 0x07, 0x70, 0xE0, 0x03, 0xE0, 0xE0, 0x01,
  0xC0, 0xE0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0xE0, 0xE0, 0x07,
  0x70, 0xE0, 0x0E, 0x30, 0x70, 0x3C, 0x38, 0x7F, 0xF0, 0x18, 0x3F, 0xE0,
  0x1C, 0x39, 0xDE, 0xE7, 0x39, 0xCE, 0x77, 0x39, 0xCE, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x18, 0x07, 0xFC, 0x18, 0x3F, 0x7F, 0x99, 0xFE, 0x0F,
  0xDF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x68, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x87, 0x00, 0x07, 0x07, 0x00, 0x0F,
  0x03, 0x80, 0x1E, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x10,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x0E,
  0x07, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7C, 0xFF, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x1E, 0x01, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x38, 0xE0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00,
  0x07, 0x1C, 0x0C, 0x0E, 0x38, 0x3C, 0x1C, 0x70, 0x78, 0x38, 0xC0, 0xF0,
  0x61, 0x81, 0xC0, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3,
  0x00, 0x03, 0x86, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x3C,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x0F, 0x38, 0x01, 0xC3, 0x00,
  0x78, 0x30, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xC0, 0x1E,
  0x03, 0x80, 0x0E, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x61, 0xC0, 0x00, 0xC3,
  0x80, 0x01, 0x87, 0x00, 0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x1C,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x06, 0x1C, 0x00, 0x63, 0x80,
  0x06, 0x70, 0x00, 0x66, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x06, 0x00, 0x18, 0xFF, 0x80,
  0x6F, 0xFF, 0x03, 0xF0, 0x1E, 0x0F, 0x00, 0x38, 0x38, 0x00, 0x60, 0xE0,
  0x01, 0xC3, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x8C,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x80, 0x0E, 0x0E, 0x00,
  0x30, 0x1E, 0x03, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x8F, 0x00, 0x19,
  0xFF, 0x01, 0xFC, 0xFC, 0x1F, 0x00, 0xF0, 0xE0, 0x03, 0x8E, 0x00, 0x0E,
  0x60, 0x00, 0x77, 0x00, 0x03, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0xE6,
  0x00, 0x06, 0x38, 0x00, 0x61, 0xC0, 0x07, 0x07, 0x80, 0xF0, 0x1F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0x00, 0x01,
  0xD8, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x06, 0x38,
  0x00, 0x38, 0xE0, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xE7, 0xE0, 0x0E,
  0x01, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x38, 0x00, 0x30, 0x70, 0x00,
  0xE0, 0x60, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x00, 0xF1, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x3C, 0x1C, 0x00,
  0xE0, 0x1E, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x70,
  0x00, 0x30, 0xC0, 0x00, 0x63, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x8E, 0x00,
  0x07, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x38, 0x03,
  0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFC,
  0x00, 0xF0, 0xF8, 0x1E, 0x01, 0xE0, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0xE0,
  0x00, 0xE6, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x03, 0xB0, 0x00, 0x19, 0x80, 0x01, 0xCC, 0x00,
  0x0E, 0x70, 0x00, 0xE3, 0xC0, 0x0F, 0x0F, 0x01, 0xF0, 0x3F, 0xFB, 0x00,
  0xFF, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0x38, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x0F, 0x8C, 0x38, 0x07, 0xF9, 0x87, 0x01, 0xE3, 0xB0, 0xC0,
  0x70, 0x1E, 0x18, 0x0C, 0x01, 0xC3, 0x03, 0x80, 0x30, 0x60, 0x60, 0x06,
  0x1C, 0x0C, 0x00, 0xC3, 0x81, 0x80, 0x38, 0x60, 0x30, 0x07, 0x0C, 0x0E,
  0x00, 0xE1, 0x81, 0xC0, 0x18, 0x30, 0x30, 0x03, 0x0E, 0x06, 0x00, 0x61,
  0xC0, 0xC0, 0x1C, 0x38, 0x18, 0x03, 0x86, 0x03, 0x80, 0xF0, 0xC0, 0x70,
  0x3C, 0x18, 0x07, 0xFD, 0x83, 0x00, 0x7F, 0x30, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x06, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00,
  0x61, 0x80, 0x03, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x60, 0x01, 0x81,
  0xC0, 0x06, 0x07, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xE0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x61, 0xC0, 0x01,
  0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x30, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x18, 0x01, 0xE0, 0x30, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0xC0,
  0x01, 0x83, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0E,
  0x07, 0x00, 0x38, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x30, 0x0F, 0x80,
  0x60, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x86, 0x00, 0x07, 0x0C,
  0x00, 0x0E, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x18, 0x00,
  0x70, 0x70, 0x07, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0x1F, 0x00, 0xE0, 0x1E, 0x07, 0x00, 0x38,
  0x38, 0x00, 0x70, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x31, 0x80, 0x01, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x06,
  0x30, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0xE0, 0x78, 0x0F, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x18, 0x03, 0xC0, 0x30, 0x01, 0xC0, 0x60,
  0x01, 0xC0, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x07, 0x00, 0x06, 0x0E, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE1, 0xC0, 0x01,
  0xC3, 0x80, 0x03, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x70, 0x60, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x70, 0xE0,
  0x00, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x07, 0x06, 0x00, 0x1C, 0x0C, 0x00,
  0x70, 0x18, 0x01, 0xC0, 0x70, 0x0F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0x1F, 0x00, 0xE0,
  0x1E, 0x07, 0x00, 0x38, 0x38, 0x00, 0x70, 0xC0, 0x01, 0xC7, 0x00, 0x03,
  0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x01, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x03, 0xFF, 0x9C, 0x0F, 0xFC, 0x70, 0x00, 0x31,
  0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x73, 0x80,
  0x01, 0x8E, 0x00, 0x06, 0x30, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x78, 0x0F, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x70, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x07,
  0x00, 0x06, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x70, 0x60,
  0x00, 0xE1, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x07, 0x00, 0x06, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x30, 0x00, 0x70, 0x60, 0x00, 0xC1, 0xC0, 0x01,
  0x83, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38,
  0x30, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06,
  0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x70, 0x00, 0x60, 0xE0,
  0x00, 0xC1, 0xC0, 0x01, 0x80, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x70,
  0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0x70, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x01,
  0xC0, 0x30, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x60, 0x0E, 0x00,
  0x70, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x38, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x1C, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x01, 0x80, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0x70, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0C, 0x00, 0x18,
  0x06, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x01, 0x80, 0x01, 0x81, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x07, 0x83, 0x60, 0x03, 0xC1,
  0xB0, 0x03, 0x60, 0xD8, 0x01, 0xF0, 0x6C, 0x01, 0xB8, 0x36, 0x00, 0xD8,
  0x19, 0x80, 0xCC, 0x1C, 0xC0, 0x66, 0x0E, 0x60, 0x63, 0x06, 0x30, 0x33,
  0x83, 0x08, 0x31, 0xC1, 0x86, 0x10, 0xC0, 0xC3, 0x18, 0x60, 0xE1, 0x98,
  0x30, 0x70, 0xCC, 0x18, 0x38, 0x2C, 0x1C, 0x18, 0x1E, 0x0E, 0x0C, 0x0E,
  0x06, 0x06, 0x07, 0x03, 0x03, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC1, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x03, 0x83,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x30,
  0x70, 0x00, 0x38, 0x00, 0x07, 0x80, 0x06, 0x0F, 0x00, 0x0C, 0x1E, 0x00,
  0x18, 0x36, 0x00, 0x30, 0x6C, 0x00, 0xE0, 0xD8, 0x01, 0xC3, 0xB0, 0x03,
  0x07, 0x30, 0x06, 0x0C, 0x60, 0x0C, 0x18, 0xC0, 0x18, 0x31, 0x80, 0x70,
  0x63, 0x80, 0xE1, 0xC3, 0x01, 0x83, 0x86, 0x03, 0x06, 0x0C, 0x06, 0x0C,
  0x18, 0x0C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0xC1, 0xC0,
  0xC1, 0x83, 0x80, 0xC3, 0x06, 0x01, 0x86, 0x0C, 0x03, 0x0C, 0x18, 0x06,
  0x38, 0x30, 0x06, 0x60, 0xE0, 0x0C, 0xC1, 0xC0, 0x19, 0x83, 0x00, 0x33,
  0x06, 0x00, 0x76, 0x0C, 0x00, 0x6C, 0x18, 0x00, 0xF8, 0x70, 0x01, 0xE0,
  0xE0, 0x03, 0xC1, 0x80, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0x3F, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0,
  0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01,
  0x86, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC7, 0x00, 0x07, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0x71, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x60, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0x78, 0x0E,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x06, 0x00, 0x1E, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x06, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x78, 0x18, 0x03, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0x3F, 0x00, 0xE0, 0x1C,
  0x07, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0x80,
  0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE3, 0x80, 0x03,
  0x8E, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0xC0, 0x78, 0x0F, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x06, 0x00, 0x3C, 0x06, 0x00, 0x0E,
  0x06, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0C, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0E,
  0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x70,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x18, 0x0C, 0x00, 0x38, 0x0C, 0x00,
  0x38, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x30, 0x07, 0x00, 0x30, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x03, 0x80, 0x70, 0x01, 0x80, 0x60, 0x01, 0x80,
  0x60, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0,
  0x03, 0xE7, 0xE0, 0x1E, 0x01, 0xE0, 0x30, 0x01, 0xC0, 0xE0, 0x01, 0xC1,
  0x80, 0x03, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0xE7,
  0x00, 0x01, 0x8E, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0x3C, 0x03, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00,
  0x60, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x06, 0x0E, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC3,
  0x80, 0x03, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x70, 0x60, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x07, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x70, 0x60, 0x00,
  0xE1, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x18,
  0x0C, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80,
  0x00, 0xEC, 0x00, 0x06, 0x70, 0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x18,
  0x60, 0x01, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x06, 0x06, 0x00,
  0x70, 0x30, 0x03, 0x01, 0xC0, 0x18, 0x0E, 0x01, 0xC0, 0x30, 0x0C, 0x01,
  0x80, 0xE0, 0x0C, 0x06, 0x00, 0x60, 0x70, 0x03, 0x03, 0x00, 0x18, 0x18,
  0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x00, 0xC6, 0x00, 0x06,
  0x70, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x0E, 0x01,
  0xD8, 0x07, 0x80, 0x66, 0x01, 0xE0, 0x19, 0x80, 0x78, 0x0E, 0x60, 0x16,
  0x03, 0x18, 0x0D, 0x80, 0xC6, 0x03, 0x60, 0x31, 0x80, 0xD8, 0x18, 0x60,
  0x66, 0x06, 0x18, 0x19, 0x81, 0x86, 0x06, 0x60, 0xE1, 0x83, 0x18, 0x30,
  0x60, 0xC6, 0x0C, 0x18, 0x31, 0x83, 0x06, 0x08, 0x61, 0xC1, 0x86, 0x18,
  0x60, 0x61, 0x86, 0x18, 0x18, 0x41, 0x86, 0x06, 0x30, 0x63, 0x01, 0x8C,
  0x18, 0xC0, 0x63, 0x06, 0x30, 0x39, 0x81, 0x9C, 0x0E, 0x60, 0x66, 0x03,
  0x98, 0x19, 0x80, 0xE4, 0x04, 0x60, 0x33, 0x01, 0x30, 0x0C, 0xC0, 0x4C,
  0x03, 0x20, 0x13, 0x00, 0xD8, 0x05, 0xC0, 0x36, 0x01, 0x60, 0x0D, 0x00,
  0x58, 0x03, 0xC0, 0x16, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xC0, 0x0E,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x30, 0x00, 0x70, 0x06,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x06, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x38, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC7, 0x00,
  0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x18, 0x01,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xE0,
  0x01, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x30, 0x00,
  0x06, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3B, 0x00, 0x0E, 0x60,
  0x01, 0x8C, 0x00, 0x71, 0xC0, 0x0C, 0x18, 0x03, 0x83, 0x00, 0xE0, 0x70,
  0x18, 0x0E, 0x07, 0x00, 0xC0, 0xC0, 0x18, 0x38, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0x06, 0x70, 0x00, 0xFC, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0xE0, 0xC1, 0xC1, 0xC1, 0x83, 0x80, 0x00, 0xFE, 0x18, 0x1F,
  0xFD, 0xC1, 0xC0, 0x6E, 0x1C, 0x01, 0xF1, 0xC0, 0x07, 0x0C, 0x00, 0x38,
  0xE0, 0x01, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00,
  0x18, 0xE0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x8C,
  0x00, 0x1C, 0xE0, 0x00, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x31, 0xC0, 0x03,
  0x8E, 0x00, 0x1C, 0x70, 0x01, 0xE1, 0xC0, 0x1F, 0x0F, 0x01, 0xB0, 0x3F,
  0xF9, 0x80, 0xFF, 0x8C, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x3F, 0xC0, 0x33, 0xFF, 0x80, 0xD8, 0x0F, 0x03,
  0xC0, 0x1C, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0x86, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE1, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x30,
  0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x70, 0x00,
  0xE1, 0xC0, 0x07, 0x07, 0x80, 0x18, 0x3B, 0x01, 0xE0, 0xEF, 0xFE, 0x03,
  0x9F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xE0, 0x78, 0x1C,
  0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x33, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x39, 0xC0, 0x01, 0x8E, 0x00, 0x1C, 0x70, 0x00,
  0xC1, 0xC0, 0x0E, 0x0F, 0x01, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0xFE,
  0x18, 0x0F, 0xFE, 0xE0, 0x70, 0x1B, 0x83, 0x80, 0x3E, 0x1C, 0x00, 0x70,
  0x60, 0x01, 0xC3, 0x80, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x71, 0xC0,
  0x01, 0xC7, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01,
  0x86, 0x00, 0x0E, 0x18, 0x00, 0x38, 0xE0, 0x00, 0xC3, 0x80, 0x03, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x07, 0x00,
  0x7C, 0x1E, 0x03, 0x60, 0x3F, 0xF9, 0x80, 0x7F, 0xC6, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xFC, 0x07, 0x01, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0x71, 0x80,
  0x07, 0x38, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x37, 0x00, 0x07, 0x70,
  0x00, 0x77, 0x00, 0x07, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x01, 0xCE, 0x00, 0x18, 0x70, 0x03, 0x87, 0x80, 0xF0, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x18, 0x1F, 0xFD, 0xC1, 0xC0, 0x6E, 0x1C, 0x01, 0xF1, 0xC0,
  0x07, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x73,
  0x80, 0x03, 0x9C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x80, 0x03, 0x8C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x06, 0x18,
  0x00, 0x70, 0xE0, 0x07, 0x87, 0x00, 0x7C, 0x1E, 0x06, 0xE0, 0x7F, 0xE7,
  0x01, 0xFC, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x3F, 0xC0, 0x67, 0xFF, 0x03, 0x70, 0x3C, 0x1E,
  0x00, 0xE1, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0x63, 0x00, 0x03,
  0x18, 0x00, 0x38, 0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x70, 0x00, 0x63, 0x80,
  0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x73,
  0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x71, 0x80, 0x03, 0x9C, 0x00, 0x18, 0xE0, 0x00, 0xC7, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x18, 0x07, 0x00,
  0x18, 0x0E, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x30, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x60, 0x03, 0x80, 0x60, 0x01, 0xC0,
  0x60, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x0C, 0xF8, 0x7C,
  0x0F, 0xFC, 0xFE, 0x1A, 0x1D, 0x07, 0x1C, 0x0D, 0x07, 0x1C, 0x0E, 0x07,
  0x18, 0x0C, 0x07, 0x18, 0x0C, 0x06, 0x18, 0x0C, 0x06, 0x38, 0x0C, 0x06,
  0x38, 0x1C, 0x06, 0x30, 0x1C, 0x06, 0x30, 0x18, 0x0E, 0x30, 0x18, 0x0E,
  0x30, 0x18, 0x0C, 0x70, 0x18, 0x0C, 0x70, 0x18, 0x0C, 0x60, 0x38, 0x0C,
  0x60, 0x38, 0x1C, 0x60, 0x30, 0x1C, 0x60, 0x30, 0x18, 0xE0, 0x30, 0x18,
  0xE0, 0x30, 0x18, 0xE0, 0x70, 0x18, 0xC0, 0x70, 0x38, 0xC0, 0x60, 0x38,
  0xC0, 0x60, 0x38, 0x0E, 0x3F, 0xC0, 0x67, 0xFF, 0x03, 0x70, 0x3C, 0x1E,
  0x00, 0xE1, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0x63, 0x00, 0x03,
  0x18, 0x00, 0x38, 0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x70, 0x00, 0x63, 0x80,
  0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x73,
  0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x71, 0x80, 0x03, 0x9C, 0x00, 0x18, 0xE0, 0x00, 0xC7, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0x01, 0xE0, 0xE0, 0x0E, 0x1C, 0x00,
  0x71, 0x80, 0x07, 0x38, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x37, 0x00,
  0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0x66, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0x70, 0x03, 0x07, 0x80, 0xE0,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0x1F, 0xE0, 0x0C, 0xFF, 0xE0, 0x1B,
  0x01, 0xE0, 0x3C, 0x01, 0xC0, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80,
  0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x30, 0x00,
  0x70, 0xE0, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xC1,
  0xC0, 0x01, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x30, 0x3B,
  0x01, 0xE0, 0x77, 0xFF, 0x00, 0xE3, 0xFC, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x18, 0x1F, 0xFD,
  0xC1, 0xC0, 0x6E, 0x1C, 0x01, 0xF1, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0xE0,
  0x01, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x18,
  0xE0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x8C, 0x00,
  0x1C, 0xE0, 0x00, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x31, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x01, 0xE1, 0xC0, 0x1F, 0x0F, 0x01, 0xB0, 0x3F, 0xF9,
  0x80, 0xFF, 0x8C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x0C, 0x7F, 0xC0, 0x33, 0xFF, 0x80, 0xD8, 0x0F, 0x07, 0xC0, 0x1C,
  0x1E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x86, 0x00, 0x0E, 0x18,
  0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x78, 0x07, 0x83, 0x80, 0x0E,
  0x0C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80,
  0x01, 0x87, 0x00, 0x0E, 0x1E, 0x00, 0x70, 0x3F, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x02, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0E,
  0x30, 0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x71, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xC7,
  0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x1C, 0x60, 0x00,
  0xE7, 0x00, 0x06, 0x38, 0x00, 0x31, 0xC0, 0x03, 0x8E, 0x00, 0x18, 0x30,
  0x01, 0xC1, 0xC0, 0x1C, 0x0F, 0x01, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xB0, 0x00, 0x19, 0xC0, 0x01, 0xCE,
  0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x06, 0x0C, 0x00, 0x70, 0x60, 0x03,
  0x03, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18,
  0x0E, 0x00, 0xE0, 0x60, 0x03, 0x07, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x80,
  0x06, 0x18, 0x00, 0x31, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xE0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x18,
  0x07, 0xE0, 0x38, 0x06, 0xE0, 0x38, 0x06, 0xE0, 0x28, 0x06, 0xE0, 0x68,
  0x0C, 0xE0, 0x68, 0x0C, 0xE0, 0x4C, 0x0C, 0xE0, 0xCC, 0x18, 0xE0, 0xCC,
  0x18, 0xE0, 0x8C, 0x18, 0xE1, 0x8C, 0x30, 0x61, 0x8C, 0x30, 0x61, 0x0C,
  0x30, 0x63, 0x0C, 0x60, 0x63, 0x0C, 0x60, 0x66, 0x0C, 0x60, 0x66, 0x0C,
  0xE0, 0x66, 0x0C, 0xC0, 0x6C, 0x0C, 0xC0, 0x6C, 0x0D, 0xC0, 0x6C, 0x0D,
  0x80, 0x78, 0x0D, 0x80, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0x70, 0x0F,
  0x00, 0x70, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x81, 0x80, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0x30, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x03,
  0x81, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x63, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x70, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x38, 0x00, 0x38, 0x78, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x38, 0xC0, 0x01, 0xCE, 0x00, 0x0C, 0x70, 0x00,
  0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x70,
  0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0E,
  0x30, 0x00, 0x71, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0x70, 0xC0, 0x07, 0x87, 0x00, 0x7C, 0x1C, 0x0E, 0xC0,
  0xFF, 0xE6, 0x01, 0xFC, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x70, 0x38, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x19, 0xFE, 0x00, 0xDC,
  0x38, 0x06, 0xC0, 0xC0, 0x36, 0x07, 0x01, 0xF0, 0x1C, 0x1B, 0x00, 0x71,
  0xD8, 0x01, 0xFC, 0xC0, 0x07, 0x80,
};

const GFXglyph JetBrainsMono_ThinItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 9, 34, 28, 10, -34 },
  { 40, 15, 14, 28, 9, -34 },
  { 67, 27, 34, 28, 1, -34 },
  { 182, 23, 48, 28, 3, -41 },
  { 320, 32, 35, 28, -1, -35 },
  { 460, 24, 35, 28, 2, -35 },
  { 565, 5, 14, 28, 14, -34 },
  { 574, 19, 46, 28, 8, -40 },
  { 684, 19, 46, 28, 2, -40 },
  { 794, 24, 24, 28, 3, -29 },
  { 866, 21, 22, 28, 4, -27 },
  { 924, 10, 15, 28, 6, -7 },
  { 943, 15, 3, 28, 7, -17 },
  { 949, 7, 6, 28, 9, -6 },
  { 955, 26, 44, 28, 2, -39 },
  { 1098, 23, 35, 28, 3, -35 },
  { 1199, 20, 34, 28, 3, -34 },
  { 1284, 24, 35, 28, 2, -35 },
  { 1389, 23, 34, 28, 3, -34 },
  { 1487, 20, 34, 28, 4, -34 },
  { 1572, 22, 34, 28, 4, -34 },
  { 1666, 21, 34, 28, 3, -34 },
  { 1756, 22, 34, 28, 6, -34 },
  { 1850, 23, 35, 28, 3, -35 },
  { 1951, 21, 35, 28, 5, -35 },
  { 2043, 10, 26, 28, 9, -26 },
  { 2076, 13, 34, 28, 6, -26 },
  { 2132, 22, 23, 28, 4, -27 },
  { 2196, 21, 13, 28, 4, -22 },
  { 2231, 22, 23, 28, 3, -27 },
  { 2295, 18, 34, 28, 8, -34 },
  { 2372, 27, 43, 28, 1, -35 },
  { 2518, 22, 34, 28, 1, -34 },
  { 2612, 23, 34, 28, 3, -34 },
  { 2710, 22, 35, 28, 4, -35 },
  { 2807, 23, 34, 28, 3, -34 },
  { 2905, 23, 34, 28, 4, -34 },
  { 3003, 25, 34, 28, 3, -34 },
  { 3110, 22, 35, 28, 4, -35 },
  { 3207, 23, 34, 28, 3, -34 },
  { 3305, 22, 34, 28, 4, -34 },
  { 3399, 24, 34, 28, 2, -34 },
  { 3501, 25, 34, 28, 3, -34 },
  { 3608, 19, 34, 28, 4, -34 },
  { 3689, 25, 34, 28, 2, -34 },
  { 3796, 23, 34, 28, 3, -34 },
  { 3894, 22, 35, 28, 4, -35 },
  { 3991, 24, 34, 28, 3, -34 },
  { 4093, 22, 43, 28, 4, -35 },
  { 4212, 24, 34, 28, 3, -34 },
  { 4314, 23, 35, 28, 3, -35 },
  { 4415, 23, 34, 28, 6, -34 },
  { 4513, 23, 34, 28, 4, -34 },
  { 4611, 21, 34, 28, 7, -34 },
  { 4701, 26, 34, 28, 4, -34 },
  { 4812, 28, 34, 28, 0, -34 },
  { 4931, 23, 34, 28, 6, -34 },
  { 5029, 25, 34, 28, 2, -34 },
  { 5136, 18, 44, 28, 7, -39 },
  { 5235, 12, 44, 28, 9, -39 },
  { 5301, 18, 44, 28, 4, -39 },
  { 5400, 19, 18, 28, 5, -34 },
  { 5443, 23, 2, 28, 0, 1 },
  { 5449, 7, 7, 28, 13, -37 },
  { 5456, 21, 26, 28, 4, -26 },
  { 5525, 22, 34, 28, 3, -34 },
  { 5619, 21, 26, 28, 4, -26 },
  { 5688, 22, 34, 28, 4, -34 },
  { 5782, 20, 26, 28, 4, -26 },
  { 5847, 29, 42, 28, -1, -34 },
  { 6000, 21, 34, 28, 4, -26 },
  { 6090, 21, 34, 28, 3, -34 },
  { 6180, 21, 36, 28, 2, -36 },
  { 6275, 23, 44, 28, 1, -36 },
  { 6402, 24, 34, 28, 3, -34 },
  { 6504, 19, 34, 28, 5, -34 },
  { 6585, 24, 26, 28, 2, -26 },
  { 6663, 21, 26, 28, 3, -26 },
  { 6732, 20, 26, 28, 4, -26 },
  { 6797, 23, 34, 28, 2, -26 },
  { 6895, 21, 34, 28, 4, -26 },
  { 6985, 22, 26, 28, 4, -26 },
  { 7057, 22, 26, 28, 3, -26 },
  { 7129, 21, 33, 28, 5, -33 },
  { 7216, 21, 26, 28, 4, -26 },
  { 7285, 21, 26, 28, 6, -26 },
  { 7354, 24, 26, 28, 4, -26 },
  { 7432, 25, 26, 28, 1, -26 },
  { 7514, 21, 34, 28, 4, -26 },
  { 7604, 22, 26, 28, 3, -26 },
  { 7676, 23, 44, 28, 5, -39 },
  { 7803, 9, 44, 28, 10, -39 },
  { 7853, 22, 44, 28, 2, -39 },
  { 7974, 21, 9, 28, 4, -21 },
};

const GFXfont JetBrainsMono_ThinItalic47pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic47pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _JETBRAINSMONO_THINITALIC47PT7B_H_
