#ifndef _JETBRAINSMONO_THINITALIC72PT7B_H_
#define _JETBRAINSMONO_THINITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x03, 0xF0, 0x1F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0x1F, 0x00,
  0x3C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF0,
  0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xF0, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x1E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x73, 0xF8, 0x00, 0x1F,
  0x07, 0x07, 0xC0, 0x03, 0xE0, 0x70, 0x3E, 0x00, 0x78, 0x07, 0x01, 0xE0,
  0x0F, 0x00, 0x60, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0F, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x0F, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x1C, 0x00, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x00, 0x7E, 0x38, 0x00, 0x00,
  0x03, 0xFB, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x77, 0xF0, 0x00, 0x00, 0x07, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x7C, 0x00,
  0x00, 0x07, 0x03, 0xE0, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x00, 0x0E, 0x01,
  0xF0, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0x0F, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x78, 0x01, 0xC0, 0x0E, 0x07, 0x80, 0x1C, 0x01, 0xE0, 0x78, 0x01,
  0xC0, 0x1E, 0x07, 0x80, 0x18, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x7C, 0x03,
  0xE0, 0x38, 0x0F, 0x80, 0x1F, 0x03, 0x81, 0xF0, 0x01, 0xFC, 0x38, 0x7E,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x03,
  0xC0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x78, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x38, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x1F, 0x1F, 0x80, 0x00, 0x00,
  0x3C, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xE7, 0x80, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x78, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0x01, 0xE1,
  0xE0, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x80, 0x38, 0x1C, 0x00, 0x1E,
  0x01, 0xE0, 0x70, 0x00, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x0F,
  0x00, 0x01, 0xE1, 0xC0, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0xF0, 0x00, 0x0F,
  0x78, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x0E, 0x00, 0x00, 0x7F, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x01, 0xE0,
  0x00, 0x1E, 0x78, 0x07, 0x80, 0x00, 0xF9, 0xE0, 0x1F, 0x00, 0x07, 0xC3,
  0xC0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0xFC, 0x03, 0xF0, 0x1E, 0x01, 0xFF,
  0xFF, 0x00, 0x3C, 0x03, 0xFF, 0xF8, 0x00, 0xF0, 0x07, 0xFF, 0x80, 0x01,
  0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8E,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x02, 0x3C, 0x00, 0x38,
  0x00, 0x79, 0xFE, 0x00, 0xE0, 0x0F, 0xEF, 0xFE, 0x03, 0x81, 0xFF, 0xCF,
  0xFF, 0x0C, 0x3F, 0xFC, 0x07, 0xFE, 0x33, 0xFF, 0x80, 0x03, 0xFF, 0xDF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x07,
  0xF9, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0x8F, 0xE0,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0x3C,
  0x1E, 0x01, 0xF8, 0x07, 0x83, 0xC0, 0x7F, 0x00, 0xF0, 0x78, 0x0F, 0xE0,
  0x1E, 0x0F, 0x01, 0xFC, 0x07, 0x83, 0xC0, 0x1F, 0x80, 0xF0, 0x78, 0x01,
  0xE0, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xE0,
  0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x03, 0xF3, 0xC0,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0xFC, 0x03, 0x80, 0x01, 0xF0, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x01, 0x80, 0x07, 0x80, 0x01, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xBC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x7C, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x07, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x01, 0xC1, 0xFF, 0xE0, 0x00, 0x78, 0xFF, 0xFF, 0x00, 0x0F, 0x3F,
  0xFF, 0xF0, 0x01, 0xEF, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x03, 0xE0, 0x07,
  0x60, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xE3, 0xFF, 0xC0, 0x01, 0xCF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xDE, 0x00,
  0x7F, 0xFF, 0xDE, 0x00, 0x0F, 0xFF, 0x9E, 0x00, 0x01, 0xFF, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x02, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3F, 0x83, 0xC0, 0xE0, 0x00, 0x7F, 0xF1, 0xC0, 0x70, 0x00, 0xFF, 0xFC,
  0xE0, 0x78, 0x00, 0xFF, 0x1F, 0x70, 0x3C, 0x00, 0x7C, 0x01, 0xB8, 0x1E,
  0x00, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x78, 0x00, 0x3E, 0x07, 0x00, 0x3C,
  0x00, 0x1E, 0x03, 0x80, 0x1C, 0x00, 0x0F, 0x03, 0xC0, 0x0E, 0x00, 0x07,
  0x81, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x03, 0xC0, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0xE0,
  0x00, 0x38, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x81, 0xE0,
  0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x03, 0x80,
  0x01, 0xE0, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x3C, 0x00, 0x7E, 0x07, 0x00,
  0x1F, 0x00, 0x6E, 0x03, 0x80, 0x07, 0xE0, 0xF7, 0x01, 0xC0, 0x03, 0xFF,
  0xF3, 0x81, 0xE0, 0x00, 0xFF, 0xF1, 0xC0, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x1E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0xF8, 0x07, 0x00, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0xFF, 0xFC, 0x3C, 0x01, 0xFF, 0xFE, 0x0F, 0x00, 0x7F, 0xFF,
  0x83, 0xC0, 0x1F, 0xFF, 0xE0, 0xE0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x0F,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x07, 0x80, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07,
  0x70, 0x00, 0x07, 0xE0, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x1D, 0xC0, 0x00,
  0x3B, 0x80, 0x3B, 0x80, 0x00, 0xEF, 0x00, 0x73, 0x80, 0x01, 0xDE, 0x00,
  0xE7, 0x00, 0x07, 0x38, 0x03, 0xCE, 0x00, 0x0E, 0x70, 0x07, 0x9C, 0x00,
  0x38, 0xE0, 0x0E, 0x18, 0x00, 0x61, 0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x80,
  0x38, 0x70, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x0E, 0x1E, 0x01, 0xE1, 0xC0,
  0x38, 0x38, 0x03, 0xC1, 0x80, 0x70, 0x70, 0x07, 0x83, 0x81, 0xC0, 0xE0,
  0x0E, 0x07, 0x03, 0x83, 0xC0, 0x1C, 0x0E, 0x0E, 0x07, 0x80, 0x38, 0x1C,
  0x1C, 0x0F, 0x00, 0xF0, 0x18, 0x70, 0x1C, 0x01, 0xE0, 0x38, 0xE0, 0x38,
  0x03, 0xC0, 0x73, 0x80, 0x70, 0x07, 0x80, 0xE7, 0x01, 0xE0, 0x0E, 0x01,
  0xDC, 0x03, 0xC0, 0x1C, 0x01, 0xB8, 0x07, 0x80, 0x78, 0x03, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00, 0x1C,
  0x03, 0xE0, 0x00, 0x03, 0x80, 0x7E, 0x00, 0x00, 0x70, 0x1F, 0xC0, 0x00,
  0x1E, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x7F, 0x00, 0x00, 0x78, 0x0E, 0xF0,
  0x00, 0x0E, 0x01, 0xCE, 0x00, 0x01, 0xC0, 0x39, 0xC0, 0x00, 0x38, 0x0F,
  0x38, 0x00, 0x0F, 0x01, 0xE7, 0x80, 0x01, 0xE0, 0x3C, 0x70, 0x00, 0x3C,
  0x07, 0x0E, 0x00, 0x07, 0x00, 0xE1, 0xC0, 0x00, 0xE0, 0x1C, 0x3C, 0x00,
  0x1C, 0x03, 0x83, 0x80, 0x07, 0x80, 0xF0, 0x70, 0x00, 0xF0, 0x1E, 0x0E,
  0x00, 0x1E, 0x03, 0xC1, 0xE0, 0x03, 0x80, 0x70, 0x1C, 0x00, 0x70, 0x0E,
  0x03, 0x80, 0x0E, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0x78,
  0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x3C, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0x1C, 0x07, 0x80, 0xF0, 0x03, 0x80, 0xF0, 0x1C,
  0x00, 0x78, 0x1C, 0x03, 0x80, 0x07, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x70,
  0x0E, 0x00, 0x1C, 0x1E, 0x03, 0xC0, 0x03, 0xC3, 0xC0, 0x78, 0x00, 0x38,
  0x78, 0x0F, 0x00, 0x07, 0x0E, 0x01, 0xC0, 0x00, 0xE1, 0xC0, 0x38, 0x00,
  0x1E, 0x38, 0x07, 0x00, 0x01, 0xCF, 0x01, 0xE0, 0x00, 0x39, 0xE0, 0x3C,
  0x00, 0x07, 0x3C, 0x07, 0x80, 0x00, 0xF7, 0x00, 0xE0, 0x00, 0x1E, 0xE0,
  0x1C, 0x00, 0x01, 0xDC, 0x03, 0x80, 0x00, 0x3B, 0x80, 0xF0, 0x00, 0x07,
  0x70, 0x1E, 0x00, 0x00, 0xFE, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x70, 0x00,
  0x01, 0xF0, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xE0, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x00,
  0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x38, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x38, 0x00, 0x3E, 0x00, 0x0E, 0x38, 0x00, 0x3E,
  0x00, 0x1E, 0x38, 0x00, 0x3E, 0x00, 0x1E, 0x38, 0x00, 0x7E, 0x00, 0x1C,
  0x38, 0x00, 0x7E, 0x00, 0x1C, 0x38, 0x00, 0x7E, 0x00, 0x3C, 0x38, 0x00,
  0xEE, 0x00, 0x3C, 0x38, 0x00, 0xEE, 0x00, 0x38, 0x38, 0x00, 0xEE, 0x00,
  0x78, 0x38, 0x01, 0xCE, 0x00, 0x78, 0x38, 0x01, 0xCE, 0x00, 0x70, 0x38,
  0x01, 0xCE, 0x00, 0x70, 0x38, 0x01, 0x8E, 0x00, 0xF0, 0x38, 0x03, 0x8E,
  0x00, 0xF0, 0x38, 0x03, 0x8E, 0x00, 0xE0, 0x78, 0x03, 0x8E, 0x00, 0xE0,
  0x78, 0x07, 0x0E, 0x01, 0xE0, 0x78, 0x07, 0x0E, 0x01, 0xC0, 0x78, 0x07,
  0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x0E, 0x03,
  0xC0, 0x78, 0x0E, 0x0E, 0x03, 0x80, 0x70, 0x0C, 0x0E, 0x03, 0x80, 0x70,
  0x1C, 0x0E, 0x07, 0x80, 0x70, 0x1C, 0x0E, 0x07, 0x00, 0x70, 0x18, 0x0E,
  0x07, 0x00, 0x70, 0x38, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x0E, 0x0F, 0x00,
  0x70, 0x38, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0x70,
  0x0C, 0x1E, 0x00, 0x70, 0x70, 0x0C, 0x1C, 0x00, 0x70, 0x60, 0x0C, 0x1C,
  0x00, 0x70, 0xE0, 0x0C, 0x1C, 0x00, 0x70, 0xE0, 0x0C, 0x3C, 0x00, 0x70,
  0xC0, 0x0C, 0x38, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x00, 0x71, 0xC0, 0x0C,
  0x38, 0x00, 0x71, 0x80, 0x0C, 0x70, 0x00, 0x73, 0x80, 0x0C, 0x70, 0x00,
  0x73, 0x80, 0x0C, 0x70, 0x00, 0x73, 0x80, 0x0C, 0xF0, 0x00, 0x73, 0x00,
  0x0C, 0xE0, 0x00, 0xF7, 0x00, 0x0C, 0xE0, 0x00, 0xF7, 0x00, 0x0C, 0xE0,
  0x00, 0xF6, 0x00, 0x0D, 0xC0, 0x00, 0xFE, 0x00, 0x0D, 0xC0, 0x00, 0xFE,
  0x00, 0x0D, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x3C, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x07,
  0x80, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x00, 0x07, 0xFE, 0x07, 0x00, 0x1F, 0xFF, 0x87,
  0x00, 0x7F, 0xFF, 0xCF, 0x00, 0xFC, 0x03, 0xEF, 0x01, 0xF0, 0x00, 0xEF,
  0x03, 0xC0, 0x00, 0x7F, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C,
  0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xE0,
  0x3C, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x3D, 0xE0, 0x1F, 0xE3, 0xF9, 0xE0,
  0x0F, 0xFF, 0xE1, 0xC0, 0x03, 0xFF, 0x81, 0xC0, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xFE, 0x00, 0x0E, 0x0F,
  0xFF, 0x80, 0x07, 0x1F, 0xFF, 0xF0, 0x03, 0x9E, 0x00, 0xFC, 0x03, 0xDC,
  0x00, 0x3E, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x07, 0x80, 0xFC, 0x00, 0x07, 0x80, 0xF7, 0x00, 0x07, 0xC0, 0x7B, 0xC0,
  0x0F, 0xC0, 0x3C, 0xFE, 0x3F, 0xC0, 0x1E, 0x3F, 0xFF, 0x80, 0x0E, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x01,
  0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x10, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01,
  0xFF, 0x81, 0xC0, 0x01, 0xFF, 0xF8, 0x70, 0x01, 0xFF, 0xFF, 0x3C, 0x00,
  0xFC, 0x03, 0xEF, 0x00, 0x7C, 0x00, 0x3B, 0xC0, 0x3C, 0x00, 0x07, 0xF0,
  0x1E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x1F, 0x80, 0x3C, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x78, 0x01,
  0xFE, 0x3F, 0x9E, 0x00, 0x3F, 0xFF, 0x87, 0x00, 0x03, 0xFF, 0x81, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07,
  0x00, 0x1F, 0xFF, 0x07, 0x00, 0x7F, 0xFF, 0xCF, 0x00, 0xFC, 0x03, 0xCF,
  0x01, 0xF0, 0x00, 0xEF, 0x03, 0xC0, 0x00, 0x6F, 0x07, 0x80, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xF0,
  0x3C, 0x00, 0x06, 0xE0, 0x1F, 0x00, 0x1E, 0xE0, 0x1F, 0xC0, 0x7C, 0xE0,
  0x0F, 0xFF, 0xF1, 0xE0, 0x03, 0xFF, 0xE1, 0xE0, 0x00, 0xFF, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xC0,
  0x03, 0x83, 0xFF, 0xE0, 0x03, 0x8F, 0xFF, 0xF8, 0x03, 0x9E, 0x01, 0xFC,
  0x07, 0xB8, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x3E, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0x8F, 0xF0, 0x1F, 0xC0,
  0x1C, 0xFF, 0xC3, 0xFF, 0x01, 0xEF, 0xFE, 0x3F, 0xFC, 0x0E, 0xE0, 0xFB,
  0x83, 0xE0, 0x74, 0x03, 0xD0, 0x0F, 0x03, 0xC0, 0x1E, 0x80, 0x78, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0x0E, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x78, 0x00, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0x0F, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x38, 0x00, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0x78,
  0x00, 0xE0, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x38,
  0x00, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x00,
  0xE0, 0xF0, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x03, 0xC1, 0xC0, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0xF0, 0x01, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0xF0,
  0x03, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x70,
  0x01, 0xC0, 0x07, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x01,
  0xC1, 0xE0, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x70, 0x01,
  0xE0, 0x07, 0x83, 0x80, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0xC0, 0xFF, 0xC0, 0x03, 0x83, 0xFF, 0xE0, 0x03, 0x8F, 0xFF, 0xF8,
  0x03, 0x9E, 0x01, 0xFC, 0x07, 0xB8, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0xF0, 0x00,
  0x1C, 0x3F, 0xFF, 0x80, 0x03, 0x8F, 0xFF, 0xF8, 0x00, 0x73, 0xC0, 0x1F,
  0x80, 0x1E, 0xE0, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x01, 0xE0, 0x0F, 0x80, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0x1E, 0xE0, 0x00, 0xF8, 0x03, 0xDE, 0x00, 0x7E,
  0x00, 0x79, 0xFC, 0x7F, 0x80, 0x0F, 0x1F, 0xFF, 0xC0, 0x01, 0xC0, 0xFF,
  0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x07, 0x00, 0x1F, 0xFF, 0x87, 0x00, 0x7F, 0xFF, 0xCF, 0x00,
  0xFC, 0x03, 0xEF, 0x01, 0xF0, 0x00, 0xEF, 0x03, 0xC0, 0x00, 0x7F, 0x07,
  0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x3D, 0xE0, 0x1F, 0xE3, 0xF9, 0xC0, 0x0F, 0xFF, 0xE1, 0xC0, 0x03,
  0xFF, 0x81, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xFF, 0xC0, 0x01,
  0xE1, 0xFF, 0xF8, 0x00, 0xF3, 0xFF, 0xFE, 0x00, 0x73, 0xC0, 0x1F, 0x80,
  0x3B, 0x80, 0x03, 0xE0, 0x3F, 0x80, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0E, 0xE0,
  0x01, 0xF0, 0x00, 0xEE, 0x00, 0x1F, 0x00, 0x1E, 0xE0, 0x03, 0xF0, 0x01,
  0xCE, 0x00, 0x3F, 0x00, 0x1C, 0xE0, 0x03, 0x70, 0x03, 0xCE, 0x00, 0x77,
  0x00, 0x38, 0xE0, 0x07, 0x70, 0x03, 0x8E, 0x00, 0x67, 0x00, 0x78, 0xE0,
  0x0E, 0x70, 0x07, 0x0E, 0x00, 0xE7, 0x00, 0x70, 0xE0, 0x0C, 0x70, 0x0F,
  0x0E, 0x01, 0xC7, 0x00, 0xE0, 0xE0, 0x1C, 0x70, 0x0E, 0x0E, 0x03, 0x87,
  0x01, 0xE0, 0xE0, 0x38, 0x70, 0x1C, 0x0E, 0x03, 0x87, 0x01, 0xC0, 0xE0,
  0x70, 0x30, 0x3C, 0x0E, 0x07, 0x03, 0x03, 0x80, 0xE0, 0x70, 0x30, 0x38,
  0x0E, 0x0E, 0x03, 0x07, 0x80, 0xE0, 0xE0, 0x30, 0x70, 0x0E, 0x0E, 0x03,
  0x07, 0x00, 0xE1, 0xC0, 0x30, 0xF0, 0x0E, 0x1C, 0x03, 0x0E, 0x00, 0xE1,
  0xC0, 0x30, 0xE0, 0x0E, 0x38, 0x03, 0x1E, 0x00, 0xE3, 0x80, 0x39, 0xC0,
  0x0E, 0x30, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x0E, 0x70, 0x03,
  0xB8, 0x00, 0xE6, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE,
  0x00, 0x3F, 0x00, 0x0E, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x38, 0x00,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x1D, 0xE0,
  0x1F, 0x80, 0xF9, 0xE0, 0x0F, 0xFF, 0xF1, 0xE0, 0x07, 0xFF, 0xC1, 0xC0,
  0x01, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0x87, 0xFE, 0x00, 0x03, 0xC7, 0xFF, 0x80, 0x01, 0xE7, 0xC3, 0xE0, 0x00,
  0xE3, 0xC0, 0x78, 0x00, 0x73, 0xC0, 0x1E, 0x00, 0x39, 0xC0, 0x0F, 0x00,
  0x1C, 0xE0, 0x03, 0xC0, 0x1E, 0x70, 0x00, 0xF0, 0x0E, 0x38, 0x00, 0x3C,
  0x0F, 0x3C, 0x00, 0x1F, 0xFF, 0x1E, 0x00, 0x07, 0xFF, 0x0E, 0x00, 0x00,
  0xFE, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 14, 53, 43, 15, -53 },
  { 94, 22, 22, 43, 14, -53 },
  { 155, 41, 53, 43, 2, -53 },
  { 427, 36, 73, 43, 4, -63 },
  { 756, 49, 53, 43, -2, -53 },
  { 1081, 38, 54, 43, 2, -53 },
  { 1338, 7, 22, 43, 22, -53 },
  { 1358, 28, 70, 43, 13, -61 },
  { 1603, 28, 70, 43, 4, -61 },
  { 1848, 38, 37, 43, 4, -44 },
  { 2024, 33, 34, 43, 6, -41 },
  { 2165, 15, 23, 43, 9, -11 },
  { 2209, 24, 3, 43, 10, -25 },
  { 2218, 11, 11, 43, 14, -10 },
  { 2234, 41, 68, 43, 2, -60 },
  { 2583, 35, 54, 43, 5, -53 },
  { 2820, 32, 53, 43, 4, -53 },
  { 3032, 36, 53, 43, 4, -53 },
  { 3271, 35, 54, 43, 5, -53 },
  { 3508, 31, 52, 43, 6, -52 },
  { 3710, 35, 54, 43, 5, -53 },
  { 3947, 32, 54, 43, 5, -53 },
  { 4163, 34, 53, 43, 9, -53 },
  { 4389, 36, 54, 43, 4, -53 },
  { 4632, 33, 53, 43, 8, -53 },
  { 4851, 16, 41, 43, 14, -40 },
  { 4933, 21, 52, 43, 9, -40 },
  { 5070, 33, 36, 43, 7, -42 },
  { 5219, 33, 20, 43, 6, -34 },
  { 5302, 34, 36, 43, 4, -42 },
  { 5455, 28, 53, 43, 12, -53 },
  { 5641, 41, 66, 43, 2, -53 },
  { 5980, 33, 53, 43, 2, -53 },
  { 6199, 35, 53, 43, 5, -53 },
  { 6431, 34, 54, 43, 6, -53 },
  { 6661, 34, 53, 43, 5, -53 },
  { 6887, 37, 53, 43, 5, -53 },
  { 7133, 38, 53, 43, 5, -53 },
  { 7385, 34, 54, 43, 6, -53 },
  { 7615, 35, 53, 43, 5, -53 },
  { 7847, 35, 53, 43, 5, -53 },
  { 8079, 37, 54, 43, 3, -53 },
  { 8329, 38, 53, 43, 5, -53 },
  { 8581, 30, 53, 43, 5, -53 },
  { 8780, 39, 53, 43, 3, -53 },
  { 9039, 35, 53, 43, 5, -53 },
  { 9271, 33, 54, 43, 6, -53 },
  { 9494, 37, 53, 43, 5, -53 },
  { 9740, 33, 66, 43, 6, -53 },
  { 10013, 36, 53, 43, 5, -53 },
  { 10252, 36, 54, 43, 4, -53 },
  { 10495, 35, 53, 43, 9, -53 },
  { 10727, 35, 54, 43, 6, -53 },
  { 10964, 33, 53, 43, 10, -53 },
  { 11183, 40, 53, 43, 6, -53 },
  { 11448, 42, 53, 43, 1, -53 },
  { 11727, 36, 53, 43, 9, -53 },
  { 11966, 38, 53, 43, 3, -53 },
  { 12218, 27, 68, 43, 11, -60 },
  { 12448, 19, 68, 43, 13, -60 },
  { 12610, 27, 68, 43, 7, -60 },
  { 12840, 29, 29, 43, 8, -53 },
  { 12946, 35, 3, 43, 0, 2 },
  { 12960, 11, 11, 43, 20, -57 },
  { 12976, 32, 41, 43, 6, -40 },
  { 13140, 33, 54, 43, 5, -53 },
  { 13363, 32, 41, 43, 6, -40 },
  { 13527, 34, 54, 43, 6, -53 },
  { 13757, 31, 41, 43, 6, -40 },
  { 13916, 45, 66, 43, -2, -53 },
  { 14288, 32, 53, 43, 6, -40 },
  { 14500, 32, 53, 43, 5, -53 },
  { 14712, 32, 55, 43, 4, -55 },
  { 14932, 35, 68, 43, 2, -55 },
  { 15230, 36, 53, 43, 5, -53 },
  { 15469, 28, 53, 43, 8, -53 },
  { 15655, 37, 40, 43, 3, -40 },
  { 15840, 32, 40, 43, 5, -40 },
  { 16000, 31, 41, 43, 6, -40 },
  { 16159, 35, 53, 43, 3, -40 },
  { 16391, 32, 53, 43, 6, -40 },
  { 16603, 33, 40, 43, 6, -40 },
  { 16768, 33, 41, 43, 5, -40 },
  { 16938, 31, 50, 43, 8, -50 },
  { 17132, 33, 41, 43, 6, -40 },
  { 17302, 32, 40, 43, 9, -40 },
  { 17462, 36, 40, 43, 7, -40 },
  { 17642, 38, 40, 43, 2, -40 },
  { 17832, 32, 53, 43, 6, -40 },
  { 18044, 34, 40, 43, 4, -40 },
  { 18214, 34, 68, 43, 8, -60 },
  { 18503, 15, 68, 43, 15, -60 },
  { 18631, 34, 68, 43, 3, -60 },
  { 18920, 33, 13, 43, 6, -32 },
};

const GFXfont JetBrainsMono_ThinItalic72pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic72pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _JETBRAINSMONO_THINITALIC72PT7B_H_
