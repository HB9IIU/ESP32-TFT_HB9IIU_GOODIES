#ifndef _JETBRAINSMONO_THINITALIC16PT7B_H_
#define _JETBRAINSMONO_THINITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x52, 0x41, 0x60, 0x4A, 0x63, 0x19, 0x00, 0x04, 0x82,
  0x20, 0x88, 0x24, 0x37, 0xC4, 0x41, 0x20, 0x88, 0xFF, 0x11, 0x04, 0x41,
  0x20, 0x04, 0x04, 0x1E, 0x29, 0x49, 0x48, 0x48, 0x38, 0x0C, 0x12, 0x12,
  0x92, 0x92, 0x7C, 0x10, 0x20, 0x38, 0x51, 0x14, 0x49, 0x24, 0x4A, 0x0D,
  0x00, 0x80, 0x5E, 0x14, 0x89, 0x24, 0x8A, 0x1C, 0x1C, 0x22, 0x22, 0x20,
  0x20, 0x60, 0x91, 0x8A, 0x8C, 0x84, 0x8C, 0xF2, 0xF8, 0x04, 0x21, 0x08,
  0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x81, 0x04, 0x0C, 0x20, 0x40, 0x81,
  0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x10, 0x46, 0x20, 0x08, 0x08, 0x08,
  0xEB, 0x1C, 0x18, 0x2C, 0x44, 0x08, 0x08, 0x08, 0xFF, 0x10, 0x10, 0x10,
  0x29, 0x48, 0xFC, 0xD8, 0x01, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x1E, 0x23, 0x41, 0x41, 0x41,
  0x4A, 0x5A, 0x82, 0x82, 0x82, 0x84, 0x78, 0x0C, 0x28, 0x92, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x20, 0x47, 0xF0, 0x1E, 0x21, 0x41, 0x01, 0x01, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0x3F, 0x02, 0x04, 0x08, 0x10, 0x0C,
  0x02, 0x02, 0x02, 0x82, 0x84, 0x78, 0x02, 0x08, 0x10, 0x41, 0x04, 0x50,
  0xA1, 0xFE, 0x04, 0x10, 0x20, 0x3F, 0x20, 0x20, 0x40, 0x5C, 0x62, 0x42,
  0x02, 0x02, 0x82, 0x84, 0x78, 0x04, 0x10, 0x20, 0x82, 0x0F, 0x90, 0xC1,
  0x83, 0x06, 0x13, 0xC0, 0xFF, 0x82, 0x82, 0x84, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x40, 0x1E, 0x21, 0x41, 0x41, 0x22, 0x1C, 0x3C, 0x42,
  0x82, 0x82, 0x84, 0x78, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0xB7, 0x14, 0x10,
  0x20, 0x82, 0x00, 0x67, 0x00, 0x00, 0x0C, 0xC0, 0x39, 0x80, 0x00, 0x00,
  0x04, 0x42, 0x21, 0x00, 0x06, 0x31, 0x84, 0x0C, 0x04, 0x06, 0x02, 0x7F,
  0x00, 0x00, 0xFE, 0x60, 0x20, 0x30, 0x10, 0x43, 0x18, 0x40, 0x70, 0x20,
  0x41, 0x08, 0x66, 0x10, 0x40, 0x08, 0x30, 0x0F, 0x08, 0x48, 0x24, 0x14,
  0x7A, 0x45, 0x22, 0x91, 0x48, 0xA4, 0xA3, 0xD0, 0x04, 0x02, 0x00, 0xE0,
  0x04, 0x06, 0x0A, 0x0A, 0x0A, 0x12, 0x12, 0x22, 0x3E, 0x41, 0x41, 0xC1,
  0x3C, 0x22, 0x41, 0x41, 0x42, 0x74, 0x4C, 0x42, 0x42, 0x82, 0x84, 0xF8,
  0x1E, 0x21, 0x41, 0x41, 0x40, 0x40, 0x40, 0x40, 0x80, 0x82, 0x84, 0x78,
  0x3C, 0x22, 0x41, 0x41, 0x41, 0x42, 0x42, 0x42, 0x42, 0x82, 0x84, 0xF8,
  0x3F, 0x20, 0x20, 0x40, 0x40, 0x7E, 0x40, 0x40, 0x40, 0x40, 0x80, 0xFE,
  0x3F, 0x90, 0x08, 0x08, 0x04, 0x02, 0x01, 0xF8, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x00, 0x1E, 0x21, 0x41, 0x41, 0x40, 0x40, 0x4E, 0x42, 0x82, 0x82,
  0x84, 0x78, 0x21, 0x21, 0x41, 0x41, 0x42, 0x7E, 0x42, 0x42, 0x42, 0x82,
  0x84, 0x84, 0x3F, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0xFC, 0x0F, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x84,
  0x84, 0x78, 0x20, 0x90, 0x90, 0x88, 0x44, 0x43, 0xC1, 0x20, 0x88, 0x44,
  0x42, 0x20, 0x90, 0x40, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x82, 0x07, 0xF0, 0x21, 0x63, 0x63, 0x55, 0x55, 0x59, 0x52, 0x82, 0x82,
  0x82, 0x82, 0x82, 0x21, 0x21, 0x51, 0x51, 0x52, 0x52, 0x4A, 0x4A, 0x8A,
  0x8A, 0x84, 0x84, 0x1C, 0x22, 0x41, 0x41, 0x41, 0x42, 0x42, 0x42, 0x82,
  0x82, 0x84, 0x78, 0x3E, 0x21, 0x41, 0x41, 0x41, 0x42, 0x7C, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x1C, 0x22, 0x41, 0x41, 0x41, 0x42, 0x42, 0x42, 0x82,
  0x82, 0x84, 0x78, 0x08, 0x08, 0x04, 0x3E, 0x21, 0x41, 0x41, 0x41, 0x42,
  0x7C, 0x48, 0x44, 0x84, 0x84, 0x82, 0x1E, 0x21, 0x41, 0x40, 0x40, 0x30,
  0x0C, 0x02, 0x02, 0x82, 0x82, 0x7C, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42,
  0x42, 0x42, 0x82, 0x82, 0x44, 0x78, 0x81, 0x82, 0x82, 0x84, 0x44, 0x44,
  0x48, 0x48, 0x50, 0x50, 0x60, 0x20, 0x48, 0xA4, 0x52, 0x2A, 0xA9, 0x54,
  0xAA, 0x99, 0x4C, 0xAA, 0x65, 0x33, 0x18, 0x80, 0x20, 0x44, 0x21, 0x10,
  0x48, 0x0A, 0x03, 0x00, 0xC0, 0x50, 0x12, 0x08, 0x84, 0x12, 0x04, 0x81,
  0x82, 0x42, 0x44, 0x48, 0x28, 0x30, 0x20, 0x20, 0x20, 0x20, 0x20, 0x3F,
  0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0xFE, 0x3C,
  0x84, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x0E, 0x00, 0x88,
  0x84, 0x44, 0x42, 0x22, 0x22, 0x11, 0x10, 0x1C, 0x10, 0x41, 0x04, 0x10,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x4F, 0x00, 0x10, 0x62, 0x8A, 0x46, 0x18,
  0x40, 0xFF, 0xA4, 0x1D, 0x22, 0x42, 0x42, 0x42, 0x82, 0x82, 0x84, 0x7C,
  0x20, 0x41, 0x02, 0xE6, 0x28, 0x50, 0xA1, 0x43, 0x06, 0x17, 0xC0, 0x1C,
  0x45, 0x0A, 0x04, 0x10, 0x20, 0xC2, 0x78, 0x01, 0x01, 0x01, 0x1D, 0x22,
  0x42, 0x42, 0x42, 0x82, 0x82, 0x84, 0x7C, 0x1C, 0x45, 0x0A, 0x17, 0xF0,
  0x20, 0xC2, 0x78, 0x03, 0xC1, 0x00, 0x40, 0x20, 0x3F, 0x82, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0E, 0x00, 0x1D, 0x22,
  0x42, 0x42, 0x42, 0x82, 0x46, 0x6C, 0x14, 0x04, 0x04, 0x78, 0x20, 0x41,
  0x02, 0xE6, 0x28, 0x50, 0xA1, 0x43, 0x06, 0x0C, 0x20, 0x0C, 0x08, 0x03,
  0xC0, 0x81, 0x02, 0x04, 0x10, 0x20, 0x47, 0xF0, 0x03, 0x01, 0x00, 0x1E,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0xF0, 0x20,
  0x20, 0x20, 0x41, 0x42, 0x44, 0x48, 0x70, 0x48, 0x84, 0x84, 0x82, 0xF0,
  0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x0F, 0x76, 0x49, 0x89, 0x91,
  0x92, 0x92, 0x92, 0x92, 0x92, 0x5C, 0xC5, 0x0A, 0x14, 0x28, 0x60, 0xC1,
  0x84, 0x1C, 0x45, 0x0A, 0x14, 0x30, 0x60, 0xC2, 0x78, 0x5C, 0xC5, 0x0A,
  0x14, 0x28, 0x60, 0xC2, 0xF9, 0x02, 0x04, 0x00, 0x1D, 0x62, 0x42, 0x42,
  0x42, 0x82, 0x82, 0x84, 0x7C, 0x04, 0x04, 0x04, 0x3E, 0x22, 0x41, 0x41,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x3E, 0x85, 0x02, 0x03, 0xC0, 0x40, 0xC1,
  0x7C, 0x10, 0x43, 0xF9, 0x02, 0x04, 0x08, 0x20, 0x40, 0x80, 0xE0, 0x41,
  0x42, 0x42, 0x42, 0x42, 0x82, 0x82, 0x44, 0x78, 0x83, 0x0A, 0x14, 0x44,
  0x8A, 0x14, 0x30, 0x60, 0x89, 0x89, 0x99, 0x99, 0xAA, 0xAA, 0xAA, 0xC4,
  0x44, 0x20, 0x88, 0x84, 0x81, 0x80, 0x80, 0xA0, 0x50, 0x44, 0xC3, 0x00,
  0x42, 0x85, 0x0A, 0x14, 0x30, 0x61, 0x3E, 0x04, 0x08, 0x17, 0xC0, 0x7E,
  0x04, 0x10, 0x41, 0x04, 0x08, 0x20, 0xFC, 0x0E, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x70, 0x10, 0x20, 0x81, 0x02, 0x04, 0x06, 0x00, 0x12, 0x22, 0x22,
  0x24, 0x44, 0x44, 0x44, 0x80, 0x38, 0x10, 0x20, 0x41, 0x02, 0x04, 0x07,
  0x10, 0x20, 0x41, 0x02, 0x04, 0x30, 0x00, 0x71, 0x89, 0x86,
};

const GFXglyph JetBrainsMono_ThinItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 3, -12 },
  { 6, 5, 5, 10, 3, -12 },
  { 10, 10, 12, 10, 0, -12 },
  { 25, 8, 16, 10, 1, -14 },
  { 41, 10, 12, 10, 0, -12 },
  { 56, 8, 12, 10, 1, -12 },
  { 68, 1, 5, 10, 5, -12 },
  { 69, 6, 16, 10, 3, -14 },
  { 81, 6, 16, 10, 1, -14 },
  { 93, 8, 8, 10, 1, -10 },
  { 101, 8, 7, 10, 1, -9 },
  { 108, 3, 5, 10, 2, -2 },
  { 110, 6, 1, 10, 2, -6 },
  { 111, 3, 2, 10, 3, -2 },
  { 112, 8, 15, 10, 1, -13 },
  { 127, 8, 12, 10, 1, -12 },
  { 139, 7, 12, 10, 1, -12 },
  { 150, 8, 12, 10, 1, -12 },
  { 162, 8, 12, 10, 1, -12 },
  { 174, 7, 12, 10, 1, -12 },
  { 185, 8, 12, 10, 1, -12 },
  { 197, 7, 12, 10, 1, -12 },
  { 208, 8, 12, 10, 2, -12 },
  { 220, 8, 12, 10, 1, -12 },
  { 232, 7, 12, 10, 2, -12 },
  { 243, 4, 9, 10, 3, -9 },
  { 248, 5, 12, 10, 2, -9 },
  { 256, 7, 8, 10, 2, -9 },
  { 263, 8, 4, 10, 1, -7 },
  { 267, 7, 8, 10, 1, -9 },
  { 274, 6, 12, 10, 3, -12 },
  { 283, 9, 15, 10, 0, -12 },
  { 300, 8, 12, 10, 0, -12 },
  { 312, 8, 12, 10, 1, -12 },
  { 324, 8, 12, 10, 1, -12 },
  { 336, 8, 12, 10, 1, -12 },
  { 348, 8, 12, 10, 1, -12 },
  { 360, 9, 12, 10, 1, -12 },
  { 374, 8, 12, 10, 1, -12 },
  { 386, 8, 12, 10, 1, -12 },
  { 398, 8, 12, 10, 1, -12 },
  { 410, 8, 12, 10, 1, -12 },
  { 422, 9, 12, 10, 1, -12 },
  { 436, 7, 12, 10, 1, -12 },
  { 447, 8, 12, 10, 1, -12 },
  { 459, 8, 12, 10, 1, -12 },
  { 471, 8, 12, 10, 1, -12 },
  { 483, 8, 12, 10, 1, -12 },
  { 495, 8, 15, 10, 1, -12 },
  { 510, 8, 12, 10, 1, -12 },
  { 522, 8, 12, 10, 1, -12 },
  { 534, 8, 12, 10, 2, -12 },
  { 546, 8, 12, 10, 1, -12 },
  { 558, 8, 12, 10, 2, -12 },
  { 570, 9, 12, 10, 1, -12 },
  { 584, 10, 12, 10, 0, -12 },
  { 599, 8, 12, 10, 2, -12 },
  { 611, 8, 12, 10, 1, -12 },
  { 623, 6, 15, 10, 3, -13 },
  { 635, 4, 15, 10, 3, -13 },
  { 643, 6, 15, 10, 1, -13 },
  { 655, 6, 7, 10, 2, -12 },
  { 661, 8, 1, 10, 0, 0 },
  { 662, 2, 3, 10, 5, -13 },
  { 663, 8, 9, 10, 1, -9 },
  { 672, 7, 12, 10, 1, -12 },
  { 683, 7, 9, 10, 1, -9 },
  { 691, 8, 12, 10, 1, -12 },
  { 703, 7, 9, 10, 1, -9 },
  { 711, 10, 15, 10, 0, -12 },
  { 730, 8, 12, 10, 1, -9 },
  { 742, 7, 12, 10, 1, -12 },
  { 753, 7, 12, 10, 1, -12 },
  { 764, 8, 15, 10, 0, -12 },
  { 779, 8, 12, 10, 1, -12 },
  { 791, 6, 12, 10, 2, -12 },
  { 800, 8, 9, 10, 1, -9 },
  { 809, 7, 9, 10, 1, -9 },
  { 817, 7, 9, 10, 1, -9 },
  { 825, 7, 12, 10, 1, -9 },
  { 836, 8, 12, 10, 1, -9 },
  { 848, 8, 9, 10, 1, -9 },
  { 857, 7, 9, 10, 1, -9 },
  { 865, 7, 11, 10, 2, -11 },
  { 875, 8, 9, 10, 1, -9 },
  { 884, 7, 9, 10, 2, -9 },
  { 892, 8, 9, 10, 1, -9 },
  { 901, 9, 9, 10, 0, -9 },
  { 912, 7, 12, 10, 1, -9 },
  { 923, 7, 9, 10, 1, -9 },
  { 931, 7, 15, 10, 2, -13 },
  { 945, 4, 15, 10, 3, -13 },
  { 953, 7, 15, 10, 1, -13 },
  { 967, 8, 3, 10, 1, -7 },
};

const GFXfont JetBrainsMono_ThinItalic16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_THINITALIC16PT7B_H_
