#ifndef _JETBRAINSMONO_THINITALIC51PT7B_H_
#define _JETBRAINSMONO_THINITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xC1,
  0xF8, 0x3E, 0x07, 0x80, 0x3C, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E,
  0x78, 0x0E, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C,
  0x70, 0x1C, 0x60, 0x1C, 0x60, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x0C,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xC0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x18, 0x01, 0x80, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x70, 0x07,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80,
  0x00, 0xE0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x06, 0x00, 0x01, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38,
  0x03, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x18, 0x01,
  0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x38,
  0x63, 0xC0, 0x1C, 0x18, 0x70, 0x0E, 0x0C, 0x0E, 0x07, 0x03, 0x03, 0x81,
  0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x06,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x3E, 0x60, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x31, 0xE0,
  0x00, 0x0C, 0x38, 0x00, 0x03, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xE3, 0x80,
  0x60, 0x30, 0xE0, 0x38, 0x0C, 0x38, 0x0C, 0x07, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0xC0, 0xE0, 0x78, 0x30, 0x70, 0x0F, 0x8C, 0x78, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x3F, 0xE0, 0x00, 0xE0,
  0x1C, 0x1C, 0x00, 0x70, 0x0E, 0x03, 0x00, 0x18, 0x03, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0x70, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x01,
  0xC0, 0x06, 0x00, 0xC0, 0xE0, 0x01, 0x80, 0x70, 0x70, 0x00, 0x60, 0x1C,
  0x18, 0x00, 0x18, 0x06, 0x0C, 0x00, 0x06, 0x03, 0x86, 0x00, 0x01, 0xC0,
  0xC3, 0x00, 0x00, 0x7F, 0xE1, 0xC0, 0x00, 0x0F, 0xF0, 0xE0, 0x00, 0x00,
  0x20, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x01, 0xC7, 0xFC,
  0x00, 0x00, 0xE3, 0xC7, 0x80, 0x00, 0x70, 0xC0, 0xE0, 0x00, 0x38, 0x60,
  0x18, 0x00, 0x0C, 0x18, 0x06, 0x00, 0x06, 0x0E, 0x01, 0x80, 0x03, 0x03,
  0x80, 0x60, 0x01, 0xC0, 0xC0, 0x18, 0x00, 0xE0, 0x30, 0x06, 0x00, 0x70,
  0x0C, 0x03, 0x80, 0x38, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0x30, 0x1C, 0x03, 0x00, 0x0E, 0x0E, 0x01, 0xC0, 0x01, 0xFF, 0x00,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x0E, 0x1E, 0x00,
  0x11, 0x81, 0xC0, 0x1C, 0x70, 0x1C, 0x03, 0x0C, 0x03, 0x80, 0xE3, 0x80,
  0x38, 0x38, 0x70, 0x07, 0x06, 0x0E, 0x00, 0x71, 0xC1, 0x80, 0x07, 0x70,
  0x30, 0x00, 0xEC, 0x06, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00,
  0x3C, 0x07, 0x00, 0x07, 0xC0, 0xE0, 0x01, 0xF8, 0x1C, 0x00, 0x73, 0x83,
  0xC0, 0x3C, 0x30, 0x3C, 0x0F, 0x07, 0x03, 0xFF, 0x80, 0x60, 0x3F, 0xE0,
  0x0E, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0xE3, 0x8E, 0x39, 0xE7, 0x9C, 0x71,
  0xC7, 0x1C, 0x63, 0x8E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x70, 0x0E, 0x00, 0xDF, 0x03,
  0x81, 0xFF, 0xF8, 0xC3, 0xFC, 0x7F, 0xB3, 0xF8, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x81,
  0xC0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x03, 0xC0, 0x18,
  0x00, 0x70, 0x02, 0x00, 0x10, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x7E, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFC, 0x20, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x01,
  0xE0, 0x3E, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18,
  0x00, 0x07, 0x18, 0x00, 0x07, 0x38, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x3C, 0x0E, 0x30, 0x3E, 0x0E, 0x70,
  0x3E, 0x0E, 0x70, 0x3C, 0x0C, 0x70, 0x18, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0x3E,
  0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xEC, 0x00, 0x0F, 0x30, 0x00, 0xF0,
  0xC0, 0x07, 0x87, 0x00, 0x78, 0x1C, 0x01, 0xC0, 0x70, 0x04, 0x01, 0xC0,
  0x20, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x00,
  0xE0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xC0, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x70, 0x01,
  0x83, 0x80, 0x06, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x9C,
  0x00, 0x0E, 0x60, 0x00, 0x39, 0x80, 0x00, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x7F, 0xC0, 0x1C, 0xFF, 0xF0, 0x1D,
  0x80, 0xF0, 0x1B, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x60, 0x60, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x3F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x9F, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0x80, 0xF0,
  0x3C, 0x00, 0xF0, 0xF0, 0x00, 0xE1, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0xCC,
  0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0x80,
  0x00, 0x3B, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x98, 0x00,
  0x06, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x78, 0x0F,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x30, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x60, 0x00,
  0x38, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1C,
  0x01, 0xE0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE0,
  0xC0, 0x00, 0x60, 0x70, 0x00, 0x70, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x38, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x0E, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x70, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1E,
  0x00, 0x3C, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x38, 0x03, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x18,
  0x00, 0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE1, 0xC0, 0x03, 0xC3, 0xC0, 0x0F,
  0x03, 0xE0, 0x7E, 0x03, 0xFF, 0xB8, 0x01, 0xFC, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x00, 0xF8, 0x3F, 0x8F, 0xF1, 0xFE,
  0x3F, 0x83, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x03, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC0, 0x40, 0x00, 0x00,
  0x10, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x0E, 0x18, 0x30,
  0x07, 0xFC, 0xC1, 0x80, 0x7F, 0xF6, 0x1C, 0x07, 0x80, 0xB0, 0xE0, 0x38,
  0x07, 0x87, 0x03, 0x80, 0x1C, 0x38, 0x1C, 0x00, 0xE1, 0x80, 0xE0, 0x06,
  0x0C, 0x06, 0x00, 0x30, 0xE0, 0x30, 0x03, 0x87, 0x01, 0x80, 0x1C, 0x38,
  0x1C, 0x00, 0xE1, 0xC0, 0xE0, 0x07, 0x0C, 0x07, 0x00, 0x30, 0x60, 0x30,
  0x01, 0x83, 0x01, 0x80, 0x1C, 0x38, 0x0C, 0x00, 0xE1, 0xC0, 0x70, 0x0F,
  0x0E, 0x03, 0x80, 0x78, 0x60, 0x1E, 0x0D, 0x83, 0x00, 0x7F, 0xCC, 0x18,
  0x01, 0xFC, 0x60, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0xB0, 0x00, 0x03, 0x30, 0x00, 0x07, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00,
  0x70, 0x1C, 0x00, 0x60, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x80, 0x0C, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0C,
  0x00, 0x0E, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xC0, 0x0F, 0x80,
  0x60, 0x01, 0xE0, 0x30, 0x00, 0x70, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x30, 0x00,
  0x70, 0x18, 0x00, 0x78, 0x0C, 0x01, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0x80, 0x1F, 0x01, 0xC0, 0x03, 0xC0, 0xC0, 0x00, 0xE0, 0x60,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x30, 0x00, 0x70,
  0x18, 0x03, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x38,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x0E,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x07,
  0x80, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xC0, 0x1F, 0x00, 0x60, 0x03,
  0xC0, 0x30, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x70, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC1, 0xC0, 0x01,
  0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x30, 0x01, 0xE0, 0x18, 0x07,
  0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x38,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x0E,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x01, 0xFF, 0xE1, 0x80, 0xFF, 0xE0, 0xC0, 0x00, 0x30, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0C, 0x00,
  0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x07,
  0x80, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x70,
  0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x60, 0x30, 0x00, 0x18, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x20, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x01, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x60,
  0x00, 0x1C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xC0,
  0x70, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x03, 0xE0, 0x3C, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x38, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x03, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0,
  0x06, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x18,
  0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x70, 0x03, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x3C, 0x00, 0x1E, 0x03, 0x60, 0x03, 0x60, 0x36, 0x00, 0x36, 0x03, 0x60,
  0x06, 0xE0, 0x76, 0x00, 0x6E, 0x07, 0x60, 0x0C, 0xE0, 0x73, 0x00, 0xCC,
  0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x06, 0x30, 0x31, 0xC0, 0xE3,
  0x03, 0x1C, 0x0E, 0x18, 0x61, 0xC0, 0xE1, 0x86, 0x18, 0x0E, 0x18, 0xC1,
  0x80, 0xC1, 0x9C, 0x18, 0x0C, 0x0D, 0x83, 0x80, 0xC0, 0xF8, 0x38, 0x1C,
  0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x30, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x30, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x70, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x00,
  0x60, 0x3C, 0x00, 0x18, 0x0F, 0x80, 0x06, 0x03, 0x60, 0x03, 0x81, 0xD8,
  0x00, 0xE0, 0x76, 0x00, 0x38, 0x1D, 0xC0, 0x0C, 0x06, 0x30, 0x03, 0x01,
  0x8C, 0x00, 0xC0, 0x63, 0x00, 0x70, 0x38, 0xE0, 0x1C, 0x0E, 0x18, 0x07,
  0x03, 0x86, 0x01, 0xC0, 0xC1, 0x80, 0x60, 0x30, 0x60, 0x18, 0x0C, 0x1C,
  0x06, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x18,
  0x0E, 0x0C, 0x06, 0x01, 0x83, 0x01, 0x80, 0x60, 0xC0, 0xE0, 0x18, 0x70,
  0x38, 0x07, 0x1C, 0x0E, 0x00, 0xC7, 0x03, 0x00, 0x31, 0x80, 0xC0, 0x0C,
  0x60, 0x30, 0x03, 0x98, 0x0C, 0x00, 0x66, 0x07, 0x00, 0x1B, 0x81, 0xC0,
  0x06, 0xE0, 0x70, 0x01, 0xF0, 0x18, 0x00, 0x7C, 0x06, 0x00, 0x0F, 0x01,
  0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x0E, 0x07, 0x00,
  0x0E, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00,
  0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x38, 0x00,
  0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x30, 0x00,
  0x1C, 0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x60, 0x00, 0x38, 0x60, 0x00, 0x38, 0xE0, 0x00,
  0x30, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0x70, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0C,
  0x00, 0x3E, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x0C, 0x00,
  0x0E, 0x03, 0x80, 0x07, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C,
  0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C,
  0x30, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x18,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x60, 0x00, 0x38, 0x60, 0x00, 0x38,
  0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00, 0xE0,
  0x70, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x1F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x30, 0x01, 0xF0, 0x0C, 0x00, 0x1E, 0x03, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0x83, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x3C, 0x0C, 0x00,
  0x1E, 0x07, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1C,
  0x07, 0x00, 0x06, 0x01, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x0E, 0x00,
  0x38, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x03,
  0x00, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x06, 0x01, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x81,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x07, 0x00,
  0xE0, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x03,
  0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x07,
  0x00, 0xF8, 0x07, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x83, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x80, 0xE0,
  0x01, 0xC0, 0x70, 0x00, 0xC0, 0x3C, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x70, 0x00, 0x30, 0x70, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x30, 0x00, 0xC0,
  0x30, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x38, 0x07, 0x00, 0x38, 0x06, 0x00, 0x18, 0x0E, 0x00,
  0x18, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x18, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x60, 0x00,
  0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x0D, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x30, 0x07, 0x80, 0x33, 0x00, 0x78, 0x07, 0x30, 0x07, 0x80, 0x63, 0x00,
  0xD8, 0x06, 0x30, 0x0D, 0x80, 0xE7, 0x00, 0xD8, 0x0E, 0x70, 0x19, 0x80,
  0xC7, 0x01, 0x98, 0x0C, 0x70, 0x19, 0x01, 0xC7, 0x03, 0x10, 0x18, 0x70,
  0x31, 0x01, 0x87, 0x03, 0x10, 0x18, 0x70, 0x33, 0x03, 0x87, 0x06, 0x30,
  0x30, 0x60, 0x63, 0x03, 0x06, 0x06, 0x30, 0x70, 0x60, 0xC3, 0x07, 0x06,
  0x0C, 0x30, 0x60, 0x60, 0xC3, 0x06, 0x06, 0x18, 0x30, 0xE0, 0x61, 0x83,
  0x0C, 0x06, 0x18, 0x30, 0xC0, 0x61, 0x03, 0x1C, 0x06, 0x30, 0x31, 0xC0,
  0x63, 0x03, 0x18, 0x06, 0x30, 0x31, 0x80, 0x66, 0x03, 0x38, 0x06, 0x60,
  0x33, 0x00, 0x66, 0x03, 0x30, 0x06, 0xC0, 0x33, 0x00, 0x6C, 0x03, 0x70,
  0x06, 0xC0, 0x36, 0x00, 0x68, 0x03, 0x60, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x03, 0xD8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x38, 0x30,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xE0,
  0x1C, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x38, 0x07,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0x70, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x00, 0x1C, 0x38,
  0x03, 0x83, 0x80, 0x38, 0x38, 0x07, 0x01, 0x80, 0x70, 0x1C, 0x0E, 0x01,
  0xC1, 0xC0, 0x0C, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE7, 0x00,
  0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x00,
  0x0C, 0x00, 0x01, 0xFF, 0x0C, 0x07, 0xFF, 0xB8, 0x3C, 0x03, 0x70, 0x70,
  0x03, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0x80, 0x00, 0xE3, 0x00, 0x01,
  0x86, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0xC0, 0x00, 0x71, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x8E, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0,
  0x02, 0xC0, 0xF0, 0x1D, 0x80, 0xFF, 0xF7, 0x00, 0xFF, 0x8E, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x03, 0x80, 0x06, 0x1F, 0xF0, 0x06, 0x7F, 0xF8, 0x0E,
  0xE0, 0x3C, 0x0F, 0x80, 0x1C, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x38,
  0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30,
  0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x38, 0x70, 0x00, 0x38, 0x78,
  0x00, 0x70, 0x78, 0x00, 0x70, 0x6C, 0x00, 0xE0, 0x6E, 0x03, 0xC0, 0x67,
  0xFF, 0x80, 0xE3, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1E, 0x03, 0xC0, 0x70, 0x03, 0xC1, 0xC0,
  0x03, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x70, 0x00,
  0x18, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x9C, 0x00, 0x06, 0x18,
  0x00, 0x1C, 0x30, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xF0, 0x03, 0x80, 0xF0,
  0x1E, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x7F, 0xC3, 0x00, 0x7F, 0xFB, 0x80, 0xF0, 0x0D,
  0xC0, 0x70, 0x03, 0xE0, 0x70, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x38, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x06, 0x00,
  0x03, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0,
  0xC0, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0x38, 0x00, 0xB0, 0x0F, 0x01, 0xD8,
  0x03, 0xFF, 0xDC, 0x00, 0xFF, 0x8E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xE0, 0x1E, 0x07, 0x00, 0x38,
  0x38, 0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0,
  0x00, 0x73, 0x80, 0x01, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x1C, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x9C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x07, 0x18, 0x00, 0x18, 0x70, 0x00, 0xE1, 0xE0, 0x07, 0x03, 0xC0, 0x78,
  0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0x0C, 0x07, 0xFF, 0x38, 0x3C, 0x03, 0x70, 0x70, 0x03, 0xE1, 0xC0,
  0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x70, 0x00,
  0x38, 0xE0, 0x00, 0x71, 0x80, 0x00, 0xE3, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71,
  0x80, 0x00, 0xC3, 0x00, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1E,
  0x00, 0x7C, 0x1C, 0x01, 0xB8, 0x1F, 0x0E, 0x60, 0x1F, 0xF8, 0xC0, 0x0F,
  0xC1, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x06, 0x1F, 0xF0, 0x06, 0x7F, 0xF8, 0x0E, 0xE0, 0x3C, 0x0F, 0x80,
  0x1C, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xE0, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x03, 0xC3, 0x00, 0x01, 0xC1,
  0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xC0,
  0x30, 0x01, 0xC0, 0x18, 0x01, 0xE0, 0x0C, 0x01, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x01,
  0x80, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x01, 0x80,
  0x06, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x70, 0x30,
  0x00, 0x1C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x80, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x10, 0x04, 0x03, 0x3F, 0x8F,
  0xE0, 0xDF, 0xE7, 0xF8, 0x34, 0x1D, 0x07, 0x0E, 0x07, 0x81, 0xC7, 0x01,
  0xC0, 0x71, 0xC0, 0x70, 0x1C, 0x70, 0x1C, 0x07, 0x1C, 0x07, 0x01, 0xC6,
  0x01, 0x80, 0x61, 0x80, 0x60, 0x18, 0x60, 0x18, 0x06, 0x38, 0x0E, 0x03,
  0x8E, 0x03, 0x80, 0xE3, 0x80, 0xE0, 0x38, 0xC0, 0x30, 0x0C, 0x30, 0x0C,
  0x03, 0x0C, 0x03, 0x00, 0xC7, 0x01, 0xC0, 0x71, 0xC0, 0x70, 0x1C, 0x70,
  0x1C, 0x07, 0x18, 0x06, 0x01, 0xC6, 0x01, 0x80, 0x61, 0x80, 0x60, 0x18,
  0xE0, 0x18, 0x06, 0x38, 0x0E, 0x03, 0x8E, 0x03, 0x80, 0xE3, 0x80, 0xE0,
  0x38, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x06, 0x1F, 0xF0, 0x06,
  0x7F, 0xF8, 0x0E, 0xE0, 0x3C, 0x0F, 0x80, 0x1C, 0x0F, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xE0, 0x1E, 0x07, 0x00, 0x38, 0x38, 0x00,
  0x71, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x0C, 0xE0, 0x00, 0x73,
  0x80, 0x01, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x67, 0x00,
  0x01, 0x9C, 0x00, 0x06, 0x70, 0x00, 0x39, 0x80, 0x00, 0xE6, 0x00, 0x03,
  0x98, 0x00, 0x0E, 0xE0, 0x00, 0x33, 0x80, 0x01, 0xC6, 0x00, 0x07, 0x18,
  0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x03, 0xC0, 0x78, 0x07, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x01, 0x87,
  0xFC, 0x00, 0xCF, 0xFF, 0x00, 0xEE, 0x03, 0xC0, 0x7C, 0x00, 0xE0, 0x3C,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x70, 0x3C, 0x00,
  0x38, 0x1B, 0x00, 0x38, 0x0D, 0xC0, 0x78, 0x06, 0x7F, 0xF8, 0x07, 0x1F,
  0xF0, 0x03, 0x80, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x0C,
  0x07, 0xFF, 0xB8, 0x3C, 0x03, 0x70, 0x70, 0x03, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0,
  0x00, 0x71, 0x80, 0x00, 0xE3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xC0, 0x00, 0x71, 0x80, 0x00,
  0xC3, 0x00, 0x01, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x30, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0, 0x02, 0xC0, 0xF0, 0x1D, 0x80,
  0xFF, 0xF7, 0x00, 0xFF, 0x8E, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x06,
  0x3F, 0xF0, 0x0E, 0x7F, 0xF8, 0x0E, 0xC0, 0x3C, 0x0F, 0x80, 0x1C, 0x0F,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xC0, 0x1E, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0x71, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x1C, 0x00, 0x06,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x86, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x38, 0xC0, 0x00, 0x71, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00,
  0x07, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x60, 0x78, 0x01,
  0xC0, 0x78, 0x0F, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x73, 0x00, 0x01,
  0xC6, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x70,
  0x30, 0x00, 0xE0, 0x60, 0x03, 0x80, 0xC0, 0x07, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0x30, 0x60, 0x00, 0x61, 0xC0, 0x00, 0xC3,
  0x00, 0x01, 0xCE, 0x00, 0x03, 0x98, 0x00, 0x03, 0x70, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x1C,
  0x01, 0xE0, 0x0E, 0x01, 0xF0, 0x0F, 0x00, 0xD8, 0x07, 0x80, 0x6C, 0x02,
  0xC0, 0x76, 0x03, 0x60, 0x33, 0x01, 0xB0, 0x19, 0x81, 0x98, 0x1C, 0xC0,
  0xCC, 0x0C, 0x60, 0x66, 0x06, 0x30, 0x63, 0x07, 0x18, 0x31, 0x83, 0x0C,
  0x18, 0xC1, 0x86, 0x18, 0x61, 0xC3, 0x0C, 0x30, 0xC1, 0x86, 0x18, 0x60,
  0xC6, 0x0C, 0x70, 0x63, 0x06, 0x30, 0x31, 0x83, 0x18, 0x19, 0x81, 0x9C,
  0x0C, 0xC0, 0xEC, 0x06, 0x60, 0x36, 0x03, 0x60, 0x1F, 0x01, 0xB0, 0x0F,
  0x80, 0xD8, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0x81, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x0E, 0x18, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC7,
  0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0xE1, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x3C,
  0x0E, 0x00, 0xD8, 0x1F, 0x0F, 0x30, 0x1F, 0xFC, 0xE0, 0x0F, 0xC1, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x7C, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x07, 0x1F,
  0xE0, 0x06, 0x3D, 0xF0, 0x06, 0x30, 0x70, 0x06, 0x70, 0x38, 0x06, 0x60,
  0x1C, 0x0E, 0x60, 0x0E, 0x0C, 0x60, 0x0F, 0xBC, 0xE0, 0x07, 0xF8, 0xE0,
  0x01, 0xC0,
};

const GFXglyph JetBrainsMono_ThinItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 11, 37, 31, 10, -37 },
  { 52, 16, 15, 31, 10, -37 },
  { 82, 30, 37, 31, 1, -37 },
  { 221, 26, 51, 31, 3, -44 },
  { 387, 34, 37, 31, -1, -37 },
  { 545, 27, 39, 31, 2, -38 },
  { 677, 6, 15, 31, 15, -37 },
  { 689, 20, 49, 31, 9, -43 },
  { 812, 19, 49, 31, 3, -43 },
  { 929, 26, 26, 31, 3, -31 },
  { 1014, 23, 24, 31, 4, -29 },
  { 1083, 11, 16, 31, 6, -8 },
  { 1105, 17, 2, 31, 7, -18 },
  { 1110, 8, 8, 31, 10, -7 },
  { 1118, 28, 48, 31, 2, -42 },
  { 1286, 24, 39, 31, 4, -38 },
  { 1403, 22, 37, 31, 3, -37 },
  { 1505, 26, 38, 31, 3, -38 },
  { 1629, 25, 38, 31, 3, -37 },
  { 1748, 22, 37, 31, 4, -37 },
  { 1850, 24, 38, 31, 4, -37 },
  { 1964, 23, 38, 31, 3, -37 },
  { 2074, 24, 37, 31, 6, -37 },
  { 2185, 25, 39, 31, 3, -38 },
  { 2307, 23, 38, 31, 6, -38 },
  { 2417, 11, 30, 31, 10, -29 },
  { 2459, 15, 37, 31, 6, -29 },
  { 2529, 23, 26, 31, 5, -30 },
  { 2604, 23, 14, 31, 4, -24 },
  { 2645, 24, 26, 31, 3, -30 },
  { 2723, 20, 37, 31, 8, -37 },
  { 2816, 29, 47, 31, 1, -38 },
  { 2987, 24, 37, 31, 1, -37 },
  { 3098, 25, 37, 31, 3, -37 },
  { 3214, 25, 39, 31, 4, -38 },
  { 3336, 25, 37, 31, 3, -37 },
  { 3452, 26, 37, 31, 4, -37 },
  { 3573, 26, 37, 31, 4, -37 },
  { 3694, 25, 39, 31, 4, -38 },
  { 3816, 26, 37, 31, 3, -37 },
  { 3937, 24, 37, 31, 4, -37 },
  { 4048, 26, 38, 31, 2, -37 },
  { 4172, 28, 37, 31, 3, -37 },
  { 4302, 21, 37, 31, 4, -37 },
  { 4400, 28, 37, 31, 2, -37 },
  { 4530, 26, 37, 31, 3, -37 },
  { 4651, 24, 39, 31, 4, -38 },
  { 4768, 27, 37, 31, 3, -37 },
  { 4893, 24, 47, 31, 4, -38 },
  { 5034, 26, 37, 31, 3, -37 },
  { 5155, 26, 39, 31, 3, -38 },
  { 5282, 25, 37, 31, 6, -37 },
  { 5398, 25, 38, 31, 4, -37 },
  { 5517, 24, 37, 31, 7, -37 },
  { 5628, 28, 37, 31, 4, -37 },
  { 5758, 31, 37, 31, 0, -37 },
  { 5902, 26, 37, 31, 6, -37 },
  { 6023, 27, 37, 31, 2, -37 },
  { 6148, 19, 48, 31, 8, -42 },
  { 6262, 14, 48, 31, 9, -42 },
  { 6346, 19, 48, 31, 5, -42 },
  { 6460, 20, 20, 31, 6, -37 },
  { 6510, 25, 3, 31, 0, 1 },
  { 6520, 8, 7, 31, 14, -40 },
  { 6527, 23, 30, 31, 4, -29 },
  { 6614, 24, 38, 31, 3, -37 },
  { 6728, 23, 30, 31, 4, -29 },
  { 6815, 25, 38, 31, 4, -37 },
  { 6934, 22, 30, 31, 4, -29 },
  { 7017, 31, 46, 31, -1, -37 },
  { 7196, 23, 38, 31, 4, -29 },
  { 7306, 24, 37, 31, 3, -37 },
  { 7417, 22, 39, 31, 3, -39 },
  { 7525, 26, 48, 31, 1, -39 },
  { 7681, 25, 37, 31, 4, -37 },
  { 7797, 20, 37, 31, 6, -37 },
  { 7890, 26, 29, 31, 2, -29 },
  { 7985, 24, 29, 31, 3, -29 },
  { 8072, 22, 30, 31, 4, -29 },
  { 8155, 25, 38, 31, 2, -29 },
  { 8274, 23, 38, 31, 4, -29 },
  { 8384, 24, 29, 31, 4, -29 },
  { 8471, 24, 30, 31, 3, -29 },
  { 8561, 23, 36, 31, 5, -36 },
  { 8665, 23, 29, 31, 4, -28 },
  { 8749, 23, 28, 31, 6, -28 },
  { 8830, 25, 28, 31, 5, -28 },
  { 8918, 26, 28, 31, 2, -28 },
  { 9009, 23, 37, 31, 4, -28 },
  { 9116, 24, 28, 31, 3, -28 },
  { 9200, 24, 48, 31, 6, -42 },
  { 9344, 10, 48, 31, 11, -42 },
  { 9404, 24, 48, 31, 2, -42 },
  { 9548, 24, 10, 31, 4, -23 },
};

const GFXfont JetBrainsMono_ThinItalic51pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic51pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _JETBRAINSMONO_THINITALIC51PT7B_H_
