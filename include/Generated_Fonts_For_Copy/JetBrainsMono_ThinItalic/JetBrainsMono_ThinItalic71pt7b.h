#ifndef _JETBRAINSMONO_THINITALIC71PT7B_H_
#define _JETBRAINSMONO_THINITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x78,
  0x01, 0xF1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xE3, 0xE0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7,
  0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1C,
  0x3C, 0x00, 0x70, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x71, 0xF8,
  0x00, 0x3E, 0x06, 0x07, 0xC0, 0x07, 0xC0, 0xE0, 0x3C, 0x00, 0x78, 0x0E,
  0x03, 0xE0, 0x0F, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x0E,
  0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x1E,
  0x01, 0x80, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x1F, 0x03, 0x80, 0x00,
  0x00, 0xF8, 0x38, 0x00, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x00, 0x7F, 0x38,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x73, 0xF8, 0x00, 0x00, 0x06, 0x0F, 0x80, 0x00, 0x00, 0xE0,
  0x7C, 0x00, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x08, 0x01, 0xC0,
  0x0F, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x0E, 0x07, 0x00,
  0x1C, 0x01, 0xE0, 0x70, 0x01, 0x80, 0x1E, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x78, 0x03, 0x80, 0x3C, 0x07, 0xC0, 0x38, 0x07, 0x80, 0x3C, 0x03, 0x80,
  0xF0, 0x03, 0xF0, 0x38, 0x1F, 0x00, 0x1F, 0x83, 0x87, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1C, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x38, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0xF0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x07,
  0x81, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x0F,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0xFC,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1C,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x78,
  0x3C, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x70, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0xF0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x03, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x3C, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3E, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x0F, 0x00,
  0xF0, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x01, 0xC1, 0xE0, 0x07, 0xC0, 0x0F,
  0x07, 0x80, 0x0F, 0x00, 0x78, 0x1C, 0x00, 0x3E, 0x01, 0xC0, 0x70, 0x00,
  0x78, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0x03, 0xC1, 0xC0,
  0x3C, 0x00, 0x07, 0x8E, 0x00, 0xF0, 0x00, 0x0F, 0x78, 0x03, 0x80, 0x00,
  0x3F, 0xC0, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00,
  0x7E, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0x1E, 0xF0, 0x07,
  0x80, 0x00, 0xF1, 0xE0, 0x1F, 0x00, 0x07, 0x83, 0x80, 0x3C, 0x00, 0x3C,
  0x0F, 0x00, 0xF8, 0x03, 0xE0, 0x1E, 0x01, 0xFF, 0xFF, 0x00, 0x78, 0x03,
  0xFF, 0xF0, 0x00, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0x67, 0xE0, 0x07, 0x80, 0x1F, 0xBF, 0xE0, 0x38, 0x07, 0xFF, 0xFF,
  0xE1, 0xC1, 0xFF, 0xE1, 0xFF, 0x8E, 0x3F, 0xF8, 0x03, 0xFF, 0x67, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0x83, 0xF8, 0xFF,
  0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFE, 0x7F, 0xC7, 0xF0, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0xF0, 0x03, 0x00, 0x3C, 0x1E, 0x01, 0xF0, 0x0F,
  0x03, 0xC0, 0x7F, 0x01, 0xE0, 0x78, 0x0F, 0xE0, 0x3C, 0x1E, 0x01, 0xFC,
  0x07, 0x83, 0xC0, 0x3F, 0x80, 0xF0, 0x78, 0x03, 0xE0, 0x1E, 0x0F, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x78,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xBC, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xF0, 0xE0, 0x00,
  0x0F, 0x81, 0xC0, 0x00, 0x7E, 0x03, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x10, 0x00, 0x78, 0x00, 0x40,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x0F, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xF0, 0x00, 0x1E, 0x1F,
  0xFF, 0x00, 0x07, 0x9F, 0xFF, 0xF0, 0x01, 0xCF, 0x81, 0xFE, 0x00, 0x77,
  0x80, 0x0F, 0x80, 0x1D, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xE1, 0xFF, 0x00, 0x01, 0xEF, 0xFF, 0xC0, 0x03, 0xDF, 0xFF, 0xF0, 0x07,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF7,
  0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x1D, 0xC0, 0x0F,
  0xFF, 0xFB, 0xC0, 0x07, 0xFF, 0xF7, 0x80, 0x01, 0xFF, 0x87, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x0C, 0x00, 0x00, 0x07, 0x80,
  0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xFF, 0x1E, 0x07,
  0x00, 0x07, 0xFF, 0x9E, 0x0F, 0x00, 0x1F, 0xFF, 0xDE, 0x0F, 0x00, 0x1F,
  0x01, 0xDC, 0x0F, 0x00, 0x3C, 0x00, 0x5C, 0x0F, 0x00, 0x78, 0x00, 0x7C,
  0x0E, 0x00, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x70, 0x00, 0x3C, 0x1E, 0x00,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x00,
  0x38, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x00, 0x78, 0x1C,
  0x01, 0xE0, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0x00, 0x70,
  0x38, 0x01, 0xC0, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x00, 0xF0, 0x38, 0x03,
  0xC0, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x01,
  0xE0, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x03, 0xE0, 0x70,
  0x01, 0xF0, 0x06, 0xE0, 0x70, 0x01, 0xF8, 0x1C, 0xE0, 0x70, 0x00, 0xFF,
  0xFD, 0xE0, 0xF0, 0x00, 0x7F, 0xF1, 0xC0, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1E, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0x80, 0x0F, 0xF8, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x1C, 0x00, 0x00, 0xF8, 0x07, 0x00, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x3C, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x1E,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x7C, 0x07, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3F, 0x00,
  0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x10, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x7F, 0xE0,
  0x01, 0xE0, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x01,
  0xF0, 0x07, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xF0, 0x07, 0x00,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x10, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xFE, 0x0F, 0x00,
  0x7F, 0xFF, 0x83, 0x80, 0x1F, 0xFF, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0E, 0xC0, 0x00,
  0x0D, 0xC0, 0x3B, 0x80, 0x00, 0x7F, 0x00, 0xEE, 0x00, 0x01, 0xBC, 0x03,
  0xB8, 0x00, 0x0E, 0xE0, 0x0E, 0xE0, 0x00, 0x73, 0x80, 0x79, 0x80, 0x01,
  0xCE, 0x01, 0xE7, 0x00, 0x0E, 0x78, 0x07, 0x1C, 0x00, 0x39, 0xE0, 0x1C,
  0x70, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x07, 0x1C, 0x01, 0xC3, 0x00, 0x38,
  0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x0F, 0x00, 0xF0,
  0xE0, 0x1C, 0x3C, 0x03, 0xC3, 0x80, 0xE0, 0xF0, 0x0E, 0x06, 0x03, 0x83,
  0x80, 0x38, 0x1C, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x70, 0x38, 0x07, 0x81,
  0xC3, 0x81, 0xE0, 0x1E, 0x07, 0x0E, 0x07, 0x80, 0x78, 0x0C, 0x70, 0x1E,
  0x01, 0xC0, 0x39, 0xC0, 0x70, 0x07, 0x00, 0xEE, 0x01, 0xC0, 0x1C, 0x03,
  0xB8, 0x07, 0x00, 0xF0, 0x0F, 0xC0, 0x1C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x1F,
  0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x00, 0xE0,
  0x1F, 0xC0, 0x00, 0x1C, 0x03, 0xB8, 0x00, 0x03, 0x80, 0x77, 0x00, 0x00,
  0xF0, 0x0E, 0xE0, 0x00, 0x1E, 0x01, 0xCE, 0x00, 0x03, 0xC0, 0x79, 0xC0,
  0x00, 0x70, 0x0F, 0x38, 0x00, 0x0E, 0x01, 0xE7, 0x00, 0x01, 0xC0, 0x38,
  0x70, 0x00, 0x38, 0x07, 0x0E, 0x00, 0x0F, 0x00, 0xE1, 0xC0, 0x01, 0xE0,
  0x3C, 0x38, 0x00, 0x38, 0x07, 0x87, 0x80, 0x07, 0x00, 0xF0, 0x70, 0x00,
  0xE0, 0x1C, 0x0E, 0x00, 0x1C, 0x03, 0x81, 0xC0, 0x07, 0x80, 0x70, 0x3C,
  0x00, 0xF0, 0x0E, 0x03, 0x80, 0x1E, 0x03, 0xC0, 0x70, 0x03, 0x80, 0x78,
  0x0E, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x0E, 0x01,
  0xC0, 0x3C, 0x00, 0xE0, 0x38, 0x07, 0x80, 0x1C, 0x07, 0x00, 0xE0, 0x03,
  0x81, 0xE0, 0x1C, 0x00, 0x70, 0x3C, 0x03, 0x80, 0x0F, 0x07, 0x80, 0xF0,
  0x00, 0xE0, 0xE0, 0x1E, 0x00, 0x1C, 0x1C, 0x03, 0xC0, 0x03, 0x83, 0x80,
  0x70, 0x00, 0x78, 0x70, 0x0E, 0x00, 0x07, 0x1E, 0x01, 0xC0, 0x00, 0xE3,
  0xC0, 0x78, 0x00, 0x1C, 0x78, 0x0F, 0x00, 0x03, 0xCE, 0x01, 0xE0, 0x00,
  0x39, 0xC0, 0x38, 0x00, 0x07, 0x38, 0x07, 0x00, 0x00, 0xE7, 0x00, 0xE0,
  0x00, 0x1F, 0xE0, 0x1C, 0x00, 0x01, 0xFC, 0x07, 0x80, 0x00, 0x3F, 0x00,
  0xF0, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x00, 0xFC, 0x03, 0x80, 0x00, 0x1F,
  0x80, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x01, 0xE0, 0x00, 0x0F, 0xC0,
  0x1E, 0x00, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xF7,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x01, 0xE0,
  0x00, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x80, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x1E, 0x70, 0x00, 0x7C, 0x00,
  0x3C, 0xE0, 0x01, 0xF8, 0x00, 0x71, 0xC0, 0x03, 0xF0, 0x01, 0xE3, 0x80,
  0x07, 0xE0, 0x03, 0xC7, 0x00, 0x0D, 0xC0, 0x07, 0x0E, 0x00, 0x3B, 0x80,
  0x0E, 0x1C, 0x00, 0x77, 0x00, 0x3C, 0x38, 0x00, 0xCE, 0x00, 0x78, 0x70,
  0x03, 0x9C, 0x00, 0xE0, 0xE0, 0x07, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x70,
  0x07, 0x87, 0x80, 0x38, 0xE0, 0x0E, 0x0F, 0x00, 0x71, 0x80, 0x1C, 0x1E,
  0x00, 0xE3, 0x00, 0x78, 0x3C, 0x01, 0x86, 0x00, 0xF0, 0x78, 0x07, 0x0C,
  0x01, 0xC0, 0xF0, 0x0E, 0x18, 0x03, 0x81, 0xC0, 0x18, 0x30, 0x0F, 0x03,
  0x80, 0x70, 0x60, 0x1C, 0x07, 0x00, 0xE0, 0xC0, 0x38, 0x0E, 0x01, 0xC1,
  0x80, 0x70, 0x1C, 0x07, 0x03, 0x01, 0xE0, 0x38, 0x0E, 0x06, 0x03, 0x80,
  0x70, 0x1C, 0x0C, 0x07, 0x00, 0xE0, 0x30, 0x18, 0x1E, 0x01, 0xC0, 0xE0,
  0x30, 0x38, 0x03, 0x81, 0xC0, 0x60, 0x70, 0x07, 0x03, 0x00, 0xC0, 0xE0,
  0x0E, 0x0E, 0x01, 0x83, 0xC0, 0x1C, 0x1C, 0x07, 0x07, 0x00, 0x38, 0x30,
  0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x70, 0xE0, 0x03, 0x86, 0x00, 0xE1, 0xC0, 0x07, 0x1C,
  0x01, 0xC7, 0x80, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0x1C, 0x60, 0x07, 0x1C,
  0x00, 0x39, 0xC0, 0x0E, 0x38, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x01, 0xE6,
  0x00, 0x39, 0xC0, 0x03, 0xDC, 0x00, 0x73, 0x80, 0x07, 0xB8, 0x00, 0xEF,
  0x00, 0x0F, 0x60, 0x01, 0xDC, 0x00, 0x1E, 0xC0, 0x03, 0xB8, 0x00, 0x3B,
  0x80, 0x07, 0x70, 0x00, 0x76, 0x00, 0x0F, 0xC0, 0x00, 0xEC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x38, 0x03,
  0xC0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1C, 0x1E, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xC0, 0x07, 0xFF,
  0xF1, 0xE0, 0x0F, 0xE0, 0xFC, 0xE0, 0x0F, 0x80, 0x0E, 0x70, 0x0F, 0x80,
  0x03, 0xB8, 0x07, 0x80, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x7E, 0x07, 0x80,
  0x00, 0x1F, 0x03, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00,
  0xFC, 0x03, 0xC0, 0x01, 0xDC, 0x01, 0xF0, 0x01, 0xCE, 0x00, 0x7F, 0x0F,
  0xCF, 0x00, 0x1F, 0xFF, 0xC7, 0x80, 0x07, 0xFF, 0x83, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x03, 0x83, 0xFF, 0xC0, 0x03,
  0x87, 0xFF, 0xF0, 0x07, 0x9F, 0x87, 0xF8, 0x07, 0xBC, 0x00, 0xF8, 0x07,
  0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x03, 0xC0, 0xF6,
  0x00, 0x07, 0x80, 0xF7, 0x80, 0x1F, 0x00, 0xF3, 0xF0, 0xFE, 0x00, 0xE1,
  0xFF, 0xFC, 0x00, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0xFE, 0x0F, 0x00, 0x07, 0xFF, 0xF1,
  0xE0, 0x03, 0xF8, 0x3F, 0x38, 0x00, 0xF8, 0x00, 0xE7, 0x00, 0x3E, 0x00,
  0x0E, 0xE0, 0x07, 0x80, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x77,
  0x00, 0x1F, 0x00, 0x1C, 0xE0, 0x01, 0xFC, 0x3F, 0x3C, 0x00, 0x1F, 0xFF,
  0xC7, 0x80, 0x01, 0xFF, 0xE0, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xFC,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0x00, 0x3F, 0xFF, 0x8F,
  0x00, 0xFE, 0x0F, 0xCE, 0x01, 0xF0, 0x01, 0xCE, 0x03, 0xE0, 0x00, 0xEE,
  0x03, 0xC0, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x3E,
  0x0E, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x02, 0xE0, 0x3C, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x1D, 0xE0,
  0x1F, 0x80, 0x79, 0xE0, 0x0F, 0xFF, 0xF1, 0xE0, 0x07, 0xFF, 0xE1, 0xC0,
  0x01, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x03, 0x83, 0xFF, 0xC0, 0x03, 0x87, 0xFF, 0xF0, 0x07, 0x9F, 0x87, 0xF8,
  0x07, 0xBC, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xE0,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x7F, 0xC1, 0xFF, 0x00,
  0xF7, 0xFF, 0x1F, 0xFC, 0x07, 0x78, 0xF9, 0xE7, 0xE0, 0x3B, 0x03, 0xEC,
  0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x70,
  0x03, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x03,
  0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x01,
  0xC0, 0x07, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x03, 0xC1,
  0xE0, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xC0,
  0x07, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xE0,
  0x03, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x07,
  0x83, 0xC0, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xE0, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x83,
  0xC0, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xE0, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xC0,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0x0F,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x07,
  0x00, 0x1C, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0x83, 0xFF, 0xC0, 0x03, 0x87, 0xFF, 0xF0, 0x07, 0x9F, 0x87, 0xF8, 0x07,
  0xBC, 0x00, 0xF8, 0x07, 0xB0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xFC,
  0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x3F, 0xFC, 0x00, 0x0E,
  0x3F, 0xFF, 0xC0, 0x07, 0x9F, 0x87, 0xF8, 0x01, 0xEF, 0x00, 0x3E, 0x00,
  0x7F, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x1E, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0xF6, 0x00, 0x07, 0x80, 0x3D,
  0xE0, 0x07, 0xC0, 0x0F, 0x3F, 0x0F, 0xE0, 0x03, 0x87, 0xFF, 0xF0, 0x00,
  0xE0, 0xFF, 0xF0, 0x00, 0x38, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xC0, 0x07, 0xFF, 0xF1,
  0xE0, 0x0F, 0xE0, 0xFC, 0xE0, 0x0F, 0x80, 0x0E, 0x70, 0x0F, 0x80, 0x03,
  0xB8, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0x1F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x01, 0xFC,
  0x03, 0xC0, 0x01, 0xDC, 0x01, 0xF0, 0x01, 0xCE, 0x00, 0x7F, 0x0F, 0xCF,
  0x00, 0x1F, 0xFF, 0xC7, 0x80, 0x07, 0xFF, 0x83, 0xC0, 0x00, 0x7E, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xE1, 0xFF, 0xF0, 0x00,
  0xE3, 0xFF, 0xFC, 0x00, 0x73, 0xF0, 0x7F, 0x00, 0x7B, 0xC0, 0x0F, 0xC0,
  0x3D, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0x87, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x20, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x7C, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x03, 0x87, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x3F, 0x80,
  0x07, 0x80, 0x07, 0x70, 0x01, 0xF0, 0x00, 0xEE, 0x00, 0x36, 0x00, 0x3D,
  0xC0, 0x06, 0xC0, 0x07, 0x38, 0x01, 0xD8, 0x00, 0xE7, 0x00, 0x33, 0x00,
  0x3C, 0xE0, 0x0E, 0x60, 0x07, 0x1C, 0x01, 0xCC, 0x00, 0xE3, 0x80, 0x31,
  0xC0, 0x3C, 0x70, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0xE1, 0xC0,
  0x30, 0xE0, 0x3C, 0x38, 0x0E, 0x1C, 0x07, 0x07, 0x01, 0xC3, 0x80, 0xE0,
  0xE0, 0x30, 0x70, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0,
  0xE0, 0x70, 0x30, 0x38, 0x3C, 0x0E, 0x0E, 0x07, 0x07, 0x01, 0xC1, 0xC0,
  0xE0, 0xE0, 0x38, 0x30, 0x1C, 0x3C, 0x07, 0x0E, 0x03, 0x87, 0x00, 0xE1,
  0xC0, 0x70, 0xE0, 0x1C, 0x70, 0x0E, 0x3C, 0x03, 0x8E, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x38, 0xE0, 0x0E, 0x70, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x1C, 0xE0, 0x07, 0x70, 0x03, 0xBC, 0x00, 0xEE, 0x00,
  0x77, 0x00, 0x1D, 0xC0, 0x0E, 0xE0, 0x03, 0xF0, 0x01, 0xDC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0x78, 0x1F,
  0x00, 0x1E, 0xE0, 0x1F, 0x80, 0xF9, 0xC0, 0x3F, 0xFF, 0xE7, 0x80, 0x1F,
  0xFF, 0x0F, 0x00, 0x0F, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x07, 0xF8,
  0x00, 0x07, 0x0F, 0xFE, 0x00, 0x07, 0x1F, 0x3F, 0x00, 0x07, 0x3C, 0x0F,
  0x00, 0x07, 0x78, 0x07, 0x80, 0x0F, 0x70, 0x03, 0xC0, 0x0F, 0x70, 0x01,
  0xE0, 0x0E, 0x70, 0x01, 0xE0, 0x1E, 0x70, 0x00, 0xF0, 0x1C, 0xF0, 0x00,
  0x7E, 0xFC, 0xF0, 0x00, 0x3F, 0xF8, 0xE0, 0x00, 0x1F, 0xF0, 0xE0, 0x00,
  0x01, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 14, 52, 43, 15, -52 },
  { 92, 22, 21, 43, 14, -52 },
  { 150, 41, 52, 43, 2, -52 },
  { 417, 36, 72, 43, 4, -62 },
  { 741, 48, 52, 43, -2, -52 },
  { 1053, 38, 54, 43, 2, -53 },
  { 1310, 8, 21, 43, 21, -52 },
  { 1331, 28, 69, 43, 13, -60 },
  { 1573, 27, 69, 43, 4, -60 },
  { 1806, 37, 36, 43, 4, -43 },
  { 1973, 32, 33, 43, 6, -40 },
  { 2105, 15, 22, 43, 9, -11 },
  { 2147, 24, 3, 43, 10, -25 },
  { 2156, 11, 11, 43, 13, -10 },
  { 2172, 40, 67, 43, 2, -59 },
  { 2507, 35, 54, 43, 5, -53 },
  { 2744, 31, 52, 43, 4, -52 },
  { 2946, 36, 53, 43, 4, -53 },
  { 3185, 34, 53, 43, 5, -52 },
  { 3411, 31, 52, 43, 6, -52 },
  { 3613, 34, 53, 43, 5, -52 },
  { 3839, 32, 53, 43, 5, -52 },
  { 4051, 33, 52, 43, 9, -52 },
  { 4266, 35, 54, 43, 4, -53 },
  { 4503, 32, 53, 43, 8, -53 },
  { 4715, 16, 41, 43, 13, -40 },
  { 4797, 20, 51, 43, 9, -40 },
  { 4925, 33, 35, 43, 7, -41 },
  { 5070, 32, 19, 43, 6, -33 },
  { 5146, 33, 35, 43, 4, -41 },
  { 5291, 27, 52, 43, 12, -52 },
  { 5467, 40, 66, 43, 2, -53 },
  { 5797, 33, 52, 43, 2, -52 },
  { 6012, 34, 52, 43, 5, -52 },
  { 6233, 34, 54, 43, 6, -53 },
  { 6463, 34, 52, 43, 5, -52 },
  { 6684, 36, 52, 43, 5, -52 },
  { 6918, 37, 52, 43, 5, -52 },
  { 7159, 34, 54, 43, 6, -53 },
  { 7389, 35, 52, 43, 5, -52 },
  { 7617, 34, 52, 43, 5, -52 },
  { 7838, 36, 53, 43, 3, -52 },
  { 8077, 38, 52, 43, 5, -52 },
  { 8324, 30, 52, 43, 5, -52 },
  { 8519, 38, 52, 43, 3, -52 },
  { 8766, 35, 52, 43, 5, -52 },
  { 8994, 33, 54, 43, 6, -53 },
  { 9217, 36, 52, 43, 5, -52 },
  { 9451, 33, 66, 43, 6, -53 },
  { 9724, 36, 52, 43, 5, -52 },
  { 9958, 36, 54, 43, 4, -53 },
  { 10201, 34, 52, 43, 9, -52 },
  { 10422, 34, 53, 43, 6, -52 },
  { 10648, 33, 52, 43, 10, -52 },
  { 10863, 39, 52, 43, 6, -52 },
  { 11117, 42, 52, 43, 1, -52 },
  { 11390, 35, 52, 43, 9, -52 },
  { 11618, 37, 52, 43, 3, -52 },
  { 11859, 27, 67, 43, 11, -59 },
  { 12086, 19, 67, 43, 13, -59 },
  { 12246, 26, 67, 43, 7, -59 },
  { 12464, 28, 28, 43, 8, -52 },
  { 12562, 35, 3, 43, 0, 2 },
  { 12576, 10, 10, 43, 20, -56 },
  { 12589, 33, 41, 43, 5, -40 },
  { 12759, 32, 53, 43, 5, -52 },
  { 12971, 32, 41, 43, 6, -40 },
  { 13135, 35, 53, 43, 5, -52 },
  { 13367, 31, 41, 43, 6, -40 },
  { 13526, 44, 65, 43, -2, -52 },
  { 13884, 32, 53, 43, 6, -40 },
  { 14096, 32, 52, 43, 5, -52 },
  { 14304, 31, 54, 43, 4, -54 },
  { 14514, 35, 67, 43, 2, -54 },
  { 14808, 35, 52, 43, 5, -52 },
  { 15036, 28, 52, 43, 8, -52 },
  { 15218, 37, 40, 43, 2, -40 },
  { 15403, 32, 40, 43, 5, -40 },
  { 15563, 31, 41, 43, 6, -40 },
  { 15722, 34, 53, 43, 3, -40 },
  { 15948, 33, 53, 43, 5, -40 },
  { 16167, 33, 40, 43, 6, -40 },
  { 16332, 32, 41, 43, 5, -40 },
  { 16496, 31, 50, 43, 8, -50 },
  { 16690, 32, 40, 43, 6, -39 },
  { 16850, 32, 39, 43, 8, -39 },
  { 17006, 35, 39, 43, 7, -39 },
  { 17177, 38, 39, 43, 2, -39 },
  { 17363, 31, 52, 43, 6, -39 },
  { 17565, 33, 39, 43, 4, -39 },
  { 17726, 34, 67, 43, 8, -59 },
  { 18011, 14, 67, 43, 15, -59 },
  { 18129, 34, 67, 43, 3, -59 },
  { 18414, 32, 14, 43, 6, -32 },
};

const GFXfont JetBrainsMono_ThinItalic71pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic71pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _JETBRAINSMONO_THINITALIC71PT7B_H_
