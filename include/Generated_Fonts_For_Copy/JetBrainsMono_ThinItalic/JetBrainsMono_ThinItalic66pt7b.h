#ifndef _JETBRAINSMONO_THINITALIC66PT7B_H_
#define _JETBRAINSMONO_THINITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFE,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x1E, 0x00, 0xF3, 0xE0, 0x0F,
  0x3E, 0x00, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x70,
  0x03, 0x8F, 0x00, 0x38, 0xF0, 0x03, 0x8E, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xF3, 0xBF, 0x80, 0x03,
  0xC1, 0xC3, 0xE0, 0x03, 0xC0, 0xC0, 0xF0, 0x03, 0xC0, 0x60, 0x3C, 0x03,
  0xC0, 0x70, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x0E, 0x01, 0xC0, 0x70, 0x06, 0x00, 0xE0, 0x38, 0x03, 0x00, 0x70,
  0x1C, 0x01, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xF8, 0x18, 0x00,
  0x00, 0x3C, 0x0C, 0x00, 0x00, 0x1F, 0x8E, 0x00, 0x00, 0x07, 0xE7, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x77, 0xF0, 0x00, 0x00, 0x38,
  0xFC, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x06,
  0x03, 0xC0, 0x00, 0x03, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x38, 0x03, 0x83, 0x80, 0x18, 0x01, 0xC3, 0xC0, 0x0C, 0x01, 0xE1, 0xE0,
  0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x00, 0x70, 0x38, 0x03, 0x80, 0x78, 0x1E,
  0x01, 0xC0, 0x78, 0x0F, 0x00, 0xC0, 0x38, 0x03, 0xC0, 0x60, 0x7C, 0x01,
  0xF8, 0x70, 0x7C, 0x00, 0x7F, 0xBB, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x7C, 0x7E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x00, 0x38,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0xE0,
  0x00, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x00,
  0x01, 0xC0, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0xF0, 0x00, 0x00,
  0x78, 0x0F, 0x07, 0x00, 0x00, 0x01, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x0F,
  0xFF, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x81, 0xFF,
  0x00, 0x00, 0x00, 0x38, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0xF0,
  0x00, 0x00, 0x3C, 0x3C, 0x03, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x1E, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x00, 0x1E,
  0x01, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x70, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x38, 0x07, 0x80, 0x07, 0x0F, 0x00, 0x78, 0x01, 0xC1, 0xC0, 0x0F, 0x00,
  0x78, 0x38, 0x00, 0xF0, 0x0E, 0x0F, 0x00, 0x1E, 0x03, 0x81, 0xC0, 0x01,
  0xE0, 0xF0, 0x38, 0x00, 0x1C, 0x1C, 0x07, 0x00, 0x03, 0xC7, 0x00, 0xE0,
  0x00, 0x3D, 0xE0, 0x1C, 0x00, 0x07, 0xF8, 0x07, 0x80, 0x00, 0x7E, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1F,
  0x00, 0x70, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x01, 0xFE, 0x01, 0xC0, 0x00,
  0x79, 0xC0, 0x3C, 0x00, 0x1E, 0x3C, 0x07, 0x80, 0x07, 0x83, 0x80, 0x78,
  0x03, 0xE0, 0x78, 0x0F, 0xE3, 0xF8, 0x07, 0x80, 0xFF, 0xFC, 0x00, 0x70,
  0x0F, 0xFE, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x78, 0xF1,
  0xE3, 0xCF, 0x9F, 0x3E, 0x78, 0xF1, 0xE3, 0xCF, 0x9E, 0x3C, 0x78, 0xF1,
  0xC3, 0x87, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x0D, 0xF0, 0x03,
  0x80, 0x1F, 0xFF, 0x80, 0xE0, 0x3F, 0xDF, 0xF8, 0x30, 0x7F, 0xF0, 0xFF,
  0x8C, 0x7F, 0xE0, 0x0F, 0xFB, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x87,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x3F, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x1C,
  0x01, 0x80, 0x3C, 0x3C, 0x07, 0xC0, 0x3C, 0x3C, 0x07, 0xE0, 0x3C, 0x3C,
  0x07, 0xE0, 0x38, 0x3C, 0x07, 0xE0, 0x38, 0x38, 0x07, 0xE0, 0x78, 0x38,
  0x03, 0xC0, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x0F, 0x87, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x1F, 0x01, 0xC0,
  0x01, 0xF0, 0x0E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x80, 0x04,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x78, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x0E, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x0E, 0x1F,
  0xFE, 0x00, 0x3C, 0x7F, 0xFE, 0x00, 0x7B, 0xF0, 0xFE, 0x00, 0xEF, 0x00,
  0x7E, 0x01, 0xD8, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xF8,
  0x3F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x7F, 0x80, 0x01, 0xEF, 0xFF, 0x80, 0x0F, 0x7F, 0xFF,
  0x00, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1E,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0F,
  0x38, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xFF, 0xFD, 0xC0,
  0x03, 0xFF, 0xCE, 0x00, 0x01, 0xF8, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x03, 0xF8,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFC, 0x03, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x78, 0x00, 0x1F, 0xC3, 0x83, 0xC0, 0x07, 0xFF,
  0x1C, 0x1C, 0x00, 0x7F, 0xFC, 0xE0, 0xE0, 0x07, 0xC0, 0x7F, 0x07, 0x00,
  0x3C, 0x01, 0xF0, 0x38, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x1C, 0x00, 0x3C,
  0x1E, 0x01, 0xE0, 0x01, 0xE0, 0xE0, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x70,
  0x00, 0x78, 0x38, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x1C, 0x00, 0x1C, 0x1E,
  0x01, 0xE0, 0x00, 0xE0, 0xF0, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x70, 0x00,
  0x38, 0x38, 0x03, 0x80, 0x03, 0xC1, 0xC0, 0x1C, 0x00, 0x1E, 0x0E, 0x00,
  0xE0, 0x00, 0xE0, 0xF0, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x78, 0x00, 0x38,
  0x38, 0x03, 0xC0, 0x03, 0xC1, 0xC0, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0xF0,
  0x01, 0xF0, 0x70, 0x07, 0xC0, 0x1F, 0x03, 0x80, 0x1F, 0x01, 0xF8, 0x3C,
  0x00, 0xFF, 0xFD, 0xC1, 0xE0, 0x03, 0xFF, 0xCE, 0x0F, 0x00, 0x07, 0xF8,
  0x70, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07,
  0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0x00, 0x03, 0xF0, 0x03, 0x80, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x01, 0xF0, 0x07, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x03, 0xF0, 0x01, 0xE0,
  0x00, 0xF8, 0x01, 0xC0, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1F, 0x00, 0x70, 0x00,
  0x3E, 0x00, 0x70, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xFF, 0xF8, 0x1C, 0x01, 0xFF, 0xF8,
  0x3C, 0x03, 0xFF, 0xF8, 0x3C, 0x03, 0xFF, 0xF8, 0x38, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0xE0, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xF0, 0x03,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xE0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0x60,
  0x00, 0x1F, 0x80, 0xEC, 0x00, 0x07, 0x70, 0x1D, 0xC0, 0x00, 0xEE, 0x03,
  0xB8, 0x00, 0x3B, 0x80, 0x77, 0x00, 0x07, 0x70, 0x0E, 0x60, 0x01, 0xCE,
  0x03, 0xCC, 0x00, 0x31, 0xC0, 0x71, 0xC0, 0x0E, 0x38, 0x0E, 0x38, 0x01,
  0x8F, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x38, 0x60, 0x0C, 0x38, 0x07, 0x0C,
  0x03, 0x87, 0x01, 0xE1, 0xC0, 0x60, 0xE0, 0x3C, 0x38, 0x1C, 0x1C, 0x07,
  0x07, 0x03, 0x07, 0x80, 0xE0, 0x60, 0xE0, 0xE0, 0x1C, 0x0C, 0x18, 0x1C,
  0x03, 0x81, 0xC7, 0x03, 0x80, 0x70, 0x39, 0xC0, 0x70, 0x1E, 0x03, 0x38,
  0x0E, 0x03, 0x80, 0x6E, 0x03, 0xC0, 0x70, 0x0D, 0xC0, 0x78, 0x0E, 0x01,
  0xF0, 0x0E, 0x01, 0xC0, 0x3E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x0F,
  0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x7C, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x00, 0xF0,
  0x1D, 0xC0, 0x00, 0x70, 0x0E, 0xE0, 0x00, 0x38, 0x07, 0x70, 0x00, 0x1C,
  0x03, 0xB8, 0x00, 0x0E, 0x01, 0xCE, 0x00, 0x07, 0x01, 0xE7, 0x00, 0x07,
  0x80, 0xE3, 0x80, 0x03, 0x80, 0x71, 0xC0, 0x01, 0xC0, 0x38, 0x60, 0x00,
  0xE0, 0x1C, 0x38, 0x00, 0x70, 0x0E, 0x1C, 0x00, 0x38, 0x07, 0x0E, 0x00,
  0x3C, 0x07, 0x83, 0x00, 0x1C, 0x03, 0x81, 0xC0, 0x0E, 0x01, 0xC0, 0xE0,
  0x07, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x70, 0x38, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xC0,
  0x1C, 0x07, 0x01, 0xE0, 0x0E, 0x07, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x70,
  0x01, 0xC1, 0xC0, 0x38, 0x00, 0xE0, 0xE0, 0x1C, 0x00, 0x70, 0x70, 0x0E,
  0x00, 0x1C, 0x38, 0x0F, 0x00, 0x0E, 0x3C, 0x07, 0x80, 0x07, 0x1C, 0x03,
  0x80, 0x03, 0x8E, 0x01, 0xC0, 0x01, 0xC7, 0x00, 0xE0, 0x00, 0x73, 0x80,
  0x70, 0x00, 0x39, 0xC0, 0x38, 0x00, 0x1C, 0xE0, 0x3C, 0x00, 0x0E, 0xE0,
  0x1C, 0x00, 0x03, 0xF0, 0x0E, 0x00, 0x01, 0xF8, 0x07, 0x00, 0x00, 0xFC,
  0x03, 0x80, 0x00, 0x7E, 0x01, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0xF0, 0x7E, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x78, 0x03,
  0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x01, 0xF8, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x03, 0x80, 0x78, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xF7,
  0x00, 0x0F, 0x80, 0x0E, 0x70, 0x00, 0xF8, 0x00, 0xE7, 0x00, 0x1F, 0x80,
  0x1E, 0x70, 0x01, 0xF8, 0x01, 0xC7, 0x00, 0x1B, 0x80, 0x1C, 0x70, 0x03,
  0xB8, 0x01, 0xC7, 0x00, 0x3B, 0x80, 0x3C, 0x70, 0x03, 0xB8, 0x03, 0x87,
  0x00, 0x33, 0x80, 0x38, 0x70, 0x07, 0x38, 0x03, 0x87, 0x00, 0x73, 0x00,
  0x70, 0x70, 0x06, 0x30, 0x07, 0x07, 0x00, 0xE3, 0x00, 0x70, 0x70, 0x0E,
  0x30, 0x0F, 0x07, 0x00, 0xC3, 0x00, 0xE0, 0x70, 0x1C, 0x30, 0x0E, 0x07,
  0x01, 0xC3, 0x00, 0xE0, 0x70, 0x18, 0x30, 0x1C, 0x07, 0x01, 0x83, 0x01,
  0xC0, 0x70, 0x38, 0x30, 0x1C, 0x07, 0x03, 0x83, 0x01, 0xC0, 0x70, 0x30,
  0x30, 0x38, 0x07, 0x07, 0x03, 0x03, 0x80, 0xE0, 0x70, 0x30, 0x38, 0x0E,
  0x06, 0x03, 0x07, 0x00, 0xE0, 0xE0, 0x30, 0x70, 0x0E, 0x0E, 0x03, 0x07,
  0x00, 0xE0, 0xC0, 0x30, 0x70, 0x0E, 0x0C, 0x03, 0x0E, 0x00, 0xE1, 0xC0,
  0x30, 0xE0, 0x0E, 0x18, 0x03, 0x0E, 0x00, 0xE1, 0x80, 0x30, 0xC0, 0x0E,
  0x38, 0x03, 0x1C, 0x00, 0xE3, 0x00, 0x31, 0xC0, 0x0E, 0x30, 0x03, 0x1C,
  0x00, 0xE7, 0x00, 0x33, 0x80, 0x0E, 0x70, 0x03, 0x38, 0x00, 0xE6, 0x00,
  0x73, 0x80, 0x0E, 0x60, 0x07, 0x30, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x0E,
  0xC0, 0x07, 0x70, 0x00, 0xEC, 0x00, 0x77, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0x70,
  0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x00, 0xE0,
  0x1C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x70, 0x07, 0xFF,
  0xF1, 0xC0, 0x3E, 0x01, 0xEF, 0x01, 0xE0, 0x01, 0xBC, 0x0F, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x1B, 0x80, 0xF8, 0x01, 0xEE, 0x01, 0xF8, 0x1F,
  0x38, 0x03, 0xFF, 0xF1, 0xE0, 0x03, 0xFF, 0x87, 0x80, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x3F, 0x80, 0x03, 0x87,
  0xFF, 0x80, 0x0E, 0x3F, 0xFF, 0x80, 0x39, 0xE0, 0x3F, 0x00, 0xEE, 0x00,
  0x3C, 0x07, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xC1, 0xF0,
  0x00, 0x0F, 0x07, 0xE0, 0x00, 0x78, 0x1D, 0x80, 0x03, 0xC0, 0x77, 0x00,
  0x1E, 0x01, 0xCF, 0x83, 0xF0, 0x07, 0x1F, 0xFF, 0x80, 0x3C, 0x3F, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0xF0, 0x1C, 0x00, 0x1F, 0xFE, 0x1C, 0x00, 0x7F, 0xFF, 0x1C,
  0x00, 0xF8, 0x07, 0xBC, 0x01, 0xE0, 0x01, 0xBC, 0x03, 0xC0, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0xF8, 0x07, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1B, 0x80,
  0x3E, 0x00, 0x7B, 0x80, 0x1F, 0x81, 0xF3, 0x80, 0x0F, 0xFF, 0xC7, 0x80,
  0x03, 0xFF, 0x87, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x1E,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x71, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0xF0, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x20,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFF, 0xE1, 0xC0, 0x3F, 0xFF, 0x8E, 0x03, 0xE0, 0x1E,
  0xF0, 0x3C, 0x00, 0x37, 0x83, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x3C, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x1C, 0x78, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0xC0, 0xF8,
  0x03, 0xDC, 0x03, 0xFD, 0xFC, 0xE0, 0x0F, 0xFF, 0x87, 0x00, 0x1F, 0xF0,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x3F, 0x80, 0x03, 0x87, 0xFF, 0x80, 0x0E, 0x3F, 0xFF,
  0x80, 0x39, 0xE0, 0x3F, 0x00, 0xEE, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x78,
  0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x10, 0x78, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x3C, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x73, 0xFE, 0x1F, 0xE0, 0x0E, 0xFF, 0xC7, 0xFE, 0x01, 0xF0, 0x7D,
  0x83, 0xE0, 0x74, 0x07, 0xA0, 0x3C, 0x0F, 0x00, 0x78, 0x03, 0x81, 0xE0,
  0x0F, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0xE0, 0x07, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0xE0, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x70, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x07, 0x83, 0xC0,
  0x1E, 0x00, 0xF0, 0x70, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x03, 0x81,
  0xC0, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x01,
  0xC1, 0xE0, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x07, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x07, 0x83,
  0x80, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x03,
  0x81, 0xC0, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x1E, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0E, 0x1F, 0xFE, 0x00, 0x38, 0xFF,
  0xFE, 0x00, 0xE7, 0x80, 0xFC, 0x07, 0xB8, 0x00, 0xF0, 0x1F, 0x80, 0x01,
  0xE0, 0x74, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0x80,
  0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x1E, 0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xE1, 0xFF, 0xE0, 0x00,
  0xE3, 0xFF, 0xF8, 0x00, 0xE7, 0x80, 0xFC, 0x01, 0xEE, 0x00, 0x3C, 0x01,
  0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x70, 0x1F, 0x00, 0x00, 0xF0, 0x1F, 0x80, 0x01, 0xE0, 0x1D,
  0x80, 0x03, 0xC0, 0x1D, 0xC0, 0x07, 0xC0, 0x1C, 0xF8, 0x3F, 0x00, 0x1C,
  0x7F, 0xFE, 0x00, 0x3C, 0x3F, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x70, 0x07, 0xFF, 0xF1, 0xC0, 0x3E, 0x01, 0xEF, 0x01, 0xE0,
  0x01, 0xBC, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xC0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1B, 0x80, 0xF8,
  0x01, 0xEE, 0x01, 0xF8, 0x1F, 0x38, 0x03, 0xFF, 0xF1, 0xE0, 0x03, 0xFF,
  0x87, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x40, 0xFE, 0x00, 0x07, 0x0F, 0xFF, 0x80, 0x0E, 0x3F, 0xFF, 0x80, 0x1C,
  0xF0, 0x1F, 0x80, 0x3B, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7F,
  0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xF0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0xF0, 0x01, 0xDC, 0x00, 0x78, 0x00,
  0xEE, 0x00, 0x7C, 0x00, 0xF7, 0x00, 0x36, 0x00, 0x73, 0x80, 0x1B, 0x80,
  0x39, 0xC0, 0x1D, 0xC0, 0x3C, 0xE0, 0x0C, 0xE0, 0x1C, 0x70, 0x0E, 0x70,
  0x0E, 0x38, 0x07, 0x38, 0x0F, 0x1C, 0x03, 0x1C, 0x07, 0x0E, 0x03, 0x8E,
  0x03, 0x87, 0x01, 0xC7, 0x03, 0xC3, 0x80, 0xC3, 0x81, 0xC1, 0xC0, 0xE1,
  0xC0, 0xE0, 0xE0, 0x70, 0xE0, 0xF0, 0x70, 0x30, 0x30, 0x70, 0x38, 0x38,
  0x18, 0x38, 0x1C, 0x1C, 0x0C, 0x1C, 0x0E, 0x0C, 0x06, 0x1C, 0x07, 0x0E,
  0x03, 0x0E, 0x03, 0x87, 0x01, 0x87, 0x01, 0xC7, 0x00, 0xC7, 0x00, 0xE3,
  0x80, 0x63, 0x80, 0x71, 0xC0, 0x31, 0xC0, 0x39, 0xC0, 0x19, 0xC0, 0x1C,
  0xE0, 0x0C, 0xE0, 0x0E, 0x60, 0x06, 0x70, 0x07, 0x70, 0x03, 0x70, 0x03,
  0xB8, 0x01, 0xB8, 0x01, 0xD8, 0x00, 0xDC, 0x00, 0xEC, 0x00, 0x6C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0xF0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C,
  0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x1B, 0x80, 0x7C, 0x01, 0xCE, 0x01, 0xFF, 0xFE, 0x38, 0x01,
  0xFF, 0xF1, 0xE0, 0x03, 0xFF, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x0E, 0x1F, 0xF8, 0x00, 0x38, 0x7C, 0xF8, 0x00,
  0x71, 0xE0, 0x78, 0x00, 0xE3, 0x80, 0x78, 0x01, 0xC7, 0x00, 0x70, 0x03,
  0x9C, 0x00, 0xF0, 0x0F, 0x38, 0x00, 0xF0, 0x1C, 0x70, 0x00, 0xF0, 0x78,
  0xE0, 0x00, 0xFF, 0xE1, 0xC0, 0x00, 0xFF, 0x87, 0x80, 0x00, 0x78, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 13, 48, 40, 14, -48 },
  { 79, 20, 20, 40, 13, -48 },
  { 129, 38, 48, 40, 2, -48 },
  { 357, 33, 66, 40, 4, -57 },
  { 630, 45, 49, 40, -2, -49 },
  { 906, 35, 50, 40, 2, -49 },
  { 1125, 7, 20, 40, 20, -48 },
  { 1143, 26, 64, 40, 12, -56 },
  { 1351, 26, 64, 40, 3, -56 },
  { 1559, 34, 33, 40, 4, -40 },
  { 1700, 30, 30, 40, 5, -37 },
  { 1813, 14, 21, 40, 8, -10 },
  { 1850, 21, 3, 40, 10, -23 },
  { 1858, 11, 10, 40, 12, -9 },
  { 1872, 37, 62, 40, 2, -55 },
  { 2159, 32, 50, 40, 5, -49 },
  { 2359, 29, 48, 40, 4, -48 },
  { 2533, 34, 49, 40, 3, -49 },
  { 2742, 32, 49, 40, 4, -48 },
  { 2938, 29, 48, 40, 5, -48 },
  { 3112, 31, 49, 40, 5, -48 },
  { 3302, 30, 49, 40, 4, -48 },
  { 3486, 31, 48, 40, 8, -48 },
  { 3672, 33, 50, 40, 4, -49 },
  { 3879, 30, 49, 40, 7, -49 },
  { 4063, 15, 38, 40, 12, -37 },
  { 4135, 19, 48, 40, 8, -37 },
  { 4249, 31, 33, 40, 6, -38 },
  { 4377, 30, 18, 40, 5, -31 },
  { 4445, 30, 33, 40, 4, -38 },
  { 4569, 26, 48, 40, 11, -48 },
  { 4725, 37, 61, 40, 2, -49 },
  { 5008, 30, 48, 40, 2, -48 },
  { 5188, 33, 48, 40, 4, -48 },
  { 5386, 32, 50, 40, 5, -49 },
  { 5586, 32, 48, 40, 4, -48 },
  { 5778, 33, 48, 40, 5, -48 },
  { 5976, 34, 48, 40, 5, -48 },
  { 6180, 32, 50, 40, 5, -49 },
  { 6380, 33, 48, 40, 4, -48 },
  { 6578, 31, 48, 40, 5, -48 },
  { 6764, 33, 49, 40, 3, -48 },
  { 6967, 36, 48, 40, 4, -48 },
  { 7183, 27, 48, 40, 5, -48 },
  { 7345, 35, 48, 40, 3, -48 },
  { 7555, 33, 48, 40, 4, -48 },
  { 7753, 31, 50, 40, 5, -49 },
  { 7947, 35, 48, 40, 4, -48 },
  { 8157, 31, 61, 40, 5, -49 },
  { 8394, 34, 48, 40, 4, -48 },
  { 8598, 33, 50, 40, 4, -49 },
  { 8805, 32, 48, 40, 8, -48 },
  { 8997, 32, 49, 40, 5, -48 },
  { 9193, 31, 48, 40, 9, -48 },
  { 9379, 36, 48, 40, 6, -48 },
  { 9595, 39, 48, 40, 1, -48 },
  { 9829, 33, 48, 40, 8, -48 },
  { 10027, 34, 48, 40, 3, -48 },
  { 10231, 25, 62, 40, 10, -55 },
  { 10425, 17, 62, 40, 12, -55 },
  { 10557, 25, 62, 40, 6, -55 },
  { 10751, 27, 26, 40, 7, -48 },
  { 10839, 32, 3, 40, 0, 2 },
  { 10851, 9, 9, 40, 19, -52 },
  { 10862, 30, 38, 40, 5, -37 },
  { 11005, 30, 49, 40, 4, -48 },
  { 11189, 30, 38, 40, 5, -37 },
  { 11332, 32, 49, 40, 5, -48 },
  { 11528, 29, 38, 40, 5, -37 },
  { 11666, 41, 60, 40, -2, -48 },
  { 11974, 29, 49, 40, 6, -37 },
  { 12152, 30, 48, 40, 4, -48 },
  { 12332, 30, 50, 40, 3, -50 },
  { 12520, 33, 62, 40, 1, -50 },
  { 12776, 33, 48, 40, 5, -48 },
  { 12974, 25, 48, 40, 8, -48 },
  { 13124, 35, 37, 40, 2, -37 },
  { 13286, 30, 37, 40, 4, -37 },
  { 13425, 29, 38, 40, 5, -37 },
  { 13563, 32, 49, 40, 2, -37 },
  { 13759, 30, 49, 40, 5, -37 },
  { 13943, 31, 37, 40, 5, -37 },
  { 14087, 31, 38, 40, 4, -37 },
  { 14235, 29, 46, 40, 7, -46 },
  { 14402, 30, 37, 40, 5, -36 },
  { 14541, 29, 36, 40, 8, -36 },
  { 14672, 33, 36, 40, 6, -36 },
  { 14821, 35, 36, 40, 2, -36 },
  { 14979, 30, 48, 40, 5, -36 },
  { 15159, 31, 36, 40, 4, -36 },
  { 15299, 32, 62, 40, 7, -55 },
  { 15547, 13, 62, 40, 14, -55 },
  { 15648, 31, 62, 40, 3, -55 },
  { 15889, 31, 12, 40, 5, -29 },
};

const GFXfont JetBrainsMono_ThinItalic66pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic66pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _JETBRAINSMONO_THINITALIC66PT7B_H_
