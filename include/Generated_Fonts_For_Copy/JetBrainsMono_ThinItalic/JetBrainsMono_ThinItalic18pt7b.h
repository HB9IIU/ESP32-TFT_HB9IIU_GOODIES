#ifndef _JETBRAINSMONO_THINITALIC18PT7B_H_
#define _JETBRAINSMONO_THINITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x40, 0x6C, 0x8C, 0x63, 0x29, 0x00, 0x04, 0x60,
  0x88, 0x21, 0x04, 0x43, 0xFE, 0x21, 0x04, 0x40, 0x88, 0x7F, 0x94, 0x40,
  0x88, 0x22, 0x04, 0x40, 0x02, 0x02, 0x01, 0x03, 0xE2, 0x49, 0x24, 0x90,
  0x48, 0x38, 0x07, 0x02, 0xC1, 0x20, 0x94, 0x4B, 0x48, 0xF8, 0x10, 0x08,
  0x04, 0x00, 0x3C, 0x32, 0x44, 0x44, 0x44, 0x48, 0x45, 0x03, 0xA0, 0x04,
  0x00, 0x98, 0x12, 0x41, 0x44, 0x24, 0x44, 0x44, 0x83, 0x80, 0x1E, 0x10,
  0x88, 0x44, 0x02, 0x01, 0x81, 0x43, 0x12, 0x85, 0x43, 0x21, 0x91, 0xCF,
  0x10, 0x55, 0x80, 0x06, 0x10, 0x41, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x0C, 0x08, 0x10, 0x10, 0x18, 0x10, 0x18, 0x10, 0x10, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x81, 0x04, 0x10, 0xC0, 0x04, 0x02, 0x02,
  0x1D, 0x33, 0xE0, 0xC0, 0x50, 0x4C, 0x42, 0x00, 0x04, 0x04, 0x02, 0x01,
  0x0F, 0xF8, 0x40, 0x20, 0x30, 0x32, 0x24, 0x48, 0xFC, 0x7C, 0x00, 0xC0,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x00, 0x1F, 0x10, 0x48, 0x28,
  0x14, 0x0A, 0x45, 0x34, 0x82, 0x41, 0x40, 0xA0, 0x48, 0x47, 0xC0, 0x06,
  0x1C, 0x24, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0xFF,
  0x1F, 0x10, 0x50, 0x20, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x0F, 0xF0, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x80, 0x70, 0x04, 0x02,
  0x01, 0x00, 0xA0, 0x88, 0x47, 0xC0, 0x01, 0x02, 0x04, 0x08, 0x08, 0x11,
  0x21, 0x41, 0x41, 0xFE, 0x02, 0x02, 0x02, 0x3F, 0x90, 0x08, 0x04, 0x02,
  0xC2, 0x99, 0x84, 0x02, 0x01, 0x00, 0xA0, 0x48, 0x47, 0xC0, 0x02, 0x04,
  0x08, 0x10, 0x10, 0x3E, 0x61, 0x41, 0x81, 0x81, 0x81, 0x42, 0x7C, 0x7F,
  0xA0, 0xA0, 0x50, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x04, 0x00, 0x1F, 0x10, 0x48, 0x24, 0x12, 0x10, 0xB0, 0x70, 0x44, 0x41,
  0x40, 0xA0, 0x58, 0x47, 0xC0, 0x3E, 0x41, 0x41, 0x81, 0x81, 0x82, 0x46,
  0x3C, 0x08, 0x08, 0x10, 0x20, 0x40, 0x33, 0x20, 0x00, 0x00, 0x6E, 0x18,
  0xC0, 0x00, 0x00, 0x06, 0x21, 0x10, 0x88, 0x00, 0x03, 0x0C, 0x30, 0xC0,
  0x80, 0x60, 0x18, 0x06, 0x02, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x60, 0x18,
  0x04, 0x03, 0x03, 0x0C, 0x30, 0xC0, 0x80, 0x7C, 0x0C, 0x08, 0x10, 0x40,
  0x8E, 0x20, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x0F, 0x82, 0x08, 0x81, 0x10,
  0x12, 0x3C, 0x88, 0x91, 0x12, 0x42, 0x48, 0x49, 0x09, 0x22, 0x23, 0xC4,
  0x00, 0x80, 0x10, 0x01, 0xE0, 0x02, 0x02, 0x81, 0x41, 0x20, 0x90, 0x48,
  0x44, 0x22, 0x3F, 0x10, 0x90, 0x28, 0x1C, 0x08, 0x3F, 0x10, 0x48, 0x24,
  0x14, 0x12, 0x19, 0xF8, 0x82, 0x41, 0x20, 0x90, 0x50, 0x4F, 0xC0, 0x1F,
  0x10, 0x48, 0x24, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x90, 0x48,
  0x43, 0xC0, 0x3E, 0x10, 0x88, 0x24, 0x14, 0x0A, 0x09, 0x04, 0x82, 0x41,
  0x20, 0x90, 0x90, 0xCF, 0x80, 0x3F, 0x90, 0x08, 0x04, 0x02, 0x01, 0x01,
  0xFC, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0F, 0xF0, 0x3F, 0xC8, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x07, 0xF1, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x00, 0x1F, 0x10, 0x48, 0x24, 0x04, 0x02, 0x01, 0x00, 0x9E, 0x41, 0x20,
  0x90, 0x48, 0x43, 0xC0, 0x20, 0x90, 0x48, 0x24, 0x14, 0x12, 0x09, 0xFC,
  0x82, 0x41, 0x20, 0x90, 0x90, 0x48, 0x20, 0x3F, 0x82, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x0F, 0xE0, 0x07, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x41, 0x20, 0x90, 0x47,
  0xC0, 0x20, 0xC8, 0x22, 0x10, 0x88, 0x42, 0x11, 0x07, 0xC1, 0x10, 0x44,
  0x10, 0x84, 0x22, 0x08, 0x81, 0x00, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0xFF, 0x20, 0x98, 0xD4, 0x6A, 0x55,
  0x2A, 0x65, 0x24, 0x82, 0x41, 0x40, 0xA0, 0x50, 0x28, 0x20, 0x30, 0x98,
  0x4C, 0x26, 0x14, 0x92, 0x49, 0x24, 0x92, 0x45, 0x22, 0x91, 0x90, 0xC8,
  0x20, 0x1F, 0x10, 0x48, 0x24, 0x14, 0x0A, 0x09, 0x04, 0x82, 0x41, 0x20,
  0x90, 0x88, 0x47, 0xC0, 0x3F, 0x08, 0x22, 0x08, 0x82, 0x40, 0x90, 0x67,
  0xE1, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x00, 0x1F, 0x10, 0x48,
  0x24, 0x14, 0x0A, 0x09, 0x04, 0x82, 0x41, 0x20, 0x90, 0x88, 0x47, 0xC0,
  0x20, 0x10, 0x04, 0x3F, 0x10, 0x48, 0x24, 0x14, 0x0A, 0x09, 0xF8, 0x88,
  0x44, 0x22, 0x10, 0x90, 0x48, 0x10, 0x1F, 0x10, 0x48, 0x24, 0x02, 0x01,
  0x80, 0x38, 0x06, 0x01, 0x00, 0xA0, 0x58, 0x47, 0xC0, 0xFF, 0x84, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x00,
  0x20, 0x90, 0x48, 0x24, 0x14, 0x12, 0x09, 0x04, 0x82, 0x41, 0x20, 0x90,
  0x88, 0x47, 0xC0, 0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x88, 0x90,
  0x50, 0x60, 0x60, 0x40, 0x88, 0xCC, 0x66, 0x33, 0x29, 0x95, 0x4A, 0xA5,
  0x54, 0xCA, 0x65, 0x33, 0x11, 0x88, 0xC0, 0x10, 0x62, 0x08, 0x22, 0x04,
  0x80, 0xA0, 0x0C, 0x01, 0x00, 0x50, 0x12, 0x02, 0x20, 0x84, 0x20, 0x8C,
  0x08, 0x80, 0xA0, 0x90, 0x88, 0x42, 0x41, 0x40, 0xA0, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x02, 0x00, 0x3F, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20,
  0x20, 0x10, 0x10, 0x10, 0x10, 0x0F, 0xE0, 0x3E, 0x40, 0x81, 0x02, 0x04,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0xF0, 0x82, 0x10,
  0x84, 0x20, 0x84, 0x21, 0x04, 0x21, 0x08, 0x41, 0x08, 0x3C, 0x10, 0x41,
  0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0xF0, 0x08, 0x28,
  0x51, 0x24, 0x28, 0x60, 0x80, 0xFF, 0x80, 0xCC, 0x1E, 0x90, 0x90, 0x48,
  0x24, 0x12, 0x09, 0x04, 0x84, 0x42, 0x3F, 0x00, 0x20, 0x20, 0x20, 0x3E,
  0x21, 0x41, 0x41, 0x41, 0x41, 0x41, 0x42, 0xC2, 0xBC, 0x1E, 0x10, 0x90,
  0x48, 0x04, 0x02, 0x01, 0x00, 0x82, 0x42, 0x3E, 0x00, 0x00, 0x80, 0x40,
  0x23, 0xD2, 0x12, 0x09, 0x04, 0x82, 0x41, 0x20, 0x90, 0x88, 0x47, 0xE0,
  0x1E, 0x21, 0x41, 0x41, 0x7F, 0x40, 0x40, 0x40, 0x42, 0x7C, 0x03, 0xE0,
  0x80, 0x10, 0x02, 0x03, 0xFC, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x07, 0x80, 0x3D, 0x42, 0x82, 0x82,
  0x82, 0x82, 0x82, 0x84, 0xFC, 0x04, 0x04, 0x04, 0xF8, 0x20, 0x20, 0x20,
  0x3E, 0x61, 0x41, 0x41, 0x41, 0x41, 0x41, 0x42, 0x82, 0x82, 0x06, 0x06,
  0x00, 0x00, 0x3C, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF,
  0x00, 0x80, 0xC0, 0x00, 0x01, 0xF0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0xF8, 0x00, 0x20, 0x10, 0x08, 0x04,
  0x12, 0x12, 0x11, 0x10, 0xF0, 0x48, 0x22, 0x11, 0x10, 0x48, 0x30, 0xF0,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xE0, 0x7B,
  0xA6, 0x52, 0x29, 0x18, 0x8C, 0x4A, 0x25, 0x22, 0x91, 0x48, 0x80, 0x3E,
  0x61, 0x41, 0x41, 0x41, 0x41, 0x41, 0x42, 0x82, 0x82, 0x1E, 0x21, 0x41,
  0x41, 0x41, 0x41, 0x41, 0x42, 0x42, 0x7C, 0x3E, 0x21, 0x41, 0x41, 0x41,
  0x41, 0x41, 0x42, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x1E, 0x90, 0x90, 0x48,
  0x24, 0x12, 0x09, 0x04, 0x84, 0x42, 0x3F, 0x00, 0x80, 0x40, 0x20, 0x2F,
  0x18, 0x88, 0x28, 0x14, 0x12, 0x01, 0x00, 0x80, 0x40, 0x60, 0x00, 0x1F,
  0x21, 0x40, 0x40, 0x38, 0x06, 0x01, 0x01, 0x82, 0x7E, 0x10, 0x10, 0x10,
  0xFF, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x3C, 0x20, 0xA0,
  0x90, 0x48, 0x24, 0x12, 0x09, 0x04, 0x84, 0x42, 0x3E, 0x00, 0x81, 0x81,
  0x42, 0x44, 0x44, 0x48, 0x48, 0x50, 0x30, 0x20, 0x88, 0xCC, 0xA6, 0x55,
  0x2A, 0xA5, 0x53, 0x29, 0x98, 0x8C, 0x46, 0x00, 0x60, 0x90, 0x84, 0x82,
  0x80, 0x80, 0xC0, 0x50, 0x48, 0x42, 0x41, 0x80, 0x41, 0x41, 0x41, 0x41,
  0x41, 0x41, 0x42, 0x42, 0x7E, 0x02, 0x02, 0x04, 0x7C, 0x3F, 0x01, 0x02,
  0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0xFE, 0x03, 0x82, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0xF0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x1C, 0x00, 0x24, 0x92, 0x52, 0x49, 0x25, 0x24, 0x80, 0x38, 0x04,
  0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x07, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0xE0, 0x70, 0xA4, 0x71, 0xC0,
};

const GFXglyph JetBrainsMono_ThinItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 5, 5, 11, 4, -13 },
  { 10, 11, 13, 11, 0, -13 },
  { 28, 9, 19, 11, 1, -16 },
  { 50, 12, 13, 11, 0, -13 },
  { 70, 9, 13, 11, 1, -13 },
  { 85, 2, 5, 11, 5, -13 },
  { 87, 7, 17, 11, 3, -15 },
  { 102, 7, 17, 11, 1, -15 },
  { 117, 9, 9, 11, 1, -11 },
  { 128, 9, 8, 11, 1, -10 },
  { 137, 4, 6, 11, 2, -3 },
  { 140, 6, 1, 11, 3, -6 },
  { 141, 3, 2, 11, 3, -2 },
  { 142, 10, 17, 11, 1, -15 },
  { 164, 9, 13, 11, 1, -13 },
  { 179, 8, 13, 11, 1, -13 },
  { 192, 9, 13, 11, 1, -13 },
  { 207, 9, 13, 11, 1, -13 },
  { 222, 8, 13, 11, 1, -13 },
  { 235, 9, 13, 11, 1, -13 },
  { 250, 8, 13, 11, 1, -13 },
  { 263, 9, 13, 11, 2, -13 },
  { 278, 9, 13, 11, 1, -13 },
  { 293, 8, 13, 11, 2, -13 },
  { 306, 4, 10, 11, 3, -10 },
  { 311, 5, 13, 11, 2, -10 },
  { 320, 8, 9, 11, 2, -10 },
  { 329, 9, 4, 11, 1, -8 },
  { 334, 8, 9, 11, 1, -10 },
  { 343, 7, 13, 11, 3, -13 },
  { 355, 11, 16, 11, 0, -13 },
  { 377, 9, 13, 11, 0, -13 },
  { 392, 9, 13, 11, 1, -13 },
  { 407, 9, 13, 11, 1, -13 },
  { 422, 9, 13, 11, 1, -13 },
  { 437, 9, 13, 11, 1, -13 },
  { 452, 10, 13, 11, 1, -13 },
  { 469, 9, 13, 11, 1, -13 },
  { 484, 9, 13, 11, 1, -13 },
  { 499, 9, 13, 11, 1, -13 },
  { 514, 9, 13, 11, 1, -13 },
  { 529, 10, 13, 11, 1, -13 },
  { 546, 8, 13, 11, 1, -13 },
  { 559, 9, 13, 11, 1, -13 },
  { 574, 9, 13, 11, 1, -13 },
  { 589, 9, 13, 11, 1, -13 },
  { 604, 10, 13, 11, 1, -13 },
  { 621, 9, 16, 11, 1, -13 },
  { 639, 9, 13, 11, 1, -13 },
  { 654, 9, 13, 11, 1, -13 },
  { 669, 9, 13, 11, 2, -13 },
  { 684, 9, 13, 11, 1, -13 },
  { 699, 8, 13, 11, 3, -13 },
  { 712, 9, 13, 11, 2, -13 },
  { 727, 11, 13, 11, 0, -13 },
  { 745, 9, 13, 11, 2, -13 },
  { 760, 9, 13, 11, 1, -13 },
  { 775, 7, 17, 11, 3, -15 },
  { 790, 5, 17, 11, 3, -15 },
  { 801, 6, 17, 11, 2, -15 },
  { 814, 7, 7, 11, 2, -13 },
  { 821, 9, 1, 11, 0, 0 },
  { 823, 3, 2, 11, 5, -14 },
  { 824, 9, 10, 11, 1, -10 },
  { 836, 8, 13, 11, 1, -13 },
  { 849, 9, 10, 11, 1, -10 },
  { 861, 9, 13, 11, 1, -13 },
  { 876, 8, 10, 11, 1, -10 },
  { 886, 11, 16, 11, 0, -13 },
  { 908, 8, 13, 11, 2, -10 },
  { 921, 8, 13, 11, 1, -13 },
  { 934, 8, 14, 11, 1, -14 },
  { 948, 9, 17, 11, 0, -14 },
  { 968, 9, 13, 11, 1, -13 },
  { 983, 7, 13, 11, 2, -13 },
  { 995, 9, 10, 11, 1, -10 },
  { 1007, 8, 10, 11, 1, -10 },
  { 1017, 8, 10, 11, 1, -10 },
  { 1027, 8, 13, 11, 1, -10 },
  { 1040, 9, 13, 11, 1, -10 },
  { 1055, 9, 10, 11, 1, -10 },
  { 1067, 8, 10, 11, 1, -10 },
  { 1077, 8, 13, 11, 2, -13 },
  { 1090, 9, 10, 11, 1, -10 },
  { 1102, 8, 10, 11, 2, -10 },
  { 1112, 9, 10, 11, 2, -10 },
  { 1124, 9, 10, 11, 1, -10 },
  { 1136, 8, 13, 11, 1, -10 },
  { 1149, 8, 10, 11, 1, -10 },
  { 1159, 9, 17, 11, 2, -15 },
  { 1179, 3, 17, 11, 4, -15 },
  { 1186, 8, 17, 11, 1, -15 },
  { 1203, 9, 3, 11, 1, -8 },
};

const GFXfont JetBrainsMono_ThinItalic18pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic18pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _JETBRAINSMONO_THINITALIC18PT7B_H_
