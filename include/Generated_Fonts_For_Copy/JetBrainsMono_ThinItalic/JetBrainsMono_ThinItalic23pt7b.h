#ifndef _JETBRAINSMONO_THINITALIC23PT7B_H_
#define _JETBRAINSMONO_THINITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x33, 0x32, 0x22, 0x22, 0x44, 0x00, 0x0C, 0xC0, 0xC7, 0x8B,
  0x14, 0x28, 0x51, 0xA2, 0x00, 0x02, 0x10, 0x30, 0x81, 0x0C, 0x08, 0x40,
  0xC2, 0x3F, 0xFC, 0x21, 0x03, 0x08, 0x10, 0x80, 0x84, 0x08, 0x21, 0xFF,
  0xC2, 0x10, 0x20, 0x81, 0x08, 0x08, 0x40, 0x86, 0x00, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x7C, 0x09, 0x61, 0x13, 0x11, 0x13, 0x22, 0x32, 0x01, 0x20,
  0x1E, 0x00, 0x70, 0x02, 0xC0, 0x24, 0x04, 0x60, 0x46, 0x44, 0x44, 0x44,
  0x64, 0x83, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07, 0x01, 0x09, 0x82,
  0x10, 0x84, 0x10, 0x88, 0x10, 0x90, 0x11, 0x20, 0x11, 0x60, 0x0E, 0x40,
  0x00, 0x80, 0x01, 0x30, 0x02, 0x4C, 0x04, 0x84, 0x08, 0x84, 0x18, 0x84,
  0x10, 0x88, 0x20, 0x88, 0xC0, 0xF0, 0x07, 0x80, 0x84, 0x10, 0x61, 0x06,
  0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x64, 0x14, 0x42, 0x42, 0x68, 0x34,
  0x81, 0x88, 0x18, 0x81, 0x8C, 0x64, 0x7C, 0x60, 0x5F, 0xE8, 0x01, 0x83,
  0x03, 0x03, 0x01, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x02, 0x03, 0x03, 0x07, 0x04, 0x00,
  0x03, 0x00, 0x20, 0x02, 0x04, 0x20, 0xF2, 0x71, 0xFC, 0x06, 0x00, 0xB0,
  0x19, 0x03, 0x18, 0x60, 0x82, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x39, 0x98, 0xC4, 0x42,
  0x00, 0xFF, 0x7F, 0x60, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x00, 0x0F, 0x83, 0x18, 0x81, 0x30, 0x34, 0x06, 0x80,
  0x90, 0x12, 0x22, 0xCC, 0x58, 0x8A, 0x03, 0x40, 0x68, 0x09, 0x01, 0x20,
  0x66, 0x18, 0x7E, 0x00, 0x01, 0x81, 0xE0, 0xD0, 0x44, 0x21, 0x00, 0x40,
  0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10,
  0xFF, 0xC0, 0x07, 0xC1, 0x86, 0x10, 0x32, 0x01, 0x20, 0x10, 0x02, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x09, 0x01, 0x20,
  0x46, 0x18, 0x7C, 0x00, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x00,
  0x80, 0x41, 0x20, 0xD8, 0x24, 0x0A, 0x02, 0xFF, 0x80, 0x20, 0x18, 0x04,
  0x01, 0x00, 0x3F, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x13, 0xC2,
  0x8C, 0x60, 0x88, 0x18, 0x03, 0x00, 0x40, 0x09, 0x01, 0x20, 0x66, 0x18,
  0x7E, 0x00, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00,
  0xFC, 0x30, 0xC4, 0x0D, 0x00, 0xA0, 0x14, 0x06, 0x80, 0x90, 0x33, 0x0C,
  0x3F, 0x00, 0x7F, 0xF8, 0x0F, 0x01, 0x40, 0x48, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x40, 0x00, 0x07, 0xC0, 0x86, 0x10, 0x31, 0x03, 0x30, 0x21, 0x02, 0x10,
  0x40, 0xD8, 0x07, 0x01, 0x98, 0x20, 0x44, 0x04, 0x40, 0x44, 0x04, 0x40,
  0x46, 0x08, 0x3F, 0x00, 0x1F, 0x08, 0x64, 0x0F, 0x01, 0x80, 0x60, 0x18,
  0x0A, 0x02, 0xC3, 0x1F, 0x40, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x80,
  0x60, 0x00, 0x19, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xE6, 0x00, 0x0C,
  0x38, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0xC1, 0x86, 0x0C, 0x10,
  0x40, 0x80, 0x00, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xEF, 0xF8, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x70, 0x38, 0x1C, 0x0E, 0x03, 0x00, 0x00, 0x7C, 0x01, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x04, 0x3C, 0x10, 0x08, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x07, 0xC0, 0x41, 0x84, 0x04, 0x40, 0x22, 0x01, 0x30,
  0x09, 0x0F, 0x48, 0xC6, 0x44, 0x12, 0x20, 0xB1, 0x0D, 0x18, 0x48, 0x82,
  0x46, 0x12, 0x13, 0x90, 0x64, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0xE0, 0x00, 0x01, 0x00, 0xC0, 0x28, 0x1A, 0x04, 0x81, 0x20, 0x88, 0x22,
  0x10, 0x84, 0x23, 0x08, 0xFF, 0x20, 0x50, 0x14, 0x06, 0x01, 0x80, 0x40,
  0x3F, 0x04, 0x18, 0x81, 0x10, 0x22, 0x04, 0x80, 0x90, 0x32, 0x0C, 0x7F,
  0x08, 0x31, 0x03, 0x60, 0x68, 0x0D, 0x01, 0x20, 0x24, 0x18, 0xFC, 0x00,
  0x0F, 0x83, 0x18, 0x81, 0x90, 0x16, 0x06, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x08, 0x09, 0x01, 0x20, 0x22, 0x08, 0x7E, 0x00,
  0x3F, 0x08, 0x62, 0x04, 0x81, 0x20, 0x50, 0x14, 0x05, 0x01, 0x40, 0x50,
  0x34, 0x0B, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x18, 0xFC, 0x00, 0x3F, 0xE4,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x7F, 0x88, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0x80, 0x3F, 0xF2,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x7F, 0xC4,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00,
  0x0F, 0x83, 0x18, 0x81, 0x90, 0x16, 0x06, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0xFB, 0x01, 0x40, 0x68, 0x09, 0x01, 0x20, 0x22, 0x08, 0x7E, 0x00,
  0x20, 0x24, 0x04, 0x81, 0x90, 0x22, 0x04, 0x80, 0x90, 0x12, 0x02, 0x7F,
  0xC8, 0x11, 0x02, 0x60, 0x48, 0x09, 0x01, 0x20, 0x24, 0x0C, 0x81, 0x00,
  0x3F, 0xE0, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0xFF, 0x00,
  0x03, 0xF0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x80, 0x48, 0x0C, 0xC0, 0x84, 0x10,
  0x3E, 0x00, 0x20, 0x32, 0x02, 0x20, 0x42, 0x0C, 0x20, 0x86, 0x10, 0x43,
  0x04, 0x20, 0x7E, 0x04, 0x20, 0x42, 0x0C, 0x30, 0x81, 0x08, 0x10, 0x81,
  0x88, 0x08, 0x80, 0x80, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x80,
  0x18, 0x31, 0x83, 0x28, 0x52, 0x85, 0x28, 0x92, 0x4B, 0x25, 0x22, 0x52,
  0x66, 0x24, 0x62, 0x40, 0x24, 0x06, 0x40, 0x44, 0x04, 0x40, 0x48, 0x04,
  0x80, 0x40, 0x30, 0x26, 0x04, 0xC1, 0x94, 0x22, 0x84, 0x90, 0x92, 0x12,
  0x42, 0x44, 0x48, 0x91, 0x12, 0x42, 0x48, 0x29, 0x05, 0x20, 0xA4, 0x1C,
  0x81, 0x00, 0x0F, 0x82, 0x18, 0x81, 0x10, 0x26, 0x04, 0x80, 0x90, 0x12,
  0x02, 0x40, 0x48, 0x1B, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x46, 0x18,
  0x7E, 0x00, 0x3F, 0x84, 0x18, 0x80, 0x90, 0x12, 0x02, 0x80, 0x50, 0x1A,
  0x02, 0x7F, 0x8F, 0x81, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x00, 0x0F, 0x82, 0x18, 0x81, 0x10, 0x26, 0x04, 0x80, 0x90, 0x12,
  0x02, 0x40, 0x48, 0x1B, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x46, 0x18,
  0x7E, 0x00, 0x80, 0x08, 0x01, 0x00, 0x30, 0x3F, 0x84, 0x18, 0x81, 0x90,
  0x12, 0x02, 0x80, 0x50, 0x12, 0x06, 0x7F, 0x88, 0x81, 0x08, 0x61, 0x08,
  0x21, 0x02, 0x20, 0x44, 0x0C, 0x80, 0x80, 0x07, 0xC0, 0x86, 0x10, 0x31,
  0x01, 0x30, 0x23, 0x00, 0x10, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x64, 0x04, 0x40, 0x46, 0x08, 0x3F, 0x00, 0xFF, 0xE0, 0x80,
  0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x00, 0x20, 0x24, 0x04,
  0x81, 0x90, 0x26, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x13, 0x02,
  0x40, 0x48, 0x09, 0x01, 0x20, 0x42, 0x18, 0x7E, 0x00, 0x80, 0x38, 0x0B,
  0x01, 0x20, 0x44, 0x08, 0x83, 0x10, 0x42, 0x08, 0x42, 0x08, 0x41, 0x90,
  0x12, 0x02, 0xC0, 0x50, 0x0A, 0x01, 0x80, 0x30, 0x00, 0x42, 0x1A, 0x30,
  0xB1, 0x85, 0x0C, 0x28, 0xA2, 0x45, 0x12, 0x28, 0x91, 0x48, 0x92, 0x44,
  0x92, 0x24, 0x91, 0x45, 0x0A, 0x28, 0x51, 0x43, 0x0C, 0x18, 0x60, 0xC3,
  0x00, 0x18, 0x0C, 0x20, 0x20, 0x81, 0x01, 0x08, 0x04, 0x20, 0x19, 0x00,
  0x28, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x48, 0x02, 0x20, 0x18, 0x40,
  0x41, 0x02, 0x06, 0x18, 0x08, 0xC0, 0x30, 0x80, 0x30, 0x09, 0x01, 0x20,
  0x44, 0x10, 0x42, 0x08, 0x81, 0x20, 0x14, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x00, 0x1F, 0xF0, 0x01, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xFF, 0xC0, 0x1F, 0x10, 0x10,
  0x30, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40,
  0x40, 0xC0, 0x80, 0x80, 0x80, 0xF8, 0xF8, 0xC1, 0x04, 0x10, 0x41, 0x82,
  0x08, 0x20, 0xC1, 0x04, 0x10, 0x41, 0x82, 0x08, 0x20, 0xC1, 0x04, 0x10,
  0x1F, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x8F, 0xC7,
  0xC0, 0x04, 0x07, 0x02, 0x82, 0x43, 0x21, 0x19, 0x84, 0x82, 0x81, 0x80,
  0xFF, 0xE0, 0x89, 0x80, 0x0E, 0x4C, 0x76, 0x0D, 0x03, 0x40, 0xD0, 0x2C,
  0x0A, 0x02, 0x80, 0xA0, 0x28, 0x1B, 0x0E, 0x7D, 0x00, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x2F, 0x14, 0x66, 0x0D, 0x01, 0x40, 0x50, 0x34, 0x0B, 0x02,
  0x80, 0xA0, 0x28, 0x13, 0x0C, 0xBE, 0x00, 0x0F, 0x0C, 0x62, 0x0D, 0x01,
  0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x28, 0x1B, 0x0C, 0x7E, 0x00,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0xE4, 0x63, 0x98, 0x32, 0x06, 0x40,
  0xC8, 0x13, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x66, 0x1C, 0x7D, 0x00,
  0x0F, 0x0C, 0x62, 0x0D, 0x01, 0x40, 0x50, 0x3F, 0xFA, 0x00, 0x80, 0x20,
  0x08, 0x1B, 0x0C, 0x7E, 0x00, 0x00, 0x3E, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x07, 0xFF, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x0F, 0x80, 0x00, 0x0E, 0x4C, 0x56,
  0x0D, 0x03, 0x40, 0xD0, 0x2C, 0x0A, 0x02, 0x80, 0xB0, 0x64, 0x28, 0xF6,
  0x01, 0x00, 0x40, 0x10, 0x08, 0xFC, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x2F, 0x14, 0x66, 0x0D, 0x01, 0x40, 0xD0, 0x24, 0x0B, 0x02, 0x80, 0xA0,
  0x28, 0x0A, 0x06, 0x81, 0x00, 0x01, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x07,
  0xC0, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60,
  0x10, 0x04, 0x3F, 0xF0, 0x00, 0x20, 0x07, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x03, 0x0F,
  0xC0, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x02, 0xC0, 0x90, 0x22, 0x08,
  0x43, 0x08, 0xC1, 0xF0, 0x62, 0x08, 0x21, 0x04, 0x20, 0x44, 0x08, 0x80,
  0x80, 0xF8, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0x80, 0x2C, 0xE3, 0x33,
  0x62, 0x34, 0x22, 0x42, 0x24, 0x22, 0x44, 0x24, 0x42, 0x44, 0x28, 0x46,
  0x84, 0x48, 0x44, 0x8C, 0x40, 0x6F, 0x14, 0x66, 0x0D, 0x01, 0x40, 0xD0,
  0x24, 0x0B, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x06, 0x81, 0x00, 0x0F, 0x0C,
  0x62, 0x0D, 0x01, 0x40, 0x50, 0x3C, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x13,
  0x0C, 0x7E, 0x00, 0x37, 0x85, 0x18, 0xC1, 0x90, 0x12, 0x02, 0x40, 0xC8,
  0x13, 0x02, 0x40, 0x48, 0x09, 0x02, 0x30, 0xC5, 0xF1, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x00, 0x0E, 0x4C, 0x76, 0x0D, 0x03, 0x40, 0xD0, 0x2C, 0x0A,
  0x02, 0x80, 0xA0, 0x28, 0x1B, 0x0C, 0x7D, 0x00, 0x40, 0x10, 0x04, 0x03,
  0x00, 0x27, 0x07, 0x18, 0x81, 0x30, 0x24, 0x04, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x00, 0x1F, 0x0C, 0x36, 0x05, 0x00,
  0x40, 0x18, 0x03, 0xF0, 0x06, 0x00, 0x80, 0x28, 0x0A, 0x06, 0x7E, 0x00,
  0x04, 0x00, 0x80, 0x30, 0x3F, 0xF8, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFC, 0x60, 0x50,
  0x14, 0x05, 0x01, 0x40, 0xD0, 0x24, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x11,
  0x0C, 0x7E, 0x00, 0x80, 0x60, 0x28, 0x0A, 0x04, 0x41, 0x10, 0x84, 0x21,
  0x10, 0x44, 0x1A, 0x02, 0x80, 0xC0, 0x30, 0x00, 0x84, 0x38, 0x62, 0x8A,
  0x28, 0xA2, 0x8A, 0x49, 0x24, 0x92, 0x49, 0x28, 0xA2, 0x8A, 0x28, 0xA3,
  0x0C, 0x30, 0xC3, 0x00, 0x20, 0x31, 0x06, 0x10, 0x40, 0x88, 0x09, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0B, 0x01, 0x10, 0x20, 0x84, 0x08, 0xC0, 0x40,
  0x40, 0x50, 0x14, 0x05, 0x03, 0x40, 0xB0, 0x28, 0x0A, 0x02, 0x80, 0xA0,
  0x64, 0x31, 0xF4, 0x01, 0x00, 0x40, 0x10, 0x08, 0xFC, 0x00, 0x1F, 0xE4,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00,
  0x80, 0x20, 0x0F, 0xFC, 0x00, 0xF0, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x78, 0x08, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0x00,
  0x30, 0x11, 0x11, 0x13, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0xC8, 0x88,
  0x1E, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x0F, 0x83, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x0F, 0x01, 0x80, 0x00, 0x78, 0x73, 0x18, 0x46, 0x0E,
};

const GFXglyph JetBrainsMono_ThinItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 7, 7, 14, 5, -17 },
  { 17, 13, 17, 14, 1, -17 },
  { 45, 12, 23, 14, 1, -20 },
  { 80, 16, 17, 14, -1, -17 },
  { 114, 12, 17, 14, 1, -17 },
  { 140, 2, 7, 14, 7, -17 },
  { 142, 9, 22, 14, 4, -19 },
  { 167, 9, 22, 14, 1, -19 },
  { 192, 12, 12, 14, 1, -14 },
  { 210, 10, 11, 14, 2, -13 },
  { 224, 5, 7, 14, 3, -3 },
  { 229, 8, 1, 14, 3, -8 },
  { 230, 4, 3, 14, 4, -3 },
  { 232, 13, 22, 14, 1, -19 },
  { 268, 11, 17, 14, 2, -17 },
  { 292, 10, 17, 14, 1, -17 },
  { 314, 12, 17, 14, 1, -17 },
  { 340, 11, 17, 14, 2, -17 },
  { 364, 10, 17, 14, 2, -17 },
  { 386, 11, 17, 14, 2, -17 },
  { 410, 11, 17, 14, 1, -17 },
  { 434, 11, 17, 14, 3, -17 },
  { 458, 12, 17, 14, 1, -17 },
  { 484, 10, 17, 14, 3, -17 },
  { 506, 5, 13, 14, 4, -13 },
  { 515, 7, 17, 14, 3, -13 },
  { 530, 11, 11, 14, 2, -13 },
  { 546, 10, 7, 14, 2, -11 },
  { 555, 11, 11, 14, 1, -13 },
  { 571, 9, 17, 14, 4, -17 },
  { 591, 13, 21, 14, 1, -17 },
  { 626, 10, 17, 14, 1, -17 },
  { 648, 11, 17, 14, 2, -17 },
  { 672, 11, 17, 14, 2, -17 },
  { 696, 10, 17, 14, 2, -17 },
  { 718, 11, 17, 14, 2, -17 },
  { 742, 12, 17, 14, 2, -17 },
  { 768, 11, 17, 14, 2, -17 },
  { 792, 11, 17, 14, 2, -17 },
  { 816, 11, 17, 14, 2, -17 },
  { 840, 12, 17, 14, 1, -17 },
  { 866, 12, 17, 14, 2, -17 },
  { 892, 9, 17, 14, 2, -17 },
  { 912, 12, 17, 14, 1, -17 },
  { 938, 11, 17, 14, 2, -17 },
  { 962, 11, 17, 14, 2, -17 },
  { 986, 11, 17, 14, 2, -17 },
  { 1010, 11, 21, 14, 2, -17 },
  { 1039, 11, 17, 14, 2, -17 },
  { 1063, 12, 17, 14, 1, -17 },
  { 1089, 11, 17, 14, 3, -17 },
  { 1113, 11, 17, 14, 2, -17 },
  { 1137, 11, 17, 14, 3, -17 },
  { 1161, 13, 17, 14, 2, -17 },
  { 1189, 14, 17, 14, 0, -17 },
  { 1219, 11, 17, 14, 3, -17 },
  { 1243, 12, 17, 14, 1, -17 },
  { 1269, 8, 22, 14, 4, -19 },
  { 1291, 6, 22, 14, 4, -19 },
  { 1308, 9, 22, 14, 2, -19 },
  { 1333, 9, 9, 14, 3, -17 },
  { 1344, 11, 1, 14, 0, 1 },
  { 1346, 3, 3, 14, 7, -18 },
  { 1348, 10, 13, 14, 2, -13 },
  { 1365, 10, 17, 14, 2, -17 },
  { 1387, 10, 13, 14, 2, -13 },
  { 1404, 11, 17, 14, 2, -17 },
  { 1428, 10, 13, 14, 2, -13 },
  { 1445, 15, 21, 14, -1, -17 },
  { 1485, 10, 17, 14, 2, -13 },
  { 1507, 10, 17, 14, 2, -17 },
  { 1529, 10, 18, 14, 1, -18 },
  { 1552, 12, 22, 14, 0, -18 },
  { 1585, 11, 17, 14, 2, -17 },
  { 1609, 9, 17, 14, 3, -17 },
  { 1629, 12, 13, 14, 1, -13 },
  { 1649, 10, 13, 14, 2, -13 },
  { 1666, 10, 13, 14, 2, -13 },
  { 1683, 11, 17, 14, 1, -13 },
  { 1707, 10, 17, 14, 2, -13 },
  { 1729, 11, 13, 14, 2, -13 },
  { 1747, 10, 13, 14, 2, -13 },
  { 1764, 11, 16, 14, 2, -16 },
  { 1786, 10, 13, 14, 2, -13 },
  { 1803, 10, 13, 14, 3, -13 },
  { 1820, 12, 13, 14, 2, -13 },
  { 1840, 12, 13, 14, 1, -13 },
  { 1860, 10, 17, 14, 2, -13 },
  { 1882, 11, 13, 14, 1, -13 },
  { 1900, 12, 22, 14, 2, -19 },
  { 1933, 4, 22, 14, 5, -19 },
  { 1944, 11, 22, 14, 1, -19 },
  { 1975, 10, 4, 14, 2, -10 },
};

const GFXfont JetBrainsMono_ThinItalic23pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic23pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _JETBRAINSMONO_THINITALIC23PT7B_H_
