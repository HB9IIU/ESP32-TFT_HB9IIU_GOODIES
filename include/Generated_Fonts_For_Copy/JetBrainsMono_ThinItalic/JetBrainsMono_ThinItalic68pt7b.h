#ifndef _JETBRAINSMONO_THINITALIC68PT7B_H_
#define _JETBRAINSMONO_THINITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xF7,
  0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E,
  0x78, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00,
  0x78, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0x8C, 0x7E, 0x00, 0x0F, 0x03, 0x07, 0xC0, 0x07, 0x81, 0xC0, 0xF8,
  0x03, 0xC0, 0x70, 0x1E, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x60, 0x0F, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0x3C,
  0x03, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x00,
  0x3E, 0x1C, 0x00, 0x00, 0x0F, 0xC7, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x00, 0x38,
  0x7C, 0x00, 0x00, 0x0C, 0x0F, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x3C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x60, 0x07, 0x07,
  0x00, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x00, 0xF0, 0x70, 0x03, 0x80, 0x3C,
  0x1C, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x30, 0x07, 0x81, 0xE0, 0x0C, 0x01,
  0xE0, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xC0, 0x78, 0x03, 0xE0, 0x70,
  0x3C, 0x00, 0x7E, 0x1C, 0x3E, 0x00, 0x0F, 0xF7, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x1E, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0,
  0x0F, 0x07, 0x00, 0x00, 0x07, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1E, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x1F, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x38, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x07, 0xF7, 0xE0,
  0x00, 0x00, 0x3C, 0x3C, 0x03, 0x80, 0x00, 0x01, 0xE0, 0xE0, 0x0F, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x1E,
  0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0x0F,
  0x01, 0xE0, 0x00, 0xE0, 0xE0, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x01,
  0xC1, 0xC0, 0x07, 0x80, 0x38, 0x1C, 0x00, 0x3C, 0x07, 0x83, 0xC0, 0x03,
  0xC0, 0xF0, 0x3C, 0x00, 0x1E, 0x0E, 0x03, 0x80, 0x00, 0xE1, 0xE0, 0x38,
  0x00, 0x0F, 0x3C, 0x03, 0x80, 0x00, 0x7B, 0x80, 0x38, 0x00, 0x07, 0xF0,
  0x07, 0x80, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x70,
  0x00, 0x0F, 0x78, 0x07, 0x80, 0x01, 0xE3, 0x80, 0x78, 0x00, 0x3E, 0x3C,
  0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x3E, 0x01, 0xF8, 0x1E, 0x03, 0xF8, 0xFE,
  0x00, 0xF0, 0x1F, 0xFF, 0xC0, 0x07, 0x00, 0x7F, 0xF0, 0x00, 0x78, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3C,
  0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x70, 0x70, 0x70,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x03, 0xC0, 0x01, 0xBE, 0x00, 0x78, 0x01, 0xF7, 0xF8, 0x0F, 0x01, 0xFF,
  0xFF, 0xC1, 0xC1, 0xFF, 0xC7, 0xFE, 0x38, 0xFF, 0xC0, 0x1F, 0xF6, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x9F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xC0, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x70, 0x0F, 0x80,
  0x78, 0x78, 0x0F, 0xE0, 0x3C, 0x3C, 0x07, 0xF0, 0x1E, 0x1E, 0x03, 0xF8,
  0x0E, 0x0F, 0x01, 0xFC, 0x0F, 0x07, 0x80, 0x7C, 0x07, 0x83, 0x80, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x17, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xF7, 0x80, 0x00, 0x1F, 0x1C, 0x00, 0x01, 0xF8, 0x70, 0x00,
  0x0F, 0x81, 0xC0, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x02, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x03, 0xC0,
  0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x71, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xC1, 0xFF, 0xC0, 0x00, 0xE3,
  0xFF, 0xF8, 0x00, 0x73, 0xFB, 0xFE, 0x00, 0x7B, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x07, 0xC0, 0x1D, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0x1C, 0xFF, 0xF0,
  0x00, 0x77, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xF8,
  0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xC0, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xFF, 0xFD, 0xC0, 0x07, 0xFF, 0xCE, 0x00, 0x07, 0xFC,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0xF8, 0x0F, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0xE0, 0xE0, 0xF0, 0x00, 0xFF,
  0xE3, 0x83, 0xC0, 0x07, 0xFF, 0xCE, 0x0E, 0x00, 0x3F, 0x07, 0xB8, 0x38,
  0x01, 0xF0, 0x07, 0xE0, 0xE0, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x78, 0x03, 0x80, 0x03, 0xC1, 0xE0,
  0x1E, 0x00, 0x0F, 0x07, 0x00, 0x78, 0x00, 0x3C, 0x1C, 0x01, 0xC0, 0x00,
  0xE0, 0x70, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x1C, 0x00, 0x0E, 0x0F, 0x00,
  0x70, 0x00, 0x38, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0xE0, 0x0F, 0x00, 0x07,
  0x83, 0x80, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x38, 0x03,
  0x80, 0x01, 0xC1, 0xE0, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x38, 0x00, 0x3C,
  0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x70, 0x03, 0xC0, 0x07, 0xC1, 0xC0, 0x0F,
  0x00, 0x3E, 0x07, 0x00, 0x3F, 0x03, 0xB8, 0x3C, 0x00, 0x7F, 0xFE, 0xE0,
  0xF0, 0x00, 0xFF, 0xE3, 0x83, 0xC0, 0x01, 0xFF, 0x0E, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x38, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x78, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x1F, 0xF0, 0x00, 0xE0, 0x00,
  0x3E, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x01, 0xC0, 0x00,
  0x3E, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x38,
  0x00, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xF0, 0x07, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x3E, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3A, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1C, 0x03, 0xFF, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x07, 0x00,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xF8, 0x01, 0xC0,
  0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04,
  0x38, 0x03, 0xFF, 0xF8, 0x38, 0x03, 0xFF, 0xF8, 0x38, 0x03, 0xFF, 0xF8,
  0x78, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3A, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0xE0, 0x1E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF4, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x37, 0x01, 0xFC, 0x00, 0x07, 0x70, 0x1C, 0xC0,
  0x00, 0x67, 0x01, 0xCC, 0x00, 0x0E, 0xE0, 0x1C, 0xE0, 0x00, 0xCE, 0x01,
  0xCE, 0x00, 0x1C, 0xE0, 0x1C, 0xE0, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0x38,
  0xE0, 0x3C, 0x60, 0x07, 0x1E, 0x03, 0x87, 0x00, 0x71, 0xE0, 0x38, 0x70,
  0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x30, 0x1C, 0x1C, 0x03,
  0x83, 0x01, 0xC1, 0xC0, 0x78, 0x38, 0x38, 0x3C, 0x07, 0x83, 0x83, 0x83,
  0xC0, 0x70, 0x38, 0x70, 0x38, 0x07, 0x01, 0x87, 0x03, 0x80, 0x70, 0x18,
  0xE0, 0x38, 0x07, 0x01, 0xCE, 0x03, 0x80, 0xF0, 0x1D, 0xC0, 0x78, 0x0F,
  0x01, 0xDC, 0x07, 0x80, 0xF0, 0x0F, 0x80, 0x70, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x01,
  0xC0, 0x3E, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x1C, 0x03, 0xF0, 0x00,
  0x0F, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x00, 0xE0, 0x1F, 0xC0,
  0x00, 0x38, 0x07, 0x38, 0x00, 0x0E, 0x01, 0xCE, 0x00, 0x03, 0x80, 0x73,
  0x80, 0x01, 0xE0, 0x1C, 0xE0, 0x00, 0x78, 0x07, 0x1C, 0x00, 0x1C, 0x03,
  0xC7, 0x00, 0x07, 0x00, 0xF1, 0xC0, 0x01, 0xC0, 0x38, 0x70, 0x00, 0x70,
  0x0E, 0x0E, 0x00, 0x1C, 0x03, 0x83, 0x80, 0x0F, 0x00, 0xE0, 0xE0, 0x03,
  0xC0, 0x78, 0x38, 0x00, 0xE0, 0x1E, 0x07, 0x00, 0x38, 0x07, 0x01, 0xC0,
  0x0E, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x1C, 0x01, 0xE0, 0x1C, 0x07,
  0x00, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x70, 0x3C, 0x03,
  0x80, 0x1C, 0x0F, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x78, 0x01, 0xC0, 0xE0,
  0x1E, 0x00, 0x38, 0x38, 0x07, 0x00, 0x0E, 0x0E, 0x01, 0xC0, 0x03, 0x83,
  0x80, 0x70, 0x00, 0xE1, 0xE0, 0x1C, 0x00, 0x1C, 0x70, 0x0F, 0x00, 0x07,
  0x1C, 0x03, 0xC0, 0x01, 0xC7, 0x00, 0xE0, 0x00, 0x71, 0xC0, 0x38, 0x00,
  0x1E, 0x70, 0x0E, 0x00, 0x03, 0xBC, 0x03, 0x80, 0x00, 0xEF, 0x00, 0xE0,
  0x00, 0x3B, 0x80, 0x78, 0x00, 0x0F, 0xE0, 0x1C, 0x00, 0x01, 0xF8, 0x07,
  0x00, 0x00, 0x7E, 0x01, 0xC0, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x07, 0xE0,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x0F,
  0x00, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0E, 0x00, 0x3F, 0xF0, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x0E, 0x00,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x07,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x0F, 0x80,
  0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x07, 0x80,
  0x00, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x70,
  0x01, 0xFF, 0x80, 0x0E, 0x00, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x0F, 0x80, 0x38, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFA, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0x80,
  0x01, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x39,
  0xC0, 0x03, 0xE0, 0x03, 0xCE, 0x00, 0x1F, 0x00, 0x1C, 0xF0, 0x01, 0xF0,
  0x00, 0xE7, 0x00, 0x0F, 0x80, 0x0F, 0x38, 0x00, 0x6C, 0x00, 0x79, 0xC0,
  0x07, 0x60, 0x03, 0x8E, 0x00, 0x3B, 0x00, 0x1C, 0x70, 0x01, 0x98, 0x01,
  0xE3, 0x80, 0x1C, 0xC0, 0x0E, 0x1C, 0x00, 0xE6, 0x00, 0x70, 0xE0, 0x07,
  0x30, 0x03, 0x87, 0x00, 0x31, 0x80, 0x3C, 0x38, 0x03, 0x8C, 0x01, 0xC1,
  0xC0, 0x1C, 0x60, 0x0E, 0x0E, 0x00, 0xC3, 0x00, 0xF0, 0x70, 0x0E, 0x18,
  0x07, 0x03, 0x80, 0x70, 0xC0, 0x38, 0x1C, 0x03, 0x06, 0x01, 0xC0, 0xE0,
  0x38, 0x30, 0x1E, 0x07, 0x01, 0xC1, 0x80, 0xE0, 0x38, 0x0C, 0x0C, 0x07,
  0x01, 0xC0, 0xE0, 0x60, 0x38, 0x0E, 0x07, 0x03, 0x03, 0x80, 0x70, 0x38,
  0x18, 0x1C, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x1C, 0x1C, 0x0E, 0x0F, 0x00,
  0xE0, 0xE0, 0x70, 0x70, 0x07, 0x06, 0x03, 0x83, 0x80, 0x38, 0x70, 0x1C,
  0x1C, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x1E, 0x18, 0x07, 0x0E, 0x00, 0xF1,
  0xC0, 0x38, 0x70, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0x38, 0x60, 0x0E, 0x38,
  0x01, 0xC3, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0x71, 0x80,
  0x1C, 0xE0, 0x03, 0x8C, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x38, 0x00,
  0xE7, 0x00, 0x39, 0xC0, 0x07, 0x30, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x0E,
  0xE0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x0E, 0xC0, 0x03, 0xF0, 0x00, 0x76,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x0F, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x07, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0,
  0x03, 0x80, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x0E, 0xF8, 0x00, 0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x1C, 0x01, 0xFF, 0xFE, 0x38, 0x07, 0xE0, 0x1E, 0xF0, 0x1F,
  0x00, 0x1D, 0xE0, 0x78, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x3E, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x1B, 0x80, 0x7C, 0x00, 0xEF, 0x00, 0xFE,
  0x0F, 0x9E, 0x00, 0xFF, 0xFE, 0x3C, 0x00, 0x7F, 0xF0, 0x70, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0x00, 0x03, 0xC3, 0xFF, 0xC0, 0x03,
  0xCF, 0xFF, 0xF0, 0x03, 0x9E, 0x01, 0xF8, 0x03, 0xB8, 0x00, 0x78, 0x03,
  0xF0, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x7E,
  0x00, 0x03, 0xC0, 0x7F, 0x00, 0x07, 0x80, 0x73, 0x80, 0x1F, 0x00, 0x73,
  0xF0, 0xFE, 0x00, 0x71, 0xFF, 0xFC, 0x00, 0xF0, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x38, 0x78, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0xE0,
  0x00, 0xFF, 0xF8, 0x70, 0x01, 0xFF, 0xFE, 0x38, 0x01, 0xF8, 0x07, 0xBC,
  0x01, 0xF0, 0x01, 0xDE, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0xE0, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0xEE, 0x00, 0x7C, 0x00, 0xEF, 0x00, 0x3F, 0x83, 0xE7, 0x80,
  0x0F, 0xFF, 0xE3, 0xC0, 0x01, 0xFF, 0xC1, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x73, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE7, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x70, 0x0F, 0xFF, 0xF1,
  0xC0, 0x7E, 0x01, 0xEF, 0x03, 0xE0, 0x03, 0xBC, 0x1E, 0x00, 0x07, 0xE0,
  0x70, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x3F, 0x03, 0xC0, 0x01, 0xBC, 0x0F, 0xC0, 0x1C,
  0xE0, 0x1F, 0xFF, 0xE3, 0x80, 0x1F, 0xFF, 0x0E, 0x00, 0x3F, 0xF0, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xF0, 0x00,
  0x78, 0x7F, 0xF8, 0x00, 0xF3, 0xFF, 0xFC, 0x01, 0xCF, 0x00, 0xFC, 0x03,
  0xB8, 0x00, 0x78, 0x07, 0x60, 0x00, 0x78, 0x1F, 0x80, 0x00, 0xF0, 0x3E,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x41, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x70, 0x00,
  0x0F, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x39, 0xFF, 0x07, 0xFC, 0x03, 0xBF, 0xF8, 0xFF, 0xC0, 0x3B,
  0x07, 0x98, 0x3E, 0x03, 0xE0, 0x3D, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x0E,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0x0E, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x70, 0x03, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x70,
  0x03, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0xF0, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0xE0, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0xE0, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x03, 0xC1, 0xE0,
  0x07, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x0F, 0x00, 0x38,
  0x1C, 0x00, 0xF0, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0x78, 0x3C, 0x00, 0xE0,
  0x07, 0x83, 0xC0, 0x0E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x07, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x38, 0x01, 0xC0, 0x0F, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x78, 0x01, 0xC0,
  0x0E, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x70, 0x03, 0xC0, 0x0E, 0x07, 0x00,
  0x38, 0x01, 0xE0, 0x70, 0x03, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0x87, 0xFF, 0x80, 0x0F, 0x3F, 0xFF, 0xC0,
  0x1C, 0xF0, 0x0F, 0xC0, 0x3B, 0x80, 0x07, 0x80, 0x76, 0x00, 0x07, 0x81,
  0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0xFF, 0xF0, 0x00, 0x79,
  0xFF, 0xFE, 0x00, 0x39, 0xE0, 0x1F, 0x80, 0x1D, 0xC0, 0x03, 0xC0, 0x0F,
  0xC0, 0x00, 0xF0, 0x0F, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x01, 0xC0, 0x3F, 0x00, 0x01, 0xE0, 0x1F, 0xC0, 0x01, 0xE0, 0x0E, 0x70,
  0x03, 0xE0, 0x07, 0x3F, 0x0F, 0xE0, 0x03, 0x8F, 0xFF, 0xE0, 0x01, 0xC1,
  0xFF, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x1C, 0x01, 0xFF, 0xFE, 0x38, 0x07, 0xE0, 0x1E, 0xF0, 0x1F, 0x00, 0x1D,
  0xE0, 0x78, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x3B, 0x80, 0x7C, 0x00, 0xEF, 0x00, 0xFE, 0x0F, 0x9E,
  0x00, 0xFF, 0xFE, 0x3C, 0x00, 0x7F, 0xF0, 0x70, 0x00, 0x1F, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0x0F, 0xFF, 0x80, 0x1E, 0x7F, 0xFF, 0x80, 0x3D, 0xE0, 0x1F, 0x80, 0x77,
  0x00, 0x0F, 0x80, 0xEC, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x3E, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0xF0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x01, 0xE0,
  0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0x38, 0xF0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x3B,
  0x80, 0x0F, 0x80, 0x0E, 0xE0, 0x03, 0x60, 0x07, 0xB8, 0x01, 0xD8, 0x01,
  0xCE, 0x00, 0x76, 0x00, 0x73, 0xC0, 0x19, 0x80, 0x3C, 0xF0, 0x0E, 0x60,
  0x0E, 0x3C, 0x03, 0x98, 0x03, 0x8F, 0x00, 0xC6, 0x00, 0xE3, 0xC0, 0x71,
  0x80, 0x70, 0xF0, 0x1C, 0x60, 0x1C, 0x3C, 0x06, 0x1C, 0x07, 0x0F, 0x03,
  0x87, 0x03, 0x81, 0xC0, 0xE1, 0xC0, 0xE0, 0x70, 0x30, 0x70, 0x38, 0x1C,
  0x1C, 0x1C, 0x1C, 0x07, 0x07, 0x07, 0x07, 0x01, 0xC1, 0x81, 0xC1, 0xC0,
  0x70, 0xE0, 0x70, 0xE0, 0x1C, 0x38, 0x1C, 0x38, 0x07, 0x1C, 0x07, 0x0E,
  0x01, 0xC7, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x71, 0xC0, 0x1C, 0xE0, 0x1C,
  0x70, 0x07, 0x38, 0x07, 0x38, 0x01, 0xCC, 0x01, 0xCE, 0x00, 0x77, 0x00,
  0x73, 0x80, 0x1D, 0xC0, 0x1D, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x01, 0xF8,
  0x01, 0xDC, 0x00, 0x7E, 0x00, 0x77, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0xDC, 0x07, 0xC0, 0x03, 0xB8, 0x07, 0xE0, 0x1E, 0xF0,
  0x07, 0xFF, 0xF9, 0xE0, 0x07, 0xFF, 0xC3, 0xC0, 0x03, 0xFE, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0x3F, 0xF8, 0x00,
  0x3C, 0xFF, 0xF8, 0x00, 0x71, 0xE0, 0xF0, 0x00, 0xE7, 0x80, 0xF0, 0x01,
  0xCE, 0x00, 0xF0, 0x03, 0x9C, 0x00, 0xF0, 0x07, 0x78, 0x01, 0xE0, 0x1C,
  0xE0, 0x01, 0xE0, 0x79, 0xC0, 0x01, 0xFF, 0xE3, 0x80, 0x01, 0xFF, 0x87,
  0x00, 0x01, 0xFE, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 13, 50, 41, 14, -50 },
  { 83, 20, 21, 41, 14, -50 },
  { 136, 39, 50, 41, 2, -50 },
  { 380, 34, 69, 41, 4, -59 },
  { 674, 46, 50, 41, -2, -50 },
  { 962, 36, 51, 41, 2, -50 },
  { 1192, 8, 21, 41, 20, -50 },
  { 1213, 27, 66, 41, 12, -57 },
  { 1436, 27, 66, 41, 3, -57 },
  { 1659, 35, 34, 41, 4, -41 },
  { 1808, 32, 31, 41, 5, -38 },
  { 1932, 15, 21, 41, 8, -10 },
  { 1972, 22, 3, 41, 10, -24 },
  { 1981, 10, 10, 41, 13, -9 },
  { 1994, 38, 63, 41, 2, -56 },
  { 2294, 33, 51, 41, 5, -50 },
  { 2505, 30, 50, 41, 4, -50 },
  { 2693, 34, 50, 41, 4, -50 },
  { 2906, 32, 51, 41, 5, -50 },
  { 3110, 29, 50, 41, 6, -50 },
  { 3292, 33, 51, 41, 5, -50 },
  { 3503, 31, 51, 41, 4, -50 },
  { 3701, 33, 50, 41, 8, -50 },
  { 3908, 34, 51, 41, 4, -50 },
  { 4125, 30, 50, 41, 8, -50 },
  { 4313, 15, 39, 41, 13, -38 },
  { 4387, 20, 49, 41, 8, -38 },
  { 4510, 32, 34, 41, 6, -39 },
  { 4646, 30, 19, 41, 6, -32 },
  { 4718, 32, 34, 41, 4, -39 },
  { 4854, 27, 50, 41, 11, -50 },
  { 5023, 38, 62, 41, 2, -50 },
  { 5318, 31, 50, 41, 2, -50 },
  { 5512, 34, 50, 41, 4, -50 },
  { 5725, 32, 51, 41, 6, -50 },
  { 5929, 33, 50, 41, 4, -50 },
  { 6136, 35, 50, 41, 5, -50 },
  { 6355, 36, 50, 41, 5, -50 },
  { 6580, 32, 51, 41, 6, -50 },
  { 6784, 34, 50, 41, 4, -50 },
  { 6997, 33, 50, 41, 5, -50 },
  { 7204, 35, 51, 41, 3, -50 },
  { 7428, 37, 50, 41, 4, -50 },
  { 7660, 28, 50, 41, 5, -50 },
  { 7835, 36, 50, 41, 3, -50 },
  { 8060, 34, 50, 41, 4, -50 },
  { 8273, 31, 51, 41, 6, -50 },
  { 8471, 36, 50, 41, 4, -50 },
  { 8696, 31, 62, 41, 6, -50 },
  { 8937, 35, 50, 41, 4, -50 },
  { 9156, 34, 51, 41, 4, -50 },
  { 9373, 34, 50, 41, 8, -50 },
  { 9586, 33, 51, 41, 5, -50 },
  { 9797, 31, 50, 41, 10, -50 },
  { 9991, 37, 50, 41, 6, -50 },
  { 10223, 40, 50, 41, 1, -50 },
  { 10473, 34, 50, 41, 8, -50 },
  { 10686, 36, 50, 41, 3, -50 },
  { 10911, 25, 63, 41, 11, -56 },
  { 11108, 18, 63, 41, 12, -56 },
  { 11250, 26, 63, 41, 6, -56 },
  { 11455, 28, 27, 41, 7, -50 },
  { 11550, 33, 3, 41, 0, 2 },
  { 11563, 10, 9, 41, 19, -53 },
  { 11575, 31, 39, 41, 5, -38 },
  { 11727, 32, 51, 41, 4, -50 },
  { 11931, 30, 39, 41, 6, -38 },
  { 12078, 33, 51, 41, 5, -50 },
  { 12289, 29, 39, 41, 6, -38 },
  { 12431, 42, 62, 41, -2, -50 },
  { 12757, 30, 50, 41, 6, -38 },
  { 12945, 31, 50, 41, 4, -50 },
  { 13139, 31, 52, 41, 3, -52 },
  { 13341, 34, 64, 41, 1, -52 },
  { 13613, 34, 50, 41, 5, -50 },
  { 13826, 26, 50, 41, 8, -50 },
  { 13989, 36, 38, 41, 2, -38 },
  { 14160, 31, 38, 41, 4, -38 },
  { 14308, 29, 39, 41, 6, -38 },
  { 14450, 33, 50, 41, 3, -38 },
  { 14657, 31, 50, 41, 5, -38 },
  { 14851, 31, 38, 41, 6, -38 },
  { 14999, 31, 39, 41, 5, -38 },
  { 15151, 30, 48, 41, 7, -48 },
  { 15331, 31, 38, 41, 5, -37 },
  { 15479, 31, 37, 41, 8, -37 },
  { 15623, 34, 37, 41, 6, -37 },
  { 15781, 36, 37, 41, 2, -37 },
  { 15948, 31, 49, 41, 5, -37 },
  { 16138, 32, 37, 41, 4, -37 },
  { 16286, 33, 63, 41, 7, -56 },
  { 16546, 13, 63, 41, 15, -56 },
  { 16649, 32, 63, 41, 3, -56 },
  { 16901, 31, 12, 41, 6, -30 },
};

const GFXfont JetBrainsMono_ThinItalic68pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic68pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _JETBRAINSMONO_THINITALIC68PT7B_H_
