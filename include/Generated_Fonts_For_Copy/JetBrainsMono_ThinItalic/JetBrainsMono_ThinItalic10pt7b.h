#ifndef _JETBRAINSMONO_THINITALIC10PT7B_H_
#define _JETBRAINSMONO_THINITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x88, 0xB6, 0x80, 0x34, 0xA7, 0xD2, 0xF9, 0x49, 0x00, 0x21,
  0x9B, 0x5E, 0x11, 0x5A, 0xE2, 0x00, 0x77, 0x31, 0xC0, 0xC3, 0x4A, 0xA6,
  0x00, 0x39, 0x02, 0x19, 0x9A, 0x4E, 0x80, 0xE0, 0x34, 0x88, 0x88, 0x88,
  0x40, 0x64, 0x92, 0x4A, 0x80, 0x25, 0x5C, 0xC9, 0x00, 0x22, 0xF4, 0x40,
  0x5A, 0xF0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x80, 0x7C, 0x63,
  0x69, 0x4B, 0x80, 0x6A, 0x22, 0x22, 0xF0, 0x7C, 0x44, 0x22, 0x23, 0xC0,
  0x79, 0x08, 0x21, 0x4B, 0x80, 0x12, 0x49, 0x97, 0x10, 0x7C, 0x3D, 0x21,
  0x4B, 0x80, 0x34, 0x69, 0x99, 0xE0, 0xFC, 0x84, 0x42, 0x21, 0x00, 0x7C,
  0x54, 0xC9, 0x4B, 0x80, 0x7C, 0x63, 0xA2, 0x11, 0x00, 0x50, 0x20, 0x24,
  0x04, 0xA4, 0x1B, 0x20, 0x83, 0x00, 0xF0, 0xF0, 0x86, 0x12, 0xC0, 0xE1,
  0x24, 0x80, 0x80, 0x3D, 0x15, 0xE9, 0xA6, 0xA9, 0x20, 0x60, 0x11, 0x4A,
  0x97, 0xA6, 0x20, 0xF4, 0x65, 0xE9, 0x4B, 0x80, 0x7C, 0x61, 0x08, 0x4B,
  0x80, 0xF9, 0x99, 0x99, 0xE0, 0x7C, 0x21, 0xE8, 0x43, 0xC0, 0xFC, 0x21,
  0xE8, 0x42, 0x00, 0x7C, 0x61, 0x69, 0x4B, 0x80, 0x8C, 0x65, 0xE9, 0x4A,
  0x40, 0x79, 0x08, 0x44, 0x23, 0x80, 0x1C, 0x20, 0x82, 0x0A, 0x27, 0x00,
  0x8C, 0xA9, 0xCA, 0x4A, 0x40, 0x48, 0x88, 0x88, 0xF0, 0x25, 0xB7, 0x56,
  0x4A, 0x28, 0x80, 0x4A, 0x75, 0x6B, 0x5A, 0x40, 0x79, 0x99, 0x99, 0xE0,
  0xFC, 0x63, 0xC8, 0x42, 0x00, 0x79, 0x99, 0x99, 0xE2, 0x20, 0xFC, 0x63,
  0xEA, 0x4A, 0x40, 0x7C, 0x60, 0xC1, 0x4B, 0x80, 0xF9, 0x08, 0x44, 0x21,
  0x00, 0x8C, 0x65, 0x29, 0x4B, 0x80, 0x8C, 0xA4, 0xA6, 0x31, 0x00, 0xAD,
  0x7B, 0xDB, 0x4A, 0x80, 0x44, 0xA1, 0x04, 0x31, 0x28, 0x80, 0x8A, 0x94,
  0x44, 0x21, 0x00, 0x3C, 0x21, 0x08, 0x21, 0x0F, 0x80, 0x6A, 0x49, 0x24,
  0xC0, 0xAA, 0x55, 0x40, 0x71, 0x22, 0x22, 0x22, 0xE0, 0x25, 0x59, 0xF8,
  0xC0, 0x79, 0x99, 0x9F, 0x8E, 0x99, 0x99, 0xE0, 0x69, 0x88, 0x9E, 0x0B,
  0x65, 0x29, 0x4B, 0xC0, 0x69, 0x9E, 0x9E, 0x1C, 0x47, 0xC8, 0x20, 0x82,
  0x08, 0xC0, 0x79, 0x99, 0x97, 0x1E, 0x8E, 0x99, 0x99, 0x90, 0x20, 0x62,
  0x22, 0x2F, 0x08, 0x0E, 0x10, 0x88, 0x42, 0x17, 0x00, 0x84, 0x65, 0x4E,
  0x52, 0x40, 0xE4, 0x44, 0x44, 0x70, 0x69, 0x55, 0x6A, 0xAA, 0xA0, 0xE9,
  0x99, 0x99, 0x69, 0x99, 0x9E, 0x72, 0x52, 0x94, 0xBA, 0x10, 0x79, 0x99,
  0x9F, 0x12, 0xAD, 0x98, 0x88, 0x69, 0x87, 0x1F, 0x2F, 0x44, 0x44, 0x70,
  0x99, 0x99, 0x9E, 0x8C, 0xA5, 0x46, 0x20, 0xAD, 0x7B, 0xEB, 0x50, 0x44,
  0xA3, 0x08, 0x53, 0x20, 0x99, 0x99, 0x97, 0x1E, 0xF1, 0x24, 0x8F, 0x19,
  0x08, 0x4C, 0x10, 0x88, 0x60, 0x55, 0x6A, 0x80, 0x30, 0x84, 0x41, 0x90,
  0x84, 0xC0, 0xF0,
};

const GFXglyph JetBrainsMono_ThinItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 5, 10, 6, 1, -9 },
  { 18, 7, 7, 6, 0, -7 },
  { 25, 6, 7, 6, 0, -7 },
  { 31, 1, 3, 6, 3, -7 },
  { 32, 4, 9, 6, 2, -8 },
  { 37, 3, 9, 6, 1, -8 },
  { 41, 5, 5, 6, 1, -6 },
  { 45, 4, 5, 6, 1, -6 },
  { 48, 2, 4, 6, 1, -2 },
  { 49, 4, 1, 6, 1, -4 },
  { 50, 1, 1, 6, 2, -1 },
  { 51, 6, 9, 6, 0, -8 },
  { 58, 5, 7, 6, 1, -7 },
  { 63, 4, 7, 6, 1, -7 },
  { 67, 5, 7, 6, 1, -7 },
  { 72, 5, 7, 6, 1, -7 },
  { 77, 4, 7, 6, 1, -7 },
  { 81, 5, 7, 6, 1, -7 },
  { 86, 4, 7, 6, 1, -7 },
  { 90, 5, 7, 6, 1, -7 },
  { 95, 5, 7, 6, 1, -7 },
  { 100, 5, 7, 6, 1, -7 },
  { 105, 2, 6, 6, 2, -6 },
  { 107, 3, 8, 6, 1, -6 },
  { 110, 5, 5, 6, 1, -6 },
  { 114, 4, 3, 6, 1, -5 },
  { 116, 4, 5, 6, 1, -6 },
  { 119, 4, 7, 6, 2, -7 },
  { 123, 6, 9, 6, 0, -7 },
  { 130, 5, 7, 6, 0, -7 },
  { 135, 5, 7, 6, 1, -7 },
  { 140, 5, 7, 6, 1, -7 },
  { 145, 4, 7, 6, 1, -7 },
  { 149, 5, 7, 6, 1, -7 },
  { 154, 5, 7, 6, 1, -7 },
  { 159, 5, 7, 6, 1, -7 },
  { 164, 5, 7, 6, 1, -7 },
  { 169, 5, 7, 6, 1, -7 },
  { 174, 6, 7, 6, 0, -7 },
  { 180, 5, 7, 6, 1, -7 },
  { 185, 4, 7, 6, 1, -7 },
  { 189, 6, 7, 6, 0, -7 },
  { 195, 5, 7, 6, 1, -7 },
  { 200, 4, 7, 6, 1, -7 },
  { 204, 5, 7, 6, 1, -7 },
  { 209, 4, 9, 6, 1, -7 },
  { 214, 5, 7, 6, 1, -7 },
  { 219, 5, 7, 6, 1, -7 },
  { 224, 5, 7, 6, 1, -7 },
  { 229, 5, 7, 6, 1, -7 },
  { 234, 5, 7, 6, 1, -7 },
  { 239, 5, 7, 6, 1, -7 },
  { 244, 6, 7, 6, 0, -7 },
  { 250, 5, 7, 6, 1, -7 },
  { 255, 6, 7, 6, 0, -7 },
  { 261, 3, 9, 6, 2, -8 },
  { 265, 2, 9, 6, 2, -8 },
  { 268, 4, 9, 6, 1, -8 },
  { 273, 4, 4, 6, 1, -7 },
  { 275, 5, 1, 6, 0, 0 },
  { 276, 1, 2, 6, 3, -8 },
  { 277, 4, 6, 6, 1, -6 },
  { 280, 4, 7, 6, 1, -7 },
  { 284, 4, 6, 6, 1, -6 },
  { 287, 5, 7, 6, 1, -7 },
  { 292, 4, 6, 6, 1, -6 },
  { 295, 6, 9, 6, 0, -7 },
  { 302, 4, 8, 6, 1, -6 },
  { 306, 4, 7, 6, 1, -7 },
  { 310, 4, 8, 6, 1, -8 },
  { 314, 5, 10, 6, 0, -8 },
  { 321, 5, 7, 6, 1, -7 },
  { 326, 4, 7, 6, 1, -7 },
  { 330, 6, 6, 6, 0, -6 },
  { 335, 4, 6, 6, 1, -6 },
  { 338, 4, 6, 6, 1, -6 },
  { 341, 5, 8, 6, 0, -6 },
  { 346, 4, 8, 6, 1, -6 },
  { 350, 4, 6, 6, 1, -6 },
  { 353, 4, 6, 6, 1, -6 },
  { 356, 4, 7, 6, 1, -7 },
  { 360, 4, 6, 6, 1, -6 },
  { 363, 5, 6, 6, 1, -6 },
  { 367, 5, 6, 6, 1, -6 },
  { 371, 6, 6, 6, 0, -6 },
  { 376, 4, 8, 6, 1, -6 },
  { 380, 4, 6, 6, 1, -6 },
  { 383, 5, 9, 6, 1, -8 },
  { 389, 2, 9, 6, 2, -8 },
  { 392, 5, 9, 6, 0, -8 },
  { 398, 4, 1, 6, 1, -4 },
};

const GFXfont JetBrainsMono_ThinItalic10pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic10pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _JETBRAINSMONO_THINITALIC10PT7B_H_
