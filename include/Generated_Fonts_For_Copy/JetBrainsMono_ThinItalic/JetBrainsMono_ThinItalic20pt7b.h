#ifndef _JETBRAINSMONO_THINITALIC20PT7B_H_
#define _JETBRAINSMONO_THINITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x33, 0x22, 0x22, 0x24, 0x40, 0x0E, 0xC0, 0x45, 0x1C, 0xF3,
  0x8A, 0x20, 0x02, 0x10, 0x22, 0x04, 0x20, 0x42, 0x04, 0x43, 0xBF, 0x08,
  0xC0, 0x88, 0x10, 0x81, 0x12, 0xFF, 0xC2, 0x10, 0x22, 0x04, 0x20, 0x42,
  0x00, 0x02, 0x00, 0x80, 0x70, 0x6B, 0x22, 0x48, 0x92, 0x40, 0x90, 0x14,
  0x03, 0x80, 0x50, 0x12, 0x08, 0xA2, 0x28, 0x89, 0x24, 0x3E, 0x02, 0x01,
  0x00, 0x40, 0x1C, 0x09, 0x10, 0x88, 0x88, 0x44, 0x84, 0x24, 0x22, 0x40,
  0xE4, 0x00, 0x40, 0x04, 0xC0, 0x49, 0x04, 0x88, 0x24, 0x42, 0x22, 0x21,
  0x12, 0x0F, 0x00, 0x07, 0x06, 0x61, 0x08, 0x82, 0x20, 0x04, 0x01, 0x01,
  0xA0, 0x4C, 0x61, 0x28, 0x32, 0x0C, 0x83, 0x21, 0x47, 0x88, 0x5F, 0xA0,
  0x03, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xC0, 0x60, 0x38, 0x08, 0x10, 0x0C, 0x06, 0x02,
  0x03, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x0C,
  0x08, 0x30, 0xE0, 0x80, 0x06, 0x00, 0x80, 0x10, 0x62, 0x73, 0xF8, 0x08,
  0x07, 0x80, 0x90, 0x23, 0x08, 0x20, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8,
  0x80, 0x40, 0x20, 0x10, 0x00, 0x19, 0x88, 0x44, 0x60, 0xFC, 0x5F, 0x00,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x00, 0x07, 0x06, 0x23, 0x04, 0x81, 0x20, 0x58, 0x14, 0x0D,
  0x32, 0x44, 0x90, 0x24, 0x09, 0x02, 0x41, 0x10, 0xC3, 0xE0, 0x03, 0x03,
  0x06, 0x84, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x43, 0xFE, 0x0F, 0x04, 0x32, 0x04, 0x81, 0x40, 0x40, 0x10, 0x08,
  0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xF8, 0x1F, 0xC0,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xF0, 0x06, 0x00, 0x80, 0x20, 0x0B,
  0x04, 0xC1, 0x10, 0xC3, 0xC0, 0x01, 0x03, 0x02, 0x04, 0x08, 0x10, 0x30,
  0x21, 0x41, 0x81, 0x81, 0xFE, 0x02, 0x02, 0x02, 0x1F, 0xC4, 0x02, 0x00,
  0x80, 0x20, 0x09, 0x83, 0x98, 0x82, 0x40, 0x80, 0x20, 0x08, 0x02, 0x41,
  0x10, 0xC3, 0xE0, 0x01, 0x01, 0x01, 0x80, 0x80, 0x80, 0x80, 0xF8, 0x63,
  0x40, 0xA0, 0x50, 0x30, 0x14, 0x1A, 0x08, 0xF8, 0x7F, 0xD0, 0x14, 0x09,
  0x02, 0x81, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x06, 0x00, 0x07, 0x06, 0x23, 0x04, 0x81, 0x20, 0x48, 0x21, 0xB0,
  0x30, 0x33, 0x18, 0x64, 0x0A, 0x02, 0x80, 0x90, 0x43, 0xE0, 0x0E, 0x18,
  0x90, 0x28, 0x18, 0x0C, 0x07, 0x06, 0x82, 0x3E, 0x01, 0x01, 0x01, 0x01,
  0x00, 0x81, 0x80, 0x77, 0x20, 0x00, 0x00, 0x4E, 0xC0, 0x1C, 0x70, 0x80,
  0x00, 0x00, 0x00, 0x18, 0xC2, 0x08, 0x43, 0x00, 0x00, 0x80, 0xC1, 0x83,
  0x06, 0x04, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x40, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x04, 0x0C, 0x18, 0x30,
  0x60, 0x00, 0x38, 0x06, 0x01, 0x01, 0x01, 0x03, 0x02, 0x3C, 0x20, 0x20,
  0x20, 0x00, 0x00, 0x60, 0xE0, 0x03, 0xC0, 0xC6, 0x10, 0x21, 0x01, 0x20,
  0x12, 0x19, 0x22, 0x62, 0x42, 0x44, 0x24, 0x42, 0x44, 0x24, 0x42, 0x44,
  0x44, 0x7C, 0x40, 0x04, 0x00, 0x40, 0x03, 0x00, 0x0E, 0x00, 0x01, 0x00,
  0xC0, 0x30, 0x14, 0x04, 0x81, 0x20, 0x88, 0x22, 0x10, 0x84, 0x23, 0xF8,
  0x82, 0x20, 0x90, 0x1C, 0x04, 0x1E, 0x08, 0x62, 0x04, 0x81, 0x20, 0x48,
  0x22, 0x18, 0xF8, 0x41, 0x90, 0x24, 0x09, 0x02, 0x40, 0x90, 0xCF, 0xE0,
  0x0E, 0x18, 0x88, 0x28, 0x14, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x28, 0x34, 0x11, 0xF0, 0x1E, 0x08, 0x62, 0x08, 0x81, 0x20, 0x48,
  0x12, 0x08, 0x82, 0x40, 0x90, 0x24, 0x09, 0x06, 0x41, 0x10, 0x8F, 0xC0,
  0x3F, 0xC8, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0xFC, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xE0, 0x1F, 0xE2, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0xFC, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x00, 0x0E, 0x18, 0x88, 0x28, 0x14, 0x02, 0x01, 0x01,
  0x00, 0x8F, 0x40, 0xA0, 0x50, 0x28, 0x34, 0x11, 0xF0, 0x10, 0x48, 0x12,
  0x04, 0x81, 0x20, 0x48, 0x22, 0x08, 0xFE, 0x40, 0x90, 0x24, 0x09, 0x04,
  0x41, 0x10, 0x48, 0x10, 0x3F, 0x82, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x83, 0xF8, 0x07, 0xC0, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x12, 0x04,
  0x81, 0x30, 0x87, 0xC0, 0x10, 0x24, 0x08, 0x81, 0x10, 0x42, 0x10, 0x42,
  0x08, 0x81, 0xF0, 0x42, 0x08, 0x41, 0x08, 0x20, 0x84, 0x10, 0x82, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0x30, 0x66, 0x18, 0xC3, 0x18, 0xA2, 0x94, 0x94,
  0x92, 0x92, 0x64, 0x44, 0x88, 0x11, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20,
  0x40, 0x10, 0x4C, 0x12, 0x84, 0xA1, 0x28, 0x4A, 0x22, 0x89, 0x12, 0x44,
  0x91, 0x24, 0x49, 0x0C, 0x43, 0x10, 0xC8, 0x30, 0x0E, 0x18, 0x88, 0x28,
  0x14, 0x0A, 0x05, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x24, 0x31,
  0xF0, 0x1F, 0x04, 0x18, 0x81, 0x10, 0x12, 0x04, 0x40, 0x88, 0x11, 0x0C,
  0x7E, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x00, 0x0E, 0x18,
  0x88, 0x28, 0x14, 0x0A, 0x05, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x28,
  0x24, 0x31, 0xF0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x1F, 0x04, 0x18, 0x81,
  0x10, 0x22, 0x04, 0x40, 0x88, 0x21, 0xF8, 0x44, 0x08, 0x41, 0x08, 0x21,
  0x04, 0x10, 0x82, 0x20, 0x60, 0x07, 0x06, 0x32, 0x04, 0x81, 0x20, 0x08,
  0x01, 0x00, 0x38, 0x01, 0x00, 0x20, 0x0A, 0x02, 0x80, 0x90, 0x43, 0xE0,
  0x7F, 0xE1, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0xA0, 0x50, 0x28, 0x14,
  0x0A, 0x09, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x24, 0x31, 0xF0,
  0x80, 0xC0, 0x60, 0x50, 0x28, 0x24, 0x12, 0x10, 0x88, 0x44, 0x24, 0x12,
  0x0A, 0x05, 0x03, 0x01, 0x80, 0x84, 0x31, 0x8A, 0x31, 0x46, 0x29, 0x45,
  0x29, 0x25, 0x24, 0xA4, 0xA5, 0x14, 0xA2, 0x94, 0x62, 0x8C, 0x61, 0x8C,
  0x21, 0x80, 0x10, 0x11, 0x02, 0x08, 0x60, 0x84, 0x08, 0x80, 0x50, 0x05,
  0x00, 0x20, 0x06, 0x00, 0x90, 0x19, 0x01, 0x08, 0x20, 0x84, 0x08, 0xC0,
  0x40, 0x80, 0x50, 0x14, 0x09, 0x04, 0x21, 0x08, 0x81, 0x40, 0x50, 0x18,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x3F, 0xC0, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40,
  0x30, 0x0F, 0xF0, 0x1F, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0xF8, 0x84, 0x21,
  0x04, 0x21, 0x08, 0x41, 0x08, 0x42, 0x08, 0x42, 0x10, 0x82, 0x1E, 0x04,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x08, 0x13, 0xC0, 0x04, 0x0C, 0x0A, 0x12, 0x32, 0x22, 0x41, 0xC1, 0xFF,
  0xC0, 0x99, 0x80, 0x3E, 0xA0, 0x90, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x04,
  0x82, 0x43, 0x1E, 0x80, 0x10, 0x10, 0x08, 0x04, 0x02, 0xF1, 0x84, 0x82,
  0x41, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x12, 0x0A, 0xF8, 0x3E, 0x30, 0x90,
  0x50, 0x28, 0x04, 0x02, 0x01, 0x02, 0x82, 0x41, 0x1F, 0x00, 0x00, 0x80,
  0x40, 0x20, 0x13, 0xEA, 0x09, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x48,
  0x24, 0x31, 0xE8, 0x3E, 0x41, 0x41, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x82,
  0x82, 0x7C, 0x00, 0x78, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x0F, 0xF8,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x3C, 0x00, 0x3E, 0xA0, 0x90,
  0x50, 0x28, 0x14, 0x0A, 0x05, 0x04, 0x86, 0x3D, 0x00, 0x80, 0x40, 0x60,
  0x63, 0xC0, 0x10, 0x10, 0x08, 0x04, 0x02, 0xF1, 0x84, 0x82, 0x41, 0x40,
  0xA0, 0x50, 0x28, 0x14, 0x12, 0x0A, 0x04, 0x07, 0x01, 0x80, 0x00, 0x03,
  0xE0, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x43, 0xFE,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x1F, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x03, 0x0F, 0x00,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x48, 0x22, 0x10, 0x88, 0x46, 0x1F,
  0x04, 0x41, 0x08, 0x42, 0x10, 0x48, 0x18, 0xF8, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x1F, 0x5F, 0xD9,
  0x14, 0x45, 0x11, 0x44, 0x52, 0x28, 0x8A, 0x22, 0x88, 0xA2, 0x28, 0x88,
  0x2F, 0x18, 0x48, 0x24, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x20, 0xA0,
  0x40, 0x3E, 0x61, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x86, 0x7C,
  0x2F, 0x18, 0x48, 0x24, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x20, 0xAF,
  0x90, 0x08, 0x04, 0x02, 0x00, 0x3E, 0xA0, 0x90, 0x50, 0x28, 0x14, 0x0A,
  0x05, 0x04, 0x82, 0x43, 0x1E, 0x80, 0x40, 0x20, 0x10, 0x10, 0x5F, 0x30,
  0x90, 0x28, 0x14, 0x12, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x1F,
  0x88, 0x22, 0x08, 0x80, 0x20, 0x07, 0xC0, 0x18, 0x02, 0x80, 0x90, 0x47,
  0xE0, 0x08, 0x04, 0x02, 0x1F, 0xF1, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x00, 0xF0, 0x40, 0xA0, 0x90, 0x50, 0x28, 0x14, 0x0A,
  0x05, 0x02, 0x82, 0x43, 0x1F, 0x00, 0x80, 0xA0, 0x50, 0x48, 0x24, 0x22,
  0x10, 0x90, 0x48, 0x28, 0x14, 0x0C, 0x00, 0x88, 0x62, 0x29, 0x4A, 0x52,
  0x95, 0x29, 0x4A, 0x52, 0x98, 0xC6, 0x31, 0x88, 0x40, 0x20, 0x48, 0x21,
  0x10, 0x68, 0x0C, 0x03, 0x01, 0xC0, 0x48, 0x22, 0x10, 0x48, 0x18, 0x41,
  0xA0, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x09, 0x04, 0x86, 0x3D, 0x00, 0x80,
  0x40, 0x40, 0x63, 0xC0, 0x3F, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x80, 0x40, 0x20, 0x10, 0x0F, 0xF0, 0x00, 0xC0, 0xC0, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x3E, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x00, 0xE0, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24,
  0x44, 0x44, 0x44, 0x80, 0x18, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x03, 0xC3, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x38, 0x00, 0x70, 0xCC, 0x62, 0x50, 0xC0,
};

const GFXglyph JetBrainsMono_ThinItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 6, 6, 12, 4, -15 },
  { 14, 12, 15, 12, 0, -15 },
  { 37, 10, 20, 12, 1, -17 },
  { 62, 13, 15, 12, 0, -15 },
  { 87, 10, 15, 12, 1, -15 },
  { 106, 2, 6, 12, 6, -15 },
  { 108, 8, 20, 12, 4, -17 },
  { 128, 8, 20, 12, 1, -17 },
  { 148, 11, 10, 12, 1, -12 },
  { 162, 9, 9, 12, 2, -11 },
  { 173, 5, 6, 12, 2, -3 },
  { 177, 6, 1, 12, 3, -7 },
  { 178, 3, 3, 12, 4, -3 },
  { 180, 11, 19, 12, 1, -17 },
  { 207, 10, 15, 12, 1, -15 },
  { 226, 9, 15, 12, 1, -15 },
  { 243, 10, 15, 12, 1, -15 },
  { 262, 10, 15, 12, 1, -15 },
  { 281, 8, 15, 12, 2, -15 },
  { 296, 10, 15, 12, 1, -15 },
  { 315, 9, 15, 12, 1, -15 },
  { 332, 10, 15, 12, 2, -15 },
  { 351, 10, 15, 12, 1, -15 },
  { 370, 9, 15, 12, 2, -15 },
  { 387, 4, 11, 12, 4, -11 },
  { 393, 6, 14, 12, 2, -11 },
  { 404, 9, 10, 12, 2, -12 },
  { 416, 9, 5, 12, 2, -9 },
  { 422, 9, 10, 12, 1, -12 },
  { 434, 8, 15, 12, 3, -15 },
  { 449, 12, 19, 12, 0, -15 },
  { 478, 10, 15, 12, 0, -15 },
  { 497, 10, 15, 12, 1, -15 },
  { 516, 9, 15, 12, 2, -15 },
  { 533, 10, 15, 12, 1, -15 },
  { 552, 10, 15, 12, 2, -15 },
  { 571, 11, 15, 12, 1, -15 },
  { 592, 9, 15, 12, 2, -15 },
  { 609, 10, 15, 12, 1, -15 },
  { 628, 9, 15, 12, 2, -15 },
  { 645, 10, 15, 12, 1, -15 },
  { 664, 11, 15, 12, 1, -15 },
  { 685, 8, 15, 12, 2, -15 },
  { 700, 11, 15, 12, 1, -15 },
  { 721, 10, 15, 12, 1, -15 },
  { 740, 9, 15, 12, 2, -15 },
  { 757, 11, 15, 12, 1, -15 },
  { 778, 9, 19, 12, 2, -15 },
  { 800, 11, 15, 12, 1, -15 },
  { 821, 10, 15, 12, 1, -15 },
  { 840, 10, 15, 12, 2, -15 },
  { 859, 9, 15, 12, 2, -15 },
  { 876, 9, 15, 12, 3, -15 },
  { 893, 11, 15, 12, 2, -15 },
  { 914, 12, 15, 12, 0, -15 },
  { 937, 10, 15, 12, 2, -15 },
  { 956, 10, 15, 12, 1, -15 },
  { 975, 8, 19, 12, 3, -17 },
  { 994, 5, 19, 12, 4, -17 },
  { 1006, 7, 19, 12, 2, -17 },
  { 1023, 8, 8, 12, 2, -15 },
  { 1031, 10, 1, 12, 0, 0 },
  { 1033, 3, 3, 12, 6, -16 },
  { 1035, 9, 11, 12, 2, -11 },
  { 1048, 9, 15, 12, 1, -15 },
  { 1065, 9, 11, 12, 2, -11 },
  { 1078, 9, 15, 12, 2, -15 },
  { 1095, 8, 11, 12, 2, -11 },
  { 1106, 13, 19, 12, -1, -15 },
  { 1137, 9, 15, 12, 2, -11 },
  { 1154, 9, 15, 12, 1, -15 },
  { 1171, 9, 15, 12, 1, -15 },
  { 1188, 10, 19, 12, 0, -15 },
  { 1212, 10, 15, 12, 1, -15 },
  { 1231, 8, 15, 12, 2, -15 },
  { 1246, 10, 11, 12, 1, -11 },
  { 1260, 9, 11, 12, 1, -11 },
  { 1273, 8, 11, 12, 2, -11 },
  { 1284, 9, 15, 12, 1, -11 },
  { 1301, 9, 15, 12, 2, -11 },
  { 1318, 9, 11, 12, 2, -11 },
  { 1331, 10, 11, 12, 1, -11 },
  { 1345, 9, 14, 12, 2, -14 },
  { 1361, 9, 11, 12, 2, -11 },
  { 1374, 9, 11, 12, 2, -11 },
  { 1387, 10, 11, 12, 2, -11 },
  { 1401, 10, 11, 12, 1, -11 },
  { 1415, 9, 15, 12, 2, -11 },
  { 1432, 10, 11, 12, 1, -11 },
  { 1446, 10, 19, 12, 2, -17 },
  { 1470, 4, 19, 12, 4, -17 },
  { 1480, 9, 19, 12, 1, -17 },
  { 1502, 9, 4, 12, 2, -9 },
};

const GFXfont JetBrainsMono_ThinItalic20pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic20pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _JETBRAINSMONO_THINITALIC20PT7B_H_
