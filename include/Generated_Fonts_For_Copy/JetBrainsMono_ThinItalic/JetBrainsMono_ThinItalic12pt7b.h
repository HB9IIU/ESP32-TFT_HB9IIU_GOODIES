#ifndef _JETBRAINSMONO_THINITALIC12PT7B_H_
#define _JETBRAINSMONO_THINITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0x40, 0x55, 0x99, 0x12, 0x24, 0x53, 0x72, 0x45,
  0x37, 0x24, 0x50, 0x10, 0xE5, 0x54, 0x60, 0xC2, 0x8A, 0xAB, 0x42, 0x10,
  0x31, 0x52, 0x54, 0x78, 0x10, 0x1C, 0x32, 0x52, 0x8C, 0x18, 0x48, 0x81,
  0x05, 0x2A, 0xA2, 0x44, 0x74, 0xF0, 0x19, 0x10, 0x84, 0x42, 0x10, 0x84,
  0x18, 0x20, 0x61, 0x11, 0x11, 0x11, 0x22, 0x48, 0x10, 0x9D, 0x88, 0x52,
  0x40, 0x11, 0x09, 0xF2, 0x10, 0x29, 0x40, 0xF0, 0x70, 0x02, 0x08, 0x10,
  0x40, 0x82, 0x04, 0x10, 0x20, 0x83, 0x00, 0x39, 0x18, 0x61, 0xAA, 0x28,
  0xA2, 0xF0, 0x13, 0xA4, 0x21, 0x10, 0x84, 0xF8, 0x39, 0x18, 0x42, 0x08,
  0x42, 0x10, 0xF8, 0x7C, 0x21, 0x0C, 0x08, 0x20, 0xA2, 0xF0, 0x08, 0x84,
  0x44, 0xC7, 0xE1, 0x08, 0x7D, 0x04, 0x1C, 0x88, 0x20, 0xA2, 0xF0, 0x18,
  0x88, 0x87, 0xC6, 0x31, 0xF0, 0x7D, 0x18, 0x82, 0x10, 0x42, 0x08, 0x40,
  0x39, 0x14, 0x52, 0x33, 0x28, 0xA2, 0xF0, 0x39, 0x18, 0x61, 0x48, 0xE1,
  0x08, 0x40, 0x6C, 0x00, 0xB0, 0x33, 0x00, 0x02, 0x44, 0x80, 0x0C, 0xC4,
  0x30, 0x30, 0x20, 0xF8, 0x01, 0xF0, 0xC1, 0x06, 0x36, 0x40, 0x70, 0x42,
  0x26, 0x21, 0x00, 0x80, 0x1C, 0x45, 0x0A, 0x75, 0x2A, 0x64, 0xCA, 0x89,
  0x01, 0xC0, 0x08, 0x21, 0x8A, 0x24, 0x95, 0xD1, 0x84, 0x79, 0x14, 0x62,
  0x72, 0x28, 0xA2, 0xF0, 0x39, 0x14, 0x60, 0x82, 0x08, 0x22, 0x70, 0x71,
  0x24, 0x62, 0x8A, 0x28, 0xA2, 0xF0, 0x7D, 0x04, 0x10, 0x7A, 0x08, 0x20,
  0xF8, 0x7D, 0x04, 0x10, 0x7A, 0x08, 0x20, 0x80, 0x39, 0x14, 0x60, 0x82,
  0xE8, 0xA2, 0x70, 0x45, 0x14, 0x62, 0x7A, 0x28, 0xA2, 0x88, 0x7C, 0x41,
  0x08, 0x20, 0x82, 0x08, 0xF0, 0x0E, 0x04, 0x10, 0x20, 0x40, 0x81, 0x42,
  0x78, 0x45, 0x14, 0xA4, 0x72, 0x49, 0x22, 0x88, 0x42, 0x10, 0x88, 0x42,
  0x10, 0xF8, 0x45, 0x3A, 0xED, 0xAA, 0x28, 0xA2, 0x88, 0x45, 0x16, 0x6A,
  0xAA, 0xA9, 0xA6, 0x90, 0x39, 0x14, 0x62, 0x8A, 0x28, 0xA2, 0xF0, 0x79,
  0x14, 0x61, 0xFA, 0x08, 0x20, 0x80, 0x39, 0x14, 0x62, 0x8A, 0x28, 0xA2,
  0xF0, 0x41, 0x00, 0x79, 0x14, 0x61, 0xFA, 0x49, 0x24, 0x88, 0x39, 0x14,
  0x10, 0x30, 0x20, 0xA2, 0xF0, 0xFC, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x45, 0x14, 0x62, 0x8A, 0x28, 0xA2, 0x70, 0x8C, 0x65, 0x29, 0x52, 0x98,
  0x40, 0x93, 0x2A, 0xD5, 0xAB, 0x5B, 0x36, 0x4C, 0x90, 0x22, 0x48, 0x90,
  0xC1, 0x05, 0x0A, 0x22, 0x84, 0x85, 0x14, 0x94, 0x30, 0x82, 0x08, 0x20,
  0x7C, 0x20, 0x84, 0x20, 0x84, 0x20, 0xF8, 0x34, 0x44, 0x44, 0x88, 0x88,
  0xE0, 0x91, 0x24, 0x91, 0x24, 0x80, 0x38, 0x44, 0x21, 0x08, 0x42, 0x21,
  0x38, 0x11, 0x8A, 0x98, 0x80, 0xFC, 0xC0, 0x3A, 0x63, 0x18, 0xC7, 0xC0,
  0x42, 0x1C, 0x98, 0xC6, 0x31, 0xF0, 0x32, 0x63, 0x08, 0x47, 0xC0, 0x04,
  0x13, 0x52, 0x8A, 0x28, 0xA2, 0xF0, 0x32, 0x63, 0xF8, 0x47, 0xC0, 0x0E,
  0x20, 0x43, 0xF1, 0x02, 0x04, 0x10, 0x20, 0x43, 0x80, 0x3A, 0x63, 0x18,
  0xCD, 0xA2, 0xF0, 0x42, 0x1C, 0x98, 0xC6, 0x31, 0x88, 0x10, 0x1C, 0x21,
  0x10, 0x84, 0xF8, 0x04, 0x03, 0xC1, 0x08, 0x20, 0x82, 0x08, 0x2F, 0x00,
  0x41, 0x04, 0x62, 0x93, 0x89, 0x24, 0x88, 0xE1, 0x08, 0x42, 0x11, 0x08,
  0x38, 0x7C, 0xA5, 0x4A, 0xA5, 0x52, 0xA5, 0x00, 0x72, 0x63, 0x18, 0xC6,
  0x20, 0x32, 0x63, 0x18, 0xC7, 0xC0, 0x38, 0x94, 0x51, 0x45, 0x17, 0xA0,
  0x80, 0x3A, 0x63, 0x18, 0xC7, 0xC2, 0x10, 0x79, 0x24, 0x60, 0x82, 0x08,
  0x00, 0x32, 0x60, 0xE0, 0xC7, 0xC0, 0x23, 0xF2, 0x08, 0x21, 0x04, 0x0E,
  0x4C, 0x63, 0x18, 0xC7, 0xC0, 0x86, 0x24, 0x94, 0x51, 0x82, 0x00, 0x96,
  0x9A, 0x76, 0xDA, 0x49, 0x00, 0x42, 0x48, 0xA0, 0x82, 0x89, 0x31, 0x00,
  0x4C, 0x63, 0x18, 0xCD, 0xA2, 0xF0, 0x78, 0x44, 0x44, 0x43, 0xE0, 0x0C,
  0x41, 0x04, 0x13, 0x82, 0x08, 0x20, 0x83, 0x00, 0x55, 0xAA, 0xA8, 0x30,
  0x21, 0x04, 0x10, 0x31, 0x04, 0x20, 0x8E, 0x00, 0xEC, 0xC0,
};

const GFXglyph JetBrainsMono_ThinItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 4, 4, 7, 2, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 12, 7, 1, -10 },
  { 24, 8, 9, 7, 0, -9 },
  { 33, 7, 9, 7, 0, -9 },
  { 41, 1, 4, 7, 4, -9 },
  { 42, 5, 12, 7, 2, -10 },
  { 50, 4, 12, 7, 1, -10 },
  { 56, 6, 6, 7, 1, -7 },
  { 61, 5, 6, 7, 1, -7 },
  { 65, 3, 4, 7, 1, -2 },
  { 67, 4, 1, 7, 2, -4 },
  { 68, 2, 2, 7, 2, -2 },
  { 69, 7, 11, 7, 0, -10 },
  { 79, 6, 9, 7, 1, -9 },
  { 86, 5, 9, 7, 1, -9 },
  { 92, 6, 9, 7, 1, -9 },
  { 99, 6, 9, 7, 1, -9 },
  { 106, 5, 9, 7, 1, -9 },
  { 112, 6, 9, 7, 1, -9 },
  { 119, 5, 9, 7, 1, -9 },
  { 125, 6, 9, 7, 1, -9 },
  { 132, 6, 9, 7, 1, -9 },
  { 139, 6, 9, 7, 1, -9 },
  { 146, 3, 7, 7, 2, -7 },
  { 149, 4, 9, 7, 1, -7 },
  { 154, 6, 6, 7, 1, -7 },
  { 159, 5, 4, 7, 1, -6 },
  { 162, 5, 6, 7, 1, -7 },
  { 166, 5, 9, 7, 2, -9 },
  { 172, 7, 11, 7, 0, -9 },
  { 182, 6, 9, 7, 0, -9 },
  { 189, 6, 9, 7, 1, -9 },
  { 196, 6, 9, 7, 1, -9 },
  { 203, 6, 9, 7, 1, -9 },
  { 210, 6, 9, 7, 1, -9 },
  { 217, 6, 9, 7, 1, -9 },
  { 224, 6, 9, 7, 1, -9 },
  { 231, 6, 9, 7, 1, -9 },
  { 238, 6, 9, 7, 1, -9 },
  { 245, 7, 9, 7, 0, -9 },
  { 253, 6, 9, 7, 1, -9 },
  { 260, 5, 9, 7, 1, -9 },
  { 266, 6, 9, 7, 1, -9 },
  { 273, 6, 9, 7, 1, -9 },
  { 280, 6, 9, 7, 1, -9 },
  { 287, 6, 9, 7, 1, -9 },
  { 294, 6, 11, 7, 1, -9 },
  { 303, 6, 9, 7, 1, -9 },
  { 310, 6, 9, 7, 1, -9 },
  { 317, 6, 9, 7, 1, -9 },
  { 324, 6, 9, 7, 1, -9 },
  { 331, 5, 9, 7, 2, -9 },
  { 337, 7, 9, 7, 1, -9 },
  { 345, 7, 9, 7, 0, -9 },
  { 353, 6, 9, 7, 1, -9 },
  { 360, 6, 9, 7, 1, -9 },
  { 367, 4, 11, 7, 2, -10 },
  { 373, 3, 11, 7, 2, -10 },
  { 378, 5, 11, 7, 1, -10 },
  { 385, 5, 5, 7, 1, -9 },
  { 389, 6, 1, 7, 0, 0 },
  { 390, 2, 1, 7, 3, -9 },
  { 391, 5, 7, 7, 1, -7 },
  { 396, 5, 9, 7, 1, -9 },
  { 402, 5, 7, 7, 1, -7 },
  { 407, 6, 9, 7, 1, -9 },
  { 414, 5, 7, 7, 1, -7 },
  { 419, 7, 11, 7, 0, -9 },
  { 429, 5, 9, 7, 1, -7 },
  { 435, 5, 9, 7, 1, -9 },
  { 441, 5, 9, 7, 1, -9 },
  { 447, 6, 11, 7, 0, -9 },
  { 456, 6, 9, 7, 1, -9 },
  { 463, 5, 9, 7, 1, -9 },
  { 469, 7, 7, 7, 0, -7 },
  { 476, 5, 7, 7, 1, -7 },
  { 481, 5, 7, 7, 1, -7 },
  { 486, 6, 9, 7, 0, -7 },
  { 493, 5, 9, 7, 1, -7 },
  { 499, 6, 7, 7, 1, -7 },
  { 505, 5, 7, 7, 1, -7 },
  { 510, 6, 8, 7, 1, -8 },
  { 516, 5, 7, 7, 1, -7 },
  { 521, 6, 7, 7, 1, -7 },
  { 527, 6, 7, 7, 1, -7 },
  { 533, 7, 7, 7, 0, -7 },
  { 540, 5, 9, 7, 1, -7 },
  { 546, 5, 7, 7, 1, -7 },
  { 551, 6, 11, 7, 1, -10 },
  { 560, 2, 11, 7, 3, -10 },
  { 563, 6, 11, 7, 0, -10 },
  { 572, 5, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_ThinItalic12pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic12pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _JETBRAINSMONO_THINITALIC12PT7B_H_
