#ifndef _JETBRAINSMONO_THINITALIC14PT7B_H_
#define _JETBRAINSMONO_THINITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x90, 0x18, 0x99, 0x99, 0x09, 0x11, 0x12, 0x7F, 0x22,
  0x24, 0xFE, 0x44, 0x48, 0x48, 0x08, 0x10, 0xF2, 0x95, 0x0A, 0x0C, 0x0E,
  0x15, 0x2A, 0x93, 0xC2, 0x04, 0x00, 0x38, 0xA4, 0x92, 0x8A, 0x82, 0x80,
  0xB0, 0xA4, 0x52, 0x49, 0x47, 0x00, 0x1E, 0x22, 0x20, 0x10, 0x30, 0x49,
  0x4A, 0x44, 0x8C, 0x72, 0x6A, 0x04, 0x62, 0x08, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x20, 0x40, 0x20, 0x82, 0x10, 0x84, 0x21, 0x08, 0x84, 0x44,
  0x40, 0x10, 0x20, 0x47, 0xF1, 0x05, 0x12, 0x44, 0x10, 0x20, 0x47, 0xF1,
  0x04, 0x08, 0x00, 0x6A, 0x40, 0xF8, 0xF0, 0x01, 0x01, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x3C, 0x85, 0x0A,
  0x19, 0x52, 0xA1, 0x42, 0x84, 0xF0, 0x19, 0xA0, 0x82, 0x10, 0x41, 0x04,
  0x13, 0xF0, 0x3C, 0x85, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41, 0xF8, 0x7E,
  0x08, 0x20, 0x80, 0xC0, 0x81, 0x42, 0x88, 0xE0, 0x04, 0x21, 0x08, 0x25,
  0x18, 0x7F, 0x04, 0x20, 0x7E, 0x81, 0x03, 0xC4, 0x40, 0x81, 0x02, 0x84,
  0xF0, 0x08, 0x42, 0x08, 0x7E, 0x18, 0x61, 0x85, 0xE0, 0xFE, 0x18, 0x82,
  0x10, 0x42, 0x08, 0x42, 0x00, 0x3C, 0x85, 0x0A, 0x23, 0x89, 0x21, 0x42,
  0x84, 0xF0, 0x7A, 0x18, 0x61, 0x89, 0xE1, 0x08, 0x43, 0x00, 0x6C, 0x00,
  0x36, 0x33, 0x00, 0x00, 0x64, 0x88, 0x06, 0x31, 0x84, 0x06, 0x03, 0x01,
  0x00, 0x7C, 0x00, 0x3F, 0x40, 0xC0, 0x81, 0x19, 0x88, 0x00, 0x78, 0x10,
  0x42, 0x19, 0x84, 0x00, 0x03, 0x00, 0x1F, 0x21, 0x41, 0x47, 0x49, 0x51,
  0x51, 0x51, 0x9E, 0x80, 0x40, 0x40, 0x38, 0x0C, 0x18, 0x50, 0xA1, 0x44,
  0x8F, 0x21, 0x43, 0x04, 0x7C, 0x85, 0x0A, 0x27, 0x90, 0xA1, 0x42, 0x85,
  0xF0, 0x3C, 0x85, 0x0A, 0x04, 0x10, 0x20, 0x42, 0x84, 0xF0, 0x7C, 0x85,
  0x0A, 0x24, 0x50, 0xA1, 0x42, 0x89, 0xE0, 0x7E, 0x81, 0x02, 0x07, 0xC8,
  0x20, 0x40, 0x81, 0xF8, 0x7E, 0x81, 0x02, 0x07, 0xC8, 0x20, 0x40, 0x81,
  0x00, 0x3C, 0x85, 0x0A, 0x04, 0x13, 0xA1, 0x42, 0x84, 0xF0, 0x42, 0x85,
  0x0A, 0x27, 0xD0, 0xA1, 0x42, 0x85, 0x10, 0x3E, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x10, 0x21, 0xF0, 0x1E, 0x04, 0x10, 0x20, 0x40, 0x81, 0x42, 0x89,
  0xE0, 0x42, 0x89, 0x12, 0x47, 0x11, 0x22, 0x44, 0x85, 0x08, 0x41, 0x04,
  0x10, 0x41, 0x08, 0x20, 0x83, 0xF0, 0x42, 0xCD, 0xAB, 0x59, 0x30, 0xA1,
  0x42, 0x85, 0x08, 0x62, 0xC5, 0x8A, 0xA5, 0x52, 0xA5, 0x46, 0x89, 0x10,
  0x3C, 0x85, 0x0A, 0x24, 0x50, 0xA1, 0x42, 0x88, 0xF0, 0x7E, 0x85, 0x0A,
  0x14, 0x57, 0x20, 0x40, 0x81, 0x00, 0x3C, 0x85, 0x0A, 0x24, 0x50, 0xA1,
  0x42, 0x88, 0xF0, 0x40, 0x40, 0x80, 0x7C, 0x85, 0x0A, 0x14, 0xD6, 0x22,
  0x44, 0x89, 0x08, 0x3C, 0x85, 0x02, 0x03, 0x01, 0x81, 0x42, 0x84, 0xF0,
  0xFE, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x80, 0x42, 0x85, 0x0A,
  0x24, 0x50, 0xA1, 0x42, 0x88, 0xE0, 0x86, 0x18, 0xA2, 0x8A, 0x45, 0x18,
  0x61, 0x00, 0x89, 0x99, 0x9A, 0xAA, 0xAA, 0xAC, 0xCC, 0xCC, 0xC8, 0x88,
  0x21, 0x12, 0x12, 0x14, 0x08, 0x18, 0x14, 0x24, 0x42, 0x82, 0x87, 0x0A,
  0x22, 0x85, 0x04, 0x08, 0x20, 0x40, 0x80, 0x7E, 0x08, 0x10, 0x41, 0x04,
  0x08, 0x20, 0x81, 0xF8, 0x39, 0x08, 0x44, 0x21, 0x08, 0x42, 0x11, 0x08,
  0x70, 0x92, 0x48, 0x92, 0x48, 0x92, 0x40, 0x3C, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x13, 0x80, 0x31, 0x95, 0x18, 0x80, 0xFE, 0x90,
  0x3D, 0x14, 0x61, 0x86, 0x18, 0x9E, 0x41, 0x07, 0x91, 0x46, 0x18, 0x61,
  0x8B, 0xE0, 0x39, 0x14, 0x60, 0x82, 0x18, 0x5E, 0x02, 0x04, 0xEA, 0x24,
  0x50, 0xA1, 0x42, 0x88, 0xF0, 0x39, 0x14, 0x7F, 0x82, 0x08, 0x5E, 0x07,
  0x08, 0x08, 0x7F, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x80,
  0x3D, 0x14, 0x61, 0x86, 0x14, 0x8E, 0x08, 0x2F, 0x00, 0x41, 0x07, 0x91,
  0x46, 0x18, 0x61, 0x86, 0x20, 0x08, 0x20, 0x1C, 0x10, 0x41, 0x04, 0x10,
  0x4F, 0xC0, 0x02, 0x04, 0x01, 0xF0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x41, 0x9C, 0x00, 0x40, 0x81, 0x0A, 0x24, 0x8E, 0x24, 0x44, 0x89, 0x08,
  0xE1, 0x08, 0x84, 0x21, 0x08, 0x43, 0xC0, 0x7E, 0x49, 0x49, 0x49, 0x4A,
  0x52, 0x52, 0x92, 0x79, 0x14, 0x61, 0x86, 0x18, 0x62, 0x39, 0x14, 0x61,
  0x86, 0x18, 0x9E, 0x79, 0x14, 0x61, 0x86, 0x18, 0xBE, 0x82, 0x08, 0x00,
  0x3D, 0x14, 0x61, 0x86, 0x18, 0x9E, 0x08, 0x20, 0x80, 0x5C, 0xC9, 0x0A,
  0x04, 0x10, 0x20, 0x40, 0x3D, 0x14, 0x18, 0x18, 0x18, 0x7E, 0x10, 0x23,
  0xF9, 0x02, 0x04, 0x08, 0x10, 0x20, 0x70, 0x45, 0x14, 0x61, 0x86, 0x18,
  0x9C, 0x86, 0x28, 0xA4, 0x92, 0x86, 0x10, 0x93, 0x26, 0xCD, 0x6A, 0xD9,
  0xB2, 0x44, 0x21, 0x22, 0x14, 0x08, 0x18, 0x24, 0x24, 0xC2, 0x45, 0x14,
  0x61, 0x86, 0x15, 0x8A, 0x08, 0x2F, 0x00, 0x7C, 0x10, 0x84, 0x21, 0x04,
  0x3E, 0x0C, 0x41, 0x04, 0x10, 0x4E, 0x08, 0x20, 0x82, 0x10, 0x20, 0x40,
  0x24, 0xA4, 0x92, 0x52, 0x49, 0x00, 0x20, 0x41, 0x04, 0x10, 0x41, 0xC4,
  0x20, 0x82, 0x08, 0x42, 0x00, 0x63, 0x38,
};

const GFXglyph JetBrainsMono_ThinItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 10, 8, 3, -10 },
  { 5, 4, 4, 8, 3, -10 },
  { 7, 8, 10, 8, 0, -10 },
  { 17, 7, 14, 8, 1, -12 },
  { 30, 9, 10, 8, 0, -10 },
  { 42, 8, 10, 8, 0, -10 },
  { 52, 2, 4, 8, 4, -10 },
  { 53, 6, 14, 8, 2, -12 },
  { 64, 5, 14, 8, 1, -12 },
  { 73, 7, 8, 8, 1, -9 },
  { 80, 7, 7, 8, 1, -8 },
  { 87, 3, 4, 8, 2, -2 },
  { 89, 5, 1, 8, 2, -5 },
  { 90, 2, 2, 8, 3, -2 },
  { 91, 8, 14, 8, 0, -12 },
  { 105, 7, 10, 8, 1, -10 },
  { 114, 6, 10, 8, 1, -10 },
  { 122, 7, 10, 8, 1, -10 },
  { 131, 7, 10, 8, 1, -10 },
  { 140, 6, 10, 8, 1, -10 },
  { 148, 7, 10, 8, 1, -10 },
  { 157, 6, 10, 8, 1, -10 },
  { 165, 6, 10, 8, 2, -10 },
  { 173, 7, 10, 8, 1, -10 },
  { 182, 6, 10, 8, 2, -10 },
  { 190, 3, 8, 8, 3, -8 },
  { 193, 4, 10, 8, 2, -8 },
  { 198, 7, 7, 8, 1, -8 },
  { 205, 6, 4, 8, 1, -7 },
  { 208, 6, 7, 8, 1, -8 },
  { 214, 6, 10, 8, 2, -10 },
  { 222, 8, 13, 8, 0, -10 },
  { 235, 7, 10, 8, 0, -10 },
  { 244, 7, 10, 8, 1, -10 },
  { 253, 7, 10, 8, 1, -10 },
  { 262, 7, 10, 8, 1, -10 },
  { 271, 7, 10, 8, 1, -10 },
  { 280, 7, 10, 8, 1, -10 },
  { 289, 7, 10, 8, 1, -10 },
  { 298, 7, 10, 8, 1, -10 },
  { 307, 7, 10, 8, 1, -10 },
  { 316, 7, 10, 8, 1, -10 },
  { 325, 7, 10, 8, 1, -10 },
  { 334, 6, 10, 8, 1, -10 },
  { 342, 7, 10, 8, 1, -10 },
  { 351, 7, 10, 8, 1, -10 },
  { 360, 7, 10, 8, 1, -10 },
  { 369, 7, 10, 8, 1, -10 },
  { 378, 7, 13, 8, 1, -10 },
  { 390, 7, 10, 8, 1, -10 },
  { 399, 7, 10, 8, 1, -10 },
  { 408, 7, 10, 8, 2, -10 },
  { 417, 7, 10, 8, 1, -10 },
  { 426, 6, 10, 8, 2, -10 },
  { 434, 8, 10, 8, 1, -10 },
  { 444, 8, 10, 8, 0, -10 },
  { 454, 7, 10, 8, 2, -10 },
  { 463, 7, 10, 8, 1, -10 },
  { 472, 5, 14, 8, 2, -12 },
  { 481, 3, 14, 8, 3, -12 },
  { 487, 6, 14, 8, 1, -12 },
  { 498, 5, 5, 8, 2, -10 },
  { 502, 7, 1, 8, 0, 0 },
  { 503, 2, 2, 8, 4, -11 },
  { 504, 6, 8, 8, 1, -8 },
  { 510, 6, 10, 8, 1, -10 },
  { 518, 6, 8, 8, 1, -8 },
  { 524, 7, 10, 8, 1, -10 },
  { 533, 6, 8, 8, 1, -8 },
  { 539, 8, 13, 8, 0, -10 },
  { 552, 6, 11, 8, 1, -8 },
  { 561, 6, 10, 8, 1, -10 },
  { 569, 6, 11, 8, 1, -11 },
  { 578, 7, 14, 8, 0, -11 },
  { 591, 7, 10, 8, 1, -10 },
  { 600, 5, 10, 8, 2, -10 },
  { 607, 8, 8, 8, 0, -8 },
  { 615, 6, 8, 8, 1, -8 },
  { 621, 6, 8, 8, 1, -8 },
  { 627, 6, 11, 8, 1, -8 },
  { 636, 6, 11, 8, 1, -8 },
  { 645, 7, 8, 8, 1, -8 },
  { 652, 6, 8, 8, 1, -8 },
  { 658, 7, 10, 8, 1, -10 },
  { 667, 6, 8, 8, 1, -8 },
  { 673, 6, 8, 8, 2, -8 },
  { 679, 7, 8, 8, 1, -8 },
  { 686, 8, 8, 8, 0, -8 },
  { 694, 6, 11, 8, 1, -8 },
  { 703, 6, 8, 8, 1, -8 },
  { 709, 6, 14, 8, 2, -12 },
  { 720, 3, 14, 8, 3, -12 },
  { 726, 6, 14, 8, 1, -12 },
  { 737, 7, 2, 8, 1, -6 },
};

const GFXfont JetBrainsMono_ThinItalic14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_THINITALIC14PT7B_H_
