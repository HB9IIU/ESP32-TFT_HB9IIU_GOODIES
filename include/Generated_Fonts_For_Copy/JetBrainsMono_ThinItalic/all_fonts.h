#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/JetBrainsMono_ThinItalic
// Headers: 67

#include "JetBrainsMono_ThinItalic6pt7b.h"
#include "JetBrainsMono_ThinItalic7pt7b.h"
#include "JetBrainsMono_ThinItalic8pt7b.h"
#include "JetBrainsMono_ThinItalic9pt7b.h"
#include "JetBrainsMono_ThinItalic10pt7b.h"
#include "JetBrainsMono_ThinItalic11pt7b.h"
#include "JetBrainsMono_ThinItalic12pt7b.h"
#include "JetBrainsMono_ThinItalic13pt7b.h"
#include "JetBrainsMono_ThinItalic14pt7b.h"
#include "JetBrainsMono_ThinItalic15pt7b.h"
#include "JetBrainsMono_ThinItalic16pt7b.h"
#include "JetBrainsMono_ThinItalic17pt7b.h"
#include "JetBrainsMono_ThinItalic18pt7b.h"
#include "JetBrainsMono_ThinItalic19pt7b.h"
#include "JetBrainsMono_ThinItalic20pt7b.h"
#include "JetBrainsMono_ThinItalic21pt7b.h"
#include "JetBrainsMono_ThinItalic22pt7b.h"
#include "JetBrainsMono_ThinItalic23pt7b.h"
#include "JetBrainsMono_ThinItalic24pt7b.h"
#include "JetBrainsMono_ThinItalic25pt7b.h"
#include "JetBrainsMono_ThinItalic26pt7b.h"
#include "JetBrainsMono_ThinItalic27pt7b.h"
#include "JetBrainsMono_ThinItalic28pt7b.h"
#include "JetBrainsMono_ThinItalic29pt7b.h"
#include "JetBrainsMono_ThinItalic30pt7b.h"
#include "JetBrainsMono_ThinItalic31pt7b.h"
#include "JetBrainsMono_ThinItalic32pt7b.h"
#include "JetBrainsMono_ThinItalic33pt7b.h"
#include "JetBrainsMono_ThinItalic34pt7b.h"
#include "JetBrainsMono_ThinItalic35pt7b.h"
#include "JetBrainsMono_ThinItalic36pt7b.h"
#include "JetBrainsMono_ThinItalic37pt7b.h"
#include "JetBrainsMono_ThinItalic38pt7b.h"
#include "JetBrainsMono_ThinItalic39pt7b.h"
#include "JetBrainsMono_ThinItalic40pt7b.h"
#include "JetBrainsMono_ThinItalic41pt7b.h"
#include "JetBrainsMono_ThinItalic42pt7b.h"
#include "JetBrainsMono_ThinItalic43pt7b.h"
#include "JetBrainsMono_ThinItalic44pt7b.h"
#include "JetBrainsMono_ThinItalic45pt7b.h"
#include "JetBrainsMono_ThinItalic46pt7b.h"
#include "JetBrainsMono_ThinItalic47pt7b.h"
#include "JetBrainsMono_ThinItalic48pt7b.h"
#include "JetBrainsMono_ThinItalic49pt7b.h"
#include "JetBrainsMono_ThinItalic50pt7b.h"
#include "JetBrainsMono_ThinItalic51pt7b.h"
#include "JetBrainsMono_ThinItalic52pt7b.h"
#include "JetBrainsMono_ThinItalic53pt7b.h"
#include "JetBrainsMono_ThinItalic54pt7b.h"
#include "JetBrainsMono_ThinItalic55pt7b.h"
#include "JetBrainsMono_ThinItalic56pt7b.h"
#include "JetBrainsMono_ThinItalic57pt7b.h"
#include "JetBrainsMono_ThinItalic58pt7b.h"
#include "JetBrainsMono_ThinItalic59pt7b.h"
#include "JetBrainsMono_ThinItalic60pt7b.h"
#include "JetBrainsMono_ThinItalic61pt7b.h"
#include "JetBrainsMono_ThinItalic62pt7b.h"
#include "JetBrainsMono_ThinItalic63pt7b.h"
#include "JetBrainsMono_ThinItalic64pt7b.h"
#include "JetBrainsMono_ThinItalic65pt7b.h"
#include "JetBrainsMono_ThinItalic66pt7b.h"
#include "JetBrainsMono_ThinItalic67pt7b.h"
#include "JetBrainsMono_ThinItalic68pt7b.h"
#include "JetBrainsMono_ThinItalic69pt7b.h"
#include "JetBrainsMono_ThinItalic70pt7b.h"
#include "JetBrainsMono_ThinItalic71pt7b.h"
#include "JetBrainsMono_ThinItalic72pt7b.h"
