#ifndef _JETBRAINSMONO_THINITALIC60PT7B_H_
#define _JETBRAINSMONO_THINITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07,
  0xE0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0,
  0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07,
  0x1C, 0x01, 0xCF, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x20, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x04, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFE, 0xDF, 0xC0, 0x03, 0xE1, 0x87, 0xC0,
  0x0F, 0x03, 0x07, 0x80, 0x1C, 0x06, 0x07, 0x80, 0x70, 0x1C, 0x07, 0x00,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E,
  0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0x8F, 0x80, 0x00, 0x07, 0x0F,
  0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x30, 0x1E,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x01, 0xC1, 0xC0, 0x18, 0x03, 0x83,
  0x80, 0x30, 0x0E, 0x07, 0x00, 0x60, 0x1C, 0x0F, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0x80, 0xE0, 0x1E, 0x07, 0x03, 0x80, 0x1E, 0x0C, 0x1E, 0x00, 0x1F,
  0x99, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00,
  0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x7D, 0xF8, 0x00, 0x1C, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x03, 0x80, 0x38, 0x07, 0x00, 0x03, 0x00, 0x38, 0x0E,
  0x00, 0x03, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x00, 0x30, 0x38, 0x00, 0x07, 0x00, 0x70, 0x70, 0x00, 0x07, 0x00, 0x70,
  0xE0, 0x00, 0x03, 0x80, 0xE1, 0xC0, 0x00, 0x03, 0xFF, 0xC3, 0x80, 0x00,
  0x01, 0xFF, 0x87, 0x00, 0x00, 0x00, 0x7E, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x7C, 0x00, 0x00,
  0x01, 0xC1, 0xFF, 0x00, 0x00, 0x01, 0xC3, 0xFF, 0x80, 0x00, 0x03, 0x87,
  0x03, 0xC0, 0x00, 0x07, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0x00, 0x70,
  0x1C, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x18, 0x01,
  0xC0, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x00, 0x1E, 0x1E, 0x00,
  0x70, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x1E, 0x07, 0x80, 0x0E, 0x1C, 0x03,
  0xC0, 0x1C, 0x3C, 0x01, 0xC0, 0x38, 0x38, 0x01, 0xE0, 0x38, 0x38, 0x00,
  0xE0, 0x70, 0x38, 0x00, 0xF0, 0xE0, 0x38, 0x00, 0x78, 0xE0, 0x70, 0x00,
  0x39, 0xC0, 0x70, 0x00, 0x3F, 0x80, 0x70, 0x00, 0x1F, 0x80, 0x70, 0x00,
  0x1F, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x70, 0x00,
  0x1F, 0x80, 0x70, 0x00, 0x3B, 0x80, 0x70, 0x00, 0x73, 0xC0, 0x70, 0x01,
  0xE1, 0xC0, 0x78, 0x03, 0xC0, 0xE0, 0x3E, 0x0F, 0x80, 0xF0, 0x3F, 0xFF,
  0x00, 0x70, 0x0F, 0xFC, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0x3C, 0xF3,
  0xCF, 0x3D, 0xE7, 0x9E, 0x79, 0xE7, 0x9C, 0x73, 0xCF, 0x3C, 0xE3, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x77, 0xE0, 0x1C, 0x07, 0xEF, 0xF8, 0x38,
  0x7F, 0xE7, 0xFC, 0x63, 0xFF, 0x01, 0xFE, 0xDF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x03,
  0xC0, 0x01, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x02, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0x0F, 0xE7, 0xF9, 0xFE, 0x7F, 0xBF, 0xE7, 0xF1, 0xFC,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x3C, 0x38, 0x0F, 0x01, 0xE1, 0xC0, 0xFC, 0x0F, 0x1E, 0x07, 0xE0,
  0x70, 0xF0, 0x3F, 0x03, 0x87, 0x01, 0xF8, 0x1C, 0x38, 0x07, 0x80, 0xE1,
  0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x78, 0x07, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0x3F,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x1F, 0x07,
  0x00, 0x07, 0x80, 0xE0, 0x03, 0xE0, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0C,
  0x00, 0xE0, 0x01, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x10, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x01, 0xC0,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x1C,
  0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x73, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x7E, 0x00, 0x07, 0x1F, 0xFE, 0x00, 0x39, 0xFF, 0xF8, 0x03, 0x9C, 0x07,
  0xE0, 0x1D, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0,
  0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x10, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x78, 0x07, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x00, 0xFC, 0x0F, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x3F, 0xE0, 0x01, 0xDF, 0xFF, 0x00, 0x7F, 0x83, 0xF0, 0x1F,
  0x80, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x70, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0x3E, 0x00, 0x78, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x70, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x0E, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x03, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF9, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x00,
  0x78, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1E,
  0x78, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x0F, 0x00,
  0x1F, 0x81, 0xF8, 0x0E, 0xE0, 0x1F, 0xFF, 0xB8, 0x00, 0xFF, 0xCE, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x01, 0xFC,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x04, 0x00,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x3F, 0x87, 0x07, 0x00, 0x3F, 0xFB, 0x83, 0x80, 0x1F, 0xFE, 0xE0,
  0xE0, 0x0F, 0x00, 0xF8, 0x38, 0x03, 0x80, 0x1E, 0x0E, 0x01, 0xC0, 0x07,
  0x83, 0x80, 0x70, 0x01, 0xE0, 0xE0, 0x3C, 0x00, 0x70, 0x70, 0x0E, 0x00,
  0x1C, 0x1C, 0x03, 0x80, 0x07, 0x07, 0x00, 0xE0, 0x01, 0xC1, 0xC0, 0x38,
  0x00, 0x70, 0x70, 0x0E, 0x00, 0x1C, 0x1C, 0x07, 0x80, 0x0F, 0x07, 0x01,
  0xC0, 0x03, 0x83, 0x80, 0x70, 0x00, 0xE0, 0xE0, 0x1C, 0x00, 0x38, 0x38,
  0x07, 0x00, 0x0E, 0x0E, 0x01, 0xC0, 0x07, 0x83, 0x80, 0x70, 0x01, 0xE0,
  0xE0, 0x1C, 0x00, 0xF0, 0x70, 0x07, 0x80, 0x6C, 0x1C, 0x00, 0xF0, 0x3F,
  0x07, 0x00, 0x3F, 0xFD, 0xC1, 0xC0, 0x07, 0xFC, 0x70, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0x30,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x38, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x01, 0x80, 0x01, 0xC0, 0x18, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0,
  0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0x00,
  0x0F, 0xC0, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x3E, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0x80,
  0x03, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0x87, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x78, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70,
  0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x1F, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0x00,
  0x1F, 0x00, 0x38, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x1F, 0x00,
  0xE0, 0x03, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xF8, 0x38,
  0x07, 0xFF, 0xC1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x78,
  0x00, 0xF8, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xE0,
  0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x07, 0x00, 0x07, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xB0, 0x00, 0x36,
  0x03, 0xB0, 0x00, 0x6E, 0x03, 0xB0, 0x00, 0xEE, 0x03, 0xB8, 0x00, 0xCE,
  0x03, 0x38, 0x01, 0xCE, 0x03, 0x18, 0x01, 0x8C, 0x07, 0x18, 0x03, 0x9C,
  0x07, 0x18, 0x03, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x06, 0x1C,
  0x07, 0x0C, 0x0E, 0x1C, 0x06, 0x0C, 0x0C, 0x1C, 0x0E, 0x0C, 0x1C, 0x38,
  0x0E, 0x0E, 0x18, 0x38, 0x0E, 0x0E, 0x38, 0x38, 0x0E, 0x06, 0x30, 0x38,
  0x0E, 0x06, 0x70, 0x38, 0x0E, 0x06, 0x60, 0x38, 0x1C, 0x07, 0xE0, 0x70,
  0x1C, 0x07, 0xC0, 0x70, 0x1C, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0x70,
  0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x70,
  0x1E, 0x00, 0x03, 0x80, 0xFC, 0x00, 0x0E, 0x03, 0xF0, 0x00, 0x38, 0x0E,
  0xC0, 0x00, 0xE0, 0x3B, 0x00, 0x03, 0x80, 0xEE, 0x00, 0x0E, 0x03, 0x38,
  0x00, 0x30, 0x1C, 0x60, 0x01, 0xC0, 0x71, 0x80, 0x07, 0x01, 0xC7, 0x00,
  0x1C, 0x07, 0x1C, 0x00, 0x70, 0x1C, 0x70, 0x01, 0xC0, 0x70, 0xC0, 0x06,
  0x03, 0x83, 0x80, 0x38, 0x0E, 0x0E, 0x00, 0xE0, 0x38, 0x38, 0x03, 0x80,
  0xE0, 0x60, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0x30,
  0x1C, 0x07, 0x01, 0xC0, 0x30, 0x1C, 0x07, 0x00, 0xE0, 0x70, 0x1C, 0x03,
  0x81, 0xC0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x18, 0x1C, 0x06, 0x00, 0x60,
  0xE0, 0x38, 0x01, 0xC3, 0x80, 0xE0, 0x07, 0x0E, 0x03, 0x80, 0x1C, 0x38,
  0x0E, 0x00, 0x30, 0xE0, 0x38, 0x00, 0xE3, 0x80, 0xE0, 0x03, 0x8C, 0x07,
  0x00, 0x0E, 0x70, 0x1C, 0x00, 0x19, 0xC0, 0x70, 0x00, 0x77, 0x01, 0xC0,
  0x01, 0xDC, 0x07, 0x00, 0x07, 0x70, 0x1C, 0x00, 0x0D, 0x80, 0xE0, 0x00,
  0x3E, 0x03, 0x80, 0x00, 0xF8, 0x0E, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0F, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xF0, 0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C,
  0x01, 0xC0, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x80,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x1F, 0x80, 0x38,
  0x00, 0x0F, 0x80, 0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1F,
  0x00, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x70, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x1E,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38,
  0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38,
  0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xF0, 0x0F,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03,
  0x80, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01,
  0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x30, 0x01, 0xE0, 0x03,
  0x98, 0x00, 0xF0, 0x01, 0xCC, 0x00, 0x78, 0x01, 0xC6, 0x00, 0x7C, 0x00,
  0xE3, 0x00, 0x3E, 0x00, 0x71, 0x80, 0x1B, 0x00, 0x31, 0xC0, 0x0D, 0x80,
  0x38, 0xE0, 0x0E, 0xC0, 0x1C, 0x70, 0x06, 0x60, 0x0E, 0x38, 0x03, 0x30,
  0x0E, 0x1C, 0x03, 0x98, 0x07, 0x0E, 0x01, 0x8C, 0x03, 0x87, 0x00, 0xC6,
  0x01, 0x83, 0x80, 0xE3, 0x01, 0xC1, 0xC0, 0x71, 0x80, 0xE0, 0xE0, 0x30,
  0xC0, 0x70, 0x70, 0x18, 0x60, 0x30, 0x38, 0x1C, 0x30, 0x38, 0x1C, 0x0C,
  0x18, 0x1C, 0x0E, 0x06, 0x0C, 0x0C, 0x07, 0x07, 0x06, 0x0E, 0x03, 0x83,
  0x03, 0x07, 0x01, 0xC1, 0x81, 0x83, 0x80, 0xE1, 0xC0, 0xC1, 0x80, 0x70,
  0xC0, 0x61, 0xC0, 0x38, 0x60, 0x30, 0xE0, 0x18, 0x30, 0x18, 0x60, 0x0C,
  0x30, 0x0C, 0x70, 0x06, 0x18, 0x0E, 0x38, 0x03, 0x0C, 0x07, 0x1C, 0x01,
  0x8E, 0x03, 0x8C, 0x00, 0xC6, 0x01, 0xCE, 0x00, 0x63, 0x00, 0xE7, 0x00,
  0x33, 0x80, 0x73, 0x00, 0x39, 0x80, 0x39, 0x80, 0x1C, 0xC0, 0x1D, 0xC0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x03, 0xB0, 0x03, 0x70,
  0x01, 0xD8, 0x01, 0xB8, 0x00, 0xF8, 0x00, 0xDC, 0x00, 0x7C, 0x00, 0x6C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x1C,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x78, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x38, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x1E, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0x70, 0x38, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFE, 0x1C, 0x03,
  0xFF, 0xE3, 0x80, 0xF8, 0x1E, 0x70, 0x3C, 0x00, 0xFC, 0x0E, 0x00, 0x0F,
  0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x07, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x3F,
  0x01, 0xF0, 0x1E, 0xE0, 0x1F, 0xFF, 0x1C, 0x00, 0xFF, 0xC3, 0x80, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0x87, 0xFE, 0x00, 0x71, 0xFF, 0xF0, 0x0E,
  0xF0, 0x1F, 0x01, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0x1E, 0x0F, 0x80, 0x01,
  0xC1, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x1C, 0x3C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x1E,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0xE0, 0xFE, 0x00, 0x78, 0x1C, 0xF0, 0x3E,
  0x03, 0x8F, 0xFF, 0x80, 0x70, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x3E, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x7F, 0xE1, 0xC0, 0x0F, 0xFF, 0x8E, 0x00, 0xF8, 0x1E,
  0x70, 0x0F, 0x00, 0x3F, 0x00, 0xE0, 0x00, 0xF8, 0x0E, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0xFC, 0x01, 0xF0, 0x1E, 0xE0, 0x07, 0xFF, 0xC7, 0x00, 0x0F, 0xFC,
  0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0xFC, 0x03, 0xC0, 0x0F, 0x01, 0xC0,
  0x01, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x7F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x78, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x0F, 0x00, 0xFC,
  0x0F, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x07, 0xFE, 0x1C, 0x03, 0xFF, 0xE3, 0x80, 0xF8, 0x1E, 0x70,
  0x3C, 0x00, 0xFC, 0x0E, 0x00, 0x0F, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00,
  0x1E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x1C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x77, 0x01, 0xF0, 0x3C, 0xE0,
  0x1F, 0xFF, 0x3C, 0x01, 0xFF, 0x87, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x87, 0xFE, 0x00, 0x71,
  0xFF, 0xF0, 0x0E, 0xF0, 0x3F, 0x01, 0xF8, 0x01, 0xE0, 0x76, 0x00, 0x1E,
  0x0F, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x87, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x0F,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x01, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0x04, 0x00, 0x60, 0x0E, 0x7F, 0x07, 0xF0, 0x1D, 0xFF, 0x1F,
  0xF0, 0x3E, 0x0F, 0x61, 0xE0, 0x68, 0x1E, 0x81, 0xE0, 0xE0, 0x1E, 0x01,
  0xC3, 0xC0, 0x38, 0x03, 0x87, 0x00, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0x0E,
  0x1C, 0x01, 0xC0, 0x18, 0x38, 0x03, 0x80, 0x70, 0x70, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x03, 0x87, 0x00, 0x70, 0x07, 0x0E,
  0x00, 0xE0, 0x0E, 0x1C, 0x01, 0xC0, 0x38, 0x38, 0x03, 0x00, 0x70, 0x70,
  0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x03, 0x87, 0x00,
  0x70, 0x07, 0x0E, 0x00, 0xE0, 0x1C, 0x1C, 0x01, 0x80, 0x38, 0x38, 0x07,
  0x00, 0x70, 0xE0, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x01, 0xC3, 0x80, 0x38,
  0x03, 0x87, 0x00, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0x1C, 0x1C, 0x03, 0x80,
  0x38, 0x70, 0x07, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0xE1, 0xFF, 0x80, 0x1C, 0x7F, 0xFC, 0x03,
  0xBC, 0x0F, 0xC0, 0x76, 0x00, 0x78, 0x1D, 0x80, 0x07, 0x83, 0xE0, 0x00,
  0x70, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x38,
  0x00, 0x07, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xC0, 0xFC, 0x03, 0xC0, 0x0F,
  0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x0F,
  0x00, 0xFC, 0x0F, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x1F, 0xF8, 0x00, 0x73, 0xFF,
  0xF0, 0x03, 0xBC, 0x07, 0xC0, 0x1F, 0x80, 0x1E, 0x01, 0xF8, 0x00, 0x78,
  0x0F, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x3C, 0x1C,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x0F,
  0x80, 0x03, 0x80, 0xFE, 0x00, 0x78, 0x07, 0x3C, 0x0F, 0x80, 0x38, 0xFF,
  0xF8, 0x01, 0xC3, 0xFF, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x07, 0xFE, 0x1C, 0x03, 0xFF, 0xE3, 0x80, 0xF8, 0x1E, 0x70,
  0x3C, 0x00, 0xFC, 0x0E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x70, 0x00,
  0x1E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x3F, 0x01, 0xF0, 0x1E, 0xE0, 0x1F, 0xFF,
  0x1C, 0x00, 0xFF, 0xC3, 0x80, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70, 0xFF,
  0xE0, 0x07, 0x3F, 0xFF, 0x00, 0x77, 0x80, 0xF8, 0x07, 0xE0, 0x07, 0xC0,
  0xFC, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x1E, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x0F,
  0xC0, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0x80,
  0x38, 0x00, 0x30, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0xEC, 0x00, 0xF0, 0x03, 0xB0, 0x03, 0xC0, 0x0C, 0xC0, 0x1F, 0x00, 0x73,
  0x00, 0x6C, 0x01, 0xCC, 0x01, 0xB0, 0x06, 0x30, 0x0E, 0xC0, 0x38, 0xC0,
  0x33, 0x00, 0xE3, 0x00, 0xCC, 0x03, 0x0C, 0x07, 0x30, 0x1C, 0x30, 0x18,
  0xC0, 0x70, 0xC0, 0x63, 0x81, 0x83, 0x03, 0x8E, 0x0E, 0x0C, 0x0C, 0x38,
  0x38, 0x30, 0x30, 0xE0, 0xC0, 0xC1, 0xC3, 0x87, 0x03, 0x06, 0x0E, 0x1C,
  0x0C, 0x38, 0x38, 0x60, 0x30, 0xE0, 0x63, 0x80, 0xC3, 0x01, 0x8E, 0x03,
  0x1C, 0x06, 0x38, 0x0C, 0x70, 0x19, 0xC0, 0x39, 0x80, 0x67, 0x00, 0xEE,
  0x01, 0x9C, 0x03, 0xB0, 0x06, 0xE0, 0x0C, 0xC0, 0x1B, 0x80, 0x37, 0x00,
  0x6E, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x38, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x83, 0x80,
  0x00, 0xF0, 0x70, 0x00, 0x3E, 0x0F, 0x00, 0x0D, 0xC0, 0xF0, 0x03, 0x70,
  0x1F, 0x81, 0xEE, 0x01, 0xFF, 0xF1, 0xC0, 0x0F, 0xFC, 0x38, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x61, 0xFE,
  0x00, 0x0C, 0x7F, 0xE0, 0x03, 0x9C, 0x1E, 0x00, 0x77, 0x01, 0xE0, 0x0E,
  0xE0, 0x1C, 0x01, 0xDC, 0x01, 0xC0, 0x33, 0x00, 0x3C, 0x0E, 0xE0, 0x03,
  0xC3, 0x9C, 0x00, 0x3F, 0xF3, 0x80, 0x03, 0xF8, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 12, 44, 36, 12, -44 },
  { 67, 18, 18, 36, 12, -44 },
  { 108, 35, 44, 36, 1, -44 },
  { 301, 31, 60, 36, 3, -52 },
  { 534, 40, 44, 36, -1, -44 },
  { 754, 32, 45, 36, 2, -44 },
  { 934, 6, 18, 36, 18, -44 },
  { 948, 24, 59, 36, 11, -51 },
  { 1125, 23, 59, 36, 3, -51 },
  { 1295, 31, 31, 36, 4, -37 },
  { 1416, 27, 28, 36, 5, -34 },
  { 1511, 13, 19, 36, 7, -9 },
  { 1542, 19, 3, 36, 9, -21 },
  { 1550, 10, 9, 36, 11, -8 },
  { 1562, 34, 57, 36, 2, -50 },
  { 1805, 29, 45, 36, 4, -44 },
  { 1969, 27, 44, 36, 3, -44 },
  { 2118, 31, 44, 36, 3, -44 },
  { 2289, 29, 45, 36, 4, -44 },
  { 2453, 26, 44, 36, 5, -44 },
  { 2596, 29, 45, 36, 4, -44 },
  { 2760, 27, 45, 36, 4, -44 },
  { 2912, 29, 44, 36, 7, -44 },
  { 3072, 29, 45, 36, 4, -44 },
  { 3236, 27, 44, 36, 7, -44 },
  { 3385, 14, 35, 36, 11, -34 },
  { 3447, 18, 44, 36, 7, -34 },
  { 3546, 27, 30, 36, 6, -35 },
  { 3648, 27, 16, 36, 5, -28 },
  { 3702, 27, 30, 36, 4, -35 },
  { 3804, 23, 44, 36, 10, -44 },
  { 3931, 34, 55, 36, 1, -44 },
  { 4165, 28, 44, 36, 1, -44 },
  { 4319, 29, 44, 36, 4, -44 },
  { 4479, 29, 45, 36, 5, -44 },
  { 4643, 29, 44, 36, 4, -44 },
  { 4803, 30, 44, 36, 5, -44 },
  { 4968, 32, 44, 36, 4, -44 },
  { 5144, 29, 45, 36, 5, -44 },
  { 5308, 30, 44, 36, 4, -44 },
  { 5473, 28, 44, 36, 5, -44 },
  { 5627, 30, 45, 36, 3, -44 },
  { 5796, 32, 44, 36, 4, -44 },
  { 5972, 24, 44, 36, 5, -44 },
  { 6104, 32, 44, 36, 3, -44 },
  { 6280, 30, 44, 36, 4, -44 },
  { 6445, 28, 45, 36, 5, -44 },
  { 6603, 31, 44, 36, 4, -44 },
  { 6774, 28, 55, 36, 5, -44 },
  { 6967, 31, 44, 36, 4, -44 },
  { 7138, 31, 45, 36, 3, -44 },
  { 7313, 30, 44, 36, 7, -44 },
  { 7478, 29, 45, 36, 5, -44 },
  { 7642, 28, 44, 36, 8, -44 },
  { 7796, 33, 44, 36, 5, -44 },
  { 7978, 35, 44, 36, 1, -44 },
  { 8171, 30, 44, 36, 7, -44 },
  { 8336, 31, 44, 36, 3, -44 },
  { 8507, 22, 57, 36, 10, -50 },
  { 8664, 16, 57, 36, 11, -50 },
  { 8778, 22, 57, 36, 6, -50 },
  { 8935, 24, 24, 36, 7, -44 },
  { 9007, 30, 3, 36, 0, 1 },
  { 9019, 9, 8, 36, 17, -47 },
  { 9028, 27, 35, 36, 5, -34 },
  { 9147, 27, 45, 36, 4, -44 },
  { 9299, 27, 35, 36, 5, -34 },
  { 9418, 29, 45, 36, 5, -44 },
  { 9582, 26, 35, 36, 5, -34 },
  { 9696, 38, 55, 36, -2, -44 },
  { 9958, 27, 45, 36, 5, -34 },
  { 10110, 27, 44, 36, 4, -44 },
  { 10259, 27, 46, 36, 3, -46 },
  { 10415, 30, 57, 36, 1, -46 },
  { 10629, 30, 44, 36, 4, -44 },
  { 10794, 23, 44, 36, 7, -44 },
  { 10921, 31, 34, 36, 2, -34 },
  { 11053, 27, 34, 36, 4, -34 },
  { 11168, 26, 35, 36, 5, -34 },
  { 11282, 29, 45, 36, 2, -34 },
  { 11446, 27, 45, 36, 5, -34 },
  { 11598, 28, 34, 36, 5, -34 },
  { 11717, 28, 35, 36, 4, -34 },
  { 11840, 27, 42, 36, 6, -42 },
  { 11982, 27, 34, 36, 5, -33 },
  { 12097, 27, 33, 36, 7, -33 },
  { 12209, 30, 33, 36, 6, -33 },
  { 12333, 31, 33, 36, 2, -33 },
  { 12461, 27, 44, 36, 5, -33 },
  { 12610, 28, 33, 36, 4, -33 },
  { 12726, 28, 57, 36, 7, -50 },
  { 12926, 12, 57, 36, 13, -50 },
  { 13012, 29, 57, 36, 2, -50 },
  { 13219, 27, 11, 36, 5, -27 },
};

const GFXfont JetBrainsMono_ThinItalic60pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic60pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _JETBRAINSMONO_THINITALIC60PT7B_H_
