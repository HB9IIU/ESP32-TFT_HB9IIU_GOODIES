#ifndef _JETBRAINSMONO_THINITALIC7PT7B_H_
#define _JETBRAINSMONO_THINITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x80, 0xB4, 0x37, 0x6F, 0xA0, 0x27, 0x62, 0x3E, 0x40, 0xFD,
  0x18, 0xAB, 0x00, 0x74, 0xDA, 0xF0, 0xC0, 0x2A, 0x49, 0x10, 0x44, 0x92,
  0x70, 0x2F, 0x60, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x11, 0x22, 0x44, 0x80,
  0x75, 0xB9, 0xE0, 0x64, 0x9E, 0x71, 0x16, 0xE0, 0x72, 0x11, 0xE0, 0x6A,
  0xF4, 0xFA, 0x9C, 0x24, 0x79, 0xE0, 0xE5, 0x28, 0x75, 0x69, 0xE0, 0xF6,
  0xA8, 0x42, 0x42, 0x80, 0x71, 0x00, 0xFC, 0x43, 0xE0, 0x65, 0x48, 0x7B,
  0xDD, 0xBC, 0x2D, 0xBA, 0x75, 0x69, 0xE0, 0xF2, 0x4C, 0x75, 0x59, 0xE0,
  0xF3, 0x4C, 0x74, 0x78, 0x80, 0xF3, 0x5C, 0x55, 0x79, 0x90, 0xE9, 0x2C,
  0x31, 0x11, 0xE0, 0x56, 0x6A, 0x90, 0xAA, 0xC0, 0x55, 0xB9, 0x90, 0x55,
  0x5A, 0xA0, 0xF6, 0xDC, 0x75, 0x68, 0x80, 0xF6, 0xDC, 0x80, 0x75, 0x6A,
  0x90, 0x74, 0x21, 0xE0, 0xE9, 0x28, 0xB6, 0xDC, 0xB7, 0x68, 0xFE, 0xEC,
  0x56, 0x26, 0x90, 0xB5, 0x28, 0x72, 0x24, 0xE0, 0x6A, 0x49, 0x30, 0xA9,
  0x54, 0x55, 0x58, 0x56, 0x80, 0xE0, 0x80, 0xF6, 0xE0, 0x47, 0x59, 0xE0,
  0xF2, 0x60, 0x3E, 0xDC, 0xFE, 0x60, 0x33, 0x44, 0x4C, 0xF6, 0xEC, 0x47,
  0x59, 0x90, 0x2C, 0x9E, 0x17, 0x22, 0x2E, 0x45, 0x6A, 0xA0, 0xD2, 0x4E,
  0xFB, 0xBD, 0x75, 0x99, 0xF6, 0xE0, 0x75, 0x9E, 0x80, 0xF6, 0xE4, 0xF6,
  0x40, 0x74, 0x3F, 0x5E, 0x4C, 0xB6, 0xE0, 0xB7, 0x40, 0xFF, 0x60, 0x52,
  0x6A, 0xB6, 0xEC, 0x72, 0x4E, 0x29, 0x44, 0x90, 0x55, 0x68, 0x42, 0x23,
  0x44, 0x80, 0xE0,
};

const GFXglyph JetBrainsMono_ThinItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 3, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 5, 5, 4, 0, -5 },
  { 15, 4, 5, 4, 0, -5 },
  { 18, 1, 2, 4, 2, -5 },
  { 19, 3, 7, 4, 1, -6 },
  { 22, 3, 7, 4, 0, -6 },
  { 25, 4, 3, 4, 0, -4 },
  { 27, 3, 3, 4, 1, -4 },
  { 29, 1, 2, 4, 1, -1 },
  { 30, 2, 1, 4, 1, -3 },
  { 31, 1, 1, 4, 1, -1 },
  { 32, 4, 7, 4, 0, -6 },
  { 36, 4, 5, 4, 0, -5 },
  { 39, 3, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 3, 5, 4, 1, -5 },
  { 49, 3, 5, 4, 1, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 3, 5, 4, 1, -5 },
  { 56, 4, 5, 4, 0, -5 },
  { 59, 3, 5, 4, 1, -5 },
  { 61, 2, 4, 4, 1, -4 },
  { 62, 2, 5, 4, 1, -4 },
  { 64, 3, 3, 4, 1, -4 },
  { 66, 3, 2, 4, 1, -3 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 3, 5, 4, 1, -5 },
  { 71, 4, 6, 4, 0, -5 },
  { 74, 3, 5, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 3, 5, 4, 1, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 3, 5, 4, 1, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 3, 5, 4, 1, -5 },
  { 91, 4, 5, 4, 0, -5 },
  { 94, 3, 5, 4, 1, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 2, 5, 4, 1, -5 },
  { 104, 4, 5, 4, 0, -5 },
  { 107, 4, 5, 4, 0, -5 },
  { 110, 3, 5, 4, 1, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 3, 6, 4, 1, -5 },
  { 118, 4, 5, 4, 0, -5 },
  { 121, 4, 5, 4, 0, -5 },
  { 124, 3, 5, 4, 1, -5 },
  { 126, 3, 5, 4, 1, -5 },
  { 128, 3, 5, 4, 1, -5 },
  { 130, 3, 5, 4, 1, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 3, 5, 4, 1, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 3, 7, 4, 1, -6 },
  { 143, 2, 7, 4, 1, -6 },
  { 145, 2, 7, 4, 1, -6 },
  { 147, 3, 3, 4, 1, -5 },
  { 149, 3, 1, 4, 0, 0 },
  { 150, 1, 1, 4, 2, -6 },
  { 151, 3, 4, 4, 1, -4 },
  { 153, 4, 5, 4, 0, -5 },
  { 156, 3, 4, 4, 1, -4 },
  { 158, 3, 5, 4, 1, -5 },
  { 160, 3, 4, 4, 1, -4 },
  { 162, 4, 6, 4, 0, -5 },
  { 165, 3, 5, 4, 1, -4 },
  { 167, 4, 5, 4, 0, -5 },
  { 170, 3, 5, 4, 0, -5 },
  { 172, 4, 6, 4, 0, -5 },
  { 175, 4, 5, 4, 0, -5 },
  { 178, 3, 5, 4, 1, -5 },
  { 180, 4, 4, 4, 0, -4 },
  { 182, 4, 4, 4, 0, -4 },
  { 184, 3, 4, 4, 1, -4 },
  { 186, 4, 5, 4, 0, -4 },
  { 189, 3, 5, 4, 1, -4 },
  { 191, 3, 4, 4, 1, -4 },
  { 193, 4, 4, 4, 0, -4 },
  { 195, 3, 5, 4, 1, -5 },
  { 197, 3, 4, 4, 1, -4 },
  { 199, 3, 4, 4, 1, -4 },
  { 201, 3, 4, 4, 1, -4 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 3, 5, 4, 1, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 3, 7, 4, 1, -6 },
  { 212, 2, 7, 4, 1, -6 },
  { 214, 4, 7, 4, 0, -6 },
  { 218, 3, 1, 4, 1, -3 },
};

const GFXfont JetBrainsMono_ThinItalic7pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic7pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _JETBRAINSMONO_THINITALIC7PT7B_H_
