#ifndef _JETBRAINSMONO_THINITALIC57PT7B_H_
#define _JETBRAINSMONO_THINITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x0F, 0x00, 0x1C,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01,
  0xE3, 0x80, 0x78, 0xE0, 0x1E, 0x78, 0x07, 0x1E, 0x01, 0xC7, 0x80, 0x71,
  0xC0, 0x1C, 0x70, 0x0F, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0xE0,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFB, 0xF0,
  0x00, 0xF0, 0xC3, 0xC0, 0x0F, 0x06, 0x0F, 0x00, 0xE0, 0x30, 0x38, 0x07,
  0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x06,
  0x01, 0x81, 0xC0, 0x30, 0x1C, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03,
  0xC1, 0x80, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x63, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x18, 0x07, 0x0E, 0x01, 0xC0, 0x38, 0x70, 0x0E, 0x03,
  0x83, 0x80, 0x60, 0x1C, 0x1C, 0x03, 0x00, 0xE0, 0xE0, 0x18, 0x0E, 0x07,
  0x80, 0xC0, 0x70, 0x1C, 0x0E, 0x07, 0x00, 0xF8, 0x70, 0xF0, 0x03, 0xF3,
  0x1F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x01, 0xFF, 0x80, 0x00,
  0xE0, 0x0F, 0xFF, 0x00, 0x03, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x01, 0xC0,
  0x30, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x03, 0x00, 0x38,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x01,
  0xC0, 0x30, 0x00, 0x70, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x1C, 0x0E, 0x00,
  0x07, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x01, 0x83, 0x80, 0x00, 0x70, 0x0E,
  0x1C, 0x00, 0x01, 0xC0, 0x70, 0xE0, 0x00, 0x03, 0xC3, 0x83, 0x00, 0x00,
  0x07, 0xFC, 0x18, 0x00, 0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3E, 0x00, 0x00, 0x01, 0x83,
  0xFE, 0x00, 0x00, 0x0E, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0xE0, 0x70, 0x00,
  0x03, 0x87, 0x00, 0xE0, 0x00, 0x1C, 0x18, 0x03, 0x80, 0x00, 0xE0, 0xE0,
  0x0E, 0x00, 0x07, 0x03, 0x80, 0x38, 0x00, 0x18, 0x0E, 0x00, 0xC0, 0x00,
  0xE0, 0x30, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x0C, 0x00, 0x38, 0x03, 0x00,
  0x70, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x0F, 0x0F,
  0x00, 0x70, 0x00, 0x1F, 0xF8, 0x03, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x71, 0xC0, 0x70,
  0x03, 0x87, 0x01, 0xE0, 0x0E, 0x38, 0x03, 0x80, 0x70, 0xE0, 0x0F, 0x03,
  0x83, 0x00, 0x1C, 0x0C, 0x1C, 0x00, 0x38, 0x70, 0x70, 0x00, 0xF3, 0x81,
  0xC0, 0x01, 0xDC, 0x07, 0x00, 0x07, 0xF0, 0x1C, 0x00, 0x0F, 0x80, 0x70,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x03, 0xE0, 0x38, 0x00,
  0x1F, 0xC0, 0xF0, 0x00, 0xE7, 0x01, 0xC0, 0x07, 0x0E, 0x07, 0x80, 0x78,
  0x38, 0x1F, 0x07, 0xC0, 0x70, 0x3F, 0xFE, 0x00, 0xE0, 0x7F, 0xE0, 0x03,
  0x80, 0x30, 0x00, 0x00, 0x00, 0x3C, 0xF3, 0xCF, 0x39, 0xE7, 0x9E, 0x79,
  0xE7, 0x1C, 0x73, 0xCF, 0x38, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x38, 0x00, 0xBE, 0x01, 0xC0, 0x3F, 0xFE, 0x0E, 0x0F,
  0xF7, 0xFC, 0x63, 0xFE, 0x07, 0xFB, 0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x78, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1E, 0x3F, 0x9F, 0xDF, 0xEF, 0xF7, 0xFB, 0xF8, 0xFC, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x3C, 0x07,
  0x01, 0xC3, 0x80, 0xF8, 0x1C, 0x38, 0x1F, 0x81, 0xC3, 0x81, 0xF8, 0x3C,
  0x38, 0x0F, 0x83, 0x83, 0x80, 0x70, 0x38, 0x38, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xF7, 0x00, 0x01, 0xF3, 0x80, 0x01, 0xE1, 0xC0, 0x03, 0xE0, 0xC0,
  0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0x80, 0x38, 0x00, 0x80, 0x1C,
  0x00, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xC3,
  0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x01, 0xF0,
  0x1F, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x78, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x30, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0xFF, 0x80, 0x0E, 0x7F, 0xFC, 0x01, 0xDF,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x06, 0xC0, 0x07, 0x81, 0xF0, 0x00, 0x70,
  0x3C, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x10, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x3C,
  0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC7, 0xF0, 0x01,
  0xCF, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0xF8, 0x01, 0xE0, 0xF8, 0x00, 0x78,
  0x78, 0x00, 0x1C, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xB8, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x03, 0xB8, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0xC0,
  0x01, 0xC0, 0xF0, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x1E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x1E,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0x78, 0x03, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xCF, 0xE0, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x03, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x1D, 0x80, 0x3F, 0xFE, 0xE0, 0x07, 0xFE,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0xF0,
  0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x10, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x1C, 0x00, 0x7F, 0xCE,
  0x0E, 0x00, 0xFF, 0xF7, 0x07, 0x00, 0x78, 0x1B, 0x03, 0x80, 0x70, 0x05,
  0x81, 0xC0, 0x78, 0x01, 0xC0, 0xC0, 0x38, 0x00, 0xE0, 0xE0, 0x1C, 0x00,
  0x70, 0x70, 0x0C, 0x00, 0x38, 0x38, 0x0E, 0x00, 0x1C, 0x1C, 0x07, 0x00,
  0x1C, 0x0E, 0x03, 0x80, 0x0E, 0x06, 0x01, 0xC0, 0x07, 0x07, 0x00, 0xE0,
  0x03, 0x83, 0x80, 0x60, 0x01, 0xC1, 0xC0, 0x70, 0x00, 0xE0, 0xE0, 0x38,
  0x00, 0xE0, 0x70, 0x1C, 0x00, 0x70, 0x38, 0x0E, 0x00, 0x38, 0x18, 0x07,
  0x00, 0x3C, 0x1C, 0x03, 0xC0, 0x1E, 0x0E, 0x00, 0xF0, 0x37, 0x07, 0x00,
  0x7F, 0xFB, 0x03, 0x80, 0x1F, 0xF1, 0x81, 0xC0, 0x03, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x1C, 0x01,
  0x80, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x18, 0x00, 0x70, 0x07, 0x00, 0x0E,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xC0,
  0x00, 0x60, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x33, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1C, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x38, 0x00, 0xF8, 0x03, 0x80, 0x03, 0xC0, 0x30, 0x00, 0x1C,
  0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x3E, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x3E, 0x01,
  0xC0, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38,
  0x30, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x38, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x00,
  0xF8, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x06,
  0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x07,
  0x81, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xF9, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x38, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x03, 0xFF, 0xE3, 0x80,
  0x7F, 0xF8, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0x86, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0xF0, 0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x03, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x02, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0x1C, 0x00,
  0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xF0, 0x0C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0xF0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x38, 0x03, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x0E,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0,
  0x3E, 0x00, 0x07, 0xC0, 0xD8, 0x00, 0x37, 0x03, 0x60, 0x00, 0xD8, 0x0D,
  0xC0, 0x06, 0x60, 0x73, 0x00, 0x1B, 0x81, 0xCC, 0x00, 0xCE, 0x07, 0x30,
  0x07, 0x38, 0x1C, 0xC0, 0x18, 0xE0, 0x63, 0x80, 0xE3, 0x01, 0x86, 0x03,
  0x0C, 0x0E, 0x18, 0x1C, 0x70, 0x38, 0x60, 0x61, 0xC0, 0xE1, 0x83, 0x87,
  0x03, 0x87, 0x0C, 0x1C, 0x0E, 0x0C, 0x70, 0x70, 0x30, 0x31, 0x81, 0x81,
  0xC0, 0xCE, 0x0E, 0x07, 0x03, 0x30, 0x38, 0x1C, 0x0F, 0xC0, 0xE0, 0x70,
  0x1E, 0x03, 0x81, 0xC0, 0x78, 0x0E, 0x06, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00,
  0x07, 0x03, 0xE0, 0x00, 0x70, 0x3E, 0x00, 0x07, 0x03, 0x60, 0x00, 0x60,
  0x36, 0x00, 0x0E, 0x07, 0x70, 0x00, 0xE0, 0x77, 0x00, 0x0E, 0x07, 0x30,
  0x00, 0xE0, 0x73, 0x00, 0x0E, 0x07, 0x38, 0x00, 0xC0, 0x63, 0x80, 0x0C,
  0x0E, 0x18, 0x01, 0xC0, 0xE1, 0x80, 0x1C, 0x0E, 0x1C, 0x01, 0xC0, 0xE1,
  0xC0, 0x1C, 0x0E, 0x0C, 0x01, 0x80, 0xC0, 0xC0, 0x18, 0x1C, 0x0E, 0x03,
  0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C,
  0x06, 0x03, 0x81, 0x80, 0x70, 0x30, 0x18, 0x07, 0x07, 0x03, 0x80, 0x30,
  0x70, 0x38, 0x03, 0x07, 0x03, 0x80, 0x38, 0x70, 0x38, 0x03, 0x87, 0x03,
  0x80, 0x18, 0x60, 0x30, 0x01, 0x8E, 0x07, 0x00, 0x1C, 0xE0, 0x70, 0x01,
  0xCE, 0x07, 0x00, 0x0C, 0xE0, 0x70, 0x00, 0xCE, 0x07, 0x00, 0x0E, 0xC0,
  0x60, 0x00, 0xEC, 0x0E, 0x00, 0x0E, 0xC0, 0xE0, 0x00, 0x7C, 0x0E, 0x00,
  0x07, 0xC0, 0xE0, 0x00, 0x7C, 0x0E, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC3, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x07, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x1C, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x30, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x1C,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x0F, 0xC0, 0x38, 0x00, 0x1F, 0x01,
  0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC7, 0xE0,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x78, 0x1C, 0x00, 0x1C, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x1E, 0x01, 0x80, 0x00,
  0x78, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x1E, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0x80, 0x70, 0x00, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x0E,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x70, 0x06, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70,
  0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x07, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xF0, 0x1F,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30,
  0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x98, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x0E, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x60,
  0x0E, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x38, 0x00, 0x60, 0x0C, 0x00, 0x1C,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0xE0,
  0x00, 0x0C, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0xE0, 0x07, 0x80, 0x1D, 0xC0, 0x0F, 0x00, 0x33, 0x80, 0x3E,
  0x00, 0xE7, 0x00, 0x6C, 0x01, 0xCE, 0x00, 0xD8, 0x03, 0x9C, 0x01, 0xB0,
  0x06, 0x38, 0x07, 0x60, 0x1C, 0x70, 0x0C, 0xC0, 0x38, 0xE0, 0x19, 0x80,
  0x61, 0xC0, 0x73, 0x01, 0xC3, 0x80, 0xC6, 0x03, 0x87, 0x01, 0x8C, 0x07,
  0x0C, 0x07, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x38, 0x30, 0x18, 0x60, 0x70,
  0x60, 0x30, 0xC0, 0xC0, 0xC0, 0xC1, 0x81, 0x81, 0x81, 0x83, 0x07, 0x03,
  0x03, 0x06, 0x0E, 0x06, 0x0E, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x70, 0x18,
  0x30, 0x30, 0xE0, 0x30, 0xE0, 0xE1, 0x80, 0x61, 0x81, 0xC3, 0x01, 0xC3,
  0x03, 0x8E, 0x03, 0x86, 0x07, 0x1C, 0x07, 0x18, 0x0E, 0x30, 0x0E, 0x30,
  0x18, 0x60, 0x1C, 0x60, 0x31, 0xC0, 0x39, 0x80, 0x63, 0x00, 0x73, 0x00,
  0xC6, 0x00, 0xE6, 0x01, 0x9C, 0x01, 0xDC, 0x03, 0x38, 0x03, 0xB0, 0x06,
  0x60, 0x07, 0x60, 0x0C, 0xC0, 0x0E, 0xC0, 0x1B, 0x80, 0x1F, 0x00, 0x37,
  0x00, 0x3E, 0x00, 0x6C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x87, 0x80, 0x00, 0x38, 0x70, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x70,
  0x00, 0x70, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80,
  0x3C, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x0E,
  0x00, 0x38, 0x3C, 0x00, 0x38, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0x80,
  0x01, 0xCE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x70, 0x38, 0x38, 0x1C,
  0x1E, 0x0E, 0x07, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFC, 0x70, 0x0F, 0xFF,
  0x9C, 0x07, 0x80, 0x77, 0x03, 0x80, 0x0F, 0xC1, 0xC0, 0x01, 0xF0, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E,
  0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x01, 0xF0, 0x3C, 0x00,
  0xFC, 0x07, 0x80, 0xF7, 0x00, 0xFF, 0xF9, 0xC0, 0x1F, 0xF8, 0x70, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x7F, 0x00, 0x18, 0x7F, 0xF0, 0x0E, 0x7F, 0xFE, 0x03, 0xB8, 0x07,
  0xC0, 0xFC, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x03,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70,
  0x78, 0x00, 0x3C, 0x3E, 0x00, 0x0E, 0x0E, 0xC0, 0x0F, 0x03, 0xBC, 0x07,
  0x80, 0xE7, 0xFF, 0xC0, 0x38, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x78, 0x07, 0xC0,
  0x70, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x39, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x07, 0x80, 0x0F, 0x01, 0xF0, 0x3E, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0xC0, 0x07, 0xFF,
  0x1C, 0x00, 0xFF, 0xF9, 0xC0, 0x1E, 0x01, 0xDC, 0x03, 0x80, 0x0F, 0xC0,
  0x70, 0x00, 0x7C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38,
  0x18, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x30, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0xFC, 0x01,
  0xE0, 0x3D, 0xC0, 0x0F, 0xFF, 0x9C, 0x00, 0x7F, 0xE1, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x78, 0x07, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x3E, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xF1, 0xC0, 0x7F, 0xFC, 0xE0, 0x78, 0x07, 0x70, 0x70,
  0x01, 0xB8, 0x70, 0x00, 0x7C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x18, 0x00, 0x03, 0x9C, 0x00, 0x01,
  0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00,
  0x78, 0x70, 0x00, 0x7C, 0x3C, 0x00, 0x6C, 0x0F, 0x80, 0xEE, 0x03, 0xFF,
  0xE7, 0x00, 0xFF, 0xC3, 0x80, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x7F, 0x00, 0x18, 0x7F,
  0xF0, 0x0E, 0x7F, 0xFE, 0x03, 0xB8, 0x07, 0xC0, 0xEC, 0x00, 0x70, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x06, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x0E,
  0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x19, 0xFE, 0x3F,
  0xC0, 0x6F, 0xF9, 0xFF, 0x83, 0xA0, 0xF4, 0x1E, 0x0F, 0x01, 0xE0, 0x38,
  0x38, 0x07, 0x80, 0xE0, 0xE0, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x0E, 0x0E,
  0x01, 0xC0, 0x38, 0x30, 0x07, 0x00, 0xE1, 0xC0, 0x18, 0x03, 0x87, 0x00,
  0xE0, 0x0C, 0x1C, 0x03, 0x80, 0x70, 0x70, 0x0E, 0x01, 0xC1, 0xC0, 0x38,
  0x07, 0x06, 0x00, 0xE0, 0x1C, 0x38, 0x03, 0x00, 0x70, 0xE0, 0x1C, 0x01,
  0x83, 0x80, 0x70, 0x06, 0x0E, 0x01, 0xC0, 0x38, 0x38, 0x07, 0x00, 0xE0,
  0xC0, 0x1C, 0x03, 0x87, 0x00, 0x60, 0x0E, 0x1C, 0x01, 0x80, 0x38, 0x70,
  0x0E, 0x00, 0xC1, 0xC0, 0x38, 0x07, 0x07, 0x00, 0xE0, 0x1C, 0x1C, 0x03,
  0x80, 0x70, 0x60, 0x0E, 0x01, 0xC3, 0x80, 0x30, 0x07, 0x0E, 0x01, 0xC0,
  0x18, 0x38, 0x07, 0x00, 0xE0, 0x01, 0x07, 0xF0, 0x01, 0x87, 0xFF, 0x00,
  0xE7, 0xFF, 0xE0, 0x3B, 0x80, 0x7C, 0x0E, 0xC0, 0x07, 0x03, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x30, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x70, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x78,
  0x07, 0x80, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x18,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x18, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x1E, 0x0E, 0x00, 0x0E, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x3E, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x41, 0xFC,
  0x00, 0x18, 0x7F, 0xF0, 0x03, 0x9F, 0xFF, 0x80, 0x3B, 0x80, 0x7C, 0x03,
  0xF0, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C,
  0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xE0, 0x3B,
  0x00, 0x3C, 0x03, 0xBC, 0x07, 0x80, 0x39, 0xFF, 0xF0, 0x03, 0x8F, 0xFC,
  0x00, 0x38, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFC, 0x70, 0x0F, 0xFF, 0x9C, 0x07, 0x80,
  0x77, 0x03, 0x80, 0x0F, 0xC1, 0xC0, 0x01, 0xF0, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x03, 0xC0, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0xFC, 0x07, 0x80,
  0xF7, 0x00, 0xFF, 0xF9, 0xC0, 0x1F, 0xF8, 0x60, 0x00, 0x60, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x07, 0xF0, 0x01, 0x8F, 0xFF, 0x00,
  0xE7, 0xFF, 0xE0, 0x3B, 0x80, 0x7C, 0x0F, 0xC0, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F,
  0x00, 0x3E, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x1C,
  0x30, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1F,
  0x00, 0x3E, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x06,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x30, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xCC,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x1C,
  0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x01,
  0xC0, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x38, 0x00, 0x03, 0x38, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x78, 0x03, 0xB8, 0x03,
  0xC0, 0x1D, 0xC0, 0x1E, 0x00, 0xEE, 0x01, 0xB0, 0x0E, 0x70, 0x0D, 0x80,
  0x73, 0x80, 0x6C, 0x03, 0x9C, 0x06, 0x60, 0x18, 0xE0, 0x33, 0x01, 0xC7,
  0x01, 0x98, 0x0E, 0x38, 0x18, 0xC0, 0x61, 0xC0, 0xC6, 0x07, 0x0E, 0x06,
  0x30, 0x38, 0x70, 0x61, 0x81, 0x83, 0x83, 0x0E, 0x1C, 0x1C, 0x38, 0x70,
  0xE0, 0xE1, 0x83, 0x86, 0x07, 0x0C, 0x1C, 0x70, 0x18, 0xE0, 0xE3, 0x80,
  0xC6, 0x03, 0x18, 0x06, 0x30, 0x19, 0xC0, 0x33, 0x80, 0xCE, 0x01, 0x98,
  0x06, 0x60, 0x0C, 0xC0, 0x37, 0x00, 0x6E, 0x01, 0xB8, 0x03, 0x60, 0x0D,
  0x80, 0x1B, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0,
  0x0E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x63, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0xC7, 0x00,
  0x01, 0xE3, 0xC0, 0x01, 0xE0, 0xE0, 0x01, 0xF0, 0x78, 0x01, 0xB8, 0x1E,
  0x01, 0xDC, 0x07, 0xFF, 0xCE, 0x01, 0xFF, 0x87, 0x00, 0x3E, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x10, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0xC7, 0xFC, 0x00, 0x73, 0x87, 0x80, 0x19, 0xC0, 0xE0, 0x06, 0x60,
  0x1C, 0x01, 0xB8, 0x03, 0x80, 0xEE, 0x00, 0xF0, 0x33, 0x80, 0x1E, 0x3C,
  0xE0, 0x03, 0xFE, 0x30, 0x00, 0x7F, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 11, 42, 34, 12, -42 },
  { 59, 18, 17, 34, 11, -42 },
  { 98, 33, 42, 34, 1, -42 },
  { 272, 29, 58, 34, 3, -50 },
  { 483, 38, 42, 34, -1, -42 },
  { 683, 30, 43, 34, 2, -42 },
  { 845, 6, 17, 34, 17, -42 },
  { 858, 23, 55, 34, 10, -48 },
  { 1017, 22, 55, 34, 3, -48 },
  { 1169, 29, 29, 34, 4, -35 },
  { 1275, 26, 26, 34, 5, -32 },
  { 1360, 12, 18, 34, 7, -9 },
  { 1387, 19, 2, 34, 8, -20 },
  { 1392, 9, 9, 34, 11, -8 },
  { 1403, 32, 53, 34, 2, -47 },
  { 1615, 28, 43, 34, 4, -42 },
  { 1766, 25, 42, 34, 3, -42 },
  { 1898, 29, 42, 34, 3, -42 },
  { 2051, 27, 43, 34, 4, -42 },
  { 2197, 25, 42, 34, 5, -42 },
  { 2329, 27, 43, 34, 4, -42 },
  { 2475, 25, 43, 34, 4, -42 },
  { 2610, 27, 42, 34, 7, -42 },
  { 2752, 29, 43, 34, 3, -42 },
  { 2908, 26, 42, 34, 6, -42 },
  { 3045, 12, 33, 34, 11, -32 },
  { 3095, 17, 41, 34, 7, -32 },
  { 3183, 27, 28, 34, 5, -33 },
  { 3278, 26, 16, 34, 5, -27 },
  { 3330, 27, 28, 34, 3, -33 },
  { 3425, 23, 42, 34, 9, -42 },
  { 3546, 33, 52, 34, 1, -42 },
  { 3761, 27, 42, 34, 1, -42 },
  { 3903, 28, 42, 34, 4, -42 },
  { 4050, 27, 43, 34, 5, -42 },
  { 4196, 27, 42, 34, 4, -42 },
  { 4338, 29, 42, 34, 4, -42 },
  { 4491, 30, 42, 34, 4, -42 },
  { 4649, 27, 43, 34, 5, -42 },
  { 4795, 28, 42, 34, 4, -42 },
  { 4942, 27, 42, 34, 4, -42 },
  { 5084, 29, 43, 34, 2, -42 },
  { 5240, 30, 42, 34, 4, -42 },
  { 5398, 24, 42, 34, 4, -42 },
  { 5524, 30, 42, 34, 3, -42 },
  { 5682, 28, 42, 34, 4, -42 },
  { 5829, 26, 43, 34, 5, -42 },
  { 5969, 29, 42, 34, 4, -42 },
  { 6122, 26, 52, 34, 5, -42 },
  { 6291, 29, 42, 34, 4, -42 },
  { 6444, 29, 43, 34, 3, -42 },
  { 6600, 28, 42, 34, 7, -42 },
  { 6747, 27, 43, 34, 5, -42 },
  { 6893, 26, 42, 34, 8, -42 },
  { 7030, 31, 42, 34, 5, -42 },
  { 7193, 33, 42, 34, 1, -42 },
  { 7367, 28, 42, 34, 7, -42 },
  { 7514, 29, 42, 34, 3, -42 },
  { 7667, 21, 53, 34, 9, -47 },
  { 7807, 15, 53, 34, 10, -47 },
  { 7907, 22, 53, 34, 5, -47 },
  { 8053, 23, 23, 34, 6, -42 },
  { 8120, 28, 3, 34, 0, 1 },
  { 8131, 8, 8, 34, 16, -45 },
  { 8139, 26, 33, 34, 4, -32 },
  { 8247, 26, 43, 34, 4, -42 },
  { 8387, 25, 33, 34, 5, -32 },
  { 8491, 28, 43, 34, 4, -42 },
  { 8642, 25, 33, 34, 5, -32 },
  { 8746, 35, 52, 34, -1, -42 },
  { 8974, 25, 42, 34, 5, -32 },
  { 9106, 26, 42, 34, 4, -42 },
  { 9243, 25, 44, 34, 3, -44 },
  { 9381, 29, 54, 34, 1, -44 },
  { 9577, 28, 42, 34, 4, -42 },
  { 9724, 23, 42, 34, 6, -42 },
  { 9845, 30, 32, 34, 2, -32 },
  { 9965, 26, 32, 34, 4, -32 },
  { 10069, 25, 33, 34, 5, -32 },
  { 10173, 28, 42, 34, 2, -32 },
  { 10320, 26, 42, 34, 4, -32 },
  { 10457, 26, 32, 34, 5, -32 },
  { 10561, 26, 33, 34, 4, -32 },
  { 10669, 25, 40, 34, 6, -40 },
  { 10794, 26, 32, 34, 5, -31 },
  { 10898, 25, 31, 34, 7, -31 },
  { 10995, 29, 31, 34, 5, -31 },
  { 11108, 30, 31, 34, 2, -31 },
  { 11225, 25, 41, 34, 5, -31 },
  { 11354, 27, 31, 34, 3, -31 },
  { 11459, 27, 53, 34, 6, -47 },
  { 11638, 11, 53, 34, 12, -47 },
  { 11711, 27, 53, 34, 2, -47 },
  { 11890, 26, 10, 34, 5, -25 },
};

const GFXfont JetBrainsMono_ThinItalic57pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic57pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _JETBRAINSMONO_THINITALIC57PT7B_H_
