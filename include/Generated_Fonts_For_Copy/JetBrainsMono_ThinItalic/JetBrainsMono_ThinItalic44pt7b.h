#ifndef _JETBRAINSMONO_THINITALIC44PT7B_H_
#define _JETBRAINSMONO_THINITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03,
  0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0x87, 0xC3, 0xE0,
  0xE0, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x30, 0x39, 0x81,
  0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x00, 0x00,
  0x0C, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x30, 0x00, 0x60, 0x1C, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x03,
  0x00, 0xE0, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x07, 0x00,
  0x06, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x1C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC0, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x03, 0x00,
  0x07, 0x00, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0x8C, 0x70, 0x1C, 0x30, 0xE0, 0xE0,
  0xC1, 0x83, 0x03, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0x61, 0xC1, 0x80,
  0x07, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x60, 0x00, 0xE1, 0x00, 0x01,
  0xE4, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0D,
  0xE0, 0x00, 0x31, 0xC0, 0x00, 0x83, 0x00, 0x06, 0x0E, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x60, 0x01, 0x81, 0x8C, 0x06, 0x06, 0x30, 0x10, 0x38, 0xC0,
  0xC0, 0xC3, 0x83, 0x07, 0x06, 0x0C, 0x18, 0x1E, 0x31, 0xC0, 0x3F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x1C,
  0x07, 0xF8, 0x00, 0xC0, 0x30, 0x70, 0x06, 0x01, 0x80, 0xC0, 0x38, 0x06,
  0x03, 0x00, 0xC0, 0x18, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x30, 0x03, 0x00,
  0xC1, 0x80, 0x0C, 0x06, 0x0C, 0x00, 0x30, 0x18, 0x60, 0x00, 0xC0, 0x63,
  0x80, 0x03, 0x83, 0x0C, 0x00, 0x07, 0xFC, 0x60, 0x00, 0x0F, 0xC3, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x20, 0x00, 0x00, 0xC7, 0xF0, 0x00, 0x06, 0x39, 0xE0, 0x00,
  0x31, 0x81, 0x80, 0x01, 0x86, 0x06, 0x00, 0x0C, 0x30, 0x18, 0x00, 0x60,
  0xC0, 0x60, 0x03, 0x83, 0x01, 0x80, 0x1C, 0x0C, 0x06, 0x00, 0x60, 0x30,
  0x18, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x03, 0x03, 0x00, 0xC0, 0x0C, 0x1C,
  0x06, 0x00, 0x3F, 0xE0, 0x38, 0x00, 0x3E, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x38, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0x38, 0x07, 0x18, 0x18, 0x0E, 0x30, 0x1C, 0x0C, 0x30, 0x0C, 0x18, 0x30,
  0x0E, 0x38, 0x30, 0x07, 0x30, 0x70, 0x03, 0x60, 0x60, 0x03, 0xE0, 0x60,
  0x01, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x03, 0xE0, 0x60, 0x07, 0x60, 0x70,
  0x0E, 0x70, 0x70, 0x1C, 0x30, 0x3F, 0xF8, 0x38, 0x1F, 0xE0, 0x1C, 0x39,
  0xDC, 0xE7, 0x39, 0xCE, 0x63, 0x39, 0xCC, 0x00, 0x00, 0x01, 0x80, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x70, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x18, 0x0C, 0x03, 0xF8, 0x30,
  0x7D, 0xFC, 0xC7, 0xF1, 0xFB, 0x7E, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x00,
  0x03, 0x40, 0x00, 0x19, 0x80, 0x00, 0xE7, 0x00, 0x07, 0x0E, 0x00, 0x38,
  0x38, 0x01, 0xE0, 0x70, 0x07, 0x01, 0xC0, 0x78, 0x03, 0x80, 0xC0, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x3C, 0xFD, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x60,
  0x00, 0x61, 0x80, 0x03, 0x86, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xC3, 0x80, 0x03, 0x0C, 0x1E, 0x0C, 0x30, 0x78, 0x30, 0xC1, 0xE1, 0xC7,
  0x07, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00,
  0x06, 0x18, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x0E, 0x00, 0x0C,
  0x38, 0x00, 0x70, 0x60, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0xF0, 0x0F,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3B,
  0x00, 0x0F, 0x30, 0x01, 0xC3, 0x00, 0x78, 0x30, 0x06, 0x03, 0x00, 0x40,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xE7, 0xC0, 0x1E, 0x01,
  0xC0, 0x30, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x04, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x38, 0x00, 0x61, 0xC0,
  0x07, 0x06, 0x00, 0x70, 0x38, 0x07, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x30,
  0x70, 0x06, 0x1C, 0x00, 0xC7, 0x00, 0x38, 0xC0, 0x07, 0x30, 0x00, 0xCE,
  0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x67, 0xFF, 0xFC, 0xFF, 0xFF, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0xFE, 0x01,
  0x9F, 0xF8, 0x0D, 0x81, 0xE0, 0x78, 0x03, 0x83, 0x80, 0x1C, 0x18, 0x00,
  0x61, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x06,
  0x18, 0x00, 0x60, 0xC0, 0x03, 0x07, 0x00, 0x30, 0x1C, 0x07, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x6F, 0xF0, 0x0D, 0xFF, 0x81, 0xE0, 0x1C, 0x3C, 0x00, 0xE3, 0x80,
  0x0E, 0x70, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xE0, 0x00, 0xC6,
  0x00, 0x18, 0x70, 0x03, 0x83, 0x80, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x67, 0x00,
  0x07, 0x30, 0x00, 0x31, 0x80, 0x03, 0x8C, 0x00, 0x18, 0xE0, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x7E, 0xF8, 0x07, 0x00, 0xE0, 0x70,
  0x03, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0xE0, 0x0E, 0x03, 0x80,
  0xE0, 0x0E, 0x1C, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0xF0, 0x01,
  0xC1, 0xC0, 0x18, 0x07, 0x03, 0x80, 0x1C, 0x18, 0x00, 0x61, 0x80, 0x03,
  0x8C, 0x00, 0x0C, 0xE0, 0x00, 0x66, 0x00, 0x07, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x8E, 0x00, 0x1C, 0x30, 0x01, 0xC1, 0xE0, 0x1C, 0x07, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x07, 0xCF, 0x80, 0xE0,
  0x1C, 0x1C, 0x00, 0xE3, 0x80, 0x06, 0x30, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6E,
  0x00, 0x0E, 0xE0, 0x00, 0xC6, 0x00, 0x1C, 0x70, 0x03, 0x83, 0x80, 0xF0,
  0x3F, 0xFB, 0x00, 0xFE, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x03, 0xF0, 0xFC, 0x7F, 0x1F, 0xC3, 0xE0, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x7E, 0x1F, 0x8F, 0xE3, 0xF8, 0x7C, 0x00, 0x00, 0x60,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x10, 0x00, 0x01, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x1F, 0xF0, 0x0F,
  0xE0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00,
  0x70, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0x80,
  0x3F, 0x30, 0xC0, 0x7F, 0xD8, 0x60, 0x70, 0x3C, 0x30, 0x30, 0x0E, 0x38,
  0x18, 0x07, 0x1C, 0x1C, 0x03, 0x8C, 0x0C, 0x01, 0x86, 0x06, 0x00, 0xC3,
  0x03, 0x00, 0x61, 0x81, 0x80, 0x30, 0xC1, 0xC0, 0x38, 0xE0, 0xE0, 0x1C,
  0x60, 0x60, 0x0C, 0x30, 0x30, 0x06, 0x18, 0x1C, 0x07, 0x0C, 0x0E, 0x07,
  0x86, 0x03, 0xEE, 0xC3, 0x00, 0xFE, 0x63, 0x80, 0x08, 0x41, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xD8, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x19, 0xC0,
  0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x0C,
  0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x0E, 0x01, 0x80,
  0x60, 0x38, 0x06, 0x03, 0x00, 0x60, 0x70, 0x06, 0x06, 0x00, 0x60, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE0, 0xC0, 0x06, 0x1C, 0x00, 0x71, 0x80, 0x03, 0x38,
  0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x3E,
  0x00, 0x03, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0x80, 0x3C, 0x1C, 0x00,
  0xE0, 0xC0, 0x03, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C,
  0x00, 0x38, 0xE0, 0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x0E,
  0x0C, 0x00, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x38, 0x1F, 0x81, 0x80,
  0x0E, 0x0C, 0x00, 0x38, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x31,
  0xC0, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x07, 0x18, 0x00,
  0x30, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x07, 0x83, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xFD, 0xF0, 0x0E, 0x01,
  0xC0, 0xE0, 0x07, 0x06, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x06, 0x18,
  0x00, 0x31, 0xC0, 0x01, 0x8C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x0E, 0x00, 0x30, 0x70, 0x03, 0x81, 0xC0, 0x38, 0x07,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0x80,
  0x78, 0x1C, 0x01, 0xC0, 0xC0, 0x07, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1,
  0x80, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0x87, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x0C, 0x38,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0E,
  0x18, 0x00, 0x71, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00,
  0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x06, 0x0E, 0x00, 0xE0, 0x60, 0x1E, 0x03,
  0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x07, 0xFC, 0x00, 0xFD, 0xF0, 0x0E, 0x01, 0xC0, 0xE0, 0x07, 0x06, 0x00,
  0x18, 0x70, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x31, 0xC0, 0x01, 0x8C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x03, 0xFF, 0x18, 0x1F, 0xF8, 0xC0,
  0x01, 0xC6, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0E, 0x00,
  0x30, 0x70, 0x03, 0x81, 0xC0, 0x38, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x06, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x80, 0x06, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00, 0x0E, 0x0C, 0x00,
  0x30, 0x70, 0x00, 0xC1, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x60, 0x01, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x38, 0x00, 0x60, 0xC0,
  0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xC0, 0xC0, 0x03,
  0x07, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x07, 0x06,
  0x00, 0x1C, 0x18, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x80, 0x06, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x01, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xC3, 0x80, 0x03, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x70, 0x03, 0x01,
  0xE0, 0x3C, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x06, 0x00, 0x0E, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0x70, 0x70, 0x00, 0xC0, 0xC0, 0x03, 0x81, 0x80,
  0x0E, 0x03, 0x00, 0x18, 0x06, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x70, 0x0E, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x60, 0x03, 0x01, 0xC0,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x18, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x70, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x07, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x60, 0x00, 0x70, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x80,
  0x1E, 0x07, 0x80, 0x36, 0x0C, 0x80, 0x36, 0x0C, 0xC0, 0x66, 0x0C, 0xC0,
  0x6C, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0x41, 0x8C, 0x0C, 0x61,
  0x0C, 0x1C, 0x63, 0x1C, 0x18, 0x62, 0x1C, 0x18, 0x66, 0x18, 0x18, 0x24,
  0x18, 0x18, 0x3C, 0x18, 0x18, 0x38, 0x18, 0x38, 0x38, 0x18, 0x30, 0x00,
  0x38, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x70, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00,
  0xE0, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x78, 0x01,
  0x83, 0x60, 0x06, 0x0D, 0x80, 0x18, 0x36, 0x00, 0x60, 0xCC, 0x01, 0x83,
  0x30, 0x0E, 0x0C, 0xC0, 0x30, 0x73, 0x00, 0xC1, 0x86, 0x03, 0x06, 0x18,
  0x0C, 0x18, 0x60, 0x30, 0x61, 0x81, 0xC1, 0x82, 0x06, 0x06, 0x0C, 0x18,
  0x38, 0x30, 0x60, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x06, 0x38, 0x30,
  0x18, 0xC0, 0xC0, 0x63, 0x07, 0x01, 0x8C, 0x18, 0x03, 0x30, 0x60, 0x0C,
  0xC1, 0x80, 0x33, 0x06, 0x00, 0xDC, 0x18, 0x01, 0xE0, 0xE0, 0x07, 0x83,
  0x00, 0x1E, 0x0C, 0x00, 0x78, 0x30, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x0F,
  0xF8, 0x03, 0xE7, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x07, 0x18,
  0x00, 0x71, 0x80, 0x03, 0x18, 0x00, 0x73, 0x80, 0x07, 0x30, 0x00, 0x63,
  0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x67, 0x00, 0x0E,
  0x70, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00,
  0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00,
  0x18, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x07, 0x0E, 0x00, 0x60, 0x70,
  0x1C, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x18, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x01,
  0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x18,
  0x70, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x83, 0x00, 0x06, 0x06,
  0x00, 0x3C, 0x0C, 0x03, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x03, 0xF7, 0xC0, 0x70,
  0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0x80, 0x03, 0x18,
  0x00, 0x73, 0x80, 0x07, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63,
  0x00, 0x06, 0x30, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xC6, 0x00, 0x0C,
  0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xCE, 0x00, 0x1C, 0xE0, 0x01,
  0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00,
  0x30, 0xC0, 0x07, 0x0E, 0x00, 0x60, 0x70, 0x1C, 0x03, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x60, 0x07, 0x83, 0x80, 0x0E, 0x0C, 0x00, 0x1C,
  0x30, 0x00, 0x70, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x70,
  0x00, 0x71, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x01,
  0xC1, 0x80, 0x0E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xC0, 0x60, 0x03,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x07, 0x00,
  0x60, 0x18, 0x01, 0x80, 0x60, 0x07, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30,
  0x18, 0x00, 0xE0, 0xE0, 0x01, 0x83, 0x80, 0x06, 0x0C, 0x00, 0x1C, 0x30,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xF7, 0xE0, 0x0E,
  0x01, 0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x07, 0x00,
  0x0E, 0x06, 0x00, 0x18, 0x0F, 0x00, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x38, 0x60, 0x01, 0xC7, 0x00,
  0x0C, 0x38, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x0E, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x06, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x8E, 0x00, 0x18, 0x70,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x86, 0x00, 0x1C,
  0x70, 0x00, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x1C, 0x30, 0x00, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x60, 0x38, 0x0E, 0x00,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xB8, 0x00,
  0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x61, 0x80, 0x07, 0x0C,
  0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x1C, 0x00, 0xC0, 0xE0, 0x0E,
  0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x18, 0x01, 0x80, 0xC0, 0x0C, 0x0E, 0x00, 0x70, 0x60, 0x01, 0x87, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xCE,
  0x00, 0x06, 0x60, 0x00, 0x37, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x1C, 0x07, 0x60, 0x3C, 0x06, 0x60,
  0x3C, 0x06, 0x60, 0x3C, 0x06, 0x60, 0x2C, 0x0E, 0x60, 0x6C, 0x0C, 0x60,
  0x6C, 0x0C, 0x60, 0x4C, 0x0C, 0x60, 0xCC, 0x18, 0x60, 0xCC, 0x18, 0x60,
  0xCC, 0x18, 0xC1, 0x8C, 0x38, 0xC1, 0x8C, 0x30, 0xC1, 0x8C, 0x30, 0xC1,
  0x0C, 0x30, 0xC3, 0x08, 0x60, 0xC3, 0x08, 0x60, 0xC2, 0x08, 0x60, 0xC6,
  0x08, 0x60, 0xC6, 0x08, 0xC0, 0xC4, 0x08, 0xC0, 0xCC, 0x08, 0xC0, 0xCC,
  0x09, 0x80, 0xCC, 0x09, 0x80, 0xC8, 0x09, 0x80, 0xD8, 0x09, 0x80, 0xD8,
  0x0B, 0x00, 0xD0, 0x0B, 0x00, 0xF0, 0x0B, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x30,
  0x07, 0x00, 0x0E, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x18, 0x00, 0x18, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80, 0x70, 0x00, 0x30, 0x1C, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00,
  0x03, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x81, 0x80, 0x0C,
  0x06, 0x00, 0x60, 0x18, 0x03, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x03,
  0x83, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x73, 0x80, 0x00, 0xCC,
  0x00, 0x03, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1B, 0x80, 0x1C,
  0xC0, 0x0C, 0x60, 0x0E, 0x30, 0x06, 0x1C, 0x07, 0x06, 0x07, 0x03, 0x03,
  0x01, 0xC3, 0x80, 0x61, 0x80, 0x31, 0xC0, 0x19, 0xC0, 0x0E, 0xC0, 0x03,
  0xE0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xC1,
  0xC1, 0x81, 0x83, 0x80, 0x00, 0x30, 0x00, 0x1F, 0xF3, 0x03, 0xC7, 0xB0,
  0x70, 0x0B, 0x0C, 0x00, 0xF1, 0xC0, 0x07, 0x18, 0x00, 0x71, 0x80, 0x06,
  0x38, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00,
  0xE7, 0x00, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00,
  0x0C, 0x60, 0x01, 0xC6, 0x00, 0x1C, 0x60, 0x03, 0x87, 0x00, 0x78, 0x38,
  0x0D, 0x81, 0xF7, 0x98, 0x0F, 0xF3, 0x80, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0xC0, 0x0C, 0xFF, 0x81, 0xDE, 0x7C, 0x1F, 0x00, 0xE1, 0xE0,
  0x06, 0x1C, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x71, 0x80, 0x06, 0x38,
  0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xE3,
  0x00, 0x0E, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x1C,
  0x60, 0x01, 0x87, 0x00, 0x18, 0xF0, 0x03, 0x0F, 0x80, 0xF0, 0xCF, 0x7C,
  0x0C, 0x7F, 0x80, 0x00, 0x38, 0x00, 0x7F, 0xE0, 0x1F, 0x3E, 0x07, 0x00,
  0xE1, 0xC0, 0x0C, 0x70, 0x01, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x70, 0x00,
  0xEC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x01, 0xCE, 0x00, 0x31, 0xC0, 0x0E, 0x1C, 0x03, 0x81, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x0C,
  0x0E, 0x01, 0xFF, 0x30, 0x0F, 0x1E, 0xC0, 0x70, 0x0B, 0x03, 0x00, 0x3C,
  0x1C, 0x00, 0x70, 0x60, 0x01, 0xC1, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x70, 0x00,
  0xC1, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1,
  0x80, 0x07, 0x06, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0x70, 0x07, 0x80, 0xE0,
  0x36, 0x01, 0xF7, 0x98, 0x03, 0xFC, 0xE0, 0x00, 0x78, 0x00, 0x7F, 0xE0,
  0x1F, 0x3E, 0x07, 0x00, 0xE1, 0x80, 0x0C, 0x70, 0x01, 0x8C, 0x00, 0x31,
  0x80, 0x07, 0x70, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFD, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x01, 0xCC, 0x00, 0x31, 0xC0, 0x0C, 0x1C,
  0x07, 0x81, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x7F, 0xCC, 0x1E, 0x3D, 0x87, 0x00, 0xB1, 0x80, 0x1E, 0x70, 0x01,
  0xCC, 0x00, 0x39, 0x80, 0x06, 0x70, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03,
  0x30, 0x00, 0x66, 0x00, 0x1C, 0xC0, 0x03, 0x38, 0x00, 0x66, 0x00, 0x0C,
  0xC0, 0x01, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x30, 0x03, 0xC7, 0x01, 0xB0,
  0x7F, 0xE6, 0x07, 0xF8, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x0C, 0xFF, 0x81, 0xDE, 0x7C, 0x1F, 0x00, 0xE1, 0xE0, 0x0E, 0x1C,
  0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x38, 0x00, 0x63,
  0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xE3, 0x00, 0x0C,
  0x70, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01,
  0xC6, 0x00, 0x18, 0xE0, 0x01, 0x8E, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x30,
  0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x38, 0x18, 0x01, 0xC0, 0x60, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xE0, 0x03, 0x01,
  0x80, 0x1C, 0x03, 0x00, 0x60, 0x0E, 0x01, 0x80, 0x18, 0x06, 0x00, 0x70,
  0x18, 0x00, 0xC0, 0x60, 0x03, 0x83, 0x80, 0x06, 0x0C, 0x00, 0x1C, 0x30,
  0x00, 0x30, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x40,
  0x60, 0x6F, 0xE7, 0xE1, 0xA3, 0xB1, 0xC7, 0x06, 0x83, 0x18, 0x1C, 0x0C,
  0x60, 0x60, 0x33, 0x81, 0x80, 0xCC, 0x06, 0x03, 0x30, 0x18, 0x1C, 0xC0,
  0x60, 0x63, 0x03, 0x81, 0x8C, 0x0C, 0x06, 0x30, 0x30, 0x19, 0xC0, 0xC0,
  0x66, 0x03, 0x03, 0x98, 0x0C, 0x0C, 0x60, 0x30, 0x31, 0x81, 0xC0, 0xC6,
  0x06, 0x03, 0x38, 0x18, 0x0C, 0xC0, 0x60, 0x33, 0x01, 0x81, 0xCC, 0x06,
  0x06, 0x30, 0x38, 0x18, 0xC0, 0xC0, 0x60, 0x00, 0x0C, 0x00, 0xCF, 0xF8,
  0x1D, 0xE7, 0xC1, 0xF0, 0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x06, 0x18, 0x00,
  0x61, 0x80, 0x06, 0x38, 0x00, 0x63, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x06, 0x30, 0x00, 0xE3, 0x00, 0x0E, 0x30, 0x00, 0xC7, 0x00, 0x0C, 0x60,
  0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0x8E,
  0x00, 0x18, 0xE0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x7F, 0xE0, 0x1F, 0x3E, 0x07, 0x00, 0xE1, 0x80, 0x0C, 0x70, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x07, 0x70, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03,
  0x30, 0x00, 0x66, 0x00, 0x0D, 0xC0, 0x03, 0xB8, 0x00, 0x76, 0x00, 0x0C,
  0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x0E, 0x60, 0x01, 0x8C, 0x00, 0x71,
  0xC0, 0x0C, 0x1C, 0x07, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x33, 0xFE, 0x03, 0xBC, 0xF8, 0x1F, 0x00, 0xE0, 0xF0, 0x03, 0x07,
  0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xE0, 0x01,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x60,
  0x01, 0xC7, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x38,
  0x60, 0x01, 0x83, 0x80, 0x0C, 0x3C, 0x00, 0xC1, 0xF0, 0x1C, 0x0C, 0xF7,
  0xC0, 0x63, 0xFC, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x1F, 0xF3, 0x03, 0xC7, 0xB0, 0x70, 0x0B, 0x0C,
  0x00, 0xF1, 0xC0, 0x07, 0x18, 0x00, 0x71, 0x80, 0x06, 0x38, 0x00, 0x63,
  0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xE7, 0x00, 0x0C,
  0x70, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01,
  0xC6, 0x00, 0x18, 0x60, 0x03, 0x87, 0x00, 0x78, 0x38, 0x0D, 0x81, 0xF7,
  0x98, 0x0F, 0xF3, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x01, 0xCF, 0xF8, 0x19, 0xC7, 0xC1, 0xB0, 0x0E, 0x1C, 0x00,
  0xE1, 0xC0, 0x06, 0x18, 0x00, 0x63, 0x80, 0x07, 0x30, 0x00, 0x63, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFC, 0x07, 0xC3, 0xE0, 0xE0,
  0x06, 0x1C, 0x00, 0x71, 0x80, 0x03, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xCC, 0x00, 0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0x70, 0x03,
  0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x18, 0x00, 0x73, 0x80,
  0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0E, 0x30,
  0x00, 0xE7, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6,
  0x00, 0x1C, 0x60, 0x01, 0xCE, 0x00, 0x18, 0xE0, 0x01, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x0E, 0x00, 0x70, 0xE0, 0x0E,
  0x07, 0x01, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0xE0, 0x00, 0x76, 0x00,
  0x06, 0x60, 0x00, 0xE6, 0x00, 0x0C, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x30,
  0x03, 0x83, 0x00, 0x30, 0x30, 0x07, 0x03, 0x00, 0x60, 0x30, 0x0E, 0x03,
  0x80, 0xC0, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x30, 0x01, 0x83, 0x00,
  0x18, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0D, 0x80,
  0x00, 0xD8, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x30, 0x0F, 0x01,
  0xC0, 0x7C, 0x07, 0x01, 0xB0, 0x14, 0x06, 0xC0, 0xD0, 0x3B, 0x03, 0x40,
  0xCC, 0x09, 0x03, 0x30, 0x64, 0x1C, 0xC1, 0x98, 0x63, 0x04, 0x61, 0x8C,
  0x31, 0x8E, 0x30, 0xC6, 0x30, 0xC6, 0x18, 0xC3, 0x18, 0x63, 0x0C, 0x61,
  0x98, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x83, 0x30, 0x6C, 0x0D, 0x81, 0xB0,
  0x36, 0x06, 0xC0, 0xD0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x03, 0x00, 0x1C, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x30, 0x01, 0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xE1, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0x73, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0xC7, 0x00, 0x01, 0x83, 0x00, 0x03, 0x03, 0x80, 0x07, 0x01, 0x80, 0x0E,
  0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0xE0, 0x30, 0x00, 0x60, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x03, 0x98, 0x00, 0x73,
  0x00, 0x0C, 0xE0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x39, 0x80, 0x06, 0x70, 0x00, 0xCE, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0x66, 0x00, 0x1C, 0xC0, 0x03, 0x9C, 0x00, 0xE3, 0x80, 0x3C, 0x38,
  0x0D, 0x83, 0xFF, 0x30, 0x3F, 0x86, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xC0,
  0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x80, 0xC0,
  0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38,
  0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x33, 0xF8, 0x03, 0x73, 0xC0, 0x36, 0x0C, 0x06, 0xC0, 0x60,
  0x6C, 0x07, 0x06, 0xC0, 0x38, 0xCC, 0x01, 0xF8, 0xC0, 0x02, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 9, 32, 26, 9, -32 },
  { 37, 13, 13, 26, 9, -32 },
  { 59, 26, 32, 26, 1, -32 },
  { 163, 22, 44, 26, 3, -38 },
  { 284, 30, 32, 26, -1, -32 },
  { 404, 24, 33, 26, 1, -33 },
  { 503, 5, 13, 26, 13, -32 },
  { 512, 17, 43, 26, 8, -37 },
  { 604, 17, 43, 26, 2, -37 },
  { 696, 22, 22, 26, 3, -27 },
  { 757, 20, 21, 26, 4, -25 },
  { 810, 10, 14, 26, 5, -7 },
  { 828, 15, 2, 26, 6, -16 },
  { 832, 7, 6, 26, 8, -6 },
  { 838, 25, 42, 26, 1, -37 },
  { 970, 22, 33, 26, 3, -33 },
  { 1061, 20, 32, 26, 2, -32 },
  { 1141, 23, 33, 26, 2, -33 },
  { 1236, 21, 32, 26, 3, -32 },
  { 1320, 19, 32, 26, 4, -32 },
  { 1396, 21, 32, 26, 3, -32 },
  { 1480, 20, 32, 26, 3, -32 },
  { 1560, 21, 32, 26, 5, -32 },
  { 1644, 21, 33, 26, 3, -33 },
  { 1731, 20, 33, 26, 5, -33 },
  { 1814, 10, 25, 26, 8, -25 },
  { 1846, 13, 32, 26, 5, -25 },
  { 1898, 21, 22, 26, 4, -26 },
  { 1956, 20, 12, 26, 4, -21 },
  { 1986, 20, 22, 26, 3, -26 },
  { 2041, 17, 32, 26, 7, -32 },
  { 2109, 25, 41, 26, 1, -33 },
  { 2238, 20, 32, 26, 1, -32 },
  { 2318, 21, 32, 26, 3, -32 },
  { 2402, 21, 33, 26, 4, -33 },
  { 2489, 21, 32, 26, 3, -32 },
  { 2573, 23, 32, 26, 3, -32 },
  { 2665, 23, 32, 26, 3, -32 },
  { 2757, 21, 33, 26, 4, -33 },
  { 2844, 22, 32, 26, 3, -32 },
  { 2932, 21, 32, 26, 3, -32 },
  { 3016, 22, 32, 26, 2, -32 },
  { 3104, 23, 32, 26, 3, -32 },
  { 3196, 18, 32, 26, 3, -32 },
  { 3268, 24, 32, 26, 2, -32 },
  { 3364, 22, 32, 26, 3, -32 },
  { 3452, 20, 33, 26, 4, -33 },
  { 3535, 23, 32, 26, 3, -32 },
  { 3627, 20, 41, 26, 4, -33 },
  { 3730, 22, 32, 26, 3, -32 },
  { 3818, 23, 33, 26, 2, -33 },
  { 3913, 22, 32, 26, 5, -32 },
  { 4001, 21, 32, 26, 4, -32 },
  { 4085, 21, 32, 26, 6, -32 },
  { 4169, 24, 32, 26, 4, -32 },
  { 4265, 27, 32, 26, 0, -32 },
  { 4373, 22, 32, 26, 5, -32 },
  { 4461, 23, 32, 26, 2, -32 },
  { 4553, 16, 42, 26, 7, -37 },
  { 4637, 12, 42, 26, 8, -37 },
  { 4700, 17, 42, 26, 4, -37 },
  { 4790, 17, 17, 26, 5, -32 },
  { 4827, 22, 2, 26, 0, 1 },
  { 4833, 7, 7, 26, 12, -35 },
  { 4840, 20, 25, 26, 3, -25 },
  { 4903, 20, 32, 26, 3, -32 },
  { 4983, 19, 25, 26, 4, -25 },
  { 5043, 22, 32, 26, 3, -32 },
  { 5131, 19, 25, 26, 4, -25 },
  { 5191, 27, 40, 26, -1, -32 },
  { 5326, 19, 33, 26, 4, -25 },
  { 5405, 20, 32, 26, 3, -32 },
  { 5485, 20, 34, 26, 2, -34 },
  { 5570, 22, 42, 26, 1, -34 },
  { 5686, 22, 32, 26, 3, -32 },
  { 5774, 17, 32, 26, 5, -32 },
  { 5842, 22, 25, 26, 2, -25 },
  { 5911, 20, 25, 26, 3, -25 },
  { 5974, 19, 25, 26, 4, -25 },
  { 6034, 21, 33, 26, 2, -25 },
  { 6121, 20, 33, 26, 3, -25 },
  { 6204, 20, 25, 26, 4, -25 },
  { 6267, 20, 25, 26, 3, -25 },
  { 6330, 19, 31, 26, 5, -31 },
  { 6404, 20, 24, 26, 4, -24 },
  { 6464, 20, 24, 26, 5, -24 },
  { 6524, 22, 24, 26, 4, -24 },
  { 6590, 24, 24, 26, 1, -24 },
  { 6662, 19, 32, 26, 4, -24 },
  { 6738, 20, 24, 26, 3, -24 },
  { 6798, 21, 42, 26, 5, -37 },
  { 6909, 9, 42, 26, 9, -37 },
  { 6957, 21, 42, 26, 2, -37 },
  { 7068, 20, 9, 26, 4, -20 },
};

const GFXfont JetBrainsMono_ThinItalic44pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic44pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _JETBRAINSMONO_THINITALIC44PT7B_H_
