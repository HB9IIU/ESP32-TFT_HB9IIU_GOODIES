#ifndef _JETBRAINSMONO_THINITALIC48PT7B_H_
#define _JETBRAINSMONO_THINITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x60, 0x30, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1,
  0xF8, 0xFC, 0x7C, 0x3E, 0x00, 0x78, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x0F,
  0x70, 0x39, 0xC0, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xCE, 0x03,
  0x30, 0x0C, 0xC0, 0x73, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x60,
  0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x01, 0x80,
  0x01, 0xC0, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x30, 0x00, 0x38,
  0x03, 0x00, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x30,
  0x00, 0x18, 0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x0C,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x18, 0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0x30, 0x07,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8,
  0x01, 0xE3, 0x3C, 0x03, 0x82, 0x0E, 0x07, 0x06, 0x0E, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x0E, 0x06, 0x06, 0x0E, 0x06, 0x06, 0x0E, 0x06, 0x00,
  0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x0C, 0x00,
  0x07, 0x8C, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x19, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x18, 0x30,
  0x00, 0x10, 0x38, 0x00, 0x30, 0x38, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18,
  0xE0, 0x30, 0x18, 0xE0, 0x30, 0x38, 0xE0, 0x30, 0x30, 0xE0, 0x60, 0x70,
  0x60, 0x60, 0x70, 0x70, 0x60, 0xE0, 0x3C, 0x63, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0x01, 0xFF, 0x00, 0x06, 0x01, 0x83, 0x80, 0x0C,
  0x03, 0x01, 0x80, 0x18, 0x07, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x70,
  0x06, 0x01, 0x80, 0xE0, 0x06, 0x01, 0x81, 0xC0, 0x06, 0x01, 0x81, 0x80,
  0x06, 0x01, 0x83, 0x00, 0x0E, 0x03, 0x06, 0x00, 0x0E, 0x03, 0x0C, 0x00,
  0x06, 0x07, 0x1C, 0x00, 0x07, 0x0E, 0x38, 0x00, 0x03, 0xFC, 0x70, 0x00,
  0x00, 0xF0, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x0E, 0x3F, 0xC0,
  0x00, 0x1C, 0x70, 0xE0, 0x00, 0x18, 0xE0, 0x70, 0x00, 0x30, 0xC0, 0x70,
  0x00, 0x60, 0xC0, 0x30, 0x00, 0xC1, 0xC0, 0x70, 0x01, 0xC1, 0x80, 0x60,
  0x03, 0x81, 0x80, 0x60, 0x07, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0xE0, 0x18, 0x01, 0x80, 0xC0, 0x30, 0x01, 0xC1, 0xC0,
  0x70, 0x00, 0xFF, 0x80, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1E, 0x07, 0x00, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x18, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0x0E, 0x00, 0x27, 0x07, 0x00, 0x63, 0x01,
  0xC0, 0x73, 0x80, 0xE0, 0x31, 0xC0, 0x38, 0x30, 0xC0, 0x0C, 0x38, 0x60,
  0x07, 0x38, 0x30, 0x01, 0xD8, 0x18, 0x00, 0xF8, 0x1C, 0x00, 0x3C, 0x0E,
  0x00, 0x0C, 0x06, 0x00, 0x0F, 0x03, 0x80, 0x0F, 0xC1, 0xC0, 0x0E, 0x60,
  0xE0, 0x0E, 0x38, 0x38, 0x1E, 0x0C, 0x1F, 0xFE, 0x07, 0x07, 0xFC, 0x01,
  0xC0, 0x39, 0xCE, 0x73, 0xBD, 0xCE, 0x73, 0x9C, 0xC6, 0x70, 0x00, 0x00,
  0x10, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x80, 0x38,
  0x02, 0xF8, 0x1C, 0x0F, 0xFF, 0x8C, 0x3F, 0xC7, 0xF6, 0x7F, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0xDC, 0x00, 0x01, 0xC6, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0xE0, 0x01,
  0xE0, 0x70, 0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x80,
  0x20, 0x01, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81,
  0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x08, 0x7E, 0x7E, 0xFE, 0xFE, 0xFE, 0x7C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00,
  0x0C, 0x38, 0x1C, 0x0C, 0x38, 0x3C, 0x1C, 0x38, 0x3E, 0x1C, 0x38, 0x3C,
  0x1C, 0x30, 0x18, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70, 0x00,
  0x18, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x70, 0x00, 0x70, 0x70, 0x00, 0x60, 0x70, 0x00,
  0xE0, 0x38, 0x01, 0xC0, 0x3E, 0x07, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x60, 0x00, 0xF3, 0x00,
  0x0E, 0x38, 0x01, 0xE1, 0xC0, 0x1C, 0x0E, 0x01, 0xC0, 0x60, 0x08, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x1C, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x61, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x06, 0x07, 0x00, 0x30, 0x70, 0x01, 0x83, 0x00, 0x1C, 0x38, 0x00, 0xE3,
  0x80, 0x06, 0x38, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0xE0, 0x00,
  0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x87, 0xF0, 0x03, 0x3F, 0xF8, 0x06, 0xE0, 0xF8, 0x0F, 0x00,
  0x70, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x07, 0x0C,
  0x00, 0x0E, 0x18, 0x00, 0x18, 0x38, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x78,
  0x0F, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x73,
  0xF8, 0x01, 0xBF, 0xF8, 0x0F, 0x81, 0xF0, 0x78, 0x01, 0xC1, 0xC0, 0x03,
  0x8E, 0x00, 0x0E, 0x30, 0x00, 0x19, 0xC0, 0x00, 0x67, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x03, 0xB8, 0x00,
  0x0C, 0x60, 0x00, 0x31, 0x80, 0x01, 0xC7, 0x00, 0x0E, 0x0E, 0x00, 0x70,
  0x3C, 0x07, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF9, 0xC0, 0x00, 0x33, 0x80, 0x00, 0xE6, 0x00, 0x01, 0x8C,
  0x00, 0x07, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE1, 0xC0,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0x0E, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0C, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x03, 0x80, 0x70, 0x01,
  0xC1, 0xE0, 0x00, 0xF7, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xE7, 0x80, 0x07, 0x81, 0xC0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x38,
  0x00, 0x30, 0x30, 0x00, 0x38, 0x70, 0x00, 0x38, 0x60, 0x00, 0x38, 0x60,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0x60,
  0x00, 0x60, 0x70, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xE0,
  0x3C, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0x80, 0x01, 0x8E, 0x00, 0x07,
  0x30, 0x00, 0x1D, 0xC0, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60,
  0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x03, 0x98, 0x00, 0x0C, 0x70, 0x00,
  0x71, 0xC0, 0x03, 0x83, 0x80, 0x1E, 0x0F, 0x81, 0xF0, 0x1F, 0xFD, 0x80,
  0x1F, 0xCE, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x03, 0x81, 0xF8, 0x3F, 0x8F, 0xF1, 0xFC,
  0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x1F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x70, 0x07, 0xE0, 0x1F,
  0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3C, 0x03, 0xC0, 0x0E,
  0x00, 0x3C, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x0E, 0x18, 0x03, 0xF9, 0xC7, 0x00, 0xFF, 0xB0,
  0xE0, 0x38, 0x1E, 0x18, 0x0E, 0x01, 0xC3, 0x01, 0x80, 0x38, 0x60, 0x70,
  0x07, 0x0C, 0x0E, 0x00, 0xE3, 0x81, 0xC0, 0x1C, 0x70, 0x30, 0x03, 0x0E,
  0x06, 0x00, 0x61, 0x80, 0xC0, 0x0C, 0x30, 0x38, 0x03, 0x86, 0x07, 0x00,
  0x71, 0xC0, 0xE0, 0x0E, 0x38, 0x1C, 0x01, 0x87, 0x03, 0x80, 0x70, 0xC0,
  0x70, 0x0E, 0x18, 0x0F, 0x06, 0xC3, 0x00, 0xFF, 0x98, 0x60, 0x0F, 0xE7,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x71, 0x80, 0x01, 0x87, 0x00,
  0x0E, 0x1C, 0x00, 0x30, 0x30, 0x01, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0xE0, 0x30, 0x03, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x60, 0x0E,
  0x03, 0x80, 0x38, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x87, 0x00, 0x07, 0x18, 0x00,
  0x1C, 0x60, 0x00, 0x73, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x70, 0x00, 0x0D,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x07, 0x00, 0xF8, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0E,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E,
  0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x38,
  0x1C, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x18, 0x01, 0xE0, 0x18, 0x00, 0x70, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x70, 0x00, 0x38, 0x70, 0x00, 0x30, 0x60, 0x00, 0x70,
  0x60, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0x60, 0x0F, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x1E, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x06,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E,
  0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x30, 0x00, 0xE0, 0x70,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1C, 0x07, 0xC0, 0x38, 0x01, 0xC0, 0x60,
  0x01, 0xC0, 0xC0, 0x03, 0x81, 0x80, 0x03, 0x83, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0xC1, 0x80, 0x01, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C,
  0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x87,
  0x00, 0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x70, 0x30, 0x03, 0xC0, 0x60, 0x1F, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x1E, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0xC0, 0x03,
  0x83, 0x80, 0x03, 0x06, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x81, 0xFF, 0xC7, 0x03, 0xFF, 0x8E, 0x00, 0x07, 0x18, 0x00,
  0x0E, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x38,
  0x30, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x70, 0x30, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60,
  0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xC0,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x07, 0x03,
  0x00, 0x03, 0x01, 0xC0, 0x03, 0x80, 0xF0, 0x03, 0x80, 0x3C, 0x07, 0x80,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x01,
  0x80, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01,
  0xC0, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0x80, 0x70, 0x00, 0x60, 0x1C, 0x00,
  0x38, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xC0, 0x0E,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x01, 0xC0,
  0x03, 0x00, 0x70, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x06, 0x00, 0x06, 0x01,
  0x80, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x1B,
  0x00, 0x36, 0x06, 0xC0, 0x0D, 0x81, 0x98, 0x06, 0x60, 0x66, 0x01, 0x98,
  0x19, 0x80, 0xCE, 0x0E, 0x60, 0x33, 0x03, 0x98, 0x18, 0xC0, 0xE3, 0x06,
  0x30, 0x30, 0xC3, 0x0C, 0x0C, 0x30, 0xC7, 0x03, 0x0C, 0x61, 0xC0, 0xC3,
  0x18, 0x70, 0x70, 0x6C, 0x18, 0x1C, 0x1B, 0x06, 0x06, 0x07, 0x81, 0x81,
  0x81, 0xE0, 0x60, 0x60, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x07, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x1C,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x38,
  0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x07, 0x80,
  0x07, 0x07, 0xC0, 0x07, 0x06, 0xC0, 0x06, 0x06, 0xC0, 0x06, 0x06, 0xC0,
  0x06, 0x06, 0xE0, 0x06, 0x06, 0x60, 0x0E, 0x0E, 0x60, 0x0E, 0x0E, 0x60,
  0x0C, 0x0C, 0x60, 0x0C, 0x0C, 0x30, 0x0C, 0x0C, 0x30, 0x0C, 0x0C, 0x30,
  0x1C, 0x1C, 0x30, 0x1C, 0x1C, 0x18, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x18, 0x38, 0x0C, 0x38, 0x38, 0x0C,
  0x38, 0x30, 0x0C, 0x30, 0x30, 0x0E, 0x30, 0x30, 0x06, 0x30, 0x30, 0x06,
  0x30, 0x30, 0x06, 0x70, 0x70, 0x07, 0x70, 0x70, 0x03, 0x60, 0x60, 0x03,
  0x60, 0x60, 0x03, 0x60, 0x60, 0x03, 0xE0, 0x60, 0x01, 0xE0, 0xE0, 0x01,
  0xE0, 0xE0, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0xF0, 0x1E, 0x07, 0x00, 0x38, 0x18, 0x00, 0x70, 0xE0, 0x01, 0xC3,
  0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0x80, 0x01, 0xC6, 0x00,
  0x07, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x80, 0x01, 0x8E, 0x00, 0x0E,
  0x30, 0x00, 0x38, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x70,
  0x00, 0x31, 0xC0, 0x00, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x60, 0x00,
  0x61, 0x80, 0x01, 0x8E, 0x00, 0x06, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3,
  0x80, 0x03, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x70, 0x03, 0x81, 0xE0,
  0x3C, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x01, 0xC0, 0x0F, 0x80, 0xE0, 0x01, 0xE0, 0x60, 0x00, 0x70, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x70,
  0x60, 0x00, 0x30, 0x70, 0x00, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x78,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xF0, 0x1E, 0x07, 0x00, 0x38, 0x18,
  0x00, 0x70, 0xE0, 0x01, 0xC3, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00,
  0x71, 0x80, 0x01, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63,
  0x80, 0x01, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xE3, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0xC0, 0x00, 0xC6, 0x00, 0x07,
  0x18, 0x00, 0x1C, 0x60, 0x00, 0x61, 0x80, 0x01, 0x8E, 0x00, 0x06, 0x38,
  0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x0E, 0x00, 0x1C, 0x18, 0x00,
  0x60, 0x70, 0x03, 0x80, 0xE0, 0x3C, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xC0, 0x0F, 0x00, 0xE0,
  0x01, 0xC0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x03, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x1C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x01, 0x80,
  0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8,
  0x01, 0xE0, 0x3C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30,
  0x70, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x1F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x06, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xC1, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x87, 0x00, 0x03,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60,
  0xC0, 0x00, 0xC1, 0x80, 0x01, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x18, 0x00,
  0x60, 0x38, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x6C, 0x00, 0x03, 0xB8, 0x00, 0x0C,
  0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60,
  0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x70, 0x03,
  0x81, 0xC0, 0x0C, 0x07, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x18, 0x00, 0xE0,
  0xE0, 0x03, 0x83, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80,
  0x01, 0x8E, 0x00, 0x06, 0x30, 0x00, 0x19, 0xC0, 0x00, 0x66, 0x00, 0x01,
  0xB8, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0xD8, 0x03, 0x80, 0x36, 0x00, 0xA0, 0x1D,
  0x80, 0x68, 0x06, 0x60, 0x1A, 0x01, 0x98, 0x06, 0x80, 0xE6, 0x03, 0x20,
  0x39, 0x80, 0xC8, 0x0C, 0x60, 0x36, 0x03, 0x18, 0x19, 0x81, 0xC6, 0x06,
  0x60, 0x61, 0x81, 0x98, 0x18, 0x60, 0x46, 0x06, 0x18, 0x31, 0x83, 0x86,
  0x0C, 0x60, 0xC1, 0x83, 0x18, 0x30, 0x61, 0x86, 0x1C, 0x18, 0x61, 0x86,
  0x06, 0x18, 0x61, 0x81, 0x8C, 0x18, 0x60, 0x63, 0x06, 0x38, 0x18, 0xC1,
  0x8C, 0x06, 0x20, 0x63, 0x01, 0x98, 0x18, 0xC0, 0xE6, 0x06, 0x60, 0x39,
  0x01, 0x98, 0x0E, 0xC0, 0x66, 0x03, 0xB0, 0x1B, 0x80, 0xEC, 0x06, 0xC0,
  0x36, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1E, 0x00, 0xD0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x03, 0x80, 0x30, 0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x70, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x30,
  0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x01, 0x80, 0x00, 0x38, 0x3C,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x0C, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x1F,
  0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1B, 0x00, 0x07, 0x70, 0x01, 0xCE, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x03,
  0x83, 0x80, 0x70, 0x70, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0xE0, 0x1C, 0x38,
  0x03, 0x87, 0x00, 0x31, 0xC0, 0x07, 0x30, 0x00, 0xEE, 0x00, 0x0F, 0x80,
  0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC3, 0x87, 0x0C, 0x38,
  0x60, 0xC0, 0x00, 0x7C, 0x04, 0x07, 0xFE, 0x60, 0x7C, 0x3D, 0x83, 0xC0,
  0x36, 0x0C, 0x00, 0x78, 0x70, 0x01, 0xE1, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x70,
  0x00, 0x71, 0x80, 0x01, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00,
  0x63, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xC3,
  0x80, 0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0xB0, 0x78, 0x0F, 0xC0, 0xFF,
  0xF7, 0x01, 0xFF, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x1F, 0x80, 0x39, 0xFF, 0x80, 0xCE, 0x1F, 0x03,
  0x60, 0x1E, 0x0F, 0x00, 0x38, 0x38, 0x00, 0x61, 0xC0, 0x01, 0x87, 0x00,
  0x07, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06,
  0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8C, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x70, 0x00,
  0x61, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1E, 0x00, 0x70, 0x6C, 0x03, 0x83,
  0xBF, 0xFC, 0x0E, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00,
  0xF9, 0xF8, 0x0E, 0x01, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x1C, 0x60, 0x00,
  0xE7, 0x00, 0x07, 0x30, 0x00, 0x39, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x19, 0xC0, 0x00, 0xCE, 0x00,
  0x0E, 0x70, 0x00, 0x61, 0x80, 0x07, 0x0E, 0x00, 0x70, 0x78, 0x0F, 0x01,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x1C, 0x03, 0xFF, 0x30, 0x1F, 0x0F,
  0x60, 0x78, 0x06, 0xC0, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x06, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x61, 0xC0, 0x00, 0xC3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x01,
  0x60, 0x78, 0x0F, 0xC0, 0x7F, 0xFB, 0x80, 0x7F, 0xC6, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFE, 0x00, 0xF0, 0xF8, 0x0E, 0x01, 0xE0, 0xE0, 0x07, 0x0E,
  0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x07, 0x30, 0x00, 0x39, 0x80, 0x01,
  0x8C, 0x00, 0x0C, 0xE0, 0x00, 0x67, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x02, 0x70, 0x00, 0x61, 0x80, 0x07, 0x0E, 0x00,
  0x70, 0x78, 0x0F, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x04, 0x07, 0xFE, 0x60,
  0x7C, 0x3D, 0x83, 0xC0, 0x36, 0x0C, 0x00, 0x58, 0x70, 0x01, 0xE1, 0x80,
  0x03, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03,
  0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0x80, 0x01, 0xC6, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x03, 0x86, 0x00, 0x0E, 0x18, 0x00,
  0x78, 0x70, 0x01, 0xC1, 0xC0, 0x0B, 0x03, 0xC0, 0xEC, 0x07, 0xFE, 0x30,
  0x07, 0xE1, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x1F, 0x80, 0x39, 0xFF,
  0x80, 0xCE, 0x1F, 0x03, 0x60, 0x1E, 0x0F, 0x00, 0x38, 0x38, 0x00, 0x61,
  0xC0, 0x01, 0x87, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80,
  0x01, 0x86, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x60, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x0C, 0x00,
  0x38, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x18, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x0E,
  0x00, 0x30, 0x06, 0x00, 0x30, 0x07, 0x00, 0x70, 0x03, 0x00, 0x70, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x60, 0x00,
  0xE0, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x7F, 0xF0, 0x0F, 0xFC, 0x02,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x78, 0x3C, 0x06, 0xFE,
  0x3F, 0x03, 0xC7, 0xA1, 0xC3, 0xC1, 0xE0, 0xE1, 0xC0, 0xE0, 0x30, 0xE0,
  0x70, 0x18, 0x60, 0x38, 0x0C, 0x30, 0x1C, 0x06, 0x18, 0x0C, 0x07, 0x1C,
  0x06, 0x03, 0x8E, 0x03, 0x01, 0xC6, 0x01, 0x80, 0xC3, 0x01, 0xC0, 0x61,
  0x80, 0xE0, 0x30, 0xC0, 0x60, 0x18, 0xE0, 0x30, 0x1C, 0x70, 0x18, 0x0E,
  0x38, 0x0C, 0x06, 0x18, 0x0E, 0x03, 0x0C, 0x07, 0x01, 0x86, 0x03, 0x00,
  0xC3, 0x01, 0x80, 0xE3, 0x80, 0xC0, 0x71, 0xC0, 0x60, 0x30, 0xC0, 0x30,
  0x18, 0x60, 0x38, 0x0C, 0x30, 0x1C, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x39,
  0xFF, 0x80, 0xCE, 0x1F, 0x03, 0x60, 0x1E, 0x0F, 0x00, 0x38, 0x38, 0x00,
  0x61, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x61,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC7, 0x00, 0x07,
  0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x60, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xFE, 0x00, 0xF8, 0xF8, 0x0E, 0x01, 0xC0, 0xC0, 0x07,
  0x0E, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x07, 0x30, 0x00, 0x39, 0x80,
  0x01, 0x8C, 0x00, 0x0C, 0xE0, 0x00, 0x67, 0x00, 0x03, 0x30, 0x00, 0x39,
  0x80, 0x01, 0xCC, 0x00, 0x0C, 0x60, 0x00, 0x67, 0x00, 0x03, 0x38, 0x00,
  0x19, 0xC0, 0x01, 0xCE, 0x00, 0x0C, 0x70, 0x00, 0xE1, 0x80, 0x06, 0x0E,
  0x00, 0x70, 0x78, 0x0F, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x0E, 0x7F, 0xE0, 0x19, 0xC3, 0xE0, 0x36, 0x01, 0xE0, 0x78, 0x01,
  0xC0, 0xE0, 0x01, 0x83, 0x80, 0x03, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x61, 0xC0, 0x00, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x30, 0xE0, 0x00, 0x61, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x18, 0x1E, 0x00, 0x70, 0x36, 0x01, 0xC0, 0xEF, 0xFF,
  0x01, 0xC7, 0xF8, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x04, 0x07, 0xFE, 0x60,
  0x7C, 0x3D, 0x83, 0xC0, 0x36, 0x0C, 0x00, 0x78, 0x70, 0x00, 0xE1, 0x80,
  0x03, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03,
  0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0x80, 0x01, 0xC6, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x63, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0xC3, 0x80, 0x07, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0xB0,
  0x78, 0x0F, 0xC0, 0xFF, 0xF7, 0x01, 0xFF, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x02, 0x1F, 0x80,
  0x31, 0xFF, 0x80, 0xDE, 0x1F, 0x03, 0x60, 0x1E, 0x0F, 0x00, 0x38, 0x78,
  0x00, 0x61, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x60, 0x00,
  0x71, 0x80, 0x01, 0x8E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x3E, 0x0F, 0x81, 0xC0, 0x0F, 0x0E,
  0x00, 0x1C, 0x30, 0x00, 0x31, 0xC0, 0x00, 0xC7, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x33, 0x80, 0x00,
  0xCE, 0x00, 0x07, 0x1C, 0x00, 0x38, 0x78, 0x01, 0xC0, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1C, 0x00, 0x1C,
  0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0,
  0x00, 0xE3, 0x80, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0x80, 0x01, 0xC6,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x30, 0xE0, 0x01, 0xC1, 0x80, 0x06, 0x07, 0x00, 0x38,
  0x0E, 0x03, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00,
  0x61, 0x80, 0x07, 0x0E, 0x00, 0x30, 0x70, 0x03, 0x81, 0x80, 0x18, 0x0C,
  0x01, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x1C, 0x06, 0x00, 0x60, 0x70,
  0x03, 0x03, 0x00, 0x18, 0x38, 0x00, 0xC1, 0x80, 0x07, 0x1C, 0x00, 0x18,
  0xC0, 0x00, 0xCE, 0x00, 0x06, 0x60, 0x00, 0x37, 0x00, 0x01, 0xB0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03,
  0x60, 0x3C, 0x07, 0x60, 0x3C, 0x06, 0x60, 0x6C, 0x06, 0x60, 0x6C, 0x0E,
  0x60, 0x6C, 0x0C, 0x60, 0xCC, 0x0C, 0x60, 0xCC, 0x1C, 0x60, 0xCC, 0x18,
  0x61, 0x8C, 0x18, 0x61, 0x8C, 0x38, 0x61, 0x8C, 0x30, 0x63, 0x0C, 0x30,
  0x63, 0x0C, 0x70, 0x63, 0x0C, 0x60, 0x66, 0x0C, 0x60, 0x66, 0x0C, 0xE0,
  0x66, 0x0C, 0xC0, 0x6C, 0x0C, 0xC0, 0x6C, 0x05, 0xC0, 0x68, 0x05, 0x80,
  0x78, 0x05, 0x80, 0x78, 0x05, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x00, 0xC0, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x70, 0x00, 0x1C,
  0x0C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x38, 0x00, 0x18, 0x3C, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73,
  0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x70, 0x00,
  0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x06,
  0x38, 0x00, 0x70, 0xE0, 0x07, 0x87, 0x00, 0x6C, 0x1E, 0x0E, 0xE0, 0x7F,
  0xE7, 0x01, 0xFC, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x70, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x0C, 0xFF, 0x00, 0x37, 0x0E, 0x01, 0xD8, 0x1C,
  0x06, 0x60, 0x38, 0x1B, 0x80, 0x70, 0xEE, 0x01, 0xFF, 0x30, 0x03, 0xF8,
  0xC0, 0x01, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 9, 35, 29, 10, -35 },
  { 41, 14, 14, 29, 10, -35 },
  { 66, 28, 35, 29, 1, -35 },
  { 189, 24, 49, 29, 3, -42 },
  { 336, 32, 35, 29, -1, -35 },
  { 476, 25, 36, 29, 2, -36 },
  { 589, 5, 14, 29, 14, -35 },
  { 598, 20, 47, 29, 8, -41 },
  { 716, 19, 47, 29, 2, -41 },
  { 828, 25, 24, 29, 3, -29 },
  { 903, 22, 22, 29, 4, -27 },
  { 964, 10, 15, 29, 6, -7 },
  { 983, 16, 2, 29, 7, -17 },
  { 987, 8, 7, 29, 9, -7 },
  { 994, 26, 45, 29, 2, -40 },
  { 1141, 24, 36, 29, 3, -36 },
  { 1249, 21, 35, 29, 3, -35 },
  { 1341, 25, 36, 29, 2, -36 },
  { 1454, 23, 35, 29, 3, -35 },
  { 1555, 21, 35, 29, 4, -35 },
  { 1647, 23, 35, 29, 4, -35 },
  { 1748, 22, 35, 29, 3, -35 },
  { 1845, 23, 35, 29, 6, -35 },
  { 1946, 24, 36, 29, 3, -36 },
  { 2054, 22, 36, 29, 5, -36 },
  { 2153, 11, 27, 29, 9, -27 },
  { 2191, 14, 35, 29, 6, -27 },
  { 2253, 22, 24, 29, 5, -28 },
  { 2319, 22, 13, 29, 4, -22 },
  { 2355, 22, 24, 29, 3, -28 },
  { 2421, 19, 35, 29, 8, -35 },
  { 2505, 27, 45, 29, 1, -36 },
  { 2657, 22, 35, 29, 1, -35 },
  { 2754, 24, 35, 29, 3, -35 },
  { 2859, 23, 36, 29, 4, -36 },
  { 2963, 23, 35, 29, 3, -35 },
  { 3064, 24, 35, 29, 4, -35 },
  { 3169, 26, 35, 29, 3, -35 },
  { 3283, 23, 36, 29, 4, -36 },
  { 3387, 24, 35, 29, 3, -35 },
  { 3492, 23, 35, 29, 4, -35 },
  { 3593, 25, 35, 29, 2, -35 },
  { 3703, 26, 35, 29, 3, -35 },
  { 3817, 19, 35, 29, 4, -35 },
  { 3901, 26, 35, 29, 2, -35 },
  { 4015, 24, 35, 29, 3, -35 },
  { 4120, 22, 36, 29, 4, -36 },
  { 4219, 25, 35, 29, 3, -35 },
  { 4329, 22, 45, 29, 4, -36 },
  { 4453, 25, 35, 29, 3, -35 },
  { 4563, 24, 36, 29, 3, -36 },
  { 4671, 23, 35, 29, 6, -35 },
  { 4772, 23, 35, 29, 4, -35 },
  { 4873, 22, 35, 29, 7, -35 },
  { 4970, 26, 35, 29, 4, -35 },
  { 5084, 29, 35, 29, 0, -35 },
  { 5211, 24, 35, 29, 6, -35 },
  { 5316, 25, 35, 29, 2, -35 },
  { 5426, 18, 45, 29, 8, -40 },
  { 5528, 12, 45, 29, 9, -40 },
  { 5596, 17, 45, 29, 5, -40 },
  { 5692, 19, 19, 29, 5, -35 },
  { 5738, 24, 2, 29, 0, 1 },
  { 5744, 6, 7, 29, 14, -38 },
  { 5750, 22, 27, 29, 4, -27 },
  { 5825, 22, 35, 29, 3, -35 },
  { 5922, 21, 27, 29, 4, -27 },
  { 5993, 23, 35, 29, 4, -35 },
  { 6094, 21, 27, 29, 4, -27 },
  { 6165, 30, 44, 29, -1, -35 },
  { 6330, 22, 36, 29, 4, -27 },
  { 6429, 22, 35, 29, 3, -35 },
  { 6526, 22, 37, 29, 2, -37 },
  { 6628, 24, 46, 29, 1, -37 },
  { 6766, 24, 35, 29, 3, -35 },
  { 6871, 19, 35, 29, 5, -35 },
  { 6955, 25, 27, 29, 2, -27 },
  { 7040, 22, 27, 29, 3, -27 },
  { 7115, 21, 27, 29, 4, -27 },
  { 7186, 23, 36, 29, 2, -27 },
  { 7290, 22, 36, 29, 4, -27 },
  { 7389, 22, 27, 29, 4, -27 },
  { 7464, 22, 27, 29, 3, -27 },
  { 7539, 21, 34, 29, 5, -34 },
  { 7629, 22, 26, 29, 4, -26 },
  { 7701, 21, 26, 29, 6, -26 },
  { 7770, 24, 26, 29, 4, -26 },
  { 7848, 26, 26, 29, 1, -26 },
  { 7933, 21, 35, 29, 4, -26 },
  { 8025, 22, 26, 29, 3, -26 },
  { 8097, 23, 45, 29, 5, -40 },
  { 8227, 10, 45, 29, 10, -40 },
  { 8284, 23, 45, 29, 2, -40 },
  { 8414, 22, 9, 29, 4, -21 },
};

const GFXfont JetBrainsMono_ThinItalic48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_THINITALIC48PT7B_H_
