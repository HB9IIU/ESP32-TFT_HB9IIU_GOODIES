#ifndef _JETBRAINSMONO_THINITALIC63PT7B_H_
#define _JETBRAINSMONO_THINITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x7E, 0x07, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x3C, 0x01,
  0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x1E,
  0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x38, 0x00, 0x00, 0x00, 0x70, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFD, 0xDF, 0x80, 0x07, 0xC3,
  0x0F, 0x80, 0x1E, 0x06, 0x07, 0x80, 0x78, 0x0C, 0x0F, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x00, 0xE0, 0x3C, 0x0E, 0x01, 0xC0,
  0x38, 0x3C, 0x03, 0x00, 0xF0, 0x78, 0x06, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x07, 0x81, 0x80, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x0F, 0x06, 0x00, 0x00,
  0x1F, 0x9C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0E, 0x3E, 0x00, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x60, 0x3C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC7, 0x80, 0x38,
  0x07, 0x0E, 0x00, 0x60, 0x0E, 0x1C, 0x00, 0xC0, 0x1C, 0x3C, 0x01, 0x80,
  0x38, 0x78, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07,
  0x01, 0xF0, 0x30, 0x3C, 0x01, 0xF0, 0x60, 0xF8, 0x01, 0xFC, 0xCF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xF9, 0xF8, 0x00, 0x0E, 0x00,
  0x3C, 0x07, 0x00, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x0C, 0x00, 0x38, 0x00, 0x38, 0x01, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0x07, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x00, 0x18, 0x1E, 0x00, 0x00, 0xE0,
  0x07, 0x03, 0x80, 0x00, 0x0C, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0x38,
  0x38, 0x00, 0x00, 0x3C, 0x0F, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xC3, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x7F,
  0xF8, 0x00, 0x00, 0x1E, 0x1E, 0x07, 0x00, 0x00, 0x03, 0x87, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x60,
  0x03, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x00,
  0x03, 0xE7, 0xE0, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x01, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x03, 0x8F, 0x01,
  0xE0, 0x03, 0x87, 0x00, 0x78, 0x01, 0xC3, 0x80, 0x3C, 0x01, 0xC3, 0xC0,
  0x0F, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x70,
  0x00, 0x70, 0xE0, 0x38, 0x00, 0x3C, 0xF0, 0x3C, 0x00, 0x0F, 0x70, 0x1C,
  0x00, 0x03, 0xF0, 0x0E, 0x00, 0x01, 0xF8, 0x07, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0xE0, 0x00, 0x3F, 0x80,
  0x70, 0x00, 0x3D, 0xE0, 0x38, 0x00, 0x3C, 0x70, 0x1E, 0x00, 0x3C, 0x1C,
  0x0F, 0x80, 0x7C, 0x0F, 0x03, 0xF0, 0xFC, 0x03, 0x80, 0xFF, 0xF8, 0x01,
  0xE0, 0x3F, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x78, 0xF1,
  0xE3, 0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0x78, 0xE1,
  0xC3, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x40, 0x01, 0xC0, 0x01, 0x78, 0x01, 0xC0, 0x0F, 0xFF, 0x01, 0xC0, 0x7F,
  0xFF, 0xC1, 0xC3, 0xFF, 0x1F, 0xF1, 0x8F, 0xFC, 0x07, 0xFD, 0xBF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0x0E, 0x0F, 0xE7, 0xF9, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFC,
  0x7E, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x78, 0x07, 0x07,
  0x01, 0xF8, 0x0E, 0x0E, 0x03, 0xF0, 0x3C, 0x1C, 0x07, 0xE0, 0x78, 0x78,
  0x0F, 0xC0, 0xF0, 0xF0, 0x0F, 0x01, 0xC1, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x3C, 0x38,
  0x00, 0x1F, 0x07, 0x00, 0x0F, 0x80, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x70,
  0x07, 0x80, 0x0C, 0x00, 0xE0, 0x02, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0,
  0x38, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x1E, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x7F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x07, 0xFC, 0x00,
  0x38, 0xFF, 0xF8, 0x00, 0xE7, 0xFF, 0xF0, 0x03, 0xB8, 0x03, 0xE0, 0x0F,
  0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1C, 0x07, 0x80,
  0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x03, 0x9F, 0xFC, 0x00, 0x3B, 0xFF, 0xF8, 0x03, 0xFC, 0x0F,
  0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0xF8, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3C, 0x01,
  0xF0, 0x00, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C,
  0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x01, 0xF8,
  0x0F, 0xE0, 0x0F, 0xFF, 0xDE, 0x00, 0x7F, 0xF9, 0xC0, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x0F,
  0xFC, 0x3F, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x06, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xE0,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x88, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0x01, 0xC1, 0xC0, 0x03,
  0xFE, 0x38, 0x38, 0x00, 0xFF, 0xF7, 0x07, 0x00, 0x3F, 0x1E, 0xE1, 0xE0,
  0x0F, 0x00, 0xDC, 0x3C, 0x03, 0xC0, 0x0F, 0x87, 0x00, 0x70, 0x00, 0xE0,
  0xE0, 0x1E, 0x00, 0x1C, 0x1C, 0x03, 0x80, 0x03, 0x83, 0x80, 0x70, 0x00,
  0x70, 0x70, 0x0E, 0x00, 0x0E, 0x1E, 0x01, 0xC0, 0x03, 0xC3, 0x80, 0x38,
  0x00, 0x70, 0x70, 0x0F, 0x00, 0x0E, 0x0E, 0x01, 0xC0, 0x01, 0xC1, 0xC0,
  0x38, 0x00, 0x38, 0x38, 0x07, 0x00, 0x07, 0x0F, 0x00, 0xE0, 0x00, 0xE1,
  0xC0, 0x1C, 0x00, 0x3C, 0x38, 0x03, 0x80, 0x07, 0x07, 0x00, 0xF0, 0x00,
  0xE0, 0xE0, 0x0E, 0x00, 0x3C, 0x1C, 0x01, 0xC0, 0x0F, 0x87, 0x80, 0x3C,
  0x03, 0x70, 0xE0, 0x07, 0xF3, 0xEE, 0x1C, 0x00, 0x7F, 0xF9, 0x83, 0x80,
  0x07, 0xFC, 0x70, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0,
  0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1C, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x0F, 0x80,
  0x1C, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x1E, 0x00, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x3E, 0x01, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x01, 0xC0,
  0x01, 0xF0, 0x07, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xF0, 0x07, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xC3, 0x80, 0x3F,
  0xFF, 0x0E, 0x01, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x01,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x00, 0x70, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01,
  0xB8, 0x00, 0x3B, 0x80, 0xE6, 0x00, 0x0C, 0xE0, 0x39, 0x80, 0x07, 0x38,
  0x0E, 0x60, 0x01, 0x9C, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0xE7, 0x00, 0x31,
  0xC0, 0x38, 0xC0, 0x1C, 0x70, 0x1E, 0x30, 0x06, 0x1C, 0x07, 0x0C, 0x03,
  0x8F, 0x01, 0xC3, 0x80, 0xC3, 0x80, 0x70, 0xE0, 0x70, 0xE0, 0x1C, 0x18,
  0x18, 0x38, 0x07, 0x06, 0x0E, 0x0E, 0x01, 0xC1, 0x83, 0x03, 0x80, 0xE0,
  0x71, 0xC0, 0xE0, 0x38, 0x1C, 0x60, 0x70, 0x0E, 0x03, 0x38, 0x1C, 0x03,
  0x80, 0xCC, 0x07, 0x00, 0xE0, 0x37, 0x01, 0xC0, 0x38, 0x0F, 0x80, 0x70,
  0x1E, 0x03, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0,
  0x00, 0x0E, 0x03, 0xE0, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x38, 0x0F, 0xC0,
  0x00, 0x70, 0x1F, 0x80, 0x00, 0xE0, 0x3F, 0x00, 0x03, 0xC0, 0xE6, 0x00,
  0x07, 0x01, 0xCC, 0x00, 0x0E, 0x03, 0x9C, 0x00, 0x1C, 0x07, 0x38, 0x00,
  0x38, 0x0E, 0x70, 0x00, 0x70, 0x1C, 0x60, 0x00, 0xE0, 0x78, 0xE0, 0x03,
  0x80, 0xE1, 0xC0, 0x07, 0x01, 0xC3, 0x80, 0x0E, 0x03, 0x83, 0x00, 0x1C,
  0x07, 0x07, 0x00, 0x38, 0x0E, 0x0E, 0x00, 0x70, 0x1C, 0x1C, 0x01, 0xC0,
  0x70, 0x18, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0xF0, 0x38,
  0x03, 0x81, 0xC0, 0x70, 0x07, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x01, 0xC0,
  0x0E, 0x0E, 0x03, 0x80, 0x1C, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x1E, 0x00,
  0x70, 0xE0, 0x38, 0x00, 0x61, 0xC0, 0x70, 0x00, 0xE3, 0x80, 0xE0, 0x01,
  0xC7, 0x01, 0xC0, 0x03, 0x8E, 0x03, 0x80, 0x03, 0x1C, 0x0F, 0x00, 0x07,
  0x70, 0x1C, 0x00, 0x0E, 0xE0, 0x38, 0x00, 0x1D, 0xC0, 0x70, 0x00, 0x1B,
  0x80, 0xE0, 0x00, 0x3F, 0x01, 0xC0, 0x00, 0x7E, 0x03, 0x80, 0x00, 0xFC,
  0x0E, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C,
  0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x03, 0xE0,
  0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0x80, 0x38, 0x00,
  0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0xFC,
  0x01, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x03, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xF0,
  0x00, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x07, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x01, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x01,
  0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x38, 0x07,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xE7,
  0x00, 0x1E, 0x00, 0x38, 0xE0, 0x03, 0xC0, 0x07, 0x1C, 0x00, 0xF8, 0x00,
  0xE3, 0x80, 0x1F, 0x00, 0x3C, 0x70, 0x03, 0x60, 0x07, 0x0E, 0x00, 0x6C,
  0x00, 0xE1, 0xC0, 0x1D, 0x80, 0x1C, 0x38, 0x03, 0x30, 0x07, 0x07, 0x00,
  0x66, 0x00, 0xE0, 0xC0, 0x1C, 0xC0, 0x1C, 0x18, 0x03, 0x98, 0x03, 0x83,
  0x00, 0x63, 0x00, 0xE0, 0x60, 0x1C, 0x60, 0x1C, 0x0C, 0x03, 0x8C, 0x03,
  0x83, 0x80, 0x61, 0x80, 0xE0, 0x70, 0x1C, 0x30, 0x1C, 0x0E, 0x03, 0x86,
  0x03, 0x81, 0xC0, 0x60, 0xC0, 0x70, 0x38, 0x0C, 0x18, 0x1C, 0x07, 0x03,
  0x83, 0x03, 0x80, 0xE0, 0x60, 0x60, 0x70, 0x1C, 0x0C, 0x0C, 0x0C, 0x03,
  0x83, 0x81, 0x83, 0x80, 0x70, 0x60, 0x30, 0x70, 0x0E, 0x0C, 0x06, 0x0E,
  0x01, 0xC3, 0x80, 0xC3, 0x80, 0x38, 0x70, 0x18, 0x70, 0x07, 0x0C, 0x03,
  0x0E, 0x00, 0xE1, 0x80, 0x61, 0x80, 0x1C, 0x70, 0x0C, 0x70, 0x03, 0x8C,
  0x01, 0x8E, 0x00, 0x71, 0x80, 0x31, 0xC0, 0x0E, 0x70, 0x0E, 0x30, 0x01,
  0xCC, 0x01, 0xCE, 0x00, 0x39, 0x80, 0x39, 0xC0, 0x07, 0x70, 0x07, 0x30,
  0x00, 0xEC, 0x00, 0xEE, 0x00, 0x1D, 0x80, 0x1D, 0xC0, 0x03, 0x30, 0x03,
  0xB8, 0x00, 0x6E, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x0F, 0xC0, 0x01, 0xB0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x0F, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x0E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x07,
  0x03, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0x71, 0xE0, 0x00,
  0x39, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x3C, 0x0E, 0x07, 0x81,
  0xC0, 0x70, 0x3C, 0x0F, 0x00, 0x1F, 0xF0, 0x78, 0x03, 0xFF, 0xE3, 0x80,
  0x3F, 0x9F, 0x9C, 0x03, 0xC0, 0x0E, 0xE0, 0x3C, 0x00, 0x37, 0x03, 0xC0,
  0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xDC, 0x07, 0x80, 0x0F, 0xE0,
  0x1F, 0x03, 0xEE, 0x00, 0x7F, 0xFC, 0x70, 0x01, 0xFF, 0xC3, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x07, 0xFC, 0x00, 0x78,
  0xFF, 0xF8, 0x03, 0x9F, 0x9F, 0xE0, 0x1D, 0xE0, 0x0F, 0x80, 0xEC, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x1D,
  0xC0, 0x0F, 0x00, 0xEF, 0x81, 0xF0, 0x0F, 0x3F, 0xFF, 0x00, 0x70, 0x7F,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x04, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x83,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x07, 0xFC, 0x1E, 0x00, 0x7F, 0xFC,
  0x70, 0x03, 0xF9, 0xF9, 0xC0, 0x1E, 0x00, 0x77, 0x00, 0xF0, 0x00, 0xDC,
  0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0xDC, 0x03, 0xC0, 0x07, 0xF0, 0x07, 0xC0, 0xFB, 0xC0, 0x0F, 0xFF, 0x8E,
  0x00, 0x1F, 0xFC, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x78, 0x03,
  0xC0, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x1E, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0xC0, 0x1F, 0x83, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x78, 0x03, 0xFF, 0xE3,
  0x80, 0x3F, 0x9F, 0x9C, 0x03, 0xC0, 0x0E, 0xE0, 0x3C, 0x00, 0x37, 0x03,
  0xC0, 0x00, 0xB8, 0x3C, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x7C, 0x0E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x7E, 0x01, 0xE0,
  0x07, 0x70, 0x0F, 0xC1, 0xF3, 0x80, 0x3F, 0xFF, 0x1C, 0x00, 0x7F, 0xE1,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x07, 0xFC, 0x00,
  0x78, 0xFF, 0xF8, 0x03, 0x8F, 0x9F, 0xE0, 0x1C, 0xE0, 0x0F, 0x80, 0xEC,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C,
  0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x07,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x03, 0x1F, 0xC0, 0xFC, 0x03, 0x9F, 0xF1, 0xFF, 0x01,
  0xDE, 0xFD, 0xEF, 0xC0, 0xE8, 0x1E, 0x81, 0xE0, 0x78, 0x07, 0x80, 0x70,
  0x38, 0x03, 0xC0, 0x3C, 0x1C, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x0E,
  0x0E, 0x00, 0x70, 0x07, 0x07, 0x00, 0x38, 0x03, 0x83, 0x80, 0x3C, 0x01,
  0xC1, 0xC0, 0x1C, 0x00, 0xE0, 0xE0, 0x0E, 0x00, 0xF0, 0x70, 0x07, 0x00,
  0x70, 0x78, 0x03, 0x80, 0x38, 0x38, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0xE0,
  0x0E, 0x0E, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x70, 0x03, 0x83, 0x80, 0x38,
  0x03, 0xC3, 0xC0, 0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x00, 0xE0, 0xE0, 0x07,
  0x00, 0x70, 0x70, 0x07, 0x00, 0x38, 0x38, 0x03, 0x80, 0x1C, 0x1C, 0x01,
  0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x07, 0x07, 0x00,
  0x38, 0x03, 0x83, 0x80, 0x3C, 0x01, 0xC1, 0xC0, 0x1C, 0x00, 0xE0, 0xE0,
  0x0E, 0x00, 0x70, 0x70, 0x07, 0x00, 0x70, 0x78, 0x03, 0x80, 0x38, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0x03, 0x83, 0xFE, 0x00, 0x3C, 0x7F, 0xFC, 0x01,
  0xC7, 0xCF, 0xF0, 0x0E, 0x70, 0x07, 0xC0, 0x76, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x1C, 0x78, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0x80, 0x03, 0xC7, 0xFF,
  0xC0, 0x07, 0x3F, 0x3F, 0xC0, 0x0E, 0xF0, 0x07, 0xC0, 0x1D, 0x80, 0x07,
  0x80, 0x3E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x78, 0x07, 0xE0, 0x01, 0xE0, 0x0E, 0xE0, 0x07, 0x80, 0x1D, 0xF0, 0x3E,
  0x00, 0x79, 0xFF, 0xF8, 0x00, 0xE0, 0xFF, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x78, 0x03, 0xFF, 0xE3, 0x80,
  0x3F, 0x9F, 0x9C, 0x03, 0xC0, 0x0E, 0xE0, 0x3C, 0x00, 0x37, 0x03, 0xC0,
  0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xDC, 0x07, 0x80, 0x0F, 0xE0,
  0x1F, 0x03, 0xEE, 0x00, 0x7F, 0xFC, 0x70, 0x01, 0xFF, 0xC3, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0x83, 0xFE, 0x00, 0x1C, 0x7F, 0xFC, 0x01, 0xEF,
  0xEF, 0xF0, 0x0E, 0xF0, 0x07, 0xC0, 0x76, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xE0, 0x03,
  0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x1C, 0x01, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xF0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x70, 0x03, 0x80, 0x03,
  0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x1E, 0x00,
  0x3F, 0x00, 0x3C, 0x00, 0xEE, 0x00, 0xF8, 0x01, 0xDC, 0x01, 0xB0, 0x03,
  0xB8, 0x03, 0x60, 0x0E, 0x70, 0x0E, 0xC0, 0x1C, 0xE0, 0x19, 0x80, 0x39,
  0xC0, 0x33, 0x80, 0xE3, 0x80, 0xE7, 0x01, 0xC7, 0x01, 0x8E, 0x03, 0x8E,
  0x03, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x1C, 0x38, 0x18, 0x70, 0x38, 0x70,
  0x30, 0xE0, 0xE0, 0xE0, 0xE1, 0xC1, 0xC1, 0xC1, 0x83, 0x83, 0x83, 0x83,
  0x07, 0x0E, 0x07, 0x0E, 0x06, 0x1C, 0x0E, 0x18, 0x0C, 0x38, 0x1C, 0x70,
  0x18, 0xE0, 0x38, 0xE0, 0x31, 0xC0, 0x71, 0x80, 0x63, 0x80, 0xE7, 0x00,
  0xCE, 0x01, 0xCE, 0x01, 0x9C, 0x03, 0x98, 0x03, 0x38, 0x07, 0x70, 0x06,
  0x60, 0x0E, 0xE0, 0x0D, 0xC0, 0x1D, 0x80, 0x1B, 0x80, 0x3F, 0x00, 0x36,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0F, 0x00,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C,
  0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x38, 0x70, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0x70, 0x3E, 0x00, 0xE7, 0x01,
  0xF8, 0x3C, 0xF0, 0x0F, 0xFF, 0x8E, 0x00, 0x7F, 0xE0, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x38, 0x7F, 0xC0, 0x01, 0xC7, 0xFF, 0x00, 0x0E,
  0x78, 0x3C, 0x00, 0x73, 0x80, 0xF0, 0x03, 0x38, 0x03, 0x80, 0x39, 0xC0,
  0x1E, 0x01, 0xCE, 0x00, 0x78, 0x1E, 0x70, 0x01, 0xE1, 0xE3, 0x00, 0x07,
  0xFE, 0x38, 0x00, 0x1F, 0xE1, 0xC0, 0x00, 0x1C, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 12, 46, 38, 13, -46 },
  { 70, 19, 19, 38, 13, -46 },
  { 116, 36, 46, 38, 2, -46 },
  { 323, 31, 64, 38, 4, -55 },
  { 571, 43, 46, 38, -2, -46 },
  { 819, 33, 48, 38, 2, -47 },
  { 1017, 7, 19, 38, 19, -46 },
  { 1034, 25, 61, 38, 11, -53 },
  { 1225, 25, 61, 38, 3, -53 },
  { 1416, 32, 32, 38, 4, -38 },
  { 1544, 29, 30, 38, 5, -36 },
  { 1653, 13, 20, 38, 8, -10 },
  { 1686, 21, 3, 38, 9, -22 },
  { 1694, 10, 10, 38, 12, -9 },
  { 1707, 35, 59, 38, 2, -52 },
  { 1966, 31, 48, 38, 4, -47 },
  { 2152, 27, 46, 38, 4, -46 },
  { 2308, 32, 47, 38, 3, -47 },
  { 2496, 31, 47, 38, 4, -46 },
  { 2679, 28, 46, 38, 5, -46 },
  { 2840, 30, 47, 38, 5, -46 },
  { 3017, 29, 47, 38, 4, -46 },
  { 3188, 30, 46, 38, 8, -46 },
  { 3361, 31, 48, 38, 4, -47 },
  { 3547, 28, 47, 38, 7, -47 },
  { 3712, 14, 36, 38, 12, -35 },
  { 3775, 18, 45, 38, 8, -35 },
  { 3877, 29, 32, 38, 6, -37 },
  { 3993, 29, 17, 38, 5, -29 },
  { 4055, 29, 32, 38, 4, -37 },
  { 4171, 25, 46, 38, 10, -46 },
  { 4315, 35, 58, 38, 2, -47 },
  { 4569, 29, 46, 38, 2, -46 },
  { 4736, 31, 46, 38, 4, -46 },
  { 4915, 30, 48, 38, 5, -47 },
  { 5095, 30, 46, 38, 4, -46 },
  { 5268, 32, 46, 38, 5, -46 },
  { 5452, 34, 46, 38, 4, -46 },
  { 5648, 30, 48, 38, 5, -47 },
  { 5828, 31, 46, 38, 4, -46 },
  { 6007, 30, 46, 38, 5, -46 },
  { 6180, 32, 47, 38, 3, -46 },
  { 6368, 34, 46, 38, 4, -46 },
  { 6564, 26, 46, 38, 5, -46 },
  { 6714, 34, 46, 38, 3, -46 },
  { 6910, 31, 46, 38, 4, -46 },
  { 7089, 29, 48, 38, 5, -47 },
  { 7263, 33, 46, 38, 4, -46 },
  { 7453, 29, 58, 38, 5, -47 },
  { 7664, 32, 46, 38, 4, -46 },
  { 7848, 31, 48, 38, 4, -47 },
  { 8034, 31, 46, 38, 8, -46 },
  { 8213, 31, 47, 38, 5, -46 },
  { 8396, 29, 46, 38, 9, -46 },
  { 8563, 35, 46, 38, 5, -46 },
  { 8765, 37, 46, 38, 1, -46 },
  { 8978, 31, 46, 38, 8, -46 },
  { 9157, 33, 46, 38, 3, -46 },
  { 9347, 24, 59, 38, 10, -52 },
  { 9524, 17, 59, 38, 11, -52 },
  { 9650, 23, 59, 38, 6, -52 },
  { 9820, 25, 25, 38, 7, -46 },
  { 9899, 31, 2, 38, 0, 2 },
  { 9907, 9, 8, 38, 18, -49 },
  { 9916, 29, 36, 38, 5, -35 },
  { 10047, 29, 47, 38, 4, -46 },
  { 10218, 28, 36, 38, 5, -35 },
  { 10344, 30, 47, 38, 5, -46 },
  { 10521, 28, 36, 38, 5, -35 },
  { 10647, 39, 57, 38, -2, -46 },
  { 10925, 29, 46, 38, 5, -35 },
  { 11092, 29, 46, 38, 4, -46 },
  { 11259, 28, 48, 38, 3, -48 },
  { 11427, 32, 59, 38, 1, -48 },
  { 11663, 32, 46, 38, 4, -46 },
  { 11847, 25, 46, 38, 7, -46 },
  { 11991, 33, 35, 38, 2, -35 },
  { 12136, 29, 35, 38, 4, -35 },
  { 12263, 28, 36, 38, 5, -35 },
  { 12389, 31, 46, 38, 2, -35 },
  { 12568, 29, 46, 38, 5, -35 },
  { 12735, 29, 35, 38, 5, -35 },
  { 12862, 29, 36, 38, 4, -35 },
  { 12993, 28, 44, 38, 7, -44 },
  { 13147, 29, 36, 38, 5, -35 },
  { 13278, 29, 35, 38, 7, -35 },
  { 13405, 31, 35, 38, 6, -35 },
  { 13541, 33, 35, 38, 2, -35 },
  { 13686, 28, 46, 38, 5, -35 },
  { 13847, 29, 35, 38, 4, -35 },
  { 13974, 30, 59, 38, 7, -52 },
  { 14196, 13, 59, 38, 13, -52 },
  { 14292, 31, 59, 38, 2, -52 },
  { 14521, 29, 12, 38, 5, -28 },
};

const GFXfont JetBrainsMono_ThinItalic63pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic63pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _JETBRAINSMONO_THINITALIC63PT7B_H_
