#ifndef _JETBRAINSMONO_THINITALIC15PT7B_H_
#define _JETBRAINSMONO_THINITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x0B, 0x00, 0x4C, 0xA5, 0x29, 0x00, 0x08, 0x84,
  0x82, 0x47, 0xF1, 0x21, 0x10, 0x89, 0xFE, 0x44, 0x22, 0x12, 0x00, 0x08,
  0x10, 0x79, 0x54, 0xA9, 0x0C, 0x0C, 0x14, 0x26, 0x4C, 0xA7, 0x84, 0x08,
  0x00, 0x38, 0x52, 0x24, 0x91, 0x28, 0x74, 0x02, 0x01, 0x70, 0x62, 0x29,
  0x12, 0x48, 0x60, 0x0E, 0x11, 0x20, 0x10, 0x10, 0x28, 0x49, 0x46, 0x44,
  0x46, 0x79, 0xF8, 0x04, 0x62, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x81, 0x02, 0x00, 0x20, 0x40, 0x82, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84,
  0x11, 0x88, 0x00, 0x08, 0x08, 0x93, 0x7C, 0x10, 0x28, 0xC4, 0x08, 0x20,
  0x47, 0xF1, 0x02, 0x04, 0x00, 0x69, 0x40, 0xF8, 0xF0, 0x03, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x1C,
  0x45, 0x0A, 0x14, 0x2B, 0x60, 0xC1, 0x85, 0x09, 0xE0, 0x08, 0xE4, 0x82,
  0x08, 0x20, 0x84, 0x10, 0x4F, 0xC0, 0x3E, 0x85, 0x08, 0x10, 0x20, 0x82,
  0x08, 0x20, 0x83, 0xF0, 0x3E, 0x08, 0x10, 0x41, 0x80, 0x81, 0x02, 0x85,
  0x09, 0xE0, 0x02, 0x08, 0x20, 0x82, 0x04, 0x51, 0x42, 0x7C, 0x08, 0x10,
  0x3E, 0x81, 0x02, 0x07, 0xC8, 0x40, 0x81, 0x05, 0x09, 0xE0, 0x04, 0x10,
  0x41, 0x03, 0x88, 0xA0, 0xC1, 0x83, 0x09, 0xE0, 0xFF, 0x06, 0x10, 0x40,
  0x82, 0x04, 0x10, 0x20, 0x83, 0x00, 0x1C, 0x45, 0x0A, 0x12, 0x47, 0x11,
  0x41, 0x85, 0x09, 0xE0, 0x7A, 0x18, 0x61, 0x86, 0x27, 0x84, 0x20, 0x84,
  0x00, 0x6C, 0x00, 0x36, 0x33, 0x00, 0x00, 0x64, 0x48, 0x02, 0x08, 0x63,
  0x0C, 0x06, 0x02, 0x02, 0x7E, 0x00, 0x07, 0xE0, 0x40, 0x40, 0x60, 0x20,
  0x63, 0x18, 0x40, 0x38, 0x10, 0x41, 0x04, 0xE2, 0x10, 0x01, 0x04, 0x00,
  0x1F, 0x10, 0x48, 0x28, 0x14, 0xFA, 0x49, 0x24, 0xA2, 0x51, 0x47, 0xA0,
  0x08, 0x04, 0x01, 0xC0, 0x04, 0x18, 0x30, 0x91, 0x22, 0x48, 0x9F, 0x42,
  0x86, 0x08, 0x3C, 0x85, 0x0A, 0x14, 0x4F, 0x11, 0x41, 0x83, 0x0B, 0xE0,
  0x1E, 0x45, 0x0A, 0x04, 0x08, 0x20, 0x40, 0x85, 0x09, 0xE0, 0x3C, 0x85,
  0x0A, 0x14, 0x28, 0x50, 0xC2, 0x85, 0x0B, 0xE0, 0x3F, 0x20, 0x40, 0x40,
  0x40, 0x7C, 0x40, 0x40, 0x80, 0x80, 0xFC, 0x3F, 0x40, 0x40, 0x40, 0x40,
  0x7E, 0x40, 0x80, 0x80, 0x80, 0x80, 0x1E, 0x45, 0x0A, 0x04, 0x08, 0x27,
  0xC1, 0x85, 0x09, 0xE0, 0x22, 0x85, 0x0A, 0x14, 0x2F, 0xD0, 0xC2, 0x85,
  0x0A, 0x10, 0x3E, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x23, 0xF0,
  0x0E, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x85, 0x0B, 0xE0, 0x21, 0x42,
  0x42, 0x44, 0x48, 0x78, 0x48, 0x88, 0x84, 0x84, 0x84, 0x20, 0x84, 0x10,
  0x41, 0x04, 0x10, 0x82, 0x0F, 0xC0, 0x63, 0x62, 0x66, 0x66, 0x5A, 0x92,
  0x82, 0x82, 0x84, 0x84, 0x84, 0x22, 0x45, 0x8A, 0x95, 0x2A, 0x54, 0xC6,
  0x8D, 0x1A, 0x10, 0x1C, 0x45, 0x0A, 0x14, 0x28, 0x60, 0xC2, 0x85, 0x09,
  0xE0, 0x3E, 0x41, 0x41, 0x41, 0x42, 0x7C, 0x40, 0x80, 0x80, 0x80, 0x80,
  0x1C, 0x45, 0x0A, 0x14, 0x28, 0x60, 0xC2, 0x85, 0x09, 0xE0, 0x40, 0x80,
  0x80, 0x3E, 0x42, 0x41, 0x42, 0x42, 0x7C, 0x48, 0x88, 0x88, 0x84, 0x84,
  0x1E, 0x45, 0x0A, 0x02, 0x03, 0x01, 0x01, 0x83, 0x09, 0xE0, 0xFE, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x41, 0x00, 0x42, 0x85, 0x0A, 0x14,
  0x28, 0x50, 0xC2, 0x85, 0x09, 0xE0, 0x83, 0x06, 0x14, 0x28, 0x89, 0x14,
  0x28, 0x50, 0xC1, 0x80, 0x89, 0x89, 0x99, 0x99, 0x9A, 0xAA, 0xAA, 0xAA,
  0xCC, 0xCC, 0x8C, 0x20, 0x88, 0x84, 0x82, 0x40, 0xC0, 0x40, 0x50, 0x28,
  0x22, 0x21, 0x20, 0xC0, 0x83, 0x09, 0x12, 0x45, 0x06, 0x08, 0x10, 0x20,
  0x41, 0x00, 0x7F, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80,
  0xFC, 0x3C, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x10, 0x83, 0xC0,
  0x88, 0x88, 0x44, 0x44, 0x22, 0x22, 0x11, 0x1C, 0x10, 0x41, 0x08, 0x20,
  0x82, 0x08, 0x21, 0x04, 0x13, 0xC0, 0x10, 0xA2, 0x92, 0x8A, 0x10, 0xFE,
  0x90, 0x3E, 0x85, 0x0C, 0x18, 0x50, 0xA1, 0x3E, 0x20, 0x81, 0x23, 0xA4,
  0x28, 0x50, 0xC2, 0x85, 0x0B, 0xE0, 0x3C, 0x85, 0x04, 0x08, 0x10, 0xA1,
  0x3C, 0x02, 0x04, 0x69, 0x34, 0x28, 0x60, 0xC2, 0x85, 0x09, 0xF0, 0x3C,
  0x85, 0x0B, 0xE8, 0x10, 0x21, 0x3C, 0x07, 0x84, 0x02, 0x07, 0xE4, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x06, 0x00, 0x3E, 0x85,
  0x0C, 0x18, 0x50, 0x93, 0x1A, 0x04, 0x11, 0xC0, 0x20, 0x81, 0x23, 0xA4,
  0x28, 0x50, 0xC2, 0x85, 0x0A, 0x10, 0x0C, 0x00, 0x1E, 0x08, 0x21, 0x04,
  0x10, 0x4F, 0xC0, 0x03, 0x00, 0x00, 0x3E, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x08, 0xF0, 0x20, 0x40, 0x41, 0x42, 0x44, 0x48, 0x70,
  0x88, 0x88, 0x84, 0x84, 0xE0, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x07,
  0xC0, 0x7F, 0x26, 0x4C, 0x99, 0x32, 0x64, 0xD2, 0x7C, 0x85, 0x0A, 0x18,
  0x50, 0xA1, 0x42, 0x3C, 0x85, 0x0C, 0x18, 0x50, 0xA1, 0x3C, 0x7C, 0x85,
  0x0A, 0x18, 0x50, 0xA1, 0x7C, 0x81, 0x02, 0x00, 0x3E, 0x85, 0x0C, 0x18,
  0x50, 0xA1, 0x3E, 0x04, 0x08, 0x20, 0x7E, 0x85, 0x0A, 0x04, 0x08, 0x20,
  0x40, 0x3E, 0x85, 0x03, 0xC0, 0x40, 0xA1, 0x3C, 0x20, 0x82, 0x3F, 0x20,
  0x84, 0x10, 0x41, 0x07, 0x80, 0x42, 0x85, 0x0A, 0x18, 0x50, 0xA1, 0x3C,
  0x87, 0x0A, 0x24, 0x45, 0x0A, 0x18, 0x30, 0x99, 0x9A, 0x9A, 0xAA, 0xAC,
  0xAC, 0xCC, 0xC8, 0x21, 0x12, 0x14, 0x08, 0x18, 0x14, 0x22, 0xC2, 0x42,
  0x85, 0x0C, 0x28, 0x50, 0x97, 0x12, 0x04, 0x13, 0xC0, 0x7E, 0x08, 0x20,
  0x82, 0x08, 0x10, 0x7E, 0x0E, 0x20, 0x40, 0x81, 0x02, 0x38, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x03, 0x00, 0x24, 0x92, 0x92, 0x49, 0x49, 0x00, 0x30,
  0x10, 0x40, 0x81, 0x02, 0x03, 0x88, 0x20, 0x40, 0x81, 0x02, 0x18, 0x00,
  0x63, 0x26, 0x38,
};

const GFXglyph JetBrainsMono_ThinItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 5, 9, 3, -11 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 7, 15, 9, 1, -13 },
  { 37, 10, 11, 9, 0, -11 },
  { 51, 8, 11, 9, 0, -11 },
  { 62, 1, 5, 9, 5, -11 },
  { 63, 6, 15, 9, 3, -13 },
  { 75, 6, 15, 9, 1, -13 },
  { 87, 8, 7, 9, 1, -9 },
  { 94, 7, 7, 9, 1, -8 },
  { 101, 3, 4, 9, 2, -2 },
  { 103, 5, 1, 9, 2, -5 },
  { 104, 2, 2, 9, 3, -2 },
  { 105, 8, 14, 9, 1, -12 },
  { 119, 7, 11, 9, 1, -11 },
  { 129, 6, 11, 9, 1, -11 },
  { 138, 7, 11, 9, 1, -11 },
  { 148, 7, 11, 9, 1, -11 },
  { 158, 7, 11, 9, 1, -11 },
  { 168, 7, 11, 9, 1, -11 },
  { 178, 7, 11, 9, 1, -11 },
  { 188, 7, 11, 9, 2, -11 },
  { 198, 7, 11, 9, 1, -11 },
  { 208, 6, 11, 9, 2, -11 },
  { 217, 3, 8, 9, 3, -8 },
  { 220, 4, 10, 9, 2, -8 },
  { 225, 7, 8, 9, 1, -9 },
  { 232, 7, 4, 9, 1, -7 },
  { 236, 7, 8, 9, 1, -9 },
  { 243, 6, 11, 9, 2, -11 },
  { 252, 9, 14, 9, 0, -11 },
  { 268, 7, 11, 9, 0, -11 },
  { 278, 7, 11, 9, 1, -11 },
  { 288, 7, 11, 9, 1, -11 },
  { 298, 7, 11, 9, 1, -11 },
  { 308, 8, 11, 9, 1, -11 },
  { 319, 8, 11, 9, 1, -11 },
  { 330, 7, 11, 9, 1, -11 },
  { 340, 7, 11, 9, 1, -11 },
  { 350, 7, 11, 9, 1, -11 },
  { 360, 7, 11, 9, 1, -11 },
  { 370, 8, 11, 9, 1, -11 },
  { 381, 6, 11, 9, 1, -11 },
  { 390, 8, 11, 9, 1, -11 },
  { 401, 7, 11, 9, 1, -11 },
  { 411, 7, 11, 9, 1, -11 },
  { 421, 8, 11, 9, 1, -11 },
  { 432, 7, 14, 9, 1, -11 },
  { 445, 8, 11, 9, 1, -11 },
  { 456, 7, 11, 9, 1, -11 },
  { 466, 7, 11, 9, 2, -11 },
  { 476, 7, 11, 9, 1, -11 },
  { 486, 7, 11, 9, 2, -11 },
  { 496, 8, 11, 9, 1, -11 },
  { 507, 9, 11, 9, 0, -11 },
  { 520, 7, 11, 9, 2, -11 },
  { 530, 8, 11, 9, 1, -11 },
  { 541, 6, 14, 9, 2, -12 },
  { 552, 4, 14, 9, 3, -12 },
  { 559, 6, 14, 9, 1, -12 },
  { 570, 6, 6, 9, 2, -11 },
  { 575, 7, 1, 9, 0, 0 },
  { 576, 2, 2, 9, 4, -12 },
  { 577, 7, 8, 9, 1, -8 },
  { 584, 7, 11, 9, 1, -11 },
  { 594, 7, 8, 9, 1, -8 },
  { 601, 7, 11, 9, 1, -11 },
  { 611, 7, 8, 9, 1, -8 },
  { 618, 9, 14, 9, 0, -11 },
  { 634, 7, 11, 9, 1, -8 },
  { 644, 7, 11, 9, 1, -11 },
  { 654, 6, 11, 9, 1, -11 },
  { 663, 8, 14, 9, 0, -11 },
  { 677, 8, 11, 9, 1, -11 },
  { 688, 6, 11, 9, 2, -11 },
  { 697, 7, 8, 9, 1, -8 },
  { 704, 7, 8, 9, 1, -8 },
  { 711, 7, 8, 9, 1, -8 },
  { 718, 7, 11, 9, 1, -8 },
  { 728, 7, 11, 9, 1, -8 },
  { 738, 7, 8, 9, 1, -8 },
  { 745, 7, 8, 9, 1, -8 },
  { 752, 6, 11, 9, 2, -11 },
  { 761, 7, 8, 9, 1, -8 },
  { 768, 7, 8, 9, 2, -8 },
  { 775, 8, 8, 9, 1, -8 },
  { 783, 8, 8, 9, 0, -8 },
  { 791, 7, 11, 9, 1, -8 },
  { 801, 7, 8, 9, 1, -8 },
  { 808, 7, 14, 9, 2, -12 },
  { 821, 3, 14, 9, 3, -12 },
  { 827, 7, 14, 9, 1, -12 },
  { 840, 7, 3, 9, 1, -7 },
};

const GFXfont JetBrainsMono_ThinItalic15pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic15pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _JETBRAINSMONO_THINITALIC15PT7B_H_
