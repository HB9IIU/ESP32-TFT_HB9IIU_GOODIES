#ifndef _JETBRAINSMONO_THINITALIC55PT7B_H_
#define _JETBRAINSMONO_THINITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x9E, 0x03,
  0xCE, 0x01, 0xC7, 0x00, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xE0,
  0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCE, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x30,
  0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x60,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x78, 0xC7,
  0xC0, 0x0E, 0x0C, 0x1C, 0x01, 0xC0, 0xC1, 0xE0, 0x38, 0x0C, 0x0E, 0x03,
  0x80, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x18,
  0x0E, 0x07, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x78, 0x38, 0x00, 0x03, 0x83, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x01, 0xE3,
  0x00, 0x00, 0x0F, 0xB0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x67, 0xC0, 0x00, 0x06, 0x1E, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x70,
  0x0C, 0x03, 0x06, 0x00, 0xC0, 0x70, 0x70, 0x1C, 0x07, 0x07, 0x01, 0x80,
  0x60, 0x70, 0x18, 0x0E, 0x07, 0x81, 0x81, 0xC0, 0x3C, 0x18, 0x3C, 0x01,
  0xF1, 0x9F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x38, 0x07, 0xFF, 0x00, 0x03, 0x00,
  0x78, 0x38, 0x00, 0x38, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x38, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x38, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x07, 0x00, 0x60, 0x18, 0x00, 0x38, 0x03, 0x01, 0xC0,
  0x01, 0xC0, 0x18, 0x1C, 0x00, 0x0C, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x0E,
  0x1C, 0x00, 0x03, 0x80, 0x61, 0xC0, 0x00, 0x1C, 0x07, 0x0C, 0x00, 0x00,
  0x79, 0xF0, 0xC0, 0x00, 0x03, 0xFF, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x0F, 0xE0,
  0x00, 0x00, 0x70, 0xFF, 0x80, 0x00, 0x07, 0x0E, 0x1E, 0x00, 0x00, 0x70,
  0xE0, 0x30, 0x00, 0x07, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x60, 0x0E, 0x00,
  0x03, 0x03, 0x00, 0x70, 0x00, 0x30, 0x18, 0x03, 0x00, 0x03, 0x81, 0xC0,
  0x18, 0x00, 0x38, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x0E, 0x00, 0x38,
  0x03, 0x00, 0x70, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x07, 0x01, 0xC0, 0x1C, 0x00, 0x3C, 0x3C, 0x01, 0xC0, 0x00,
  0xFF, 0xC0, 0x1C, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x18, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F,
  0x07, 0x00, 0x1C, 0x70, 0x3C, 0x01, 0xC7, 0x00, 0xE0, 0x1C, 0x38, 0x03,
  0x80, 0xE1, 0x80, 0x1C, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0xE0, 0x03, 0xC6,
  0x07, 0x00, 0x0E, 0x70, 0x38, 0x00, 0x3F, 0x01, 0xC0, 0x01, 0xF0, 0x0C,
  0x00, 0x07, 0x80, 0x60, 0x00, 0x38, 0x07, 0x00, 0x03, 0xE0, 0x38, 0x00,
  0x1F, 0x81, 0xC0, 0x01, 0xDC, 0x0F, 0x00, 0x1C, 0x70, 0x38, 0x03, 0xC3,
  0x81, 0xF0, 0x7C, 0x0E, 0x07, 0xFF, 0x80, 0x38, 0x1F, 0xF8, 0x01, 0xC0,
  0x08, 0x00, 0x00, 0x00, 0x3B, 0xDE, 0xF7, 0xB9, 0xDE, 0xF7, 0xBD, 0xCE,
  0x73, 0x98, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x01, 0x80, 0x38, 0x01,
  0x9F, 0x01, 0xC0, 0x7F, 0xFF, 0x0E, 0x1F, 0xF1, 0xFE, 0x33, 0xFE, 0x03,
  0xF9, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x00,
  0x0F, 0x00, 0x10, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x04, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB, 0xF9, 0xFC, 0xFC, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70,
  0xE0, 0x38, 0x0E, 0x1C, 0x0F, 0x81, 0xC3, 0x81, 0xF0, 0x38, 0x70, 0x3E,
  0x0F, 0x0E, 0x07, 0xC1, 0xC3, 0x80, 0x20, 0x38, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1C,
  0x07, 0x80, 0x07, 0x80, 0x78, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x70, 0x00, 0x3C, 0x70,
  0x00, 0xF8, 0x70, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0x60, 0x07, 0x00, 0xE0,
  0x06, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x80, 0x7C, 0x01,
  0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x01, 0xE0, 0x0F, 0x81, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x0C, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE1, 0xFF, 0x00,
  0x39, 0xFF, 0xE0, 0x0C, 0xE0, 0x7C, 0x03, 0x60, 0x07, 0x81, 0xF0, 0x00,
  0xE0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x18, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x0F,
  0x80, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x9F, 0xE0, 0x07, 0x7F, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x78, 0x38, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF9, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3C,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x78, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x70, 0x00, 0x78,
  0x70, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x38, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x83, 0x80, 0x07, 0xC1, 0xF0,
  0x07, 0xC0, 0x7F, 0x1E, 0xC0, 0x1F, 0xFC, 0xE0, 0x03, 0xF8, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x1F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x02, 0x00, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x0E, 0x0E, 0x00,
  0x7F, 0xCE, 0x0E, 0x00, 0xFF, 0xEC, 0x0E, 0x01, 0xE0, 0x6C, 0x0C, 0x03,
  0xC0, 0x3C, 0x0C, 0x03, 0x80, 0x1C, 0x1C, 0x07, 0x00, 0x1C, 0x1C, 0x07,
  0x00, 0x1C, 0x1C, 0x07, 0x00, 0x1C, 0x1C, 0x07, 0x00, 0x18, 0x1C, 0x06,
  0x00, 0x38, 0x18, 0x06, 0x00, 0x38, 0x38, 0x0E, 0x00, 0x38, 0x38, 0x0E,
  0x00, 0x38, 0x38, 0x0E, 0x00, 0x38, 0x38, 0x0E, 0x00, 0x30, 0x38, 0x0E,
  0x00, 0x70, 0x30, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x00, 0x70, 0x70, 0x0E,
  0x00, 0xF0, 0x70, 0x0F, 0x01, 0xF0, 0x70, 0x07, 0xFF, 0x60, 0x70, 0x07,
  0xFE, 0x60, 0x70, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0x30,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x18,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0x60,
  0x01, 0xC0, 0x18, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x30, 0x07, 0xF0, 0x1C, 0x00, 0x3E, 0x07, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x06, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x0E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x3C,
  0x1C, 0x00, 0x1E, 0x07, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x06, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0xC3, 0x80, 0x01, 0xE0, 0xE0, 0x01, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x07, 0x01, 0xE0,
  0x01, 0xE0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x7C,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x30, 0x0F, 0xE0, 0x1C, 0x00, 0x7C,
  0x07, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x38,
  0x00, 0x06, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x38,
  0x30, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x18, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x07, 0x01, 0xE0,
  0x01, 0xE0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x07, 0xFF, 0xC7, 0x01, 0xFF, 0xF1, 0xC0, 0x7F, 0xF8,
  0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x7C,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x60, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00,
  0x0C, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x06, 0x00,
  0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06,
  0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x01, 0xF0, 0x1E,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x70,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x38, 0x00, 0x30, 0x03, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x38, 0x03,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0xF8,
  0x1E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0E, 0xC0, 0x03, 0x60, 0x76,
  0x00, 0x3B, 0x03, 0xB0, 0x01, 0xB8, 0x19, 0x80, 0x1D, 0xC0, 0xCE, 0x00,
  0xCE, 0x06, 0x30, 0x0C, 0x70, 0x71, 0x80, 0x63, 0x03, 0x8C, 0x06, 0x18,
  0x1C, 0x60, 0x31, 0xC0, 0xE3, 0x83, 0x0E, 0x07, 0x0C, 0x18, 0x70, 0x30,
  0x61, 0x83, 0x81, 0x83, 0x0C, 0x18, 0x1C, 0x18, 0xC0, 0xC0, 0xE0, 0x66,
  0x0E, 0x07, 0x03, 0x60, 0x70, 0x38, 0x1B, 0x03, 0x81, 0x80, 0xF0, 0x1C,
  0x0C, 0x07, 0x80, 0xC0, 0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0xE0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x03, 0xF0, 0x00, 0x60, 0x7E,
  0x00, 0x0C, 0x0E, 0xC0, 0x03, 0x81, 0xD8, 0x00, 0x70, 0x33, 0x80, 0x0E,
  0x06, 0x70, 0x01, 0xC1, 0xC6, 0x00, 0x30, 0x38, 0xC0, 0x06, 0x07, 0x18,
  0x01, 0xC0, 0xE3, 0x80, 0x38, 0x1C, 0x30, 0x07, 0x03, 0x06, 0x00, 0xE0,
  0x60, 0xC0, 0x18, 0x1C, 0x1C, 0x03, 0x03, 0x83, 0x80, 0xE0, 0x70, 0x30,
  0x1C, 0x0E, 0x06, 0x03, 0x81, 0x80, 0xE0, 0x70, 0x30, 0x1C, 0x0C, 0x0E,
  0x01, 0x81, 0x81, 0xC0, 0x30, 0x30, 0x38, 0x07, 0x0E, 0x07, 0x00, 0xE1,
  0xC0, 0xC0, 0x0C, 0x38, 0x18, 0x01, 0x87, 0x07, 0x00, 0x38, 0xC0, 0xE0,
  0x07, 0x18, 0x1C, 0x00, 0x67, 0x03, 0x80, 0x0C, 0xE0, 0x60, 0x01, 0xDC,
  0x0C, 0x00, 0x3B, 0x83, 0x80, 0x07, 0x60, 0x70, 0x00, 0x6C, 0x0E, 0x00,
  0x0F, 0x81, 0xC0, 0x01, 0xF0, 0x38, 0x00, 0x3E, 0x06, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3C, 0x03,
  0xC0, 0x38, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x87,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x61, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0xF0,
  0x1E, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0x00, 0x1F, 0x80, 0x70,
  0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x07, 0xE0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xF0,
  0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x0C, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x27, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0x00, 0x3F, 0x80, 0x70,
  0x00, 0x7C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x38, 0x03, 0x80, 0x03, 0x80, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0,
  0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0x80, 0x7C, 0x00, 0xE0,
  0x01, 0xC0, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x07, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0x1F, 0x00, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x05, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x70, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30,
  0x38, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x18, 0x00,
  0x07, 0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0,
  0x1C, 0x00, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x38, 0x60, 0x00,
  0x18, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x30,
  0x01, 0xC0, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x1C, 0x00,
  0x18, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x03, 0x87, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x03, 0x30, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x1D, 0xC0, 0x1E, 0x00, 0x67, 0x00, 0x78,
  0x03, 0x98, 0x01, 0xE0, 0x0E, 0x60, 0x0F, 0x80, 0x31, 0x80, 0x36, 0x01,
  0xC6, 0x00, 0xD8, 0x07, 0x18, 0x07, 0x60, 0x1C, 0x60, 0x19, 0x80, 0x61,
  0x80, 0x66, 0x03, 0x86, 0x01, 0x98, 0x0E, 0x18, 0x0C, 0x60, 0x30, 0x60,
  0x31, 0x80, 0xC1, 0x80, 0xC6, 0x07, 0x06, 0x06, 0x18, 0x1C, 0x18, 0x18,
  0x60, 0x60, 0x60, 0x61, 0x83, 0x81, 0x83, 0x86, 0x0E, 0x0E, 0x0C, 0x18,
  0x30, 0x38, 0x30, 0x60, 0xC0, 0xE0, 0xC1, 0x87, 0x03, 0x86, 0x06, 0x1C,
  0x0E, 0x18, 0x18, 0x60, 0x38, 0x60, 0x61, 0x80, 0xE3, 0x01, 0x8E, 0x03,
  0x8C, 0x06, 0x38, 0x0E, 0x30, 0x18, 0xC0, 0x39, 0x80, 0x67, 0x00, 0xE6,
  0x01, 0x9C, 0x03, 0x98, 0x06, 0x60, 0x0E, 0x60, 0x19, 0x80, 0x3B, 0x00,
  0x6E, 0x00, 0xCC, 0x01, 0xB8, 0x03, 0x30, 0x06, 0xC0, 0x0D, 0x80, 0x1F,
  0x00, 0x36, 0x00, 0x7C, 0x00, 0xD8, 0x03, 0x60, 0x03, 0xC0, 0x0D, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03,
  0xC0, 0x03, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x0C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x03,
  0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x0E,
  0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x80, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x39, 0x80, 0x00, 0xE7, 0x00, 0x07, 0x1C, 0x00, 0x3C, 0x70,
  0x00, 0xE0, 0xC0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x07,
  0x80, 0x70, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00,
  0x38, 0xF0, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x07, 0xF0, 0x00, 0x1C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0xE1, 0xC1, 0xC1, 0xC3, 0x83, 0x87, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF1,
  0xC0, 0x7F, 0xFC, 0xE0, 0x78, 0x07, 0x70, 0x78, 0x00, 0xF8, 0x38, 0x00,
  0x7C, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x86, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0,
  0x00, 0x30, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x3C,
  0x38, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x07, 0x00, 0x1F, 0x03, 0xE0, 0x3B,
  0x80, 0xFF, 0xF9, 0xC0, 0x1F, 0xF0, 0xE0, 0x00, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x03, 0xE0, 0x03, 0x8F, 0xFE, 0x01, 0xCF, 0xFF, 0x80,
  0xEC, 0x01, 0xE0, 0x7C, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xE1, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x0C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x86, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1F,
  0x00, 0x0E, 0x0F, 0xC0, 0x0E, 0x07, 0x70, 0x1E, 0x03, 0x9F, 0xFE, 0x01,
  0x87, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0x1E, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x38, 0x00, 0x07, 0x38, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x70, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x1F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0xF0, 0x30, 0x01, 0xFF, 0x8E, 0x00, 0xFF, 0xF9, 0xC0,
  0x3C, 0x03, 0xB8, 0x0F, 0x00, 0x1F, 0x01, 0xC0, 0x03, 0xE0, 0x70, 0x00,
  0x38, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0C,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x80,
  0x7C, 0x07, 0x70, 0x07, 0xFF, 0xCE, 0x00, 0x3F, 0xE1, 0xC0, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3C,
  0x03, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0xC7, 0x00, 0x03, 0x8C, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0xE3, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x03, 0xC0,
  0x7C, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xC7, 0x03, 0xFF, 0xE7, 0x07, 0x80, 0x77, 0x0F, 0x00, 0x17, 0x0E, 0x00,
  0x1F, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x70, 0x00,
  0x0C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x78, 0x70, 0x00, 0xF8, 0x78, 0x01, 0xB8, 0x3C, 0x03,
  0xB0, 0x1F, 0xFF, 0x70, 0x0F, 0xFC, 0x70, 0x03, 0xE0, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x03, 0xE0, 0x03, 0x8F, 0xFE, 0x01, 0xCF, 0xFF, 0x80,
  0xEE, 0x01, 0xE0, 0x7C, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x0E,
  0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xE1, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x18, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x86, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1,
  0x80, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x07,
  0x87, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0x80,
  0x03, 0x80, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x07,
  0x00, 0x06, 0x01, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1C, 0x03, 0x80, 0x33, 0xF8, 0x7F, 0x03,
  0xBF, 0xE7, 0xFC, 0x1F, 0x07, 0x41, 0xE0, 0xF0, 0x3C, 0x07, 0x07, 0x00,
  0xE0, 0x38, 0x38, 0x06, 0x01, 0xC1, 0x80, 0x70, 0x0E, 0x1C, 0x03, 0x80,
  0x70, 0xE0, 0x1C, 0x03, 0x87, 0x00, 0xE0, 0x18, 0x38, 0x06, 0x00, 0xC1,
  0xC0, 0x30, 0x0E, 0x0C, 0x03, 0x80, 0x70, 0x60, 0x1C, 0x03, 0x87, 0x00,
  0xE0, 0x1C, 0x38, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x06, 0x0E, 0x01, 0x80,
  0x70, 0x60, 0x0C, 0x03, 0x83, 0x00, 0xE0, 0x1C, 0x38, 0x07, 0x00, 0xE1,
  0xC0, 0x38, 0x07, 0x0E, 0x01, 0xC0, 0x30, 0x70, 0x0C, 0x01, 0x83, 0x80,
  0x60, 0x1C, 0x18, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x07, 0x0E, 0x01, 0xC0,
  0x38, 0x70, 0x0E, 0x01, 0x83, 0x80, 0x60, 0x0C, 0x00, 0x00, 0x07, 0xC0,
  0x07, 0x1F, 0xFC, 0x03, 0x9F, 0xFF, 0x01, 0xDC, 0x03, 0xC0, 0xF8, 0x00,
  0xE0, 0x68, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x87,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x60, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x1C, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3C, 0x03, 0xE0, 0xF0, 0x01,
  0xC1, 0xC0, 0x03, 0xC7, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0x38, 0x00, 0x0E, 0x60, 0x00, 0x1D, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0x9C, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x71, 0xC0, 0x00,
  0xE3, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x03, 0xC0, 0x78, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x71, 0xFF,
  0xC0, 0x0E, 0x7F, 0xFC, 0x01, 0xDC, 0x03, 0xC0, 0x3E, 0x00, 0x38, 0x07,
  0x80, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC0, 0xF8, 0x00,
  0x70, 0x1F, 0x80, 0x1C, 0x03, 0xB8, 0x0F, 0x00, 0x73, 0xFF, 0xC0, 0x0C,
  0x3F, 0xF0, 0x01, 0x80, 0x40, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF1, 0xC0, 0x7F, 0xFC, 0xE0, 0x78,
  0x07, 0x70, 0x78, 0x00, 0xF8, 0x38, 0x00, 0x7C, 0x38, 0x00, 0x1C, 0x18,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x1E, 0x00,
  0x1E, 0x07, 0x00, 0x1F, 0x03, 0xE0, 0x3B, 0x80, 0xFF, 0xF9, 0xC0, 0x1F,
  0xF0, 0xE0, 0x00, 0x80, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x07, 0x1F, 0xFC, 0x03, 0x9F, 0xFF, 0x01, 0xDC, 0x03, 0xC0, 0xF8,
  0x00, 0xE0, 0x78, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0xF8, 0x01, 0xE0,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x07, 0xC0, 0x0F, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x0E, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0x80, 0x00,
  0x70, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x0E,
  0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x38,
  0x03, 0xC0, 0x78, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x38, 0x60, 0x00, 0x38, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x30, 0x01,
  0xC0, 0x38, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x07,
  0x00, 0x18, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x7E, 0x00,
  0xE0, 0x0E, 0xE0, 0x1A, 0x00, 0xEE, 0x01, 0xA0, 0x0C, 0xE0, 0x1A, 0x01,
  0xCE, 0x03, 0x20, 0x1C, 0xE0, 0x32, 0x01, 0x8E, 0x03, 0x30, 0x38, 0xE0,
  0x63, 0x03, 0x8E, 0x06, 0x30, 0x30, 0xE0, 0x63, 0x07, 0x0E, 0x0C, 0x30,
  0x70, 0xE0, 0xC3, 0x06, 0x0E, 0x0C, 0x30, 0xE0, 0xE1, 0x83, 0x0E, 0x0E,
  0x18, 0x30, 0xC0, 0xE3, 0x83, 0x0C, 0x0E, 0x30, 0x31, 0xC0, 0xE3, 0x03,
  0x18, 0x0E, 0x70, 0x31, 0x80, 0xE6, 0x03, 0x38, 0x0E, 0x60, 0x33, 0x00,
  0xEE, 0x03, 0x30, 0x0E, 0xC0, 0x37, 0x00, 0xEC, 0x03, 0x60, 0x0F, 0xC0,
  0x36, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x70, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x00, 0x70,
  0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC3, 0x80,
  0x01, 0xE1, 0xE0, 0x01, 0x60, 0x70, 0x01, 0xF0, 0x3C, 0x03, 0xB8, 0x0F,
  0xFF, 0x9C, 0x03, 0xFF, 0x8E, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x88, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0x9F, 0xF0, 0x01, 0x9C, 0x1C, 0x00, 0xCC,
  0x07, 0x00, 0x6E, 0x01, 0xC0, 0x77, 0x00, 0xE0, 0x3B, 0x80, 0x38, 0x39,
  0x80, 0x0F, 0xFC, 0xC0, 0x03, 0xFC, 0x60, 0x00, 0x78, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 11, 40, 33, 11, -40 },
  { 56, 17, 16, 33, 11, -40 },
  { 90, 32, 40, 33, 1, -40 },
  { 250, 28, 56, 33, 3, -48 },
  { 446, 37, 40, 33, -1, -40 },
  { 631, 29, 42, 33, 2, -41 },
  { 784, 5, 16, 33, 17, -40 },
  { 794, 22, 53, 33, 10, -46 },
  { 940, 21, 53, 33, 3, -46 },
  { 1080, 29, 28, 33, 3, -34 },
  { 1182, 26, 26, 33, 4, -31 },
  { 1267, 12, 17, 33, 7, -8 },
  { 1293, 18, 2, 33, 8, -19 },
  { 1298, 9, 9, 33, 10, -8 },
  { 1309, 31, 52, 33, 2, -46 },
  { 1511, 27, 42, 33, 4, -41 },
  { 1653, 24, 40, 33, 3, -40 },
  { 1773, 28, 41, 33, 3, -41 },
  { 1917, 26, 41, 33, 4, -40 },
  { 2051, 24, 40, 33, 5, -40 },
  { 2171, 26, 41, 33, 4, -40 },
  { 2305, 24, 41, 33, 4, -40 },
  { 2428, 26, 40, 33, 7, -40 },
  { 2558, 28, 42, 33, 3, -41 },
  { 2705, 25, 41, 33, 6, -41 },
  { 2834, 13, 32, 33, 10, -31 },
  { 2886, 16, 40, 33, 7, -31 },
  { 2966, 26, 28, 33, 5, -32 },
  { 3057, 24, 15, 33, 5, -26 },
  { 3102, 26, 28, 33, 3, -32 },
  { 3193, 21, 40, 33, 9, -40 },
  { 3298, 32, 51, 33, 1, -41 },
  { 3502, 26, 40, 33, 1, -40 },
  { 3632, 26, 40, 33, 4, -40 },
  { 3762, 26, 42, 33, 5, -41 },
  { 3899, 26, 40, 33, 4, -40 },
  { 4029, 28, 40, 33, 4, -40 },
  { 4169, 29, 40, 33, 4, -40 },
  { 4314, 26, 42, 33, 5, -41 },
  { 4451, 27, 40, 33, 4, -40 },
  { 4586, 26, 40, 33, 4, -40 },
  { 4716, 28, 41, 33, 2, -40 },
  { 4860, 29, 40, 33, 4, -40 },
  { 5005, 23, 40, 33, 4, -40 },
  { 5120, 29, 40, 33, 3, -40 },
  { 5265, 27, 40, 33, 4, -40 },
  { 5400, 25, 42, 33, 5, -41 },
  { 5532, 28, 40, 33, 4, -40 },
  { 5672, 25, 51, 33, 5, -41 },
  { 5832, 28, 40, 33, 4, -40 },
  { 5972, 28, 42, 33, 3, -41 },
  { 6119, 27, 40, 33, 7, -40 },
  { 6254, 27, 41, 33, 4, -40 },
  { 6393, 25, 40, 33, 8, -40 },
  { 6518, 30, 40, 33, 5, -40 },
  { 6668, 33, 40, 33, 0, -40 },
  { 6833, 27, 40, 33, 7, -40 },
  { 6968, 28, 40, 33, 3, -40 },
  { 7108, 20, 52, 33, 9, -46 },
  { 7238, 14, 52, 33, 10, -46 },
  { 7329, 21, 52, 33, 5, -46 },
  { 7466, 22, 21, 33, 6, -40 },
  { 7524, 27, 3, 33, 0, 1 },
  { 7535, 7, 8, 33, 16, -43 },
  { 7542, 25, 32, 33, 4, -31 },
  { 7642, 25, 41, 33, 4, -40 },
  { 7771, 24, 32, 33, 5, -31 },
  { 7867, 27, 41, 33, 4, -40 },
  { 8006, 23, 32, 33, 5, -31 },
  { 8098, 34, 50, 33, -1, -40 },
  { 8311, 24, 41, 33, 5, -31 },
  { 8434, 25, 40, 33, 4, -40 },
  { 8559, 24, 42, 33, 3, -42 },
  { 8685, 28, 52, 33, 1, -42 },
  { 8867, 27, 40, 33, 4, -40 },
  { 9002, 22, 40, 33, 6, -40 },
  { 9112, 29, 31, 33, 2, -31 },
  { 9225, 25, 31, 33, 4, -31 },
  { 9322, 23, 32, 33, 5, -31 },
  { 9414, 27, 41, 33, 2, -31 },
  { 9553, 25, 41, 33, 4, -31 },
  { 9682, 25, 31, 33, 5, -31 },
  { 9779, 25, 32, 33, 4, -31 },
  { 9879, 24, 39, 33, 6, -39 },
  { 9996, 25, 31, 33, 4, -30 },
  { 10093, 24, 30, 33, 7, -30 },
  { 10183, 28, 30, 33, 5, -30 },
  { 10288, 29, 30, 33, 2, -30 },
  { 10397, 25, 40, 33, 4, -30 },
  { 10522, 26, 30, 33, 3, -30 },
  { 10620, 26, 52, 33, 6, -46 },
  { 10789, 11, 52, 33, 12, -46 },
  { 10861, 26, 52, 33, 2, -46 },
  { 11030, 25, 10, 33, 5, -24 },
};

const GFXfont JetBrainsMono_ThinItalic55pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic55pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _JETBRAINSMONO_THINITALIC55PT7B_H_
