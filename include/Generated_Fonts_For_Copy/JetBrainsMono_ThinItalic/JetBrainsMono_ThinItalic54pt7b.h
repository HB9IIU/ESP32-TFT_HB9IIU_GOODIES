#ifndef _JETBRAINSMONO_THINITALIC54PT7B_H_
#define _JETBRAINSMONO_THINITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01,
  0xF0, 0x3F, 0x0F, 0xE1, 0xF8, 0x1E, 0x00, 0x38, 0x07, 0x38, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x1E, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x18, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x08, 0x38, 0x01, 0xC0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x03, 0xC3, 0x1E, 0x00, 0xF0, 0x61, 0xE0, 0x1C, 0x1C, 0x1C, 0x07,
  0x03, 0x01, 0xC0, 0xC0, 0x60, 0x38, 0x38, 0x0C, 0x07, 0x07, 0x01, 0x80,
  0xE0, 0xE0, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x30, 0x00, 0x0F, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1E, 0x18, 0x00,
  0x01, 0xF3, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0C, 0x78, 0x00, 0x01, 0x87, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30,
  0x1C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x70, 0xC0, 0x18, 0x0E, 0x18,
  0x07, 0x01, 0xC3, 0x00, 0xC0, 0x30, 0x70, 0x18, 0x0E, 0x0E, 0x03, 0x01,
  0xC1, 0xE0, 0x60, 0x70, 0x1E, 0x0C, 0x3C, 0x01, 0xF3, 0x9F, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x10, 0x07, 0xFC, 0x00, 0x06, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x1C,
  0x0E, 0x00, 0x1C, 0x01, 0x80, 0x60, 0x03, 0x80, 0x38, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x07, 0x00, 0x60,
  0x18, 0x00, 0x70, 0x06, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x70, 0x00, 0x60,
  0x0E, 0x0E, 0x00, 0x06, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0x0C, 0x38, 0x00,
  0x07, 0x01, 0xC3, 0x00, 0x00, 0x78, 0x38, 0x60, 0x00, 0x03, 0xFF, 0x0E,
  0x00, 0x00, 0x1F, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x81, 0xE0, 0x00, 0x00, 0x38, 0x7F, 0x80, 0x00, 0x07, 0x0F,
  0xFC, 0x00, 0x00, 0xE1, 0xC0, 0xE0, 0x00, 0x1C, 0x38, 0x0E, 0x00, 0x03,
  0x83, 0x00, 0x60, 0x00, 0x30, 0x70, 0x06, 0x00, 0x06, 0x07, 0x00, 0xE0,
  0x00, 0xE0, 0x60, 0x0E, 0x00, 0x1C, 0x06, 0x00, 0xE0, 0x03, 0x80, 0x60,
  0x0C, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x06, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x03, 0x80, 0x07, 0x07, 0x00,
  0x70, 0x00, 0x3F, 0xE0, 0x0E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x70, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC0,
  0xE0, 0x07, 0x38, 0x0F, 0x00, 0xE3, 0x80, 0x70, 0x1C, 0x30, 0x03, 0x81,
  0xC7, 0x00, 0x38, 0x38, 0x70, 0x01, 0xC7, 0x07, 0x00, 0x1E, 0x60, 0x70,
  0x00, 0xEE, 0x07, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x78, 0x0E, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0xC0, 0xE0, 0x01, 0xCE, 0x0F,
  0x00, 0x3C, 0xE0, 0x70, 0x07, 0x87, 0x07, 0x81, 0xE0, 0x30, 0x3F, 0xFC,
  0x03, 0x81, 0xFF, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x3C, 0xF3, 0x8E,
  0x39, 0xE7, 0x9E, 0x71, 0xC7, 0x1C, 0x73, 0x8E, 0x38, 0x00, 0x00, 0x08,
  0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x40, 0x07, 0x00, 0x17, 0x80, 0x70, 0x0F,
  0xFF, 0x07, 0x07, 0xF3, 0xFC, 0x61, 0xFE, 0x0F, 0xF6, 0x7F, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x18, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0,
  0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x3F, 0x9F, 0xDF, 0xEF, 0xF3, 0xF9, 0xF8, 0x20,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0,
  0x7C, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x01, 0x00, 0xE3, 0x81,
  0xE0, 0x70, 0xE0, 0xFC, 0x1C, 0x38, 0x3F, 0x07, 0x0E, 0x07, 0xC1, 0xC7,
  0x00, 0xE0, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x3C,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xC0, 0x7C, 0x01, 0xE0,
  0x0F, 0xC1, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x70, 0x00,
  0x1E, 0x70, 0x00, 0x78, 0x60, 0x00, 0xF0, 0xE0, 0x03, 0xC0, 0xE0, 0x07,
  0x80, 0xE0, 0x06, 0x00, 0xE0, 0x04, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x06, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E,
  0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x83, 0xF0, 0x00, 0xC7, 0xFF, 0x00, 0x33, 0xFF,
  0xE0, 0x1D, 0x80, 0x3C, 0x07, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x8F, 0x80, 0x07, 0x7F, 0xF0, 0x0E, 0xFF,
  0xF8, 0x0F, 0x80, 0x7C, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x60, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x70, 0x78, 0x00, 0xE0, 0x3E, 0x03, 0xC0, 0x1F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x3C, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE3, 0xE0, 0x00,
  0xF0, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x03, 0xC0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFB,
  0xF8, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x1F, 0xFF,
  0x60, 0x07, 0xFC, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFE, 0x07, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07,
  0xE0, 0x10, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x01, 0x83, 0x80, 0x0F, 0xE7, 0x07, 0x00, 0x7F, 0xEE,
  0x0E, 0x01, 0xF1, 0xFC, 0x18, 0x07, 0x80, 0xF8, 0x70, 0x0E, 0x00, 0xE0,
  0xE0, 0x38, 0x01, 0xC1, 0xC0, 0x70, 0x03, 0x83, 0x80, 0xE0, 0x07, 0x07,
  0x01, 0x80, 0x0E, 0x0C, 0x07, 0x00, 0x1C, 0x18, 0x0E, 0x00, 0x38, 0x70,
  0x1C, 0x00, 0x60, 0xE0, 0x38, 0x01, 0xC1, 0xC0, 0x70, 0x03, 0x83, 0x80,
  0xC0, 0x07, 0x07, 0x03, 0x80, 0x0E, 0x0C, 0x07, 0x00, 0x1C, 0x38, 0x0E,
  0x00, 0x70, 0x70, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x06, 0xC1, 0xC0, 0x3F,
  0x7F, 0x83, 0x80, 0x3F, 0xE7, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x83, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x38, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x07, 0x00, 0x1C, 0x03, 0x80,
  0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x07, 0x00, 0x18,
  0x03, 0x80, 0x0E, 0x01, 0x80, 0x07, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x18, 0x38, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x06, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x70, 0x01, 0xF0,
  0x1C, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00,
  0x38, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x07, 0x01, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x38, 0x00, 0xF8, 0x0E, 0x00,
  0x0F, 0x03, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x70, 0x60, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x07, 0x80, 0xE0,
  0x3F, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x07, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x07, 0x80, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xC0, 0x1F, 0x00, 0xE0, 0x03, 0xC0,
  0x70, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xE0,
  0xC0, 0x00, 0x70, 0x60, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x78,
  0x1C, 0x00, 0xF8, 0x0E, 0x07, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x41, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x03, 0xFF, 0xC3, 0x80, 0xFF, 0xF0, 0xE0, 0x00, 0x1C,
  0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x81,
  0xE0, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x07, 0x80, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x0E,
  0x00, 0x03, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x0C,
  0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x38,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x80, 0x00, 0x78, 0x38, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38,
  0x03, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x0E,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x78, 0x00, 0x70, 0x03, 0x80,
  0x03, 0x80, 0x38, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0,
  0x01, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1B, 0x07,
  0xC0, 0x01, 0xF0, 0x76, 0x00, 0x37, 0x07, 0x60, 0x03, 0x70, 0x66, 0x00,
  0x66, 0x06, 0x60, 0x06, 0x60, 0x66, 0x00, 0xCE, 0x0E, 0x30, 0x0C, 0xE0,
  0xE3, 0x01, 0x8E, 0x0E, 0x30, 0x18, 0xE0, 0xE3, 0x03, 0x0C, 0x0C, 0x30,
  0x70, 0xC0, 0xC1, 0x86, 0x1C, 0x1C, 0x18, 0xE1, 0xC1, 0xC1, 0x8C, 0x1C,
  0x1C, 0x19, 0xC1, 0xC1, 0xC1, 0x98, 0x18, 0x1C, 0x0F, 0x81, 0x81, 0x80,
  0xF0, 0x38, 0x18, 0x0F, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0xC0, 0xF0, 0x00, 0x70, 0x7C, 0x00, 0x1C, 0x1F, 0x00, 0x07, 0x07, 0xE0,
  0x01, 0xC1, 0x98, 0x00, 0x60, 0x66, 0x00, 0x18, 0x19, 0x80, 0x0E, 0x0E,
  0x70, 0x03, 0x83, 0x9C, 0x00, 0xE0, 0xE3, 0x00, 0x38, 0x38, 0xC0, 0x0C,
  0x0C, 0x38, 0x03, 0x03, 0x0E, 0x00, 0xC1, 0xC1, 0x80, 0x70, 0x70, 0x60,
  0x1C, 0x1C, 0x1C, 0x07, 0x07, 0x07, 0x01, 0xC1, 0x80, 0xC0, 0x60, 0x60,
  0x30, 0x18, 0x38, 0x0C, 0x0E, 0x0E, 0x03, 0x83, 0x83, 0x80, 0x60, 0xE0,
  0xE0, 0x18, 0x38, 0x30, 0x06, 0x0C, 0x0C, 0x01, 0xC3, 0x03, 0x00, 0x71,
  0xC1, 0xC0, 0x0C, 0x70, 0x70, 0x03, 0x1C, 0x1C, 0x00, 0xE7, 0x07, 0x00,
  0x39, 0x81, 0x80, 0x06, 0x60, 0x60, 0x01, 0x98, 0x38, 0x00, 0x7E, 0x0E,
  0x00, 0x1F, 0x83, 0x80, 0x03, 0xE0, 0xE0, 0x00, 0xF0, 0x30, 0x00, 0x3C,
  0x0C, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xE7, 0xE0, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x06,
  0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x30, 0x00,
  0x0E, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70,
  0x60, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0xE0, 0x0F, 0x80, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x3E,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x30,
  0x70, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x70, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x83, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x18, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x0F,
  0x80, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x4E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x1C, 0x00, 0x7E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x38, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x1C, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C,
  0x1C, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x03, 0xF0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xC0, 0x18, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x70, 0x00, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0x38, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x38, 0x30, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x03,
  0x80, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x80, 0x3E,
  0x03, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x18, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0C,
  0x00, 0x03, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x07, 0x80,
  0x07, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x30, 0x00,
  0x18, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0C, 0x07, 0x00, 0x0E, 0x03, 0x80,
  0x07, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01,
  0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x18, 0x00, 0x38, 0x1C, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x71, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x07, 0x80, 0x3B,
  0x00, 0x3C, 0x01, 0xD8, 0x01, 0xE0, 0x0C, 0xC0, 0x1B, 0x00, 0xE6, 0x00,
  0xD8, 0x07, 0x30, 0x06, 0xC0, 0x31, 0x80, 0x66, 0x01, 0x8C, 0x03, 0x30,
  0x1C, 0x60, 0x19, 0x80, 0xE3, 0x01, 0xCC, 0x06, 0x18, 0x0C, 0x60, 0x70,
  0xC0, 0x63, 0x03, 0x86, 0x07, 0x18, 0x18, 0x30, 0x30, 0xC0, 0xC3, 0x81,
  0x86, 0x0E, 0x1C, 0x0C, 0x30, 0x70, 0xE0, 0xC1, 0x83, 0x07, 0x06, 0x18,
  0x18, 0x38, 0x30, 0xC1, 0xC1, 0xC3, 0x06, 0x0C, 0x0E, 0x18, 0x30, 0x60,
  0x70, 0xC1, 0x87, 0x03, 0x8E, 0x0C, 0x38, 0x1C, 0x60, 0x61, 0x80, 0xE3,
  0x03, 0x0C, 0x07, 0x18, 0x18, 0xE0, 0x39, 0x80, 0xC7, 0x01, 0xCC, 0x06,
  0x30, 0x0C, 0x60, 0x31, 0x80, 0x66, 0x01, 0x9C, 0x03, 0x30, 0x0C, 0xC0,
  0x19, 0x80, 0x66, 0x00, 0xD8, 0x03, 0x70, 0x06, 0xC0, 0x1B, 0x80, 0x36,
  0x00, 0xD8, 0x01, 0xB0, 0x06, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x01, 0xC0,
  0x01, 0xC0, 0x18, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x06, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x06, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0E,
  0xE0, 0x00, 0x3B, 0x80, 0x01, 0xC6, 0x00, 0x07, 0x1C, 0x00, 0x38, 0x70,
  0x01, 0xC1, 0xC0, 0x07, 0x03, 0x00, 0x38, 0x0E, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x3C, 0x00,
  0x70, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x1C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x00, 0x3F, 0xC3, 0x80, 0x7F, 0xF1,
  0xC0, 0x78, 0x1C, 0xC0, 0x70, 0x03, 0x60, 0x70, 0x00, 0xF0, 0x70, 0x00,
  0x78, 0x30, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78,
  0x38, 0x00, 0x7C, 0x0E, 0x00, 0x6E, 0x07, 0x80, 0x76, 0x01, 0xFF, 0xE3,
  0x00, 0x3F, 0xE3, 0x80, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x1F,
  0xE0, 0x0E, 0x7F, 0xF8, 0x0E, 0xF0, 0x7C, 0x0D, 0x80, 0x1E, 0x0F, 0x00,
  0x0E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x06, 0x38, 0x00, 0x06, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30, 0x00,
  0x0E, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38, 0xF0, 0x00,
  0x70, 0xF8, 0x00, 0x70, 0xF8, 0x00, 0xE0, 0xEE, 0x03, 0xC0, 0xE7, 0xFF,
  0x80, 0xC3, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x70, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0C,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x07, 0xC0, 0x78, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x0F, 0xF0, 0xE0, 0x0F, 0xFE, 0x38, 0x07, 0x81, 0xCC, 0x03,
  0x80, 0x1B, 0x01, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x30, 0x00, 0x3C,
  0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xC0,
  0x00, 0x38, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x01,
  0x81, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x07, 0x00,
  0x0F, 0x80, 0xE0, 0x06, 0xE0, 0x3C, 0x03, 0xB0, 0x07, 0xFF, 0x8C, 0x00,
  0x7F, 0xC7, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8,
  0x01, 0xF0, 0x7C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0C, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07,
  0x38, 0x00, 0x06, 0x38, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0x3E, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x87, 0x01, 0xFF, 0xC7, 0x03, 0xC0, 0xE6, 0x07,
  0x00, 0x36, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x18, 0x00, 0x1E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x1C, 0x60,
  0x00, 0x18, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70,
  0x01, 0xF0, 0x78, 0x03, 0x70, 0x3F, 0xBE, 0x70, 0x1F, 0xFC, 0x70, 0x03,
  0xE0, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x1F, 0xE0, 0x0E, 0x7F, 0xF8, 0x0E,
  0xF0, 0x7C, 0x0D, 0x80, 0x1E, 0x0D, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1E,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x01,
  0xC0, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x07, 0x80, 0x0E,
  0x00, 0xE0, 0x01, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0,
  0x1C, 0x00, 0x18, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00,
  0x1C, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x78, 0x38, 0x00, 0x07, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x06, 0x7E, 0x0F, 0xC0, 0xEF, 0xF1, 0xFE, 0x0F, 0x87, 0xB1,
  0xE0, 0xD0, 0x3C, 0x0E, 0x0E, 0x03, 0xC0, 0x70, 0xE0, 0x38, 0x07, 0x0C,
  0x03, 0x80, 0x61, 0xC0, 0x38, 0x06, 0x1C, 0x03, 0x80, 0xE1, 0xC0, 0x30,
  0x0E, 0x1C, 0x03, 0x00, 0xE1, 0x80, 0x70, 0x0E, 0x18, 0x07, 0x00, 0xE3,
  0x80, 0x70, 0x0C, 0x38, 0x07, 0x00, 0xC3, 0x80, 0x60, 0x1C, 0x38, 0x06,
  0x01, 0xC3, 0x80, 0xE0, 0x1C, 0x30, 0x0E, 0x01, 0xC3, 0x00, 0xE0, 0x18,
  0x70, 0x0E, 0x01, 0x87, 0x00, 0xC0, 0x38, 0x70, 0x0C, 0x03, 0x87, 0x00,
  0xC0, 0x38, 0x60, 0x1C, 0x03, 0x86, 0x01, 0xC0, 0x30, 0xE0, 0x1C, 0x03,
  0x0E, 0x01, 0xC0, 0x70, 0xE0, 0x18, 0x07, 0x0E, 0x01, 0x80, 0x70, 0x0E,
  0x1F, 0xE0, 0x0E, 0x7F, 0xF8, 0x0E, 0xF0, 0x7C, 0x0D, 0x80, 0x1E, 0x0D,
  0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x30, 0xC0, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xF0, 0x7C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0C,
  0x00, 0x06, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x38,
  0x00, 0x06, 0x38, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30,
  0x00, 0x0E, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x1C, 0x60,
  0x00, 0x18, 0x70, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x38,
  0x00, 0xE0, 0x3E, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x87, 0xF8, 0x00, 0xE7, 0xFF, 0x80, 0x3B, 0xC1, 0xF0,
  0x0D, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x78, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x60,
  0x00, 0x18, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x0F,
  0x80, 0x07, 0x03, 0xE0, 0x03, 0x80, 0xEE, 0x03, 0xC0, 0x39, 0xFF, 0xE0,
  0x0C, 0x3F, 0xE0, 0x07, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC3, 0x80, 0x7F, 0xF1, 0xC0, 0xF8, 0x1C, 0xC0, 0x70, 0x03,
  0x60, 0x70, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x30, 0x00, 0x3C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0x60,
  0x00, 0x18, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x7C, 0x0E, 0x00, 0x6E,
  0x07, 0xC0, 0x76, 0x01, 0xFF, 0xE3, 0x00, 0x3F, 0xE3, 0x80, 0x03, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x0F, 0xF0, 0x03, 0x9F, 0xFE, 0x01,
  0xDE, 0x0F, 0x80, 0xD8, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x86, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x40, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x3E,
  0x07, 0x80, 0x0F, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x78,
  0x7C, 0x00, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0C, 0x00,
  0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x3C, 0x00, 0x78, 0x0E, 0x00, 0x78, 0x07, 0xC0, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xB0, 0x00,
  0x03, 0x98, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x38, 0x00, 0x30, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x03, 0x00,
  0x06, 0x03, 0x80, 0x03, 0x01, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0x30, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x30,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F,
  0x80, 0x78, 0x03, 0x70, 0x0F, 0x00, 0xEE, 0x01, 0xE0, 0x1D, 0xC0, 0x6C,
  0x03, 0x38, 0x0D, 0x80, 0xE7, 0x01, 0xB0, 0x1C, 0xE0, 0x66, 0x03, 0x1C,
  0x0C, 0xC0, 0xE3, 0x83, 0x98, 0x1C, 0x70, 0x63, 0x03, 0x0E, 0x0C, 0x60,
  0xE1, 0xC3, 0x8C, 0x1C, 0x38, 0x61, 0x83, 0x07, 0x0C, 0x30, 0xE0, 0xE3,
  0x86, 0x1C, 0x1C, 0x60, 0xC3, 0x03, 0x8C, 0x1C, 0x60, 0x73, 0x83, 0x9C,
  0x0E, 0x60, 0x33, 0x01, 0xCC, 0x06, 0x60, 0x3B, 0x00, 0xDC, 0x07, 0x60,
  0x1B, 0x00, 0xEC, 0x03, 0x60, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x1C, 0x06, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x78, 0x70, 0x00, 0x78, 0x38, 0x00, 0xF8, 0x3C, 0x03, 0xB8, 0x1F,
  0xFF, 0x30, 0x0F, 0xFC, 0x30, 0x03, 0xF0, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0x8F, 0xF8, 0x00,
  0xCF, 0x1E, 0x00, 0xE7, 0x07, 0x00, 0x77, 0x01, 0xC0, 0x3B, 0x80, 0x70,
  0x19, 0xC0, 0x3C, 0x1C, 0xC0, 0x0F, 0x1C, 0x60, 0x03, 0xFC, 0x70, 0x00,
  0x7C, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 11, 39, 32, 11, -39 },
  { 55, 16, 16, 32, 11, -39 },
  { 87, 32, 39, 32, 1, -39 },
  { 243, 27, 55, 32, 3, -47 },
  { 429, 36, 40, 32, -1, -40 },
  { 609, 28, 41, 32, 2, -40 },
  { 753, 6, 16, 32, 16, -39 },
  { 765, 21, 53, 32, 10, -46 },
  { 905, 21, 53, 32, 3, -46 },
  { 1045, 28, 27, 32, 3, -33 },
  { 1140, 25, 26, 32, 4, -31 },
  { 1222, 11, 17, 32, 7, -8 },
  { 1246, 17, 2, 32, 8, -19 },
  { 1251, 9, 8, 32, 10, -7 },
  { 1260, 30, 51, 32, 2, -45 },
  { 1452, 26, 41, 32, 4, -40 },
  { 1586, 24, 39, 32, 3, -39 },
  { 1703, 27, 40, 32, 3, -40 },
  { 1838, 26, 40, 32, 4, -39 },
  { 1968, 24, 39, 32, 4, -39 },
  { 2085, 26, 40, 32, 4, -39 },
  { 2215, 24, 40, 32, 4, -39 },
  { 2335, 25, 39, 32, 7, -39 },
  { 2457, 27, 41, 32, 3, -40 },
  { 2596, 24, 40, 32, 6, -40 },
  { 2716, 12, 31, 32, 10, -30 },
  { 2763, 15, 39, 32, 7, -30 },
  { 2837, 25, 27, 32, 5, -31 },
  { 2922, 25, 14, 32, 4, -25 },
  { 2966, 25, 27, 32, 3, -31 },
  { 3051, 21, 39, 32, 9, -39 },
  { 3154, 31, 50, 32, 1, -40 },
  { 3348, 25, 39, 32, 1, -39 },
  { 3470, 26, 39, 32, 4, -39 },
  { 3597, 26, 41, 32, 4, -40 },
  { 3731, 25, 39, 32, 4, -39 },
  { 3853, 27, 39, 32, 4, -39 },
  { 3985, 28, 39, 32, 4, -39 },
  { 4122, 26, 41, 32, 4, -40 },
  { 4256, 26, 39, 32, 4, -39 },
  { 4383, 26, 39, 32, 4, -39 },
  { 4510, 28, 40, 32, 2, -39 },
  { 4650, 29, 39, 32, 4, -39 },
  { 4792, 22, 39, 32, 4, -39 },
  { 4900, 28, 39, 32, 3, -39 },
  { 5037, 26, 39, 32, 4, -39 },
  { 5164, 26, 41, 32, 4, -40 },
  { 5298, 28, 39, 32, 4, -39 },
  { 5435, 26, 50, 32, 4, -40 },
  { 5598, 27, 39, 32, 4, -39 },
  { 5730, 27, 41, 32, 3, -40 },
  { 5869, 26, 39, 32, 7, -39 },
  { 5996, 26, 40, 32, 4, -39 },
  { 6126, 25, 39, 32, 8, -39 },
  { 6248, 29, 39, 32, 5, -39 },
  { 6390, 33, 39, 32, 0, -39 },
  { 6551, 27, 39, 32, 7, -39 },
  { 6683, 28, 39, 32, 3, -39 },
  { 6820, 20, 51, 32, 9, -45 },
  { 6948, 14, 51, 32, 10, -45 },
  { 7038, 20, 51, 32, 5, -45 },
  { 7166, 22, 21, 32, 6, -39 },
  { 7224, 27, 3, 32, 0, 1 },
  { 7235, 8, 7, 32, 15, -42 },
  { 7242, 25, 31, 32, 4, -30 },
  { 7339, 24, 40, 32, 4, -39 },
  { 7459, 25, 31, 32, 4, -30 },
  { 7556, 26, 40, 32, 4, -39 },
  { 7686, 24, 31, 32, 4, -30 },
  { 7779, 33, 49, 32, -1, -39 },
  { 7982, 24, 40, 32, 5, -30 },
  { 8102, 24, 39, 32, 4, -39 },
  { 8219, 24, 41, 32, 3, -41 },
  { 8342, 27, 51, 32, 1, -41 },
  { 8515, 27, 39, 32, 4, -39 },
  { 8647, 21, 39, 32, 6, -39 },
  { 8750, 28, 30, 32, 2, -30 },
  { 8855, 24, 30, 32, 4, -30 },
  { 8945, 24, 31, 32, 4, -30 },
  { 9038, 26, 40, 32, 2, -30 },
  { 9168, 25, 40, 32, 4, -30 },
  { 9293, 25, 30, 32, 4, -30 },
  { 9387, 24, 31, 32, 4, -30 },
  { 9480, 24, 38, 32, 6, -38 },
  { 9594, 25, 31, 32, 4, -30 },
  { 9691, 25, 30, 32, 6, -30 },
  { 9785, 27, 30, 32, 5, -30 },
  { 9887, 28, 30, 32, 2, -30 },
  { 9992, 24, 40, 32, 4, -30 },
  { 10112, 25, 30, 32, 3, -30 },
  { 10206, 26, 51, 32, 6, -45 },
  { 10372, 10, 51, 32, 12, -45 },
  { 10436, 26, 51, 32, 2, -45 },
  { 10602, 25, 10, 32, 4, -24 },
};

const GFXfont JetBrainsMono_ThinItalic54pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic54pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _JETBRAINSMONO_THINITALIC54PT7B_H_
