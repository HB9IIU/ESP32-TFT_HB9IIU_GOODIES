#ifndef _JETBRAINSMONO_THINITALIC49PT7B_H_
#define _JETBRAINSMONO_THINITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xE0, 0x38, 0x1E,
  0xF0, 0x3D, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38,
  0x1C, 0x60, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x18, 0x06,
  0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x38, 0x03, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x80, 0x70, 0x00, 0x18, 0x03, 0x80,
  0x01, 0xC0, 0x18, 0x00, 0x0E, 0x01, 0xC2, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x70, 0x06, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x18, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x38,
  0x03, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x79, 0x9F, 0x00, 0x70, 0xC3,
  0x80, 0x70, 0x60, 0xE0, 0x70, 0x30, 0x70, 0x30, 0x30, 0x38, 0x18, 0x18,
  0x0C, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x81,
  0x80, 0x01, 0xC1, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x3C, 0x60, 0x00, 0x0F,
  0x30, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x06, 0xF8, 0x00, 0x03, 0x1E, 0x00, 0x01, 0x87, 0x80, 0x00, 0xC1, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x0E,
  0x38, 0x0C, 0x06, 0x1C, 0x06, 0x03, 0x0E, 0x03, 0x03, 0x87, 0x01, 0x81,
  0x81, 0xC0, 0xC1, 0xC0, 0xF0, 0xC1, 0xC0, 0x3C, 0x63, 0xC0, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x7F, 0x80, 0x03, 0x80,
  0x70, 0xE0, 0x01, 0x80, 0x70, 0x38, 0x01, 0x80, 0x30, 0x1C, 0x01, 0x80,
  0x38, 0x0E, 0x01, 0x80, 0x18, 0x07, 0x01, 0xC0, 0x0C, 0x03, 0x01, 0xC0,
  0x06, 0x01, 0x81, 0xC0, 0x03, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x60, 0xC0,
  0x01, 0xC0, 0x70, 0xC0, 0x00, 0x60, 0x30, 0xC0, 0x00, 0x38, 0x38, 0xE0,
  0x00, 0x1F, 0xF8, 0xE0, 0x00, 0x07, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0xFC, 0x00, 0x00, 0x71, 0xFF, 0x00, 0x00, 0x71,
  0xC1, 0xC0, 0x00, 0x30, 0xC0, 0x60, 0x00, 0x30, 0xC0, 0x30, 0x00, 0x30,
  0x60, 0x18, 0x00, 0x30, 0x30, 0x0C, 0x00, 0x38, 0x18, 0x06, 0x00, 0x38,
  0x1C, 0x03, 0x00, 0x38, 0x0C, 0x03, 0x80, 0x18, 0x06, 0x01, 0x80, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0xE0, 0x18, 0x00, 0xE0, 0xE0, 0x1C,
  0x00, 0x3F, 0xE0, 0x1C, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0x98, 0x00, 0x07, 0x0E, 0x00, 0x67, 0x03, 0x80, 0x73, 0x01,
  0xC0, 0x73, 0x80, 0x70, 0x31, 0xC0, 0x18, 0x38, 0xC0, 0x0E, 0x38, 0x60,
  0x03, 0x98, 0x30, 0x01, 0xDC, 0x18, 0x00, 0x7C, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x0F, 0xC1, 0xC0, 0x0E, 0x70,
  0xE0, 0x0E, 0x18, 0x38, 0x1E, 0x0E, 0x1F, 0xFE, 0x03, 0x03, 0xFC, 0x01,
  0xC0, 0x3B, 0xDC, 0xE7, 0x39, 0xDE, 0xF7, 0x39, 0xCE, 0x63, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x70, 0x0C, 0x03, 0xFE, 0x06, 0x0F, 0xDF, 0xE3, 0x1F, 0xC1,
  0xF9, 0x3F, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0x10, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xE0, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1C, 0x3E, 0x7F, 0xFF, 0xFE, 0x7E, 0x7C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xF8, 0x01, 0xF8, 0x7C, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C,
  0x00, 0x06, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x38, 0x3E, 0x0E, 0x38,
  0x3E, 0x0E, 0x38, 0x3E, 0x0C, 0x38, 0x1E, 0x0C, 0x38, 0x00, 0x1C, 0x30,
  0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x18, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x3E,
  0x07, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7B, 0x80, 0x0F, 0x18, 0x00, 0xF0, 0xC0,
  0x1E, 0x06, 0x00, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0x40, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xF8, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x07, 0x06, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00,
  0x70, 0x60, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x07, 0x03, 0x80, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x0C, 0x38, 0x00, 0x61,
  0xC0, 0x03, 0x1C, 0x00, 0x39, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0x60, 0x00,
  0x67, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x40, 0x03, 0x8F, 0xF8, 0x06, 0x7F,
  0xF8, 0x0D, 0x80, 0xF8, 0x1E, 0x00, 0x70, 0x78, 0x00, 0xE0, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x30, 0x70,
  0x00, 0xE0, 0x70, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x40, 0x01, 0xDF, 0xF0, 0x06, 0xFF,
  0xF0, 0x3E, 0x03, 0xC1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80,
  0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x39, 0x80, 0x00,
  0xC7, 0x00, 0x07, 0x1C, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xF0, 0x0E, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0x80, 0x00, 0x77, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x18, 0x00,
  0x0E, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x71, 0xC0, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xF0, 0x3C, 0x01, 0xC0,
  0x0E, 0x03, 0x80, 0x06, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x06, 0x00,
  0x0E, 0x07, 0x00, 0x1C, 0x03, 0x00, 0x38, 0x03, 0xC0, 0x70, 0x01, 0xE1,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xC3,
  0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x30, 0x70, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0x03, 0xC0, 0x38, 0x01,
  0xC0, 0xE0, 0x01, 0x83, 0x80, 0x03, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66,
  0x00, 0x01, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x70, 0x70, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0xFC, 0x7E, 0x00, 0xFF,
  0xDC, 0x00, 0x7C, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xC1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x7C, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC1, 0xF0, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x40, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x3F,
  0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06,
  0x0C, 0x00, 0x78, 0x60, 0xC0, 0x1F, 0xE6, 0x1C, 0x03, 0xEF, 0x61, 0xC0,
  0x70, 0x16, 0x1C, 0x0E, 0x00, 0xE1, 0x80, 0xC0, 0x0C, 0x18, 0x0C, 0x00,
  0xC1, 0x81, 0xC0, 0x0C, 0x38, 0x1C, 0x00, 0xC3, 0x81, 0xC0, 0x1C, 0x38,
  0x18, 0x01, 0xC3, 0x01, 0x80, 0x1C, 0x30, 0x18, 0x01, 0x83, 0x03, 0x80,
  0x18, 0x70, 0x38, 0x01, 0x87, 0x03, 0x80, 0x38, 0x70, 0x38, 0x03, 0x87,
  0x03, 0x80, 0x78, 0x60, 0x1C, 0x0F, 0x06, 0x01, 0xFF, 0xB0, 0x60, 0x0F,
  0xE3, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x36, 0x00, 0x00,
  0xEC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x18,
  0x60, 0x00, 0x70, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x06, 0x06,
  0x00, 0x1C, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x70,
  0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x70, 0x03, 0x00,
  0xC0, 0x06, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x38,
  0x00, 0x70, 0x60, 0x00, 0x61, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0x01,
  0xFC, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x06, 0x00,
  0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x0E, 0x00,
  0x06, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x0C, 0x00,
  0x38, 0x1C, 0x00, 0x70, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x18, 0x00, 0xF0, 0x18, 0x00, 0x38, 0x18, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x30, 0x00,
  0x1C, 0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x70, 0x60, 0x00, 0xE0, 0x60, 0x01, 0xE0, 0x60, 0x0F, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0x81,
  0xE0, 0x1C, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x80, 0x03,
  0x86, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x20,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xC7, 0x00, 0x01,
  0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x60,
  0x70, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0x07, 0xF8, 0x07, 0x00, 0x3C,
  0x07, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06,
  0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x0C,
  0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x1C,
  0x18, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x38, 0x00, 0x18, 0x38, 0x00, 0x18,
  0x38, 0x00, 0x38, 0x30, 0x00, 0x38, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x60, 0x01, 0xC0,
  0x60, 0x07, 0x80, 0x60, 0x1F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x1C,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x86, 0x00,
  0x03, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x20, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x11, 0x81, 0xFF, 0xC7,
  0x03, 0xFF, 0x8E, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60,
  0x00, 0x38, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x8E, 0x00,
  0x07, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x60, 0x70, 0x01,
  0xC0, 0x78, 0x0F, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00,
  0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x70,
  0x00, 0x70, 0x38, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x38, 0x00, 0x18,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x70, 0x00,
  0x70, 0x38, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x07, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xC0,
  0x00, 0xE0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x38, 0x00, 0x18, 0x1C,
  0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0C,
  0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC0,
  0xE0, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x38, 0x0C,
  0x00, 0x0E, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x1C,
  0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00,
  0x18, 0x03, 0x80, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0C, 0x03, 0x80, 0x01,
  0x80, 0x30, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x0C,
  0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C,
  0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1F, 0x00,
  0x1B, 0x07, 0x40, 0x0D, 0xC1, 0x98, 0x03, 0x70, 0x66, 0x01, 0x98, 0x19,
  0x80, 0x66, 0x06, 0x60, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0xE3, 0x06, 0x38,
  0x38, 0xC1, 0x8E, 0x0C, 0x30, 0xC3, 0x03, 0x0C, 0x30, 0xC0, 0xC1, 0x98,
  0x30, 0x30, 0x66, 0x0C, 0x1C, 0x1B, 0x07, 0x07, 0x06, 0xC1, 0xC1, 0xC1,
  0xE0, 0x70, 0x60, 0x38, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x1C, 0x00,
  0x07, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x03,
  0x81, 0xE0, 0x01, 0x80, 0xF0, 0x00, 0xC0, 0xF8, 0x00, 0x60, 0x7C, 0x00,
  0x70, 0x36, 0x00, 0x38, 0x19, 0x80, 0x1C, 0x0C, 0xC0, 0x0C, 0x06, 0x60,
  0x06, 0x07, 0x30, 0x03, 0x03, 0x8C, 0x01, 0x81, 0x86, 0x01, 0xC0, 0xC3,
  0x00, 0xE0, 0x61, 0x80, 0x60, 0x30, 0xE0, 0x30, 0x38, 0x30, 0x18, 0x1C,
  0x18, 0x0C, 0x0E, 0x0C, 0x0E, 0x06, 0x07, 0x07, 0x03, 0x01, 0x83, 0x01,
  0x80, 0xC1, 0x80, 0xC0, 0x60, 0xC0, 0xE0, 0x38, 0x60, 0x70, 0x0C, 0x70,
  0x30, 0x06, 0x38, 0x18, 0x03, 0x1C, 0x0C, 0x01, 0xCC, 0x06, 0x00, 0x66,
  0x07, 0x00, 0x33, 0x03, 0x80, 0x19, 0x81, 0x80, 0x0D, 0xC0, 0xC0, 0x07,
  0xE0, 0x60, 0x01, 0xE0, 0x30, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x1C, 0x00,
  0x3C, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x1C,
  0x01, 0xE0, 0x70, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x06, 0x00,
  0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x70, 0x00, 0x30, 0xC0, 0x00,
  0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0C,
  0x38, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC7,
  0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x70, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x0E, 0x00,
  0x06, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x30, 0x30, 0x00, 0xE0, 0x70, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x30, 0x0F, 0xE0, 0x1C, 0x00, 0x3C, 0x07,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x38, 0x00,
  0x0E, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x01, 0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x01,
  0x83, 0x80, 0x03, 0x06, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18,
  0x70, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x8E,
  0x00, 0x07, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0xE1, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xE3, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x30,
  0x30, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0xC0, 0x3F, 0x80, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x18,
  0x18, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x60, 0x00,
  0x38, 0x30, 0x00, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x0E, 0x00,
  0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0x80, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x06, 0x00, 0x38, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03,
  0x80, 0x06, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x38,
  0x00, 0x70, 0x38, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xC0, 0xE0,
  0x00, 0xE0, 0x78, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x07, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06,
  0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E,
  0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x0C,
  0x18, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x18,
  0x38, 0x00, 0x18, 0x38, 0x00, 0x18, 0x38, 0x00, 0x38, 0x30, 0x00, 0x38,
  0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x70, 0x00, 0x30, 0x70, 0x00, 0x30,
  0x70, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60,
  0xE0, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0xC0,
  0x70, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x38, 0x07, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x77,
  0x00, 0x00, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x30,
  0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x60,
  0x03, 0x81, 0xC0, 0x07, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x1C, 0x00,
  0x18, 0x30, 0x00, 0x30, 0xE0, 0x00, 0x61, 0x80, 0x00, 0xC7, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x07, 0x00, 0xEE, 0x01, 0xE0, 0x1D, 0xC0, 0x3C, 0x03, 0x38, 0x07, 0x80,
  0x67, 0x01, 0xB0, 0x1C, 0xC0, 0x36, 0x03, 0x18, 0x06, 0xC0, 0x63, 0x00,
  0x98, 0x0C, 0x60, 0x33, 0x03, 0x8C, 0x06, 0x60, 0x61, 0x80, 0xCC, 0x0C,
  0x30, 0x31, 0x83, 0x86, 0x06, 0x30, 0x70, 0xC0, 0xC6, 0x0C, 0x18, 0x30,
  0xC1, 0x83, 0x06, 0x18, 0x70, 0x60, 0xC3, 0x0C, 0x0C, 0x30, 0x41, 0x81,
  0x86, 0x08, 0x30, 0x30, 0xC1, 0x0E, 0x06, 0x10, 0x21, 0x80, 0xC6, 0x04,
  0x30, 0x18, 0xC0, 0x8E, 0x03, 0x18, 0x11, 0x80, 0x66, 0x02, 0x30, 0x0C,
  0xC0, 0x46, 0x01, 0x98, 0x19, 0xC0, 0x36, 0x03, 0x30, 0x0E, 0xC0, 0x66,
  0x01, 0xD8, 0x0D, 0xC0, 0x3A, 0x01, 0xB0, 0x07, 0xC0, 0x36, 0x00, 0xF8,
  0x06, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x06, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00,
  0x0E, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x38, 0x00,
  0x30, 0x38, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x0C, 0x03, 0x80, 0x0E, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x0E,
  0x00, 0x07, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x38, 0x00, 0x03, 0xB0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x77, 0x00, 0x07, 0x30, 0x00,
  0xE3, 0x00, 0x0C, 0x38, 0x01, 0xC3, 0x80, 0x38, 0x18, 0x03, 0x81, 0xC0,
  0x70, 0x1C, 0x06, 0x01, 0xC0, 0xE0, 0x0C, 0x1C, 0x00, 0xE1, 0xC0, 0x0E,
  0x38, 0x00, 0x63, 0x00, 0x06, 0xF0, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xC1, 0xC1, 0xC1, 0xC0, 0x00, 0xFF, 0x0C, 0x0F,
  0xFF, 0x70, 0x78, 0x0D, 0xC3, 0x80, 0x1F, 0x0C, 0x00, 0x38, 0x60, 0x00,
  0xE1, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xE3,
  0x00, 0x03, 0x1C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0xC0, 0x00, 0xC6, 0x00,
  0x07, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00, 0x06,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x86, 0x00, 0x1E, 0x1C,
  0x00, 0xF0, 0x38, 0x06, 0xC0, 0xFF, 0xF3, 0x00, 0xFF, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x7F, 0xC0, 0x39, 0xFF, 0xC0, 0x7E, 0x03, 0xC0, 0xD0, 0x03,
  0x81, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0C,
  0x38, 0x00, 0x18, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC3,
  0x00, 0x03, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x60,
  0x00, 0x70, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x18, 0x3C, 0x00, 0x70, 0x78, 0x01, 0xC0, 0xD8, 0x07,
  0x03, 0x9F, 0xFC, 0x07, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x78, 0x0F, 0x03, 0x80, 0x1E, 0x0C, 0x00, 0x38, 0x70, 0x00, 0x61,
  0x80, 0x01, 0x8E, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x07, 0x38,
  0x00, 0x18, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x86, 0x00, 0x1C, 0x1C, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0xFF, 0x0C, 0x03, 0xFF, 0xDC, 0x07, 0x80, 0xDC, 0x0E, 0x00,
  0x7C, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x30, 0x00, 0x38, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x70, 0x00,
  0x30, 0x70, 0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00,
  0x70, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x60, 0x01, 0xE0, 0x70, 0x03,
  0xC0, 0x38, 0x06, 0xC0, 0x3F, 0xFC, 0xC0, 0x0F, 0xF1, 0xC0, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0x01, 0xE0, 0x3C, 0x1C, 0x00, 0xE0, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0x60, 0x00, 0xE7, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x01,
  0xCC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x06, 0x70, 0x00, 0x71, 0x80, 0x07, 0x0E, 0x00,
  0x70, 0x38, 0x07, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x0C, 0x0F, 0xFF, 0x70, 0x78, 0x0D, 0xC3, 0x80, 0x1F, 0x0C, 0x00, 0x38,
  0x60, 0x00, 0xE1, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x38, 0xC0,
  0x00, 0xE3, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0xC0, 0x00,
  0xC6, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x71, 0x80, 0x01, 0x86,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xE0, 0xE0, 0x0F, 0x83, 0xC0,
  0xEE, 0x07, 0xFF, 0x30, 0x07, 0xF0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0xFF, 0x80, 0xE7, 0xFF, 0x03, 0xB0, 0x1E, 0x0D, 0x80,
  0x38, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0x70, 0x00, 0x71, 0x80, 0x01, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x18, 0x60,
  0x00, 0x63, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xC0, 0x00,
  0xE3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0xC0, 0x00, 0xC7,
  0x00, 0x07, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x71, 0x80, 0x01, 0x8E, 0x00,
  0x06, 0x38, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x01, 0xC3,
  0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x60, 0x01, 0xC0,
  0x30, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x01, 0x80, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x70, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x03,
  0x00, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x38, 0x03, 0x80,
  0x0C, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x30,
  0x00, 0x38, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x0C,
  0xFC, 0x7E, 0x06, 0xFF, 0x7F, 0x83, 0x83, 0xA0, 0xE3, 0xC0, 0xE0, 0x71,
  0xC0, 0x60, 0x38, 0xE0, 0x30, 0x1C, 0x60, 0x18, 0x0E, 0x30, 0x1C, 0x06,
  0x18, 0x0E, 0x03, 0x1C, 0x06, 0x01, 0x8E, 0x03, 0x00, 0xC7, 0x01, 0x80,
  0xE3, 0x00, 0xC0, 0x71, 0x80, 0xE0, 0x38, 0xC0, 0x70, 0x18, 0x60, 0x38,
  0x0C, 0x70, 0x18, 0x06, 0x38, 0x0C, 0x07, 0x18, 0x06, 0x03, 0x8C, 0x03,
  0x01, 0xC6, 0x03, 0x80, 0xC3, 0x01, 0xC0, 0x63, 0x80, 0xC0, 0x31, 0xC0,
  0x60, 0x18, 0xE0, 0x30, 0x1C, 0x60, 0x18, 0x0E, 0x30, 0x1C, 0x06, 0x00,
  0x0E, 0x3F, 0xE0, 0x39, 0xFF, 0xC0, 0xEC, 0x07, 0x83, 0x60, 0x0E, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00,
  0x1C, 0x60, 0x00, 0x71, 0x80, 0x01, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x18,
  0xE0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x38, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0xC0, 0x01,
  0xC6, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x63, 0x80, 0x01, 0x8E,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xE0, 0x3C, 0x1C,
  0x00, 0xE0, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x60, 0x00, 0x67, 0x00, 0x03,
  0x30, 0x00, 0x19, 0x80, 0x01, 0xCC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x03, 0x38, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0x77,
  0x00, 0x03, 0xB8, 0x00, 0x19, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x70, 0x00,
  0x61, 0x80, 0x07, 0x0E, 0x00, 0x70, 0x38, 0x07, 0x00, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x07, 0x1F, 0xF0, 0x07, 0x3F, 0xF8, 0x07, 0xE0, 0x3C, 0x06,
  0x80, 0x1C, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0E,
  0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C,
  0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x1C,
  0x00, 0x1C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x18, 0x38, 0x00, 0x38, 0x38, 0x00, 0x30, 0x3C, 0x00, 0x70, 0x3C,
  0x00, 0xE0, 0x36, 0x01, 0xC0, 0x73, 0xFF, 0x80, 0x71, 0xFF, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x0C, 0x0F, 0xFF, 0x70, 0x78, 0x0D, 0xC3, 0x80,
  0x1F, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x30, 0x00, 0x38, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x70,
  0x00, 0x31, 0xC0, 0x00, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x60, 0x00,
  0x73, 0x80, 0x01, 0x8E, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3,
  0x80, 0x03, 0x86, 0x00, 0x1E, 0x1C, 0x00, 0xF0, 0x38, 0x0E, 0xC0, 0xFF,
  0xF3, 0x00, 0xFF, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x0E, 0x3F, 0xE0, 0x1D, 0xFF, 0xE0, 0x37,
  0x01, 0xE0, 0x68, 0x01, 0xC0, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x60, 0x00,
  0x71, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x1E, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0xE0,
  0x00, 0xE1, 0x80, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x78, 0x01, 0xE0, 0x7F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0x80, 0x01, 0xC6,
  0x00, 0x07, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x63, 0x80, 0x01, 0x8E, 0x00,
  0x06, 0x38, 0x00, 0x38, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x8C, 0x00, 0x0C,
  0x70, 0x00, 0x31, 0xC0, 0x00, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x60,
  0x00, 0x71, 0x80, 0x01, 0x86, 0x00, 0x06, 0x38, 0x00, 0x18, 0xE0, 0x00,
  0xE1, 0x80, 0x03, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x38, 0x0F, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xEE,
  0x00, 0x03, 0xB8, 0x00, 0x1C, 0x60, 0x00, 0x71, 0x80, 0x03, 0x86, 0x00,
  0x0E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0x80, 0xC0, 0x0E, 0x03, 0x00, 0x30,
  0x0C, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xE0, 0x38, 0x01, 0x80, 0xC0, 0x06,
  0x07, 0x00, 0x18, 0x18, 0x00, 0x60, 0xE0, 0x01, 0xC3, 0x00, 0x03, 0x1C,
  0x00, 0x0C, 0x60, 0x00, 0x33, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x38, 0x03,
  0xC0, 0x38, 0x07, 0xC0, 0x28, 0x06, 0xC0, 0x68, 0x06, 0xC0, 0x68, 0x0E,
  0xC0, 0x48, 0x0C, 0xC0, 0xC8, 0x0C, 0xC0, 0xC8, 0x1C, 0xC0, 0x88, 0x18,
  0xC1, 0x88, 0x18, 0xC1, 0x88, 0x38, 0xC3, 0x08, 0x30, 0xC3, 0x08, 0x30,
  0xC3, 0x0C, 0x70, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0xE0,
  0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0D, 0xC0, 0xD8, 0x0D, 0x80,
  0xD8, 0x0D, 0x80, 0xD8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x03,
  0x80, 0xC0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x01,
  0xC0, 0x03, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x38,
  0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1C, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x01, 0x80, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x30,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x60, 0x00,
  0x71, 0x80, 0x01, 0x86, 0x00, 0x06, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3,
  0x00, 0x03, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC7, 0x00,
  0x03, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0x80, 0x01, 0xC6, 0x00, 0x07,
  0x18, 0x00, 0x18, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x18,
  0x00, 0x78, 0x70, 0x01, 0xE1, 0xE0, 0x1B, 0x03, 0xC1, 0xCC, 0x07, 0xFE,
  0x30, 0x07, 0xE1, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x11, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xC0,
  0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x0E,
  0x3F, 0x80, 0x18, 0xE3, 0x80, 0x33, 0x83, 0x80, 0x66, 0x03, 0x80, 0xCC,
  0x07, 0x03, 0xB8, 0x07, 0x0E, 0x70, 0x07, 0xF8, 0xC0, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_ThinItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 10, 36, 29, 10, -36 },
  { 46, 15, 15, 29, 10, -36 },
  { 75, 29, 36, 29, 1, -36 },
  { 206, 25, 50, 29, 3, -43 },
  { 363, 33, 36, 29, -1, -36 },
  { 512, 25, 36, 29, 2, -36 },
  { 625, 5, 15, 29, 15, -36 },
  { 635, 19, 47, 29, 9, -41 },
  { 747, 20, 47, 29, 2, -41 },
  { 865, 25, 25, 29, 3, -30 },
  { 944, 22, 23, 29, 4, -28 },
  { 1008, 11, 15, 29, 6, -7 },
  { 1029, 16, 2, 29, 7, -17 },
  { 1033, 8, 7, 29, 9, -7 },
  { 1040, 27, 46, 29, 2, -41 },
  { 1196, 24, 36, 29, 3, -36 },
  { 1304, 21, 36, 29, 3, -36 },
  { 1399, 24, 36, 29, 3, -36 },
  { 1507, 24, 36, 29, 3, -36 },
  { 1615, 21, 36, 29, 4, -36 },
  { 1710, 23, 36, 29, 4, -36 },
  { 1814, 22, 36, 29, 3, -36 },
  { 1913, 23, 36, 29, 6, -36 },
  { 2017, 24, 36, 29, 3, -36 },
  { 2125, 23, 36, 29, 5, -36 },
  { 2229, 11, 27, 29, 9, -27 },
  { 2267, 14, 35, 29, 6, -27 },
  { 2329, 22, 24, 29, 5, -28 },
  { 2395, 22, 13, 29, 4, -23 },
  { 2431, 23, 24, 29, 3, -28 },
  { 2500, 19, 36, 29, 8, -36 },
  { 2586, 28, 45, 29, 1, -36 },
  { 2744, 23, 36, 29, 1, -36 },
  { 2848, 24, 36, 29, 3, -36 },
  { 2956, 23, 36, 29, 4, -36 },
  { 3060, 24, 36, 29, 3, -36 },
  { 3168, 25, 36, 29, 4, -36 },
  { 3281, 26, 36, 29, 3, -36 },
  { 3398, 23, 36, 29, 4, -36 },
  { 3502, 25, 36, 29, 3, -36 },
  { 3615, 23, 36, 29, 4, -36 },
  { 3719, 25, 36, 29, 2, -36 },
  { 3832, 27, 36, 29, 3, -36 },
  { 3954, 20, 36, 29, 4, -36 },
  { 4044, 26, 36, 29, 2, -36 },
  { 4161, 25, 36, 29, 3, -36 },
  { 4274, 23, 36, 29, 4, -36 },
  { 4378, 26, 36, 29, 3, -36 },
  { 4495, 23, 45, 29, 4, -36 },
  { 4625, 25, 36, 29, 3, -36 },
  { 4738, 25, 36, 29, 3, -36 },
  { 4851, 24, 36, 29, 6, -36 },
  { 4959, 24, 36, 29, 4, -36 },
  { 5067, 23, 36, 29, 7, -36 },
  { 5171, 27, 36, 29, 4, -36 },
  { 5293, 30, 36, 29, 0, -36 },
  { 5428, 24, 36, 29, 6, -36 },
  { 5536, 26, 36, 29, 2, -36 },
  { 5653, 18, 46, 29, 8, -41 },
  { 5757, 13, 46, 29, 9, -41 },
  { 5832, 18, 46, 29, 5, -41 },
  { 5936, 20, 19, 29, 5, -36 },
  { 5984, 24, 2, 29, 0, 1 },
  { 5990, 7, 6, 29, 14, -38 },
  { 5996, 22, 27, 29, 4, -27 },
  { 6071, 23, 36, 29, 3, -36 },
  { 6175, 22, 27, 29, 4, -27 },
  { 6250, 24, 36, 29, 4, -36 },
  { 6358, 21, 27, 29, 4, -27 },
  { 6429, 30, 45, 29, -1, -36 },
  { 6598, 22, 36, 29, 4, -27 },
  { 6697, 22, 36, 29, 3, -36 },
  { 6796, 22, 37, 29, 2, -37 },
  { 6898, 24, 46, 29, 1, -37 },
  { 7036, 25, 36, 29, 3, -36 },
  { 7149, 19, 36, 29, 6, -36 },
  { 7235, 25, 27, 29, 2, -27 },
  { 7320, 22, 27, 29, 3, -27 },
  { 7395, 21, 27, 29, 4, -27 },
  { 7466, 24, 36, 29, 2, -27 },
  { 7574, 22, 36, 29, 4, -27 },
  { 7673, 23, 27, 29, 4, -27 },
  { 7751, 23, 27, 29, 3, -27 },
  { 7829, 22, 34, 29, 5, -34 },
  { 7923, 22, 27, 29, 4, -27 },
  { 7998, 22, 27, 29, 6, -27 },
  { 8073, 24, 27, 29, 5, -27 },
  { 8154, 25, 27, 29, 2, -27 },
  { 8239, 22, 36, 29, 4, -27 },
  { 8338, 23, 27, 29, 3, -27 },
  { 8416, 24, 46, 29, 5, -41 },
  { 8554, 10, 46, 29, 10, -41 },
  { 8612, 23, 46, 29, 2, -41 },
  { 8745, 23, 9, 29, 4, -22 },
};

const GFXfont JetBrainsMono_ThinItalic49pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic49pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _JETBRAINSMONO_THINITALIC49PT7B_H_
