#ifndef _JETBRAINSMONO_THINITALIC26PT7B_H_
#define _JETBRAINSMONO_THINITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x46, 0x31, 0x8C, 0x42, 0x10, 0x8C, 0x42, 0x10, 0x00, 0x67,
  0x18, 0x63, 0x63, 0x63, 0x43, 0x42, 0xC2, 0xC2, 0xC6, 0x01, 0x04, 0x06,
  0x18, 0x08, 0x20, 0x10, 0x40, 0x61, 0x87, 0xFF, 0xCF, 0xFF, 0x86, 0x18,
  0x08, 0x20, 0x30, 0xC0, 0x41, 0x00, 0x82, 0x0F, 0xFF, 0x9F, 0xFF, 0x08,
  0x20, 0x30, 0xC0, 0x41, 0x00, 0x82, 0x03, 0x0C, 0x00, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x03, 0xF0, 0x32, 0x60, 0x88, 0x84, 0x22, 0x10,
  0x88, 0x44, 0x01, 0x90, 0x06, 0x40, 0x0F, 0x00, 0x0F, 0x00, 0x16, 0x00,
  0xCC, 0x02, 0x10, 0x08, 0x44, 0x21, 0x10, 0x8C, 0x42, 0x21, 0x89, 0x01,
  0xF8, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x07, 0x80, 0xC2,
  0x30, 0x61, 0x84, 0x10, 0x41, 0x08, 0x10, 0xC4, 0x04, 0x22, 0x01, 0x09,
  0x00, 0x7C, 0xC0, 0x04, 0x60, 0x00, 0x10, 0x00, 0x08, 0x80, 0x04, 0xF8,
  0x02, 0x42, 0x01, 0x10, 0x80, 0xC4, 0x20, 0x61, 0x08, 0x30, 0xC2, 0x08,
  0x11, 0x0C, 0x07, 0x80, 0x03, 0xE0, 0x30, 0xC0, 0x81, 0x06, 0x04, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x98, 0x16, 0x20, 0x90,
  0x44, 0x41, 0xB3, 0x02, 0x8C, 0x0C, 0x20, 0x30, 0xC1, 0xA3, 0x0C, 0xC7,
  0xC1, 0x00, 0x6B, 0x6D, 0xA4, 0x00, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x04,
  0x03, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0x0C, 0x01, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x10, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0xC0, 0xE0, 0x00, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x08, 0x20, 0xF9, 0x3C, 0xFF, 0x00, 0xC0, 0x0A, 0x00,
  0xC8, 0x0C, 0x60, 0xC1, 0x04, 0x0C, 0x00, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x1C, 0x63, 0x0C, 0x21, 0x84, 0x30, 0xFF, 0x2F, 0xFE, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x07, 0xE1, 0xC7, 0x30, 0x32, 0x01,
  0x20, 0x16, 0x01, 0x60, 0x16, 0x03, 0x46, 0x34, 0x73, 0x42, 0x2C, 0x02,
  0xC0, 0x2C, 0x06, 0x80, 0x6C, 0x04, 0xC0, 0xC6, 0x18, 0x3F, 0x00, 0x00,
  0xC0, 0x34, 0x06, 0xC1, 0x8C, 0x10, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x20, 0xFF, 0xF0, 0x07, 0xF0, 0x30, 0x61, 0x80, 0x84, 0x02, 0x30,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x78, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x80,
  0x48, 0x04, 0xC0, 0x84, 0x18, 0x7E, 0x00, 0x00, 0x30, 0x04, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x21, 0x02, 0x20, 0x66,
  0x06, 0xC0, 0x6F, 0xFC, 0xFF, 0xC0, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x1F, 0xF1, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0xFC,
  0x30, 0x66, 0x06, 0x60, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x68, 0x04,
  0xC0, 0xC6, 0x18, 0x3F, 0x00, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60,
  0x18, 0x02, 0x00, 0x80, 0x2F, 0xCE, 0x0D, 0x81, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x02, 0xC0, 0xCC, 0x30, 0xFC, 0x00, 0x7F, 0xFA, 0x00, 0x90,
  0x0D, 0x80, 0x4C, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x18, 0x00, 0x07, 0xC1, 0x83, 0x10, 0x13, 0x01, 0x20, 0x12, 0x01,
  0x30, 0x21, 0x84, 0x0D, 0x80, 0xF0, 0x11, 0x86, 0x04, 0x40, 0x68, 0x02,
  0x80, 0x28, 0x06, 0x80, 0x4C, 0x18, 0x7F, 0x00, 0x0F, 0xC3, 0x06, 0x60,
  0x24, 0x02, 0xC0, 0x2C, 0x02, 0x80, 0x28, 0x06, 0xC0, 0x46, 0x0C, 0x7F,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x60,
  0x00, 0x10, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCE,
  0x00, 0x04, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x18, 0x30, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x00, 0x18, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x02, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x80,
  0x00, 0x3F, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x01,
  0x87, 0x83, 0x00, 0xC0, 0x20, 0x08, 0x00, 0x00, 0x00, 0x60, 0x38, 0x06,
  0x00, 0x03, 0xF0, 0x30, 0x61, 0x80, 0xC4, 0x01, 0x30, 0x04, 0x80, 0x12,
  0x06, 0x58, 0x7D, 0x63, 0x0D, 0x08, 0x34, 0x20, 0x91, 0x82, 0x46, 0x0B,
  0x10, 0x2C, 0x41, 0xA1, 0x86, 0x87, 0xF2, 0x04, 0x08, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0xC0, 0x14, 0x01, 0x40,
  0x34, 0x02, 0x40, 0x64, 0x04, 0x40, 0x44, 0x08, 0x40, 0x86, 0x18, 0x61,
  0x02, 0x3F, 0xE3, 0xFE, 0x20, 0x24, 0x02, 0x40, 0x2C, 0x03, 0x80, 0x30,
  0x1F, 0xC3, 0x06, 0x30, 0x32, 0x01, 0x20, 0x12, 0x01, 0x20, 0x32, 0x06,
  0x61, 0xC7, 0xF8, 0x40, 0x44, 0x02, 0x40, 0x24, 0x02, 0xC0, 0x2C, 0x06,
  0x80, 0xC8, 0x18, 0xFE, 0x00, 0x07, 0xE0, 0xC1, 0x84, 0x04, 0x60, 0x22,
  0x01, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x03, 0x01, 0x98, 0x08, 0xC0, 0xC3, 0x0C, 0x0F, 0xC0,
  0x1F, 0x83, 0x0E, 0x30, 0x22, 0x03, 0x20, 0x12, 0x01, 0x20, 0x32, 0x03,
  0x60, 0x26, 0x02, 0x40, 0x24, 0x02, 0x40, 0x64, 0x06, 0xC0, 0x4C, 0x0C,
  0x80, 0x88, 0x30, 0xFE, 0x00, 0x1F, 0xF8, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0xFF, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xF0,
  0x1F, 0xFC, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0xFF, 0x86, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0,
  0xC1, 0x84, 0x04, 0x60, 0x22, 0x01, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0xFC, 0x80, 0x44, 0x02, 0x60, 0x13, 0x01, 0x98, 0x08,
  0xC0, 0xC3, 0x0C, 0x0F, 0xC0, 0x10, 0x19, 0x80, 0x8C, 0x04, 0x40, 0x22,
  0x01, 0x10, 0x18, 0x80, 0xC4, 0x04, 0x60, 0x23, 0xFF, 0x10, 0x08, 0x80,
  0xC4, 0x06, 0x20, 0x23, 0x01, 0x18, 0x08, 0x80, 0x44, 0x02, 0x20, 0x30,
  0x1F, 0xF0, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC4, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x13, 0x00, 0x98, 0x0C, 0x40, 0x43, 0x04, 0x0F, 0xC0,
  0x10, 0x0C, 0xC0, 0x63, 0x01, 0x08, 0x08, 0x20, 0x60, 0x81, 0x02, 0x08,
  0x08, 0x60, 0x61, 0x01, 0xFC, 0x04, 0x10, 0x10, 0x40, 0x41, 0x81, 0x02,
  0x0C, 0x08, 0x30, 0x30, 0x80, 0x42, 0x01, 0x08, 0x06, 0x00, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0xFF,
  0x80, 0x18, 0x0C, 0x60, 0x51, 0x41, 0xC5, 0x0B, 0x14, 0x28, 0xD1, 0x23,
  0x44, 0x88, 0xA2, 0x22, 0x98, 0x8C, 0x62, 0x31, 0x18, 0x04, 0x60, 0x11,
  0x00, 0x44, 0x03, 0x10, 0x0C, 0x40, 0x23, 0x00, 0x8C, 0x02, 0x00, 0x18,
  0x19, 0xC0, 0x8E, 0x04, 0x50, 0x22, 0xC1, 0x12, 0x18, 0x90, 0xC4, 0x84,
  0x66, 0x22, 0x11, 0x10, 0x88, 0x84, 0x44, 0x26, 0x20, 0xA3, 0x05, 0x18,
  0x28, 0x81, 0x44, 0x0E, 0x20, 0x30, 0x07, 0xC1, 0x82, 0x10, 0x33, 0x01,
  0x20, 0x12, 0x01, 0x20, 0x36, 0x03, 0x60, 0x24, 0x02, 0x40, 0x24, 0x02,
  0x40, 0x6C, 0x06, 0xC0, 0x4C, 0x04, 0xC0, 0xC6, 0x18, 0x3F, 0x00, 0x1F,
  0xE1, 0x81, 0x8C, 0x06, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x64, 0x02,
  0x60, 0x23, 0xFE, 0x1F, 0x80, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x07, 0xC1, 0x82, 0x10, 0x33, 0x01,
  0x20, 0x12, 0x01, 0x20, 0x36, 0x03, 0x60, 0x24, 0x02, 0x40, 0x24, 0x02,
  0x40, 0x6C, 0x06, 0xC0, 0x4C, 0x04, 0xC0, 0xC6, 0x18, 0x3F, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x1F, 0xC1, 0x83, 0x8C, 0x04, 0x40,
  0x32, 0x01, 0x90, 0x0C, 0x80, 0x44, 0x06, 0x60, 0x63, 0xFE, 0x10, 0x80,
  0x82, 0x04, 0x10, 0x20, 0xC3, 0x02, 0x18, 0x10, 0x80, 0xC4, 0x02, 0x20,
  0x18, 0x03, 0xF0, 0x30, 0x60, 0x80, 0x84, 0x02, 0x10, 0x08, 0x40, 0x01,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x44, 0x01, 0x10, 0x0C, 0x60, 0x21, 0xC1, 0x01, 0xF8, 0x00, 0xFF,
  0xF8, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x10, 0x19, 0x80, 0x8C, 0x04, 0x40,
  0x22, 0x01, 0x10, 0x18, 0x80, 0xCC, 0x04, 0x60, 0x22, 0x01, 0x10, 0x08,
  0x80, 0x44, 0x06, 0x20, 0x33, 0x01, 0x18, 0x08, 0x40, 0xC3, 0x0C, 0x0F,
  0xC0, 0x80, 0x38, 0x02, 0x80, 0x68, 0x04, 0x80, 0xCC, 0x08, 0xC0, 0x8C,
  0x10, 0x41, 0x04, 0x30, 0x42, 0x04, 0x60, 0x44, 0x04, 0x40, 0x68, 0x06,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x00, 0x41, 0x85, 0x0A, 0x14, 0x30, 0xD0,
  0xC2, 0x47, 0x09, 0x14, 0x24, 0x51, 0x91, 0x44, 0x49, 0x11, 0x24, 0x44,
  0x92, 0x34, 0x48, 0xD1, 0x23, 0x45, 0x8E, 0x14, 0x38, 0x50, 0xE1, 0x42,
  0x86, 0x0C, 0x18, 0x00, 0x08, 0x03, 0x0C, 0x06, 0x04, 0x0C, 0x04, 0x08,
  0x02, 0x10, 0x02, 0x30, 0x03, 0x20, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x03, 0xC0, 0x02, 0x40, 0x04, 0x40, 0x0C, 0x20, 0x18, 0x20, 0x10, 0x30,
  0x30, 0x10, 0x60, 0x10, 0xC0, 0x18, 0xC0, 0x1A, 0x00, 0x90, 0x0C, 0xC0,
  0xC2, 0x04, 0x10, 0x60, 0xC6, 0x02, 0x20, 0x13, 0x00, 0xD0, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x1F, 0xFC, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xC3, 0xF0, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x03, 0x00, 0xFC, 0x00, 0x81, 0x03, 0x06, 0x04, 0x08,
  0x10, 0x30, 0x20, 0x40, 0x81, 0x83, 0x02, 0x04, 0x08, 0x18, 0x10, 0x20,
  0x40, 0xC1, 0x81, 0x02, 0x06, 0x0F, 0xC3, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0xFC,
  0x00, 0x03, 0x01, 0x40, 0x50, 0x24, 0x19, 0x84, 0x23, 0x09, 0x83, 0x40,
  0xF0, 0x10, 0xFF, 0xF8, 0xC2, 0x30, 0x02, 0x01, 0xFF, 0x30, 0x72, 0x02,
  0x60, 0x24, 0x02, 0x40, 0x24, 0x06, 0x40, 0x6C, 0x04, 0xC0, 0x4C, 0x04,
  0xC0, 0xC6, 0x14, 0x3E, 0xC0, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x21,
  0x02, 0xFC, 0x30, 0x62, 0x02, 0x60, 0x26, 0x02, 0x40, 0x24, 0x02, 0x40,
  0x64, 0x06, 0xC0, 0x4C, 0x04, 0xC0, 0xCA, 0x18, 0xBF, 0x00, 0x02, 0x00,
  0xFC, 0x30, 0x62, 0x02, 0x60, 0x24, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x6C, 0x04, 0xC0, 0xC6, 0x18, 0x3F, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x21, 0x0F, 0xF8, 0xC1, 0xC4, 0x04, 0x60, 0x22,
  0x01, 0x10, 0x08, 0x80, 0xC4, 0x06, 0x60, 0x23, 0x01, 0x18, 0x08, 0xC0,
  0xC3, 0x0A, 0x0F, 0xB0, 0x03, 0x03, 0xF8, 0xC1, 0x90, 0x16, 0x02, 0x80,
  0x50, 0x0B, 0xFF, 0x40, 0x18, 0x03, 0x00, 0x60, 0x2C, 0x0C, 0xC3, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x0F, 0xFE, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF8,
  0x00, 0x02, 0x01, 0xFB, 0x30, 0x72, 0x02, 0x60, 0x24, 0x02, 0x40, 0x24,
  0x06, 0x40, 0x6C, 0x04, 0xC0, 0x44, 0x0C, 0x61, 0x43, 0xE4, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x18, 0x07, 0x07, 0xC0, 0x10, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x21, 0x02, 0xFC, 0x30, 0x62, 0x02, 0x60, 0x26, 0x02, 0x40, 0x24,
  0x02, 0x40, 0x64, 0x06, 0xC0, 0x4C, 0x04, 0x80, 0x48, 0x04, 0x80, 0xC0,
  0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x03, 0xC0, 0xF8, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x90, 0x08, 0x80, 0x84, 0x08,
  0x60, 0xC3, 0x0C, 0x10, 0xC0, 0xFC, 0x04, 0x20, 0x21, 0x83, 0x04, 0x18,
  0x30, 0xC0, 0x84, 0x06, 0x20, 0x18, 0xFC, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0xFC, 0x06, 0x21, 0x7B, 0xCC, 0x62, 0x42,
  0x12, 0x10, 0xB0, 0x85, 0x8C, 0x68, 0x43, 0x42, 0x12, 0x10, 0x90, 0x85,
  0x84, 0x2C, 0x61, 0x43, 0x1A, 0x10, 0xC0, 0x01, 0x02, 0xFC, 0x30, 0x62,
  0x02, 0x60, 0x26, 0x02, 0x40, 0x24, 0x02, 0x40, 0x64, 0x06, 0xC0, 0x4C,
  0x04, 0x80, 0x48, 0x04, 0x80, 0xC0, 0x03, 0x01, 0xF8, 0xC1, 0x90, 0x16,
  0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x78, 0x0F, 0x01, 0x60, 0x2C, 0x0C,
  0xC3, 0x0F, 0xC0, 0x00, 0x80, 0xBF, 0x06, 0x0C, 0x20, 0x23, 0x01, 0x18,
  0x08, 0x80, 0x44, 0x02, 0x20, 0x31, 0x01, 0x98, 0x08, 0xC0, 0x46, 0x06,
  0x28, 0x61, 0x7E, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x00,
  0x02, 0x01, 0xFF, 0x30, 0x72, 0x02, 0x60, 0x24, 0x02, 0x40, 0x24, 0x06,
  0x40, 0x6C, 0x04, 0xC0, 0x4C, 0x04, 0xC0, 0xC6, 0x14, 0x3E, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x83, 0xFE, 0x28, 0x23, 0x03,
  0x20, 0x32, 0x03, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x81, 0xFE, 0x30, 0x22, 0x03, 0x60,
  0x06, 0x00, 0x30, 0x01, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x68, 0x06, 0x80,
  0x4C, 0x0C, 0x7F, 0x80, 0x04, 0x01, 0x80, 0x30, 0x04, 0x0F, 0xFE, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x03, 0xF0, 0x20, 0x32, 0x03, 0x60, 0x26, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x24, 0x06, 0x40, 0x6C, 0x04, 0xC0, 0x44, 0x0C, 0x61,
  0x83, 0xF0, 0xC0, 0x3C, 0x06, 0x40, 0x44, 0x0C, 0x40, 0x84, 0x18, 0x61,
  0x02, 0x30, 0x22, 0x02, 0x60, 0x24, 0x03, 0xC0, 0x18, 0x01, 0x80, 0xC3,
  0x0E, 0x18, 0x71, 0x47, 0x8A, 0x2C, 0x51, 0x64, 0x99, 0x24, 0x8B, 0x24,
  0x51, 0x62, 0x8A, 0x1C, 0x50, 0xC3, 0x86, 0x18, 0x20, 0xC0, 0x30, 0x18,
  0xC1, 0x82, 0x08, 0x18, 0x80, 0x48, 0x03, 0xC0, 0x0C, 0x00, 0xE0, 0x0D,
  0x80, 0x44, 0x04, 0x30, 0x40, 0x86, 0x06, 0x60, 0x18, 0x20, 0x36, 0x02,
  0x60, 0x24, 0x02, 0x40, 0x24, 0x06, 0x40, 0x6C, 0x04, 0xC0, 0x4C, 0x04,
  0x40, 0xC6, 0x34, 0x3C, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x70,
  0xFC, 0x00, 0x3F, 0xF0, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x0F, 0xFC, 0x00,
  0x30, 0x0F, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC8, 0x07,
  0x00, 0x18, 0xC4, 0x21, 0x08, 0xC6, 0x21, 0x08, 0x46, 0x31, 0x88, 0x42,
  0x11, 0x8C, 0x42, 0x10, 0x80, 0x0C, 0x00, 0xF0, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01,
  0xF0, 0x30, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x01, 0x80, 0xE0, 0x00, 0x10, 0x17, 0xC1, 0x46, 0x1C,
  0x22, 0x81, 0xE0,
};

const GFXglyph JetBrainsMono_ThinItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 19, 16, 5, -19 },
  { 13, 8, 8, 16, 5, -19 },
  { 21, 15, 19, 16, 1, -19 },
  { 57, 14, 27, 16, 1, -23 },
  { 105, 18, 19, 16, -1, -19 },
  { 148, 14, 19, 16, 1, -19 },
  { 182, 3, 8, 16, 8, -19 },
  { 185, 10, 25, 16, 5, -22 },
  { 217, 10, 25, 16, 1, -22 },
  { 249, 13, 13, 16, 2, -16 },
  { 271, 12, 12, 16, 2, -15 },
  { 289, 6, 8, 16, 3, -4 },
  { 295, 8, 1, 16, 4, -9 },
  { 296, 4, 4, 16, 5, -4 },
  { 298, 14, 25, 16, 1, -22 },
  { 342, 12, 19, 16, 2, -19 },
  { 371, 12, 19, 16, 1, -19 },
  { 400, 14, 19, 16, 1, -19 },
  { 434, 12, 19, 16, 2, -19 },
  { 463, 12, 19, 16, 2, -19 },
  { 492, 12, 19, 16, 2, -19 },
  { 521, 11, 19, 16, 2, -19 },
  { 548, 13, 19, 16, 3, -19 },
  { 579, 12, 19, 16, 2, -19 },
  { 608, 12, 19, 16, 3, -19 },
  { 637, 6, 15, 16, 5, -15 },
  { 649, 8, 19, 16, 3, -15 },
  { 668, 13, 13, 16, 2, -15 },
  { 690, 12, 7, 16, 2, -12 },
  { 701, 12, 13, 16, 2, -15 },
  { 721, 10, 19, 16, 4, -19 },
  { 745, 14, 24, 16, 1, -19 },
  { 787, 12, 19, 16, 1, -19 },
  { 816, 12, 19, 16, 2, -19 },
  { 845, 13, 19, 16, 2, -19 },
  { 876, 12, 19, 16, 2, -19 },
  { 905, 13, 19, 16, 2, -19 },
  { 936, 14, 19, 16, 2, -19 },
  { 970, 13, 19, 16, 2, -19 },
  { 1001, 13, 19, 16, 2, -19 },
  { 1032, 12, 19, 16, 2, -19 },
  { 1061, 13, 19, 16, 1, -19 },
  { 1092, 14, 19, 16, 2, -19 },
  { 1126, 11, 19, 16, 2, -19 },
  { 1153, 14, 19, 16, 1, -19 },
  { 1187, 13, 19, 16, 2, -19 },
  { 1218, 12, 19, 16, 2, -19 },
  { 1247, 13, 19, 16, 2, -19 },
  { 1278, 12, 24, 16, 2, -19 },
  { 1314, 13, 19, 16, 2, -19 },
  { 1345, 14, 19, 16, 1, -19 },
  { 1379, 13, 19, 16, 3, -19 },
  { 1410, 13, 19, 16, 2, -19 },
  { 1441, 12, 19, 16, 4, -19 },
  { 1470, 14, 19, 16, 2, -19 },
  { 1504, 16, 19, 16, 0, -19 },
  { 1542, 13, 19, 16, 3, -19 },
  { 1573, 14, 19, 16, 1, -19 },
  { 1607, 10, 25, 16, 4, -22 },
  { 1639, 7, 25, 16, 5, -22 },
  { 1661, 10, 25, 16, 2, -22 },
  { 1693, 10, 10, 16, 3, -19 },
  { 1706, 13, 1, 16, 0, 1 },
  { 1708, 4, 3, 16, 7, -20 },
  { 1710, 12, 15, 16, 2, -15 },
  { 1733, 12, 19, 16, 2, -19 },
  { 1762, 12, 15, 16, 2, -15 },
  { 1785, 13, 19, 16, 2, -19 },
  { 1816, 11, 15, 16, 2, -15 },
  { 1837, 16, 24, 16, -1, -19 },
  { 1885, 12, 20, 16, 2, -15 },
  { 1915, 12, 19, 16, 2, -19 },
  { 1944, 12, 20, 16, 1, -20 },
  { 1974, 13, 25, 16, 1, -20 },
  { 2015, 13, 19, 16, 2, -19 },
  { 2046, 10, 19, 16, 3, -19 },
  { 2070, 13, 15, 16, 1, -15 },
  { 2095, 12, 15, 16, 2, -15 },
  { 2118, 11, 15, 16, 2, -15 },
  { 2139, 13, 20, 16, 1, -15 },
  { 2172, 12, 20, 16, 2, -15 },
  { 2202, 12, 15, 16, 2, -15 },
  { 2225, 12, 15, 16, 2, -15 },
  { 2248, 11, 18, 16, 3, -18 },
  { 2273, 12, 14, 16, 2, -14 },
  { 2294, 12, 14, 16, 3, -14 },
  { 2315, 13, 14, 16, 2, -14 },
  { 2338, 13, 14, 16, 1, -14 },
  { 2361, 12, 19, 16, 2, -14 },
  { 2390, 12, 14, 16, 2, -14 },
  { 2411, 12, 25, 16, 3, -22 },
  { 2449, 5, 25, 16, 6, -22 },
  { 2465, 12, 25, 16, 1, -22 },
  { 2503, 12, 5, 16, 2, -12 },
};

const GFXfont JetBrainsMono_ThinItalic26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_THINITALIC26PT7B_H_
