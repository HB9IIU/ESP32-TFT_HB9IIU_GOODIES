#ifndef _JETBRAINSMONO_THINITALIC43PT7B_H_
#define _JETBRAINSMONO_THINITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x78, 0xF8, 0xF8, 0xF0, 0x70, 0x3B, 0x81, 0x9C,
  0x1C, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0x9C, 0x0C, 0xC0, 0x66, 0x03,
  0x30, 0x39, 0x81, 0x8C, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03,
  0x80, 0x06, 0x01, 0x80, 0x03, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80,
  0x60, 0x01, 0xC0, 0x70, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x0F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x18, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x01, 0x80, 0x07, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xC0, 0x30, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x03, 0x80, 0xE0, 0x01, 0x80, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xFE, 0x00, 0x79, 0xBC, 0x03, 0x86, 0x38, 0x0C, 0x10, 0x60, 0x60,
  0x41, 0xC1, 0x83, 0x07, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x00, 0xE0, 0xC0,
  0x03, 0x82, 0x00, 0x06, 0x08, 0x00, 0x1C, 0x60, 0x00, 0x79, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0x78, 0x00, 0x0C,
  0x70, 0x00, 0x30, 0xE0, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x1C,
  0x00, 0x20, 0x71, 0x80, 0x81, 0x86, 0x06, 0x06, 0x18, 0x18, 0x18, 0x70,
  0x60, 0xC1, 0xC1, 0x87, 0x03, 0x86, 0x38, 0x07, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x08, 0x0F, 0xE0,
  0x01, 0x80, 0xE3, 0x80, 0x18, 0x06, 0x0C, 0x01, 0xC0, 0x60, 0x30, 0x0C,
  0x03, 0x01, 0x80, 0xC0, 0x18, 0x08, 0x0C, 0x01, 0x80, 0xC0, 0xC0, 0x0C,
  0x06, 0x0C, 0x00, 0x60, 0x30, 0xC0, 0x03, 0x01, 0x8E, 0x00, 0x18, 0x18,
  0x60, 0x00, 0xE1, 0xC6, 0x00, 0x03, 0xFC, 0x60, 0x00, 0x07, 0x86, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x1F, 0x80, 0x00, 0x31, 0xFE, 0x00, 0x03, 0x18, 0x38, 0x00, 0x30,
  0x80, 0xC0, 0x03, 0x0C, 0x06, 0x00, 0x30, 0x60, 0x30, 0x03, 0x83, 0x01,
  0x80, 0x18, 0x18, 0x0C, 0x01, 0x81, 0x80, 0xC0, 0x18, 0x0C, 0x06, 0x01,
  0x80, 0x60, 0x30, 0x18, 0x01, 0x83, 0x01, 0x80, 0x0F, 0xF0, 0x1C, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xC3, 0xC0, 0x06,
  0x03, 0x80, 0x1C, 0x03, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x1C, 0x30, 0x02, 0x30, 0x70, 0x18, 0xC0, 0x60, 0x31, 0x80, 0xE0, 0xC3,
  0x00, 0xC3, 0x06, 0x00, 0xCE, 0x1C, 0x01, 0xD8, 0x30, 0x01, 0xE0, 0x60,
  0x03, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0F, 0x03, 0x00, 0x37, 0x06, 0x00,
  0xE6, 0x0E, 0x07, 0x8E, 0x0F, 0xFC, 0x0C, 0x0F, 0xF0, 0x0C, 0x77, 0x77,
  0x76, 0xEE, 0xEE, 0xCC, 0xC0, 0x00, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x01, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x7C, 0x0C, 0x0F, 0xFC,
  0x31, 0xFC, 0xFC, 0x9F, 0x80, 0x7F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x06, 0x60, 0x00, 0x39, 0x80, 0x01, 0xC7, 0x00, 0x0E, 0x0E, 0x00,
  0x30, 0x38, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x80,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3C, 0xFB, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFC, 0xF8, 0x0F, 0x01, 0xE0, 0x60, 0x07,
  0x06, 0x00, 0x18, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x18, 0x00, 0x38, 0xC0,
  0x01, 0x8E, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x38,
  0xC1, 0xC1, 0xC6, 0x0F, 0x0E, 0x30, 0xF8, 0x63, 0x83, 0x83, 0x1C, 0x00,
  0x18, 0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x71, 0x80, 0x03, 0x1C,
  0x00, 0x18, 0xE0, 0x00, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x60, 0xC0, 0x07,
  0x07, 0x00, 0x70, 0x3C, 0x07, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x01, 0xEC, 0x00, 0x71, 0x80, 0x38, 0x70, 0x0E,
  0x0E, 0x01, 0x01, 0x80, 0x40, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x0E,
  0x07, 0x00, 0x18, 0x38, 0x00, 0x70, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x1C,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x1C, 0x38, 0x00, 0xC0, 0xC0, 0x0E, 0x07, 0x00, 0xE0, 0x1F, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x30, 0xE0,
  0x1C, 0x70, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x67, 0x00, 0x1B, 0x80, 0x06,
  0xC0, 0x03, 0xB0, 0x00, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x0F, 0x00, 0x31, 0xFE, 0x01, 0xBC, 0xF8, 0x0F,
  0x00, 0xE0, 0x70, 0x03, 0x03, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0xE0, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0xE0,
  0xC0, 0x0E, 0x07, 0x00, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x67, 0xE0, 0x1B, 0xFE, 0x07, 0xC1, 0xE0, 0xE0,
  0x0E, 0x38, 0x00, 0xC6, 0x00, 0x1D, 0x80, 0x01, 0xB0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x31, 0x80, 0x0E, 0x38, 0x01, 0x83, 0x80, 0xE0, 0x7F, 0xF8, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9C, 0x00, 0x0C, 0xE0, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x07, 0x1C, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xFE, 0x00, 0x70, 0x78, 0x06, 0x00, 0xE0, 0x60, 0x03,
  0x06, 0x00, 0x1C, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x83, 0x00, 0x18, 0x18, 0x01, 0xC0, 0x60, 0x1C, 0x03, 0x81, 0xC0,
  0x07, 0x78, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x3C, 0x70, 0x03, 0x81,
  0xC0, 0x30, 0x03, 0x03, 0x00, 0x1C, 0x38, 0x00, 0x61, 0x80, 0x03, 0x1C,
  0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x71, 0xC0, 0x03,
  0x06, 0x00, 0x38, 0x38, 0x03, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x3C, 0x1E, 0x0E, 0x00, 0xE3, 0x80, 0x0C, 0x60,
  0x01, 0xDC, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x03, 0xB8, 0x00, 0x63, 0x00,
  0x1C, 0x70, 0x07, 0x07, 0xC7, 0xE0, 0x7F, 0x98, 0x00, 0x86, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x83, 0xE1, 0xFC, 0x7E, 0x1F, 0x83, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x81, 0xF0, 0x7E, 0x3F, 0x8F, 0xC1, 0xE0, 0x00, 0xF0, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0x80, 0x00, 0x08, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0x06, 0x03, 0x00, 0x07, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x03, 0xE3, 0x18,
  0x0F, 0xF3, 0x18, 0x1E, 0x1E, 0x18, 0x18, 0x0E, 0x38, 0x38, 0x06, 0x38,
  0x30, 0x06, 0x30, 0x30, 0x06, 0x30, 0x30, 0x06, 0x30, 0x30, 0x0E, 0x30,
  0x70, 0x0C, 0x30, 0x60, 0x0C, 0x70, 0x60, 0x0C, 0x60, 0x60, 0x0C, 0x60,
  0x60, 0x1C, 0x60, 0x60, 0x1C, 0x60, 0x70, 0x38, 0x60, 0x7C, 0xF8, 0xE0,
  0x3F, 0xD8, 0xE0, 0x06, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x0D, 0x80,
  0x01, 0x98, 0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x06, 0x18,
  0x00, 0x60, 0xC0, 0x0E, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x01, 0x80,
  0xC0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x00, 0xE0, 0x60,
  0x06, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x18,
  0x00, 0x63, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x07, 0x60, 0x00, 0x36,
  0x00, 0x03, 0xC0, 0x00, 0x30, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0x00,
  0x38, 0x18, 0x00, 0xE0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1,
  0x80, 0x06, 0x1C, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x30, 0x01,
  0xC1, 0x80, 0x1C, 0x0C, 0x03, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x30,
  0x03, 0x81, 0x80, 0x0E, 0x0C, 0x00, 0x30, 0x60, 0x01, 0xC7, 0x00, 0x06,
  0x30, 0x00, 0x31, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00,
  0x0E, 0x18, 0x00, 0x61, 0xC0, 0x0E, 0x0C, 0x00, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xC3, 0xC0, 0x60,
  0x0E, 0x0C, 0x00, 0x61, 0xC0, 0x07, 0x18, 0x00, 0x31, 0x80, 0x03, 0x38,
  0x00, 0x33, 0x00, 0x04, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00,
  0x30, 0xE0, 0x06, 0x07, 0x01, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0xFC, 0x0C, 0x01, 0xE0, 0xC0, 0x0E, 0x0C, 0x00, 0x70,
  0xC0, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x71, 0x80, 0x07, 0x18, 0x00, 0x61, 0x80, 0x06, 0x38, 0x00,
  0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x00,
  0x0C, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x60,
  0x01, 0x86, 0x00, 0x38, 0x60, 0x07, 0x0E, 0x00, 0xE0, 0xC0, 0x3C, 0x0F,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xC3, 0xC0, 0x60, 0x0E, 0x0C,
  0x00, 0x61, 0xC0, 0x07, 0x18, 0x00, 0x31, 0x80, 0x03, 0x38, 0x00, 0x33,
  0x00, 0x04, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x07, 0xFC, 0x60, 0x7F,
  0xC6, 0x00, 0x0C, 0xE0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00,
  0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xE0,
  0x06, 0x07, 0x01, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x06, 0x00, 0x18,
  0x30, 0x00, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x1C, 0x00, 0x30, 0xC0, 0x03, 0x86,
  0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x07, 0x0C, 0x00, 0x30,
  0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00,
  0x38, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0,
  0x01, 0xC3, 0x80, 0x06, 0x06, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x78, 0x0E,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x0C, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0x60, 0x01, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x0C,
  0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00,
  0x60, 0x1C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xE0, 0x03, 0x03, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x18, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x07, 0x01, 0x80, 0x0E,
  0x07, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0x00, 0x1E, 0x0F, 0x00, 0x2C, 0x1E, 0x00, 0xD0, 0x6C, 0x01, 0x60, 0xC8,
  0x06, 0xC1, 0x90, 0x09, 0x83, 0x30, 0x33, 0x06, 0x60, 0x46, 0x0C, 0xC1,
  0x9C, 0x38, 0x86, 0x30, 0x61, 0x0C, 0x60, 0xC3, 0x30, 0xC1, 0x86, 0x61,
  0x83, 0x0D, 0x83, 0x06, 0x0B, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x38, 0x30,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x07, 0x06,
  0x00, 0x0C, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0,
  0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x00, 0x07, 0x00, 0x18, 0x38, 0x00, 0xC3, 0x40,
  0x06, 0x1B, 0x00, 0x70, 0xD8, 0x03, 0x06, 0xC0, 0x18, 0x36, 0x00, 0xC1,
  0x98, 0x06, 0x18, 0xC0, 0x30, 0xC6, 0x01, 0x86, 0x30, 0x18, 0x30, 0xC0,
  0xC1, 0x86, 0x06, 0x0C, 0x30, 0x30, 0xE1, 0x81, 0x86, 0x06, 0x0C, 0x30,
  0x30, 0xC1, 0x81, 0x86, 0x0C, 0x0C, 0x30, 0x60, 0x21, 0x87, 0x01, 0x8C,
  0x30, 0x0C, 0x61, 0x80, 0x67, 0x0C, 0x03, 0x30, 0x60, 0x0D, 0x83, 0x00,
  0x6C, 0x18, 0x03, 0x61, 0x80, 0x1B, 0x0C, 0x00, 0x78, 0x60, 0x03, 0x83,
  0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0x83, 0xC0, 0x60,
  0x0C, 0x0C, 0x00, 0xE1, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x38,
  0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xE3,
  0x00, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C,
  0x60, 0x01, 0xC6, 0x00, 0x18, 0xE0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00,
  0x60, 0xE0, 0x0E, 0x07, 0x01, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xC0, 0x07, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x1C, 0x30, 0x00, 0x70, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x1C,
  0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x60,
  0x01, 0x83, 0x80, 0x1C, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0x83, 0xC0, 0x60, 0x0C, 0x0C,
  0x00, 0xE1, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x38, 0x00, 0x63,
  0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xE3, 0x00, 0x0C,
  0x70, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01,
  0xC6, 0x00, 0x18, 0xE0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00,
  0x18, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xE0,
  0x0E, 0x07, 0x01, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xC0,
  0x07, 0x03, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01,
  0x83, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x03, 0x86,
  0x00, 0x0C, 0x18, 0x00, 0x70, 0x60, 0x03, 0x83, 0x80, 0x3C, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x07, 0x00,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x60,
  0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x38, 0x00, 0xC0, 0xC0, 0x01,
  0x83, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x0E, 0x03, 0x00, 0x18, 0x18, 0x00, 0x70,
  0x60, 0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x1C, 0x00, 0x30,
  0x70, 0x01, 0xC0, 0xE0, 0x0E, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x18,
  0x70, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x1C, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xE0, 0x01,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x07, 0x0C, 0x00, 0x30,
  0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0xE0, 0x0E, 0x03, 0x80,
  0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x06,
  0xC0, 0x00, 0xEE, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x01,
  0x86, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x70, 0x60, 0x06, 0x07, 0x00,
  0x60, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x03, 0x01, 0x80, 0x30,
  0x38, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x06, 0x00, 0x38, 0x60, 0x01,
  0x8E, 0x00, 0x18, 0xC0, 0x01, 0x9C, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00,
  0x1B, 0x00, 0x01, 0xB0, 0x00, 0x1A, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x38, 0x06, 0xC0, 0x70, 0x0D, 0x80, 0xA0, 0x33, 0x03, 0x40,
  0x66, 0x06, 0x80, 0xCC, 0x0D, 0x03, 0x90, 0x12, 0x06, 0x20, 0x64, 0x0C,
  0xC0, 0xC8, 0x19, 0x81, 0x10, 0x63, 0x06, 0x20, 0xC6, 0x0C, 0x41, 0x8C,
  0x10, 0x83, 0x18, 0x61, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x8C, 0x30, 0xC2,
  0x18, 0xC1, 0x8C, 0x31, 0x83, 0x18, 0x63, 0x06, 0x20, 0xC6, 0x0C, 0xC1,
  0x98, 0x19, 0x83, 0x30, 0x32, 0x06, 0x60, 0x6C, 0x0D, 0x80, 0xD8, 0x1B,
  0x01, 0xA0, 0x36, 0x03, 0x40, 0x6C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x60,
  0x00, 0xE0, 0x18, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x38, 0x07, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x38, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x70, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03,
  0x80, 0x06, 0x00, 0x60, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x60,
  0x00, 0xC0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x1D, 0x80, 0x00, 0xE6, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0xE0, 0xC0, 0x03, 0x01, 0x80, 0x18, 0x06, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x30, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00, 0x06, 0x18, 0x00,
  0x18, 0xE0, 0x00, 0x63, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x19, 0xC0, 0x1C, 0x60, 0x0C, 0x30,
  0x0E, 0x18, 0x06, 0x0E, 0x06, 0x03, 0x07, 0x01, 0x83, 0x00, 0xE3, 0x80,
  0x33, 0x80, 0x19, 0x80, 0x0D, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE1, 0x83, 0x0E, 0x18, 0x30, 0x00, 0xFC, 0x30, 0x3F, 0xF3, 0x07,
  0x03, 0xF0, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x18, 0x00, 0x63,
  0x00, 0x06, 0x30, 0x00, 0xE3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C,
  0x70, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x1C, 0x60, 0x01,
  0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x38, 0x70, 0x07, 0x83, 0x80,
  0xF8, 0x3F, 0x7B, 0x00, 0xFE, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x63,
  0xF0, 0x1D, 0xFF, 0x83, 0x60, 0x38, 0x78, 0x03, 0x0E, 0x00, 0x71, 0x80,
  0x06, 0x30, 0x00, 0xCE, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00,
  0x1C, 0xC0, 0x03, 0x18, 0x00, 0x67, 0x00, 0x0C, 0xE0, 0x01, 0x98, 0x00,
  0x33, 0x00, 0x0E, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0E, 0x78, 0x03,
  0x8D, 0x80, 0xE1, 0x9E, 0xF8, 0x31, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x38, 0x0E, 0x0E, 0x00, 0xE3, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x33, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x01,
  0x98, 0x00, 0x73, 0x00, 0x0C, 0x60, 0x03, 0x8E, 0x00, 0x60, 0xE0, 0x38,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x1F, 0x86, 0x03, 0xFF, 0x30, 0x38, 0x1F, 0x83, 0x80, 0x38, 0x38, 0x01,
  0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x1C, 0x30,
  0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00, 0x0C,
  0x30, 0x00, 0x61, 0x80, 0x07, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00,
  0x0C, 0x18, 0x00, 0xE0, 0xE0, 0x0F, 0x03, 0x80, 0xF8, 0x1F, 0xBD, 0x80,
  0x3F, 0x8C, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xE0, 0x38, 0x70, 0x06,
  0x38, 0x01, 0xCC, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x36, 0x00, 0x1D, 0xFF, 0xFE, 0xFF, 0xFF, 0xB0, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x33, 0x00, 0x1C,
  0xE0, 0x0E, 0x1C, 0x07, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x60,
  0xFF, 0xCC, 0x38, 0x1F, 0x8E, 0x00, 0xE3, 0x80, 0x1C, 0x60, 0x03, 0x8C,
  0x00, 0x33, 0x00, 0x06, 0x60, 0x01, 0xCC, 0x00, 0x31, 0x80, 0x06, 0x30,
  0x00, 0xCE, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x1C, 0xC0,
  0x03, 0x1C, 0x00, 0xE1, 0x80, 0x3C, 0x38, 0x0D, 0x83, 0xFF, 0x30, 0x3F,
  0x8E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x1F, 0xFC, 0x07, 0xF8,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x63, 0xF0, 0x1D, 0xFF, 0x83, 0x60,
  0x38, 0x78, 0x03, 0x0E, 0x00, 0x71, 0x80, 0x06, 0x30, 0x00, 0xCE, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00,
  0x67, 0x00, 0x0C, 0xE0, 0x01, 0x98, 0x00, 0x73, 0x00, 0x0C, 0x60, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x06, 0x70, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x07,
  0x30, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x03, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x07, 0x0C, 0x00, 0x38, 0x70,
  0x01, 0xC1, 0x80, 0x0E, 0x06, 0x00, 0x70, 0x18, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x60, 0x0E, 0x03, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x30, 0x30, 0x01, 0xC0, 0x60, 0x06, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0x80, 0x18, 0x06, 0x00, 0x70,
  0x18, 0x00, 0xC0, 0xE0, 0x03, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x3F, 0xFC, 0x0F, 0xFC, 0x0C, 0xF8, 0xF8, 0x1B, 0xFB, 0xF8,
  0x38, 0x74, 0x30, 0x60, 0x70, 0x70, 0xC0, 0xC0, 0xE3, 0x81, 0x81, 0x86,
  0x03, 0x03, 0x0C, 0x06, 0x06, 0x18, 0x18, 0x0C, 0x30, 0x30, 0x18, 0x60,
  0x60, 0x31, 0xC0, 0xC0, 0xE3, 0x01, 0x81, 0x86, 0x03, 0x03, 0x0C, 0x0E,
  0x06, 0x18, 0x18, 0x0C, 0x30, 0x30, 0x18, 0x60, 0x60, 0x71, 0x80, 0xC0,
  0xC3, 0x01, 0x81, 0x86, 0x03, 0x03, 0x0C, 0x0C, 0x06, 0x18, 0x18, 0x0C,
  0x70, 0x30, 0x38, 0x0C, 0x7E, 0x03, 0xBF, 0xF0, 0x6C, 0x07, 0x0D, 0x00,
  0x61, 0xC0, 0x0E, 0x30, 0x00, 0xC6, 0x00, 0x19, 0xC0, 0x03, 0x30, 0x00,
  0x66, 0x00, 0x1C, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0xE0, 0x01,
  0x9C, 0x00, 0x33, 0x00, 0x0E, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06,
  0x30, 0x00, 0xCE, 0x00, 0x19, 0x80, 0x07, 0x30, 0x00, 0xE6, 0x00, 0x18,
  0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xE0, 0x38, 0x70, 0x06, 0x38, 0x01, 0xCC,
  0x00, 0x33, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00,
  0x1D, 0x80, 0x06, 0xE0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06,
  0xC0, 0x03, 0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x18, 0xE0, 0x0E, 0x1C,
  0x07, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x06, 0x3F, 0x80, 0xEF, 0xFC, 0x0D,
  0x80, 0xE0, 0xF0, 0x06, 0x0E, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00, 0x31,
  0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x71, 0x80, 0x06,
  0x18, 0x00, 0x63, 0x80, 0x06, 0x38, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00,
  0xE3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x78, 0x03, 0x86, 0xC0,
  0x70, 0x67, 0xBE, 0x06, 0x3F, 0xC0, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xFC, 0x30, 0x3F, 0xF3, 0x07, 0x03, 0xF0, 0xE0, 0x0E,
  0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x18, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00,
  0xE3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xC6, 0x00,
  0x0C, 0x60, 0x00, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60,
  0x01, 0x86, 0x00, 0x38, 0x70, 0x07, 0x83, 0x80, 0xF8, 0x3F, 0x7B, 0x00,
  0xFE, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x18, 0x7E,
  0x03, 0x3F, 0xF0, 0x6C, 0x0F, 0x0F, 0x00, 0x61, 0xC0, 0x0E, 0x70, 0x01,
  0xCE, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x1C, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC,
  0x0F, 0x01, 0xE0, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x07, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xE0, 0x01, 0x87,
  0x00, 0x30, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x1C, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x31, 0x80, 0x07, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00,
  0x63, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x00,
  0x0C, 0x30, 0x00, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x1C, 0x60,
  0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0x70, 0x07, 0x03,
  0x80, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1D,
  0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x00, 0xC3,
  0x80, 0x38, 0x30, 0x06, 0x06, 0x01, 0xC0, 0xC0, 0x30, 0x18, 0x0E, 0x03,
  0x01, 0x80, 0x30, 0x70, 0x06, 0x0C, 0x00, 0xC3, 0x80, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0xC0, 0x30, 0x1F, 0x01, 0xC0, 0x6C, 0x07, 0x01,
  0xB0, 0x34, 0x0C, 0xC0, 0xD0, 0x33, 0x02, 0x40, 0xCC, 0x19, 0x06, 0x30,
  0x64, 0x18, 0xC1, 0x10, 0x63, 0x0C, 0x43, 0x8C, 0x31, 0x0C, 0x30, 0x84,
  0x30, 0xC6, 0x11, 0xC3, 0x18, 0x46, 0x0C, 0x41, 0x18, 0x33, 0x04, 0xE0,
  0xCC, 0x13, 0x03, 0x20, 0x4C, 0x0D, 0x81, 0x30, 0x36, 0x07, 0x80, 0xD0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x1C, 0x01, 0x80, 0x18, 0x06,
  0x00, 0x38, 0x1C, 0x00, 0x30, 0x70, 0x00, 0x71, 0xC0, 0x00, 0x63, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x63, 0x00, 0x01, 0x87, 0x00, 0x06,
  0x06, 0x00, 0x18, 0x0E, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x1C, 0x07, 0x00,
  0x18, 0x0C, 0x00, 0x18, 0x70, 0x00, 0x38, 0x18, 0x00, 0x71, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x63, 0x80, 0x06, 0x30, 0x00,
  0xE3, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC7, 0x00,
  0x0C, 0x60, 0x00, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60,
  0x03, 0x86, 0x00, 0x38, 0x70, 0x05, 0x83, 0x80, 0xF8, 0x1F, 0xFB, 0x00,
  0xFE, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x7F, 0xF0,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF0, 0x03, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x0F, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x6F, 0xF0, 0x0D, 0x87, 0x01, 0xE0,
  0x60, 0x3C, 0x06, 0x0D, 0x80, 0xE1, 0xB0, 0x0F, 0xE6, 0x00, 0x78,
};

const GFXglyph JetBrainsMono_ThinItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 31, 26, 9, -31 },
  { 32, 13, 13, 26, 9, -31 },
  { 54, 25, 31, 26, 1, -31 },
  { 151, 22, 43, 26, 2, -37 },
  { 270, 29, 32, 26, -1, -32 },
  { 386, 23, 32, 26, 1, -32 },
  { 478, 4, 13, 26, 13, -31 },
  { 485, 17, 41, 26, 8, -36 },
  { 573, 17, 41, 26, 2, -36 },
  { 661, 22, 22, 26, 3, -26 },
  { 722, 20, 20, 26, 3, -24 },
  { 772, 10, 14, 26, 5, -7 },
  { 790, 14, 2, 26, 6, -15 },
  { 794, 7, 6, 26, 8, -6 },
  { 800, 24, 41, 26, 1, -36 },
  { 923, 21, 32, 26, 3, -32 },
  { 1007, 19, 31, 26, 2, -31 },
  { 1081, 22, 32, 26, 2, -32 },
  { 1169, 21, 31, 26, 3, -31 },
  { 1251, 18, 31, 26, 4, -31 },
  { 1321, 21, 31, 26, 3, -31 },
  { 1403, 19, 31, 26, 3, -31 },
  { 1477, 21, 31, 26, 5, -31 },
  { 1559, 21, 32, 26, 3, -32 },
  { 1643, 19, 32, 26, 5, -32 },
  { 1719, 10, 24, 26, 8, -24 },
  { 1749, 13, 31, 26, 5, -24 },
  { 1800, 20, 22, 26, 4, -25 },
  { 1855, 19, 12, 26, 4, -20 },
  { 1884, 19, 22, 26, 3, -25 },
  { 1937, 17, 31, 26, 7, -31 },
  { 2003, 24, 40, 26, 1, -32 },
  { 2123, 20, 31, 26, 1, -31 },
  { 2201, 21, 31, 26, 3, -31 },
  { 2283, 20, 32, 26, 4, -32 },
  { 2363, 20, 31, 26, 3, -31 },
  { 2441, 22, 31, 26, 3, -31 },
  { 2527, 23, 31, 26, 3, -31 },
  { 2617, 20, 32, 26, 4, -32 },
  { 2697, 21, 31, 26, 3, -31 },
  { 2779, 21, 31, 26, 3, -31 },
  { 2861, 22, 31, 26, 2, -31 },
  { 2947, 23, 31, 26, 3, -31 },
  { 3037, 18, 31, 26, 3, -31 },
  { 3107, 23, 31, 26, 2, -31 },
  { 3197, 21, 31, 26, 3, -31 },
  { 3279, 20, 32, 26, 4, -32 },
  { 3359, 22, 31, 26, 3, -31 },
  { 3445, 20, 40, 26, 4, -32 },
  { 3545, 22, 31, 26, 3, -31 },
  { 3631, 22, 32, 26, 2, -32 },
  { 3719, 21, 31, 26, 5, -31 },
  { 3801, 21, 31, 26, 3, -31 },
  { 3883, 20, 31, 26, 6, -31 },
  { 3961, 23, 31, 26, 4, -31 },
  { 4051, 26, 31, 26, 0, -31 },
  { 4152, 22, 31, 26, 5, -31 },
  { 4238, 22, 31, 26, 2, -31 },
  { 4324, 16, 41, 26, 7, -36 },
  { 4406, 11, 41, 26, 8, -36 },
  { 4463, 16, 41, 26, 4, -36 },
  { 4545, 17, 16, 26, 5, -31 },
  { 4579, 21, 2, 26, 0, 1 },
  { 4585, 6, 6, 26, 12, -34 },
  { 4590, 20, 24, 26, 3, -24 },
  { 4650, 19, 31, 26, 3, -31 },
  { 4724, 19, 24, 26, 4, -24 },
  { 4781, 21, 31, 26, 3, -31 },
  { 4863, 18, 24, 26, 4, -24 },
  { 4917, 27, 39, 26, -1, -31 },
  { 5049, 19, 32, 26, 4, -24 },
  { 5125, 19, 31, 26, 3, -31 },
  { 5199, 19, 33, 26, 2, -33 },
  { 5278, 21, 41, 26, 1, -33 },
  { 5386, 22, 31, 26, 3, -31 },
  { 5472, 17, 31, 26, 5, -31 },
  { 5538, 23, 24, 26, 1, -24 },
  { 5607, 19, 24, 26, 3, -24 },
  { 5664, 18, 24, 26, 4, -24 },
  { 5718, 20, 32, 26, 2, -24 },
  { 5798, 20, 32, 26, 3, -24 },
  { 5878, 19, 24, 26, 4, -24 },
  { 5935, 20, 24, 26, 3, -24 },
  { 5995, 19, 30, 26, 5, -30 },
  { 6067, 20, 24, 26, 3, -24 },
  { 6127, 19, 24, 26, 5, -24 },
  { 6184, 22, 24, 26, 4, -24 },
  { 6250, 23, 24, 26, 1, -24 },
  { 6319, 20, 32, 26, 3, -24 },
  { 6399, 20, 24, 26, 3, -24 },
  { 6459, 20, 41, 26, 5, -36 },
  { 6562, 9, 41, 26, 9, -36 },
  { 6609, 20, 41, 26, 2, -36 },
  { 6712, 19, 8, 26, 4, -19 },
};

const GFXfont JetBrainsMono_ThinItalic43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_THINITALIC43PT7B_H_
