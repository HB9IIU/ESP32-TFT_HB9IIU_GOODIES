#ifndef _ROBOTOCONDENSED_ITALIC34PT7B_H_
#define _ROBOTOCONDENSED_ITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3,
  0x87, 0x0C, 0x38, 0x70, 0x00, 0x00, 0x06, 0x1C, 0x38, 0x30, 0x33, 0x73,
  0x73, 0x67, 0x66, 0x66, 0x66, 0xC6, 0x00, 0xE3, 0x00, 0x63, 0x80, 0x31,
  0x80, 0x38, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x0E, 0x30, 0x7F, 0xFE, 0x3F,
  0xFF, 0x03, 0x8C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0x63, 0x80,
  0x31, 0x81, 0xFF, 0xF8, 0xFF, 0xFC, 0x0C, 0x60, 0x0E, 0x30, 0x06, 0x38,
  0x03, 0x18, 0x03, 0x8C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x1F, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0x0E,
  0x1C, 0x1C, 0x38, 0x18, 0x70, 0x30, 0xE0, 0x61, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x9C, 0x07, 0x38, 0x0E, 0x70, 0x3C, 0x70, 0xF0, 0xFF, 0xC0, 0xFF, 0x00,
  0xFC, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x73, 0x00, 0x63, 0x04, 0xE3, 0x8E, 0xC3, 0x9C, 0xC3, 0x18, 0xC3, 0x30,
  0x67, 0x70, 0x7E, 0x60, 0x3C, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x3C,
  0x06, 0x7E, 0x0E, 0xE6, 0x0C, 0xC7, 0x19, 0xC3, 0x31, 0xC7, 0x71, 0x87,
  0x61, 0xC6, 0x00, 0xCE, 0x00, 0xFC, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xF8,
  0x07, 0xF8, 0x0E, 0x18, 0x0E, 0x1C, 0x0C, 0x1C, 0x0C, 0x38, 0x0E, 0x78,
  0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x80, 0x3F, 0xC6,
  0x79, 0xC6, 0x71, 0xEE, 0xE0, 0xEE, 0xE0, 0xFC, 0xE0, 0x7C, 0xE0, 0x78,
  0x70, 0x78, 0x7F, 0xFC, 0x3F, 0xDC, 0x1F, 0x8E, 0x66, 0x66, 0xEE, 0xCC,
  0x00, 0x40, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x02, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x01, 0x00, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x06, 0x31, 0xFD, 0xFD, 0xFF, 0xE1, 0xF8, 0x0F, 0x00,
  0xFC, 0x0E, 0x60, 0xE3, 0x86, 0x1C, 0x10, 0x40, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x1F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF0, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0x1C, 0x73, 0x8E, 0x39, 0xCE, 0x10, 0xFF, 0xFF,
  0xF0, 0x6E, 0xFE, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFE,
  0x78, 0x73, 0x83, 0x98, 0x0D, 0xC0, 0x6E, 0x03, 0x70, 0x3B, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xDC, 0x0E, 0xE0, 0x76, 0x03,
  0xB8, 0x19, 0xC1, 0xCE, 0x1E, 0x3F, 0xE1, 0xFE, 0x07, 0xE0, 0x01, 0x83,
  0xCF, 0xDF, 0xEF, 0x74, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x0E, 0x0E, 0x1C, 0x0E, 0x1C,
  0x0E, 0x1C, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF,
  0xFC, 0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0x07, 0x1C, 0x1C, 0xE0, 0x73,
  0x81, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3B, 0x80, 0xEE, 0x07, 0x38, 0x1C,
  0xF0, 0xF1, 0xFF, 0x83, 0xFC, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x77, 0x00, 0xCE, 0x03, 0x9C,
  0x0E, 0x38, 0x38, 0xE0, 0x71, 0xC1, 0xC3, 0x87, 0x07, 0x0E, 0x0E, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x3B, 0xC0, 0x7F, 0xC0, 0xFF,
  0xC3, 0xC3, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x39,
  0x80, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x0E, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F,
  0x80, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0xF0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x77, 0xC7, 0xFE, 0x7F, 0xF7, 0x87, 0xF0, 0x7E, 0x07, 0xE0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0x70, 0xE7, 0xFC, 0x3F, 0x81,
  0xF0, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x1F, 0xE0, 0xFF, 0xC3, 0x87, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07,
  0x1C, 0x1C, 0x70, 0xE0, 0xFF, 0x81, 0xF8, 0x1F, 0xE0, 0xE1, 0xC7, 0x03,
  0x1C, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0x70, 0xF1, 0xFF,
  0x83, 0xFC, 0x07, 0xE0, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x0E, 0x70, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xE1, 0xEF,
  0xFE, 0x7F, 0xE3, 0xEE, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x0F, 0x0F,
  0xE0, 0xFC, 0x0F, 0x00, 0x18, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0xE3, 0x8E, 0x00, 0x03, 0x03, 0xC1, 0xE0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x81, 0x80, 0x00, 0x08, 0x01,
  0xC0, 0x3C, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x60, 0x01, 0x00, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE7, 0xFF, 0x3F, 0xF8, 0x20, 0x01, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F,
  0x80, 0x70, 0x02, 0x00, 0x00, 0x0F, 0x07, 0xF9, 0xFF, 0x38, 0x7E, 0x0F,
  0xC1, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x38,
  0x0E, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xC1, 0xC0, 0x1E,
  0x01, 0xC0, 0x30, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x06, 0x0F,
  0x83, 0x18, 0x3F, 0x86, 0x70, 0xE3, 0x0C, 0xC3, 0x86, 0x19, 0x86, 0x1C,
  0x37, 0x1C, 0x38, 0x6C, 0x30, 0x60, 0xD8, 0x60, 0xC1, 0xB1, 0xC3, 0x82,
  0xE3, 0x87, 0x0D, 0xC7, 0x0C, 0x1B, 0x0C, 0x18, 0x36, 0x18, 0x70, 0xCC,
  0x38, 0xE1, 0x98, 0x73, 0xC6, 0x30, 0x7D, 0xF8, 0x60, 0xF1, 0xE0, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x83, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0E, 0x60, 0x03, 0x98, 0x01, 0xC6, 0x00, 0x71, 0xC0, 0x18, 0x70, 0x0E,
  0x1C, 0x03, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x30, 0x3F, 0xFC, 0x0F, 0xFF,
  0x87, 0xFF, 0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x3B, 0x80, 0x06, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x1C, 0x0F,
  0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x0E, 0x38, 0x1E,
  0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x3C, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x0F,
  0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0x70, 0x38, 0x7F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0x81,
  0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x0C, 0x38, 0x07, 0x38, 0x03, 0x9C,
  0x01, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x1C,
  0xE0, 0x0E, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x0E, 0x07, 0x8E, 0x07,
  0x87, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03,
  0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0x71, 0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x0F, 0xF7, 0x07,
  0xF3, 0x83, 0xF9, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x9E,
  0x03, 0x87, 0x03, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0x80, 0x0E, 0x00,
  0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03,
  0x87, 0x00, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x70, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x03, 0x87, 0x00, 0x70, 0x0E, 0x1C, 0x38, 0xF1, 0xC3,
  0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x1C, 0x38, 0x70, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xF0, 0x70, 0x70, 0xF0, 0x7F, 0xE0,
  0x3F, 0xC0, 0x1F, 0x80, 0x0E, 0x01, 0xC1, 0xC0, 0x78, 0x38, 0x1E, 0x0E,
  0x07, 0x81, 0xC1, 0xE0, 0x38, 0x78, 0x07, 0x1E, 0x00, 0xE7, 0x80, 0x38,
  0xE0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0x38, 0x03, 0xC7, 0x00, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC1,
  0xE0, 0x38, 0x1C, 0x0E, 0x03, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1B, 0x80,
  0xEE, 0x1B, 0x80, 0xEC, 0x3B, 0x81, 0xDC, 0x39, 0x81, 0xDC, 0x39, 0x83,
  0x9C, 0x39, 0x83, 0x9C, 0x39, 0xC7, 0x1C, 0x71, 0xC7, 0x38, 0x71, 0xCE,
  0x38, 0x71, 0xCE, 0x38, 0x70, 0xDC, 0x38, 0x70, 0xDC, 0x38, 0x70, 0xF8,
  0x70, 0xE0, 0xF8, 0x70, 0xE0, 0xF0, 0x70, 0xE0, 0xF0, 0x70, 0xE0, 0x60,
  0x70, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x3C, 0x03, 0x8F, 0x80, 0x71, 0xF0,
  0x0E, 0x3F, 0x03, 0x87, 0xE0, 0x70, 0xEC, 0x0E, 0x3D, 0xC1, 0xC7, 0x38,
  0x38, 0xE3, 0x07, 0x1C, 0x71, 0xC3, 0x8E, 0x38, 0x70, 0xC7, 0x1C, 0x1C,
  0xE3, 0x83, 0x9C, 0x70, 0x37, 0x0E, 0x07, 0xE1, 0xC0, 0xFC, 0x38, 0x0F,
  0x8E, 0x01, 0xF1, 0xC0, 0x3E, 0x38, 0x03, 0x87, 0x00, 0x70, 0x01, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xC1, 0xE1, 0xC0, 0x71, 0xC0, 0x38, 0xE0,
  0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xDC, 0x00, 0xEE,
  0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x0E, 0x70, 0x07,
  0x38, 0x07, 0x9C, 0x03, 0x87, 0x03, 0x83, 0xFF, 0xC0, 0xFF, 0x80, 0x1F,
  0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0x80, 0xF1, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x01,
  0xC7, 0x01, 0xE3, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xC0, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xC1,
  0xE3, 0xC0, 0x71, 0xC0, 0x39, 0xC0, 0x0C, 0xE0, 0x06, 0x70, 0x03, 0x38,
  0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D,
  0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x87, 0x03,
  0x83, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x02, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x1C, 0x07,
  0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x0F,
  0x38, 0x1E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x0E,
  0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xF0, 0x78, 0x7F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70,
  0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03,
  0x8E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0,
  0x70, 0x78, 0x3C, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0xE0, 0x03,
  0xF0, 0x03, 0xB8, 0x01, 0xDE, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0xF1, 0xC0,
  0x70, 0xE0, 0x38, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x06, 0x0E, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1D, 0xC0,
  0x06, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0xE0, 0x18, 0x0E, 0xE0, 0x38, 0x0E, 0xE0, 0x38, 0x0E, 0x60, 0x78,
  0x1C, 0x60, 0x78, 0x1C, 0x60, 0x7C, 0x1C, 0x60, 0xFC, 0x38, 0x60, 0xDC,
  0x38, 0x61, 0xDC, 0x38, 0x61, 0xDC, 0x70, 0x71, 0x8C, 0x70, 0x73, 0x8C,
  0x70, 0x73, 0x0C, 0xE0, 0x73, 0x0C, 0xE0, 0x77, 0x0C, 0xC0, 0x76, 0x0D,
  0xC0, 0x7E, 0x0D, 0xC0, 0x7E, 0x0D, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x0E,
  0x00, 0x07, 0x00, 0xF0, 0x70, 0x0E, 0x07, 0x81, 0xE0, 0x38, 0x3C, 0x03,
  0x83, 0x80, 0x3C, 0x78, 0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0x9C, 0x00, 0x71, 0xC0, 0x0F, 0x1E,
  0x01, 0xE0, 0xE0, 0x1C, 0x0E, 0x03, 0xC0, 0xF0, 0x78, 0x07, 0x07, 0x00,
  0x70, 0xE0, 0x07, 0xF0, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0x70,
  0x38, 0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x19, 0xC0, 0x1D, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0x07, 0xC1, 0xF0, 0x7C, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0F, 0xC3, 0xE0, 0xF8,
  0x00, 0xE0, 0xC1, 0x83, 0x07, 0x0E, 0x1C, 0x38, 0x30, 0x60, 0xC1, 0xC3,
  0x87, 0x0E, 0x0C, 0x18, 0x30, 0x70, 0xE1, 0xC3, 0x83, 0x06, 0x0C, 0x1C,
  0x07, 0xE0, 0xF8, 0x1F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x38, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0x80,
  0xE0, 0x78, 0x1E, 0x0F, 0x83, 0x61, 0xDC, 0x67, 0x39, 0xCC, 0x37, 0x0D,
  0x83, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x71, 0xE3, 0x87, 0x0C, 0x03, 0xE0,
  0x7F, 0x87, 0xFE, 0x70, 0x73, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0xFF, 0x3F,
  0xF3, 0xE3, 0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0x9F, 0xFC,
  0x7F, 0xE1, 0xE7, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF0, 0xF0, 0xF1, 0xC0, 0xE3, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E,
  0x70, 0x1C, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9E, 0x0E, 0x3F,
  0xFC, 0x6F, 0xF1, 0xC7, 0x80, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x70, 0x77,
  0x03, 0xB8, 0x0D, 0xC0, 0x6C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x07, 0x70, 0x39, 0xC3, 0x8F, 0xFC, 0x3F, 0xC0, 0xF8, 0x00, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x07, 0x9C, 0x1F, 0xFC, 0x3F, 0xFC, 0x38, 0x3C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x38, 0x60, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x70, 0x70, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x1E, 0x60, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x70, 0x73, 0x03, 0xB8,
  0x1D, 0xC0, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0xC1, 0x8F, 0xBE, 0x3F, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xFC,
  0x3F, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xFF, 0x9F, 0xE0, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xE6, 0x0F,
  0xF6, 0x1F, 0xFE, 0x1C, 0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x30,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x18, 0x70,
  0x38, 0x38, 0x78, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x40, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0x00, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0x87, 0x1C, 0x1C, 0x60, 0x73,
  0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0x9C, 0x0E, 0x70, 0x39,
  0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x73, 0x81, 0xC0, 0x00, 0x1C, 0x78,
  0x60, 0x00, 0x00, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x3E, 0x0F, 0x83, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x1E, 0x38, 0x78, 0x71, 0xE0, 0xE3, 0x81, 0xCE, 0x03,
  0x38, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xF7, 0x01, 0xCE,
  0x07, 0x1C, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x71, 0xC0, 0xF0,
  0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x87,
  0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x1C,
  0xF0, 0xF8, 0x3F, 0xF3, 0xF8, 0x7F, 0xFF, 0xF8, 0xE0, 0xF8, 0x71, 0xC1,
  0xE0, 0xE3, 0x03, 0x81, 0xCE, 0x07, 0x03, 0x9C, 0x0E, 0x07, 0x38, 0x1C,
  0x0E, 0x70, 0x38, 0x18, 0xE0, 0xE0, 0x71, 0x81, 0xC0, 0xE7, 0x03, 0x81,
  0xCE, 0x07, 0x03, 0x9C, 0x0E, 0x07, 0x38, 0x1C, 0x1C, 0x70, 0x70, 0x38,
  0xC0, 0xE0, 0x70, 0x1C, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0x87, 0x1C, 0x1C,
  0x60, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0x8C, 0x0E,
  0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x73, 0x81, 0xC0, 0x07,
  0xE0, 0x3F, 0xC1, 0xFF, 0x8E, 0x0E, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xD8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x06, 0xE0, 0x3B, 0x80, 0xE7,
  0x07, 0x1F, 0x78, 0x3F, 0xC0, 0x7E, 0x00, 0x0E, 0x78, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0x0E, 0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x18, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x3C,
  0x1C, 0x3F, 0xFC, 0x3F, 0xF8, 0x73, 0xE0, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xCC, 0x3F,
  0xF8, 0xFF, 0xF1, 0xC1, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x0E, 0x30, 0x1C,
  0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x1C, 0x0E, 0x3C,
  0x1C, 0x3F, 0xF8, 0x3F, 0xF0, 0x3E, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x1D, 0xE3, 0xFC, 0x7F,
  0x0F, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x00, 0x07, 0xC0, 0xFF,
  0x07, 0xFC, 0x70, 0xF3, 0x83, 0x98, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x78, 0x01, 0xCE, 0x07, 0x70, 0x33, 0x83, 0x8F, 0xFC, 0x7F,
  0xC0, 0xF8, 0x00, 0x0E, 0x07, 0x03, 0x81, 0x87, 0xFF, 0xFC, 0x70, 0x38,
  0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0F, 0x83, 0xC1, 0xE0, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38,
  0x18, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x18,
  0x1C, 0xE0, 0x73, 0x81, 0xC7, 0x0F, 0x1F, 0xFC, 0x7F, 0xE0, 0x7B, 0x80,
  0xE0, 0x77, 0x03, 0xB8, 0x1C, 0xC1, 0xC6, 0x0E, 0x30, 0xE1, 0x87, 0x0E,
  0x30, 0x73, 0x83, 0x98, 0x1D, 0xC0, 0x6E, 0x03, 0x60, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x60, 0x7E, 0x0E, 0x06, 0xE0,
  0xE0, 0xEE, 0x1E, 0x0E, 0x61, 0xF1, 0xC6, 0x3F, 0x1C, 0x63, 0xF1, 0x86,
  0x37, 0x38, 0x67, 0x73, 0x86, 0x63, 0x30, 0x6E, 0x37, 0x06, 0xC3, 0x60,
  0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x70, 0x38,
  0x07, 0x03, 0x80, 0x1E, 0x0E, 0x0E, 0x1E, 0x0E, 0x1C, 0x06, 0x38, 0x07,
  0x38, 0x07, 0x70, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0x70, 0x38, 0x70, 0x78,
  0x70, 0x70, 0x38, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C,
  0x1C, 0x0C, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF,
  0xC0, 0x00, 0x40, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x03, 0xC0, 0xF0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x0C,
  0x30, 0xC7, 0x1C, 0x71, 0x86, 0x18, 0x63, 0x8E, 0x30, 0xC3, 0x0C, 0x71,
  0xC7, 0x18, 0x61, 0x8E, 0x38, 0xE3, 0x0C, 0x30, 0x06, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x60, 0x0F, 0x00, 0xE0, 0x3C, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x1E, 0x03, 0x80, 0x40, 0x00, 0x1E, 0x07, 0x7F, 0x07, 0x7F, 0x86,
  0xE3, 0x8E, 0xC1, 0xFC, 0xC0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Italic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 24, 8, 1, -24 },
  { 22, 8, 8, 11, 3, -26 },
  { 30, 17, 24, 18, 2, -24 },
  { 81, 15, 31, 16, 1, -28 },
  { 140, 16, 24, 21, 3, -24 },
  { 188, 16, 24, 18, 1, -24 },
  { 236, 4, 8, 6, 3, -26 },
  { 240, 10, 35, 10, 2, -27 },
  { 284, 11, 35, 11, -2, -27 },
  { 333, 13, 14, 14, 2, -24 },
  { 356, 14, 18, 16, 1, -20 },
  { 388, 6, 8, 6, -2, -4 },
  { 394, 7, 3, 8, 1, -12 },
  { 397, 4, 4, 9, 1, -4 },
  { 399, 16, 26, 12, -2, -24 },
  { 451, 13, 24, 16, 2, -24 },
  { 490, 9, 24, 16, 4, -24 },
  { 517, 16, 24, 16, 0, -24 },
  { 565, 14, 24, 16, 1, -24 },
  { 607, 15, 24, 16, 0, -24 },
  { 652, 15, 24, 16, 2, -24 },
  { 697, 12, 24, 16, 2, -24 },
  { 733, 15, 24, 16, 2, -24 },
  { 778, 14, 24, 16, 1, -24 },
  { 820, 12, 24, 16, 3, -24 },
  { 856, 6, 19, 8, 1, -19 },
  { 871, 9, 23, 7, -2, -19 },
  { 897, 13, 15, 15, 1, -18 },
  { 922, 13, 11, 16, 2, -17 },
  { 940, 13, 15, 15, 1, -18 },
  { 965, 11, 24, 14, 3, -24 },
  { 998, 23, 32, 25, 1, -24 },
  { 1090, 18, 24, 19, -1, -24 },
  { 1144, 16, 24, 18, 1, -24 },
  { 1192, 16, 24, 19, 2, -24 },
  { 1240, 17, 24, 19, 1, -24 },
  { 1291, 16, 24, 16, 1, -24 },
  { 1339, 16, 24, 16, 1, -24 },
  { 1387, 17, 24, 19, 2, -24 },
  { 1438, 19, 24, 20, 1, -24 },
  { 1495, 7, 24, 8, 1, -24 },
  { 1516, 16, 24, 16, 0, -24 },
  { 1564, 19, 24, 18, 1, -24 },
  { 1621, 12, 24, 16, 1, -24 },
  { 1657, 24, 24, 25, 1, -24 },
  { 1729, 19, 24, 20, 1, -24 },
  { 1786, 17, 24, 20, 2, -24 },
  { 1837, 17, 24, 18, 1, -24 },
  { 1888, 17, 28, 20, 2, -24 },
  { 1948, 16, 24, 18, 1, -24 },
  { 1996, 16, 24, 17, 1, -24 },
  { 2044, 16, 24, 17, 3, -24 },
  { 2092, 18, 24, 19, 1, -24 },
  { 2146, 17, 24, 19, 3, -24 },
  { 2197, 24, 24, 25, 3, -24 },
  { 2269, 20, 24, 18, -1, -24 },
  { 2329, 16, 24, 17, 3, -24 },
  { 2377, 18, 24, 17, 0, -24 },
  { 2431, 10, 33, 8, 0, -28 },
  { 2473, 7, 26, 12, 3, -24 },
  { 2496, 11, 33, 8, -2, -28 },
  { 2542, 10, 12, 12, 1, -24 },
  { 2557, 13, 3, 13, -2, 0 },
  { 2562, 6, 5, 10, 3, -26 },
  { 2566, 13, 18, 16, 1, -18 },
  { 2596, 15, 26, 16, 0, -26 },
  { 2645, 13, 18, 15, 1, -18 },
  { 2675, 16, 26, 16, 1, -26 },
  { 2727, 13, 18, 15, 1, -18 },
  { 2757, 11, 26, 10, 2, -26 },
  { 2793, 16, 25, 16, 0, -18 },
  { 2843, 14, 26, 16, 0, -26 },
  { 2889, 7, 25, 8, 1, -25 },
  { 2911, 10, 32, 7, -3, -25 },
  { 2951, 15, 26, 15, 0, -26 },
  { 3000, 7, 26, 8, 1, -26 },
  { 3023, 23, 18, 25, 0, -18 },
  { 3075, 14, 18, 16, 0, -18 },
  { 3107, 14, 18, 17, 1, -18 },
  { 3139, 16, 25, 16, -1, -18 },
  { 3189, 15, 25, 17, 1, -18 },
  { 3236, 11, 18, 10, 0, -18 },
  { 3261, 13, 18, 15, 1, -18 },
  { 3291, 9, 22, 10, 1, -22 },
  { 3316, 14, 18, 16, 1, -18 },
  { 3348, 13, 18, 14, 2, -18 },
  { 3378, 20, 18, 21, 2, -18 },
  { 3423, 16, 18, 14, -1, -18 },
  { 3459, 16, 25, 14, -1, -18 },
  { 3509, 14, 18, 14, 0, -18 },
  { 3541, 11, 33, 10, 1, -27 },
  { 3587, 6, 28, 8, 1, -24 },
  { 3608, 11, 33, 10, -2, -27 },
  { 3654, 16, 7, 19, 2, -14 },
};

const GFXfont RobotoCondensed_Italic34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_ITALIC34PT7B_H_
