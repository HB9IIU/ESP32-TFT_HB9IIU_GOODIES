#ifndef _ROBOTOCONDENSED_ITALIC23PT7B_H_
#define _ROBOTOCONDENSED_ITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x33, 0x66, 0x66, 0x66, 0x40, 0x0C, 0xC0, 0x6D, 0x24,
  0x92, 0xDB, 0x60, 0x02, 0x20, 0x26, 0x06, 0x60, 0x44, 0x3F, 0xF3, 0xFE,
  0x0C, 0x80, 0x98, 0x19, 0x81, 0x90, 0x13, 0x0F, 0xFC, 0xFF, 0xC2, 0x60,
  0x66, 0x06, 0x40, 0x4C, 0x00, 0x02, 0x00, 0x80, 0xF0, 0x7E, 0x31, 0x8C,
  0x63, 0x08, 0xC0, 0x30, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x00, 0xCC, 0x13,
  0x0C, 0xC3, 0x1F, 0x83, 0xC0, 0x40, 0x30, 0x00, 0x38, 0x0D, 0x03, 0x31,
  0x66, 0x6C, 0xD9, 0x9A, 0x36, 0xC3, 0xB0, 0x04, 0x01, 0xB8, 0x69, 0x0B,
  0x32, 0x66, 0xC8, 0xD1, 0x10, 0x36, 0x03, 0x80, 0x0F, 0x07, 0xC3, 0x18,
  0xC6, 0x31, 0x8C, 0xC3, 0xE0, 0x70, 0x3C, 0x1F, 0x3E, 0xEF, 0x1B, 0xC7,
  0xB0, 0xEC, 0x39, 0xFE, 0x3D, 0xC0, 0x5F, 0x80, 0x02, 0x0C, 0x30, 0xC1,
  0x86, 0x0C, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81,
  0x02, 0x06, 0x06, 0x04, 0x00, 0x10, 0x30, 0x30, 0x60, 0x40, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x18,
  0x20, 0x00, 0x04, 0x06, 0x03, 0x0D, 0xBF, 0xF8, 0xE0, 0xF0, 0x6C, 0x66,
  0x21, 0x00, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xFF, 0xFE, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x36, 0x66, 0xC8, 0x7F, 0xC0, 0x3C, 0x00, 0xC0,
  0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x00, 0x0F, 0x0F, 0xCC,
  0x64, 0x36, 0x0B, 0x0D, 0x86, 0xC3, 0x41, 0xE0, 0xF0, 0x78, 0x2C, 0x36,
  0x1B, 0x18, 0xFC, 0x3C, 0x00, 0x0C, 0xEF, 0xB6, 0x18, 0x61, 0x84, 0x30,
  0xC3, 0x0C, 0x31, 0x86, 0x18, 0x60, 0x07, 0x83, 0xF8, 0x63, 0x18, 0x63,
  0x0C, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x1C, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0x1F, 0xCC, 0x6C, 0x36, 0x18,
  0x0C, 0x0E, 0x3E, 0x1E, 0x01, 0x80, 0xC0, 0x6C, 0x36, 0x1B, 0x18, 0xFC,
  0x3C, 0x00, 0x00, 0xC0, 0x70, 0x3C, 0x0F, 0x06, 0xC3, 0x60, 0xD8, 0x66,
  0x31, 0x8C, 0x66, 0x1B, 0xFF, 0xFF, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x1F, 0xC7, 0xF1, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0xE1, 0xFC, 0x23, 0x80,
  0x60, 0x18, 0x06, 0xC1, 0xB0, 0xC6, 0x31, 0xF8, 0x3C, 0x00, 0x07, 0x07,
  0x86, 0x06, 0x03, 0x03, 0x01, 0xB8, 0xFE, 0x63, 0x70, 0xF0, 0x78, 0x3C,
  0x1E, 0x19, 0x8C, 0xFC, 0x3C, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x00, 0x0F, 0x0F, 0xCC, 0x66, 0x32, 0x19,
  0x0C, 0xC6, 0x7E, 0x3E, 0x31, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0x1C, 0xFC,
  0x3C, 0x00, 0x1C, 0x7E, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFF,
  0x7A, 0x06, 0x06, 0x0C, 0x1C, 0xF8, 0xE0, 0x27, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x31, 0x98,
  0xC0, 0x01, 0x07, 0x1E, 0x78, 0xE0, 0xE0, 0x70, 0x1C, 0x0E, 0x02, 0x7F,
  0xBF, 0xC0, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x40, 0x38, 0x0F, 0x01, 0xC0,
  0x38, 0x38, 0x78, 0xF0, 0xE0, 0x40, 0x00, 0x3C, 0x7E, 0xE6, 0xC6, 0x06,
  0x06, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x40,
  0x01, 0xF0, 0x0F, 0x70, 0x30, 0x30, 0xC0, 0x33, 0x00, 0x24, 0x38, 0x58,
  0xD8, 0xA3, 0x11, 0x44, 0x63, 0x98, 0xC7, 0x31, 0x0C, 0x62, 0x38, 0x8C,
  0x51, 0x19, 0xA3, 0xF6, 0x47, 0x38, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xCC, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x14, 0x03, 0x60,
  0x36, 0x06, 0x60, 0x66, 0x0C, 0x60, 0xC6, 0x18, 0x61, 0xFE, 0x3F, 0xF3,
  0x03, 0x70, 0x36, 0x03, 0xE0, 0x30, 0x3F, 0x87, 0xF8, 0xC3, 0x18, 0x73,
  0x0E, 0xC1, 0x98, 0x33, 0xFC, 0x7F, 0x0C, 0x31, 0x86, 0x60, 0x6C, 0x19,
  0x83, 0x30, 0xE7, 0xF8, 0xFE, 0x00, 0x07, 0x81, 0xFE, 0x18, 0x63, 0x06,
  0x70, 0x66, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0xC4, 0x0C, 0x61, 0x87, 0xF8, 0x1E, 0x00, 0x3F, 0x07, 0xF8, 0xC3,
  0x18, 0x33, 0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x6C, 0x19, 0x83, 0x60,
  0x6C, 0x0D, 0x83, 0x30, 0xE7, 0xF8, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0xFC, 0x7F, 0x8C, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0xF8, 0x7F, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x07, 0x81, 0xFE, 0x38,
  0x63, 0x06, 0x60, 0x76, 0x00, 0x60, 0x06, 0x00, 0x63, 0xEC, 0x3E, 0xC0,
  0x6C, 0x0C, 0xC0, 0xC6, 0x0C, 0x61, 0xC7, 0xF8, 0x1F, 0x00, 0x30, 0x19,
  0x80, 0xCC, 0x0C, 0x60, 0x63, 0x03, 0x30, 0x19, 0x80, 0xCF, 0xFE, 0x7F,
  0xE3, 0x03, 0x18, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x03, 0x18, 0x18,
  0xC0, 0xC0, 0x33, 0x33, 0x33, 0x66, 0x66, 0x66, 0xCC, 0xCC, 0xC0, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xCC, 0x19, 0x86, 0x18, 0xC3, 0xF0, 0x3C, 0x00, 0x30,
  0x73, 0x06, 0x30, 0xC3, 0x18, 0x33, 0x86, 0x70, 0x6E, 0x06, 0xC0, 0x7C,
  0x07, 0x60, 0x66, 0x0C, 0x70, 0xC3, 0x0C, 0x30, 0xC1, 0x8C, 0x18, 0xC1,
  0xC0, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0E,
  0x38, 0x0E, 0x2C, 0x1E, 0x6C, 0x1E, 0x6C, 0x36, 0x6C, 0x36, 0x6C, 0x6C,
  0x6C, 0x6C, 0x64, 0xCC, 0xC4, 0xCC, 0xC7, 0x8C, 0xC7, 0x8C, 0xC7, 0x18,
  0xC7, 0x18, 0xC6, 0x18, 0x30, 0x19, 0xC0, 0xCE, 0x0C, 0x70, 0x63, 0xC3,
  0x36, 0x19, 0x90, 0xCC, 0xC6, 0x66, 0x63, 0x13, 0x18, 0xD9, 0x86, 0xCC,
  0x16, 0x60, 0xF3, 0x07, 0x18, 0x38, 0xC0, 0xC0, 0x07, 0x81, 0xFC, 0x38,
  0x63, 0x06, 0x60, 0x36, 0x03, 0x60, 0x36, 0x06, 0x60, 0x6C, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0xC6, 0x0C, 0x61, 0x87, 0xF8, 0x1E, 0x00, 0x3F, 0x87,
  0xF8, 0xC1, 0x98, 0x33, 0x06, 0xC0, 0xD8, 0x1B, 0x07, 0x7F, 0xCF, 0xE1,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x07, 0x81,
  0xFC, 0x38, 0x63, 0x06, 0x60, 0x66, 0x03, 0x60, 0x66, 0x06, 0x60, 0x6C,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0x61, 0x87, 0xF8, 0x1F, 0x00,
  0x38, 0x01, 0xC0, 0x08, 0x3F, 0x87, 0xF8, 0xC3, 0x18, 0x33, 0x06, 0xC0,
  0xD8, 0x33, 0x0E, 0x7F, 0x8F, 0xE1, 0x8C, 0x61, 0x8C, 0x31, 0x86, 0x30,
  0x66, 0x0C, 0xC1, 0x80, 0x07, 0x80, 0xFE, 0x18, 0x63, 0x86, 0x30, 0x33,
  0x00, 0x18, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xC0, 0x0C, 0x60, 0xC6,
  0x0C, 0x61, 0xC3, 0xF8, 0x1E, 0x00, 0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x30, 0x33, 0x03, 0x30, 0x67, 0x06,
  0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0xC6, 0x0C, 0xC0, 0xCC, 0x0C,
  0xC0, 0xCC, 0x18, 0xE1, 0x87, 0xF0, 0x3E, 0x00, 0xC0, 0x6C, 0x06, 0xC0,
  0xEE, 0x0C, 0x61, 0xC6, 0x18, 0x61, 0x86, 0x30, 0x63, 0x06, 0x60, 0x66,
  0x02, 0x60, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x00, 0xC1, 0x83,
  0xC1, 0x86, 0xC3, 0x86, 0xC3, 0x86, 0xC2, 0x8C, 0xC6, 0x8C, 0x46, 0x8C,
  0x44, 0x88, 0x4C, 0x98, 0x48, 0xD8, 0x58, 0xD0, 0x58, 0xF0, 0x50, 0xF0,
  0x70, 0xE0, 0x70, 0xE0, 0x60, 0xE0, 0x60, 0xC0, 0x18, 0x38, 0xC1, 0x86,
  0x18, 0x19, 0xC0, 0xCC, 0x06, 0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x33, 0x01, 0x98, 0x18, 0xC1, 0xC7, 0x0C, 0x18, 0xC0, 0xC0,
  0xC0, 0xFC, 0x19, 0x87, 0x30, 0xC6, 0x30, 0xC6, 0x0D, 0x81, 0xB0, 0x3C,
  0x07, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00,
  0x1F, 0xF3, 0xFF, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0F, 0xFC,
  0xFF, 0xC0, 0x1E, 0x3C, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x1E, 0x3C, 0x00, 0xC6,
  0x10, 0x86, 0x31, 0x8C, 0x61, 0x08, 0x63, 0x18, 0xC6, 0x10, 0x80, 0x1E,
  0x3C, 0x10, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x30, 0x60, 0xC1, 0x83, 0x1E, 0x38, 0x00, 0x0C, 0x38, 0x71, 0xE3,
  0x4C, 0x99, 0x63, 0xFF, 0xFF, 0x80, 0x66, 0x30, 0x1E, 0x1F, 0x98, 0xCC,
  0x20, 0x31, 0xF9, 0xCD, 0x86, 0xC3, 0x63, 0x3F, 0x8E, 0xC0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x78, 0xFF, 0x30, 0xCC, 0x32, 0x0D,
  0x83, 0x60, 0xD8, 0x36, 0x19, 0x86, 0x5F, 0x33, 0x80, 0x1E, 0x1F, 0x98,
  0x78, 0x3C, 0x06, 0x03, 0x01, 0x80, 0xC3, 0x63, 0xBF, 0x87, 0x80, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x21, 0xD9, 0xFE, 0x61, 0xB0, 0x6C,
  0x1B, 0x04, 0xC3, 0x30, 0xCC, 0x33, 0x0C, 0xFF, 0x1E, 0x80, 0x1E, 0x1F,
  0x98, 0xC8, 0x3C, 0x1F, 0xFF, 0xFD, 0x80, 0xC0, 0x61, 0x1F, 0x87, 0x80,
  0x0F, 0x1E, 0x18, 0x18, 0x30, 0x30, 0x7C, 0xFC, 0x30, 0x20, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x0E, 0x47, 0xF8, 0xC3, 0x30, 0x66,
  0x0C, 0xC1, 0x98, 0x63, 0x0C, 0x61, 0x8C, 0x31, 0xFE, 0x1E, 0xC0, 0x30,
  0x06, 0x00, 0xC7, 0xF0, 0x7C, 0x00, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0x03, 0x78, 0xFE, 0x31, 0xCC, 0x32, 0x09, 0x86, 0x61, 0x98, 0x66,
  0x19, 0x86, 0x41, 0x30, 0xC0, 0x18, 0xC0, 0x03, 0x18, 0xC6, 0x31, 0x98,
  0xC6, 0x31, 0x88, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x83, 0x06, 0x0C, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC7, 0x0E, 0x00, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x1C, 0xC6, 0x33, 0x0D, 0x82, 0xC1,
  0xF0, 0x7C, 0x19, 0x86, 0x61, 0x9C, 0x43, 0x30, 0xC0, 0x18, 0xC6, 0x31,
  0x88, 0xC6, 0x31, 0x8C, 0x46, 0x31, 0x8C, 0x62, 0x00, 0x37, 0x1C, 0x3F,
  0xBE, 0x31, 0xC6, 0x30, 0xC3, 0x30, 0xC2, 0x61, 0x86, 0x61, 0x86, 0x61,
  0x86, 0x61, 0x86, 0x61, 0x86, 0x41, 0x0C, 0xC3, 0x0C, 0x37, 0x8F, 0xE3,
  0x1C, 0xC3, 0x30, 0x98, 0x66, 0x19, 0x86, 0x61, 0x98, 0x64, 0x13, 0x0C,
  0x1E, 0x1F, 0x98, 0x6C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0x61, 0x9F,
  0x87, 0x80, 0x1B, 0xC3, 0xF8, 0x61, 0x8C, 0x31, 0x86, 0x60, 0xCC, 0x19,
  0x83, 0x30, 0xC6, 0x18, 0xFE, 0x37, 0x86, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x00, 0x1C, 0xBF, 0xD8, 0x78, 0x3C, 0x1E, 0x0F, 0x0D, 0x86, 0xC3,
  0x61, 0xBF, 0xCF, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x36, 0x7C,
  0xE1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x00, 0x0F, 0x0F, 0xCC,
  0x66, 0x33, 0x00, 0xE0, 0x3C, 0x06, 0x41, 0x31, 0x9F, 0xC7, 0xC0, 0x30,
  0xC3, 0x3F, 0xF8, 0x86, 0x18, 0x61, 0x86, 0x10, 0xC1, 0xC7, 0x00, 0x61,
  0xB0, 0xD8, 0x6C, 0x36, 0x16, 0x1B, 0x0D, 0x86, 0xC3, 0x63, 0xBF, 0x8F,
  0xC0, 0xC1, 0xA1, 0x98, 0xCC, 0xC6, 0x63, 0x21, 0xB0, 0xD8, 0x38, 0x1C,
  0x0C, 0x06, 0x00, 0x43, 0x0D, 0x0C, 0x64, 0x71, 0x99, 0xC4, 0x6D, 0x31,
  0xB4, 0xC6, 0x96, 0x1E, 0x78, 0x71, 0xC1, 0xC7, 0x06, 0x1C, 0x18, 0x60,
  0x18, 0xE3, 0x18, 0x26, 0x07, 0xC0, 0xF0, 0x0C, 0x03, 0x80, 0x70, 0x1B,
  0x06, 0x60, 0xC6, 0x30, 0xC0, 0x30, 0x63, 0x18, 0x63, 0x0C, 0xC1, 0x98,
  0x36, 0x06, 0xC0, 0xD0, 0x1E, 0x03, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x0C, 0x07, 0x80, 0xE0, 0x00, 0x3F, 0xCF, 0xE0, 0x38, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xE0, 0x30, 0x18, 0x0F, 0xF3, 0xFC, 0x02, 0x1C, 0x60, 0xC1,
  0x82, 0x0C, 0x18, 0x30, 0x63, 0x86, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x03, 0x06, 0x00, 0x18, 0xC6, 0x31, 0x08, 0xC6, 0x31, 0x88, 0x42,
  0x31, 0x8C, 0x62, 0x11, 0x80, 0x10, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x18, 0x71, 0xC3, 0x06, 0x08, 0x30, 0x60, 0xC3, 0x0E, 0x10,
  0x00, 0x38, 0x6F, 0x8D, 0x19, 0x63, 0xEC, 0x38,
};

const GFXglyph RobotoCondensed_Italic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 5, 1, -17 },
  { 10, 6, 6, 7, 2, -17 },
  { 15, 12, 17, 12, 1, -17 },
  { 41, 10, 21, 11, 1, -19 },
  { 68, 11, 17, 14, 2, -17 },
  { 92, 10, 17, 12, 1, -17 },
  { 114, 2, 5, 4, 2, -17 },
  { 116, 7, 23, 7, 1, -18 },
  { 137, 7, 23, 7, -1, -18 },
  { 158, 9, 10, 10, 1, -17 },
  { 170, 9, 12, 11, 1, -14 },
  { 184, 4, 6, 4, -1, -2 },
  { 187, 5, 2, 6, 0, -8 },
  { 189, 2, 3, 6, 1, -3 },
  { 190, 10, 18, 8, -1, -17 },
  { 213, 9, 17, 11, 1, -17 },
  { 233, 6, 17, 11, 3, -17 },
  { 246, 11, 17, 11, 0, -17 },
  { 270, 9, 17, 11, 1, -17 },
  { 290, 10, 17, 11, 0, -17 },
  { 312, 10, 17, 11, 1, -17 },
  { 334, 9, 17, 11, 1, -17 },
  { 354, 11, 17, 11, 1, -17 },
  { 378, 9, 17, 11, 1, -17 },
  { 398, 8, 17, 11, 2, -17 },
  { 415, 4, 13, 5, 1, -13 },
  { 422, 5, 17, 5, -1, -13 },
  { 433, 8, 10, 10, 1, -12 },
  { 443, 9, 7, 11, 1, -11 },
  { 451, 9, 10, 10, 1, -12 },
  { 463, 8, 17, 9, 2, -17 },
  { 480, 15, 21, 17, 1, -16 },
  { 520, 12, 17, 13, -1, -17 },
  { 546, 11, 17, 12, 1, -17 },
  { 570, 12, 17, 13, 1, -17 },
  { 596, 11, 17, 13, 1, -17 },
  { 620, 11, 17, 11, 1, -17 },
  { 644, 11, 17, 11, 1, -17 },
  { 668, 12, 17, 13, 1, -17 },
  { 694, 13, 17, 14, 1, -17 },
  { 722, 4, 17, 6, 1, -17 },
  { 731, 11, 17, 11, 0, -17 },
  { 755, 12, 17, 12, 1, -17 },
  { 781, 8, 17, 11, 1, -17 },
  { 798, 16, 17, 17, 1, -17 },
  { 832, 13, 17, 14, 1, -17 },
  { 860, 12, 17, 13, 1, -17 },
  { 886, 11, 17, 12, 1, -17 },
  { 910, 12, 20, 13, 1, -17 },
  { 940, 11, 17, 12, 1, -17 },
  { 964, 12, 17, 12, 0, -17 },
  { 990, 11, 17, 12, 2, -17 },
  { 1014, 12, 17, 13, 1, -17 },
  { 1040, 12, 17, 13, 2, -17 },
  { 1066, 16, 17, 17, 2, -17 },
  { 1100, 13, 17, 12, 0, -17 },
  { 1128, 11, 17, 12, 2, -17 },
  { 1152, 12, 17, 12, 0, -17 },
  { 1178, 7, 23, 6, 0, -19 },
  { 1199, 5, 18, 8, 2, -17 },
  { 1211, 7, 23, 6, -1, -19 },
  { 1232, 7, 8, 8, 1, -17 },
  { 1239, 9, 2, 9, -1, 0 },
  { 1242, 4, 3, 7, 2, -17 },
  { 1244, 9, 12, 11, 1, -12 },
  { 1258, 10, 18, 11, 0, -18 },
  { 1281, 9, 12, 10, 1, -12 },
  { 1295, 10, 18, 11, 1, -18 },
  { 1318, 9, 12, 10, 1, -12 },
  { 1332, 8, 18, 7, 1, -18 },
  { 1350, 11, 17, 11, 0, -12 },
  { 1374, 10, 18, 11, 0, -18 },
  { 1397, 5, 16, 5, 0, -16 },
  { 1407, 7, 21, 5, -2, -16 },
  { 1426, 10, 18, 10, 0, -18 },
  { 1449, 5, 18, 5, 0, -18 },
  { 1461, 16, 12, 17, 0, -12 },
  { 1485, 10, 12, 11, 0, -12 },
  { 1500, 9, 12, 11, 1, -12 },
  { 1514, 11, 17, 11, -1, -12 },
  { 1538, 9, 17, 11, 1, -12 },
  { 1558, 7, 12, 7, 0, -12 },
  { 1569, 9, 12, 10, 0, -12 },
  { 1583, 6, 15, 7, 1, -15 },
  { 1595, 9, 12, 11, 1, -12 },
  { 1609, 9, 12, 10, 1, -12 },
  { 1623, 14, 12, 15, 1, -12 },
  { 1644, 11, 12, 10, -1, -12 },
  { 1661, 11, 17, 9, -1, -12 },
  { 1685, 10, 12, 10, 0, -12 },
  { 1700, 7, 22, 7, 1, -18 },
  { 1720, 5, 20, 5, 0, -17 },
  { 1733, 7, 22, 7, -1, -18 },
  { 1753, 11, 5, 13, 1, -10 },
};

const GFXfont RobotoCondensed_Italic23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_ITALIC23PT7B_H_
