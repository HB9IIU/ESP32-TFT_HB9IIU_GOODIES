#ifndef _ROBOTOCONDENSED_ITALIC55PT7B_H_
#define _ROBOTOCONDENSED_ITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x03,
  0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x79, 0xE3, 0xCF,
  0x1E, 0x78, 0xF3, 0x87, 0x1C, 0x39, 0xE3, 0xCF, 0x1E, 0x70, 0xF3, 0x87,
  0x1C, 0x38, 0xE1, 0xCE, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C,
  0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0x81, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0x83, 0xC0, 0x00,
  0x78, 0x3C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0x83, 0xE0, 0x7E, 0x07,
  0xC0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x1F, 0x00, 0x1E,
  0x3E, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xFC, 0x1F, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC1, 0xC0, 0x21,
  0xC0, 0xF0, 0x3D, 0xE0, 0x78, 0x1E, 0xF0, 0x3C, 0x1E, 0x78, 0x1E, 0x1E,
  0x3C, 0x0F, 0x0F, 0x1E, 0x07, 0x0F, 0x0F, 0x03, 0x8F, 0x07, 0x83, 0xC7,
  0x01, 0xC3, 0xC7, 0x80, 0xFF, 0xE7, 0x80, 0x3F, 0xE3, 0x80, 0x0F, 0xE3,
  0xC0, 0x00, 0x83, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x40, 0x00, 0xF1, 0xFC, 0x00, 0xF3, 0xFF, 0x00,
  0xF1, 0xFF, 0x80, 0x71, 0xE1, 0xE0, 0x78, 0xE0, 0xF0, 0x78, 0xF0, 0x38,
  0x38, 0x78, 0x1C, 0x3C, 0x38, 0x0E, 0x3C, 0x1C, 0x07, 0x1C, 0x0E, 0x03,
  0x9E, 0x07, 0x03, 0xDE, 0x03, 0x81, 0xE6, 0x01, 0xC0, 0xE1, 0x00, 0xF0,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0x81, 0xE0,
  0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1E,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x1F, 0x80, 0x0F, 0x9F,
  0x80, 0x07, 0xDF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7E,
  0xF8, 0x1E, 0x7E, 0x7C, 0x1F, 0x3E, 0x1F, 0x0F, 0x3E, 0x0F, 0x87, 0x9F,
  0x03, 0xE3, 0xDF, 0x01, 0xF3, 0xCF, 0x80, 0x7D, 0xE7, 0xC0, 0x3F, 0xF3,
  0xE0, 0x0F, 0xF1, 0xF0, 0x07, 0xF8, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xFC,
  0x3E, 0x00, 0x7E, 0x0F, 0x80, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFC, 0xF8, 0x0F, 0xF8, 0x7E, 0x00, 0xC0, 0x00, 0x00, 0x3D,
  0xE7, 0x9E, 0x79, 0xE7, 0x3C, 0xF3, 0xCF, 0x38, 0xE0, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x0E,
  0x0F, 0x07, 0x7E, 0x79, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xBE, 0x00, 0xF8, 0xF0, 0x0F, 0x87, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8,
  0x0C, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E,
  0x3E, 0x1F, 0x1F, 0x1F, 0x07, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x11, 0xF7, 0xFF, 0x7D, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0x03, 0xE0,
  0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xF1, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF0, 0x01, 0xF3, 0xC0, 0x07,
  0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x79, 0xF0, 0x01, 0xE7, 0xC0, 0x07, 0x9E,
  0x00, 0x3E, 0x78, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x3C, 0xF8, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x7C,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF0,
  0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xE0, 0x7F, 0xFF,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x78, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF, 0x9F,
  0xFF, 0x3E, 0x3C, 0x70, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78,
  0x00, 0xF8, 0x78, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xE7, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xF1,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x1F,
  0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x3F,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xEF,
  0xE0, 0x1F, 0x03, 0xF0, 0x06, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x01,
  0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x78, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE7, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE7, 0xF8, 0x7E, 0x7F, 0x03, 0xE7, 0xE0, 0x1F, 0x7C, 0x01, 0xF7,
  0xC0, 0x1F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xEF, 0x80, 0x3E, 0x78, 0x03, 0xC7, 0xC0, 0x7C, 0x7E, 0x0F, 0x83, 0xFF,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x0C, 0x00, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x1F,
  0x07, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0xF8, 0x0F, 0xC3, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x0F,
  0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x7E, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1,
  0xF8, 0x3E, 0x3E, 0x01, 0xE3, 0xE0, 0x1F, 0x3C, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0x7C, 0x07, 0xE7, 0xC0, 0xFE, 0x7E, 0x1F, 0xE3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFF, 0xBC, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0x83,
  0xEF, 0xC0, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x78, 0x03, 0xF0, 0x07, 0x07, 0x80, 0x3F, 0xE0,
  0x38, 0x3C, 0x07, 0xFF, 0x81, 0xC3, 0xC0, 0x3F, 0x7E, 0x07, 0x1E, 0x03,
  0xC0, 0xE0, 0x38, 0xE0, 0x3C, 0x0F, 0x01, 0xCF, 0x01, 0xE0, 0x78, 0x0E,
  0x78, 0x1E, 0x03, 0xC0, 0xF3, 0x80, 0xF0, 0x1C, 0x07, 0xBC, 0x0F, 0x01,
  0xE0, 0x39, 0xE0, 0x78, 0x0F, 0x01, 0xCE, 0x03, 0xC0, 0x78, 0x0E, 0x70,
  0x3C, 0x03, 0x80, 0x77, 0x81, 0xE0, 0x3C, 0x03, 0xBC, 0x0F, 0x01, 0xE0,
  0x3D, 0xE0, 0x78, 0x0F, 0x01, 0xCF, 0x07, 0x80, 0x70, 0x0E, 0x70, 0x3C,
  0x07, 0x80, 0x73, 0x81, 0xE0, 0x3C, 0x07, 0x1C, 0x0F, 0x03, 0xE0, 0x38,
  0xE0, 0x78, 0x1F, 0x03, 0xC7, 0x03, 0xE1, 0xF8, 0x3C, 0x38, 0x0F, 0x9F,
  0xC3, 0xC1, 0xC0, 0x7F, 0xCF, 0xFE, 0x0F, 0x03, 0xFE, 0x7F, 0xC0, 0x78,
  0x0F, 0xC1, 0xFC, 0x03, 0xC0, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x0C, 0x00, 0x00, 0x3F, 0xE3, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x78, 0x07,
  0x80, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xE0, 0x00,
  0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xE7, 0xE0,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x3E, 0x01, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x1E, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x7F, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0xFC,
  0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x7E, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x78, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xE0, 0x7F, 0x80, 0x3E,
  0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07,
  0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00,
  0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3C, 0x1F, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E,
  0x07, 0xC0, 0x1F, 0xC0, 0x7C, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xFF,
  0x1E, 0x01, 0xFF, 0xE7, 0xC0, 0x3F, 0xFC, 0xF8, 0x07, 0xFF, 0x9F, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0x80,
  0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xC0, 0x3F,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xE3, 0xF0, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xF9, 0xF0, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0,
  0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xF0, 0x00, 0xFB, 0xC0, 0x79, 0xE0, 0x01, 0xF7, 0x80, 0xF3, 0xC0, 0x07,
  0xDF, 0x01, 0xE7, 0x80, 0x0F, 0xBE, 0x07, 0xCF, 0x00, 0x3E, 0x7C, 0x0F,
  0x9E, 0x00, 0x7C, 0xF0, 0x1F, 0x3E, 0x01, 0xF1, 0xE0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x78, 0x78, 0x0F, 0x8F, 0x80, 0xF0, 0xF0, 0x1F, 0x1F, 0x03,
  0xE1, 0xE0, 0x7C, 0x3C, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x0F, 0x87, 0x81,
  0xE1, 0xF0, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x3C, 0x0F, 0x0F, 0x07, 0xC0,
  0xF8, 0x1E, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x78, 0x1E, 0x03, 0xE0, 0x79,
  0xF0, 0x7C, 0x07, 0xC0, 0xF3, 0xC0, 0xF8, 0x0F, 0x81, 0xEF, 0x81, 0xF0,
  0x1E, 0x03, 0xFE, 0x03, 0xE0, 0x7C, 0x03, 0xFC, 0x07, 0xC0, 0xF8, 0x07,
  0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x1E, 0x03, 0xF8, 0x00, 0x1E, 0x03, 0xF8, 0x00, 0x3E,
  0x03, 0xFC, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x3E,
  0x03, 0xFE, 0x00, 0x3C, 0x07, 0xDE, 0x00, 0x7C, 0x07, 0xDE, 0x00, 0x7C,
  0x07, 0xDF, 0x00, 0x7C, 0x07, 0xCF, 0x00, 0x7C, 0x07, 0xCF, 0x00, 0x7C,
  0x07, 0x8F, 0x80, 0x78, 0x0F, 0x87, 0x80, 0xF8, 0x0F, 0x87, 0x80, 0xF8,
  0x0F, 0x87, 0xC0, 0xF8, 0x0F, 0x83, 0xC0, 0xF8, 0x0F, 0x83, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0xF0, 0x1F, 0x01, 0xE1, 0xF0, 0x1F, 0x01, 0xE1, 0xF0,
  0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x00, 0xF1, 0xF0, 0x1E, 0x00, 0xF1, 0xE0,
  0x3E, 0x00, 0xFB, 0xE0, 0x3E, 0x00, 0x7B, 0xE0, 0x3E, 0x00, 0x7B, 0xE0,
  0x3E, 0x00, 0x7F, 0xE0, 0x3E, 0x00, 0x3F, 0xE0, 0x3C, 0x00, 0x3F, 0xC0,
  0x7C, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0,
  0x7C, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x3E, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x7F, 0x81,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0x3E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x33, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x3E, 0x01, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF8,
  0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03,
  0xF0, 0x3E, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x03, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0x78, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x01,
  0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xE0, 0x03,
  0xE7, 0x80, 0x0F, 0x80, 0x0F, 0x9E, 0x00, 0x3E, 0x00, 0x3E, 0x78, 0x01,
  0xF8, 0x01, 0xF1, 0xE0, 0x07, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0xC0, 0x1F,
  0x1E, 0x00, 0xFF, 0x00, 0x78, 0x78, 0x03, 0xFC, 0x03, 0xE1, 0xE0, 0x0F,
  0xF0, 0x0F, 0x87, 0x80, 0x7B, 0xC0, 0x3C, 0x1E, 0x01, 0xEF, 0x01, 0xF0,
  0x78, 0x0F, 0xBC, 0x07, 0xC1, 0xE0, 0x3C, 0xF0, 0x1E, 0x07, 0x80, 0xF3,
  0xC0, 0xF8, 0x1F, 0x07, 0x8F, 0x03, 0xE0, 0x7C, 0x1E, 0x3C, 0x0F, 0x01,
  0xF0, 0x78, 0x70, 0x7C, 0x07, 0xC3, 0xC1, 0xC1, 0xE0, 0x1F, 0x0F, 0x07,
  0x07, 0x80, 0x7C, 0x78, 0x1C, 0x3E, 0x01, 0xF1, 0xE0, 0x70, 0xF0, 0x07,
  0xC7, 0x81, 0xE3, 0xC0, 0x1F, 0x3C, 0x07, 0x9F, 0x00, 0x7C, 0xF0, 0x1E,
  0x78, 0x01, 0xF3, 0xC0, 0x79, 0xE0, 0x07, 0xDE, 0x01, 0xEF, 0x80, 0x0F,
  0x78, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00,
  0x3F, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x07, 0xE0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x9F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xF8, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0,
  0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x38,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xC0,
  0xF0, 0xE0, 0x78, 0x70, 0x78, 0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xE0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x07, 0x83, 0xE0, 0x1F, 0x1F,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0x80, 0xF0,
  0xF8, 0x03, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xE0,
  0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x3F,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFB, 0xE0, 0x3F, 0xCF, 0x80,
  0x10, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x08, 0x00, 0x79, 0xFE, 0x01, 0xF7, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xE0, 0x7C, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x1F,
  0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xE3,
  0xC0, 0x03, 0xC7, 0x80, 0x07, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x78, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xF0,
  0x3F, 0x1F, 0xFF, 0xFC, 0x3E, 0xFF, 0xF0, 0x78, 0xFF, 0xC0, 0xF0, 0xFF,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xC0, 0xF8, 0x7C, 0x03, 0xE7, 0xC0,
  0x0F, 0x3E, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0xF3, 0xE0, 0x07, 0x9F, 0x00, 0x7C, 0x78, 0x03, 0xC3, 0xE0, 0x7E,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x1F, 0xE3, 0xE0, 0x1F, 0xF9, 0xF0, 0x1F, 0xFE,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x0F, 0x83,
  0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF0,
  0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0x80, 0x0F, 0xF3, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x0F, 0xC0, 0xF8, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF8, 0x01, 0xF7, 0x80, 0x0F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x10, 0x7C, 0x01, 0x83, 0xF0, 0x3E, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFF, 0xFC, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xC3, 0xC0, 0x3F, 0xF1, 0xE0, 0x3F, 0xFD, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03,
  0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x7C,
  0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0x81, 0xFC, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0x00, 0x1F, 0xE7, 0x80, 0x01, 0x87, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x08, 0x00, 0xF8,
  0x0E, 0x00, 0xF8, 0x07, 0xC1, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x9F, 0xE0, 0x3E, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xE0, 0xFC, 0x3F, 0x01, 0xF0, 0xF8, 0x07,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0x80, 0x1F, 0x1E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0xF8,
  0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF0, 0x03,
  0xE0, 0x00, 0xC0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x7E,
  0x0F, 0x80, 0x7E, 0x0F, 0x80, 0xFC, 0x0F, 0x81, 0xF8, 0x0F, 0x83, 0xF0,
  0x0F, 0x07, 0xE0, 0x0F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x3F, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x3C, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF0, 0x03, 0xE0,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x79, 0xFE, 0x07, 0xF8, 0x0F,
  0xFF, 0xF1, 0xFF, 0xC0, 0xFF, 0xFF, 0xBF, 0xFE, 0x0F, 0xFF, 0xFB, 0xFF,
  0xE0, 0xFC, 0x0F, 0xF8, 0x3F, 0x0F, 0x80, 0x7F, 0x01, 0xF0, 0xF0, 0x07,
  0xE0, 0x1F, 0x1F, 0x00, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xC0, 0x1F, 0x1F,
  0x00, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0x01,
  0xF1, 0xE0, 0x07, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0x01, 0xF3, 0xE0, 0x0F,
  0x80, 0x1E, 0x3E, 0x00, 0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x80, 0x3E, 0x3C,
  0x00, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x00, 0x3E, 0x7C, 0x00, 0xF0, 0x03,
  0xE7, 0xC0, 0x1F, 0x00, 0x3C, 0x7C, 0x01, 0xF0, 0x07, 0xC7, 0x80, 0x1F,
  0x00, 0x7C, 0x78, 0x01, 0xF0, 0x07, 0xCF, 0x80, 0x1E, 0x00, 0x7C, 0xF8,
  0x01, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE0, 0x0F,
  0x8F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x7F, 0x80, 0xFB,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x83, 0xF0, 0xFC, 0x07,
  0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x3C,
  0x7C, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0x78,
  0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xE3, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x8F,
  0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00,
  0x0F, 0x78, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1E, 0xF8,
  0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0x3E, 0x00, 0x7C, 0x7C, 0x03,
  0xE1, 0xF8, 0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0xF3, 0xFC,
  0x00, 0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xC1,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x1F, 0xC0, 0x7E, 0x0F, 0xFF, 0xFE, 0x07, 0xDF, 0xFE, 0x03, 0xEF, 0xFE,
  0x01, 0xE1, 0xFE, 0x00, 0xF0, 0x10, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFC, 0x3C, 0x0F, 0xFE, 0xF8,
  0x7F, 0xFD, 0xF0, 0xFF, 0xFF, 0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xE3, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF0,
  0xF8, 0x03, 0xE0, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0xBC, 0x01, 0xFE, 0xF8, 0x00, 0x61, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xBF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xF1, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xE0, 0xFC, 0x3E, 0x03, 0xE1, 0xE0, 0x0F, 0x1F, 0x00,
  0x78, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0xF3, 0xE0,
  0x07, 0x9F, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x1F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x07, 0xE0, 0x02, 0x00, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x7C, 0x00,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1E,
  0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0x87, 0xC0,
  0x0F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3C, 0x03,
  0xF0, 0x7C, 0x0F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x01, 0xFE, 0x7C, 0x00, 0x60, 0x00, 0x00, 0xF8, 0x00, 0xF3, 0xC0, 0x0F,
  0x9E, 0x00, 0x7C, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x3E, 0x03, 0xC1, 0xE0, 0x1E, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x8F,
  0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0xF0, 0x07, 0x80, 0x3E, 0xF0, 0x07, 0xC0, 0x3E,
  0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x0F, 0xC0, 0x7C, 0xF0, 0x1F, 0xC0, 0x78,
  0xF0, 0x1F, 0xC0, 0xF8, 0xF0, 0x3F, 0xC0, 0xF8, 0xF0, 0x3F, 0xC0, 0xF0,
  0xF0, 0x7F, 0xC1, 0xF0, 0xF8, 0x7B, 0xC1, 0xE0, 0xF8, 0x7B, 0xC1, 0xE0,
  0xF8, 0xF3, 0xC3, 0xE0, 0xF8, 0xF1, 0xC3, 0xC0, 0x79, 0xE1, 0xE7, 0xC0,
  0x79, 0xE1, 0xE7, 0x80, 0x7B, 0xE1, 0xE7, 0x80, 0x7B, 0xC1, 0xEF, 0x00,
  0x7B, 0xC1, 0xEF, 0x00, 0x7F, 0x81, 0xEF, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x83,
  0xE0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0,
  0x0F, 0x07, 0xC0, 0x07, 0xC7, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF3, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3E,
  0x78, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x07, 0x80, 0x1F,
  0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0x78, 0x0F, 0x80, 0x3E, 0x0F,
  0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3C, 0x01,
  0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x3E,
  0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x79,
  0xF0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x40,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0xF1, 0xFF, 0x80, 0x3C, 0xFF, 0xF0, 0x1E, 0x7E,
  0xFE, 0x07, 0x9E, 0x0F, 0xC3, 0xEF, 0x81, 0xF9, 0xF3, 0xC0, 0x3F, 0xFC,
  0xF0, 0x07, 0xFE, 0x3C, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_Italic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 40, 13, 2, -39 },
  { 56, 13, 13, 17, 5, -41 },
  { 78, 28, 39, 29, 2, -39 },
  { 215, 23, 52, 26, 2, -46 },
  { 365, 25, 41, 34, 5, -40 },
  { 494, 25, 41, 29, 2, -40 },
  { 623, 6, 13, 9, 5, -41 },
  { 633, 16, 57, 17, 3, -44 },
  { 747, 17, 57, 17, -3, -44 },
  { 869, 21, 23, 23, 3, -39 },
  { 930, 23, 28, 27, 2, -32 },
  { 1011, 9, 14, 11, -3, -6 },
  { 1027, 11, 4, 13, 1, -19 },
  { 1033, 6, 7, 14, 1, -6 },
  { 1039, 25, 42, 20, -3, -39 },
  { 1171, 22, 41, 26, 3, -40 },
  { 1284, 15, 39, 26, 6, -39 },
  { 1358, 24, 40, 26, 1, -40 },
  { 1478, 24, 41, 26, 1, -40 },
  { 1601, 25, 39, 26, 0, -39 },
  { 1723, 24, 40, 26, 3, -39 },
  { 1843, 20, 40, 26, 3, -39 },
  { 1943, 25, 39, 26, 3, -39 },
  { 2065, 23, 41, 26, 2, -40 },
  { 2183, 20, 40, 26, 4, -40 },
  { 2283, 10, 31, 13, 1, -30 },
  { 2322, 14, 38, 11, -3, -30 },
  { 2389, 20, 25, 24, 2, -30 },
  { 2452, 21, 15, 26, 3, -26 },
  { 2492, 21, 24, 25, 2, -29 },
  { 2555, 18, 41, 23, 5, -40 },
  { 2648, 37, 50, 41, 2, -38 },
  { 2880, 29, 39, 31, -2, -39 },
  { 3022, 27, 39, 29, 1, -39 },
  { 3154, 27, 41, 30, 3, -40 },
  { 3293, 28, 39, 30, 1, -39 },
  { 3430, 27, 39, 27, 1, -39 },
  { 3562, 27, 39, 26, 1, -39 },
  { 3694, 27, 41, 32, 3, -40 },
  { 3833, 32, 39, 33, 1, -39 },
  { 3989, 12, 39, 13, 1, -39 },
  { 4048, 26, 40, 26, 0, -39 },
  { 4178, 31, 39, 29, 1, -39 },
  { 4330, 21, 39, 25, 1, -39 },
  { 4433, 39, 39, 40, 1, -39 },
  { 4624, 32, 39, 33, 1, -39 },
  { 4780, 27, 41, 32, 3, -40 },
  { 4919, 29, 39, 30, 1, -39 },
  { 5061, 27, 47, 32, 3, -40 },
  { 5220, 27, 39, 28, 1, -39 },
  { 5352, 27, 41, 28, 1, -40 },
  { 5491, 25, 39, 28, 5, -39 },
  { 5613, 29, 40, 30, 2, -39 },
  { 5758, 28, 39, 30, 5, -39 },
  { 5895, 38, 39, 41, 5, -39 },
  { 6081, 32, 39, 29, -1, -39 },
  { 6237, 26, 39, 28, 5, -39 },
  { 6364, 29, 39, 28, 0, -39 },
  { 6506, 17, 53, 13, 0, -45 },
  { 6619, 11, 42, 20, 5, -39 },
  { 6677, 17, 53, 13, -3, -45 },
  { 6790, 17, 20, 20, 2, -39 },
  { 6833, 21, 4, 22, -3, 0 },
  { 6844, 9, 8, 16, 6, -41 },
  { 6853, 22, 31, 26, 1, -30 },
  { 6939, 23, 42, 26, 1, -41 },
  { 7060, 21, 31, 25, 2, -30 },
  { 7142, 25, 42, 26, 2, -41 },
  { 7274, 21, 31, 25, 2, -30 },
  { 7356, 18, 42, 17, 3, -42 },
  { 7451, 25, 41, 26, 0, -30 },
  { 7580, 22, 41, 26, 1, -41 },
  { 7693, 11, 40, 12, 1, -40 },
  { 7748, 17, 51, 12, -5, -40 },
  { 7857, 24, 41, 24, 1, -41 },
  { 7980, 12, 41, 12, 1, -41 },
  { 8042, 36, 30, 40, 1, -30 },
  { 8177, 22, 30, 26, 1, -30 },
  { 8260, 22, 31, 27, 2, -30 },
  { 8346, 25, 41, 26, -1, -30 },
  { 8475, 23, 41, 27, 2, -30 },
  { 8593, 16, 30, 16, 1, -30 },
  { 8653, 21, 31, 24, 1, -30 },
  { 8735, 14, 37, 16, 2, -36 },
  { 8800, 23, 30, 26, 2, -29 },
  { 8887, 21, 29, 23, 3, -29 },
  { 8964, 32, 29, 35, 4, -29 },
  { 9080, 25, 29, 23, -1, -29 },
  { 9171, 26, 40, 22, -2, -29 },
  { 9301, 23, 29, 23, 0, -29 },
  { 9385, 17, 53, 16, 2, -43 },
  { 9498, 11, 46, 13, 1, -39 },
  { 9562, 18, 53, 16, -3, -43 },
  { 9682, 26, 11, 31, 3, -22 },
};

const GFXfont RobotoCondensed_Italic55pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic55pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic55pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _ROBOTOCONDENSED_ITALIC55PT7B_H_
