#ifndef _ROBOTOCONDENSED_ITALIC48PT7B_H_
#define _ROBOTOCONDENSED_ITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x07, 0x83, 0xE0, 0x78, 0x1C, 0x00, 0x78, 0xEF, 0x3D, 0xC7,
  0xB8, 0xE7, 0x1C, 0xE3, 0x9C, 0x77, 0x0C, 0xE3, 0x9C, 0x73, 0x8E, 0x61,
  0xC0, 0x00, 0x07, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE1,
  0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0xC0, 0x03, 0x83,
  0x80, 0x03, 0x83, 0x80, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x07, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x01, 0xFF,
  0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7C, 0x3E, 0x0F, 0x81, 0xE0, 0xF0,
  0x1F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x80, 0xF8, 0x7C, 0x1F, 0x07, 0xFF,
  0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x11, 0xC1, 0xC0, 0xE7,
  0x07, 0x07, 0x9C, 0x1C, 0x1C, 0x70, 0x70, 0xE1, 0xC1, 0xC7, 0x07, 0x07,
  0x3C, 0x1C, 0x3C, 0xE0, 0x70, 0xE7, 0x01, 0xFF, 0x3C, 0x03, 0xFC, 0xE0,
  0x07, 0xC7, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x1E, 0x00,
  0x39, 0xFE, 0x01, 0xEF, 0xF8, 0x07, 0x38, 0x70, 0x39, 0xE1, 0xC1, 0xE7,
  0x07, 0x0F, 0x1C, 0x1C, 0x38, 0x70, 0x71, 0xC1, 0xC1, 0xCF, 0x07, 0x07,
  0x38, 0x1C, 0x1D, 0xC0, 0x70, 0xF1, 0x01, 0xC3, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xE1, 0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x3C, 0x00,
  0xF1, 0xF0, 0x03, 0xCF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC1, 0xC7, 0xCF, 0x0F,
  0x3E, 0x3E, 0x3D, 0xF0, 0x78, 0xF7, 0x81, 0xF3, 0x9E, 0x03, 0xDE, 0x78,
  0x0F, 0xF9, 0xE0, 0x1F, 0xC7, 0x80, 0x7E, 0x1E, 0x00, 0xF8, 0x78, 0x03,
  0xE1, 0xF0, 0x1F, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFC, 0xF8,
  0x0F, 0xC1, 0xE0, 0x39, 0xDE, 0xF7, 0x39, 0xCE, 0xF7, 0x38, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x06, 0x00, 0x04, 0x00, 0x01, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x06,
  0x0E, 0x1F, 0xF3, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF0, 0xFF, 0xC0, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xE7, 0x00, 0xF1, 0xE0, 0x7C, 0x3C,
  0x3E, 0x0F, 0x03, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x7C, 0x3C, 0x3C, 0x1C, 0x04, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7B, 0xEF, 0xBE, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0x81, 0xE0,
  0xF0, 0x1E, 0x0F, 0x00, 0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F,
  0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x3E, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x07, 0x8F, 0x00, 0x78, 0x70, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x07,
  0xC1, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x30, 0x0F, 0x07, 0xF1, 0xFE, 0xFF, 0xEF, 0xFE, 0xF9, 0xEC, 0x1E,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xE0, 0x78, 0x07, 0xC3, 0xC0,
  0x1F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7C, 0x1F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1E, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3E, 0x00, 0xF0,
  0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3E, 0x07, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C,
  0x00, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0x87, 0x80, 0x78,
  0x3C, 0x07, 0xC3, 0xE0, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81,
  0xE0, 0x3C, 0x1E, 0x01, 0xE1, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF7, 0xC0, 0x07,
  0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0x07, 0xC0, 0x70, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0xF0, 0x03, 0xC3, 0x80, 0x1E, 0x1E, 0x00, 0xF0,
  0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x1E, 0x0F, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x8F, 0x83, 0xDF,
  0xF1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7E, 0x0F, 0xFE, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x81, 0xF3, 0xC1, 0xF1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xC1, 0xE0, 0xF8, 0x1E, 0x0F, 0x01, 0xF1, 0xF0, 0x0F, 0x1E, 0x00,
  0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0,
  0x7C, 0x07, 0xDF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3E,
  0x1F, 0x03, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF8,
  0xF0, 0x0F, 0x07, 0x81, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xE0, 0xF1, 0xE0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xBE, 0x0F, 0xCF, 0xFF, 0xE7, 0xFF, 0xF1,
  0xFF, 0x70, 0x3E, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC3, 0xE1, 0xF0, 0xF8, 0x38, 0x00, 0x01, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E,
  0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0x40, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF9,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC0, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0xF8, 0x06, 0x0E, 0x03,
  0xFE, 0x06, 0x1E, 0x07, 0xFF, 0x07, 0x1C, 0x0F, 0x0F, 0x07, 0x3C, 0x1E,
  0x0F, 0x07, 0x38, 0x1C, 0x0E, 0x07, 0x38, 0x3C, 0x0E, 0x07, 0x78, 0x38,
  0x0E, 0x07, 0x70, 0x38, 0x1E, 0x07, 0x70, 0x78, 0x1C, 0x07, 0x70, 0x70,
  0x1C, 0x06, 0xF0, 0x70, 0x1C, 0x0E, 0xE0, 0xF0, 0x3C, 0x0E, 0xE0, 0xF0,
  0x38, 0x0E, 0xE0, 0xF0, 0x38, 0x0E, 0xE0, 0xE0, 0x38, 0x0C, 0xE0, 0xE0,
  0x78, 0x1C, 0xE0, 0xE0, 0x78, 0x1C, 0xE0, 0xE0, 0xF8, 0x38, 0xE0, 0xF0,
  0xF8, 0x38, 0xE0, 0xFB, 0xB8, 0x70, 0xE0, 0xFF, 0xBF, 0xE0, 0xE0, 0x7F,
  0x3F, 0xC0, 0xE0, 0x3C, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF,
  0x00, 0x03, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x1E, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xC0, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C,
  0xF8, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xE0,
  0xF0, 0x07, 0xC1, 0xE0, 0x1F, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x07, 0x83, 0xE0,
  0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x1F,
  0x0F, 0x00, 0x7C, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x8F,
  0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x7C,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0x07,
  0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0x80, 0x3E, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x7C,
  0x00, 0xF8, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xF0, 0x78, 0x07, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFC, 0x07, 0xC1, 0xF0, 0x07,
  0x87, 0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x1F, 0xFB, 0xC0,
  0x7F, 0xF7, 0x80, 0xFF, 0xCF, 0x01, 0xFF, 0x9E, 0x00, 0x0F, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE3, 0xC0, 0x03,
  0xC7, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x80, 0xFE, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83,
  0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0xF8, 0x03, 0xC1, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x3E, 0x07,
  0x80, 0xF8, 0x0F, 0x83, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x78, 0x01, 0xF8,
  0x0F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0xF8, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01,
  0xF0, 0xFC, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF1, 0xF0,
  0x00, 0x1E, 0x7C, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x78, 0x00, 0x0F, 0xCF, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xE0, 0x1E, 0x00,
  0x7C, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x01, 0xFE, 0x07, 0x78, 0x00, 0xFF, 0x83, 0xDE, 0x00, 0x3D, 0xC0,
  0xF7, 0x80, 0x1F, 0xF0, 0x3D, 0xE0, 0x07, 0xBC, 0x0F, 0x78, 0x01, 0xEF,
  0x03, 0xDE, 0x00, 0xF3, 0xC0, 0xF3, 0x80, 0x3C, 0xF0, 0x78, 0xE0, 0x1E,
  0x78, 0x1E, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0,
  0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3E, 0x1C, 0x1E, 0x3E, 0x0F, 0x07,
  0x0F, 0x0F, 0x03, 0xC1, 0xC3, 0xC3, 0xC0, 0xF0, 0x79, 0xE0, 0xF0, 0x3C,
  0x1E, 0x78, 0x3C, 0x0F, 0x07, 0xBC, 0x1F, 0x07, 0xC1, 0xEF, 0x07, 0x81,
  0xE0, 0x3F, 0x81, 0xE0, 0x78, 0x0F, 0xE0, 0x78, 0x1E, 0x03, 0xF0, 0x1E,
  0x07, 0x80, 0xFC, 0x07, 0x81, 0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x80,
  0xF0, 0x3C, 0x01, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x7E, 0x00, 0x1E, 0x07, 0xF0, 0x01, 0xE0,
  0x7F, 0x00, 0x1E, 0x07, 0xF0, 0x03, 0xE0, 0x7F, 0x80, 0x3C, 0x07, 0xF8,
  0x03, 0xC0, 0xFB, 0x80, 0x3C, 0x0F, 0x3C, 0x03, 0xC0, 0xF3, 0xC0, 0x3C,
  0x0F, 0x1C, 0x07, 0xC0, 0xF1, 0xE0, 0x78, 0x0F, 0x1E, 0x07, 0x81, 0xF0,
  0xE0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0xF8, 0x1E, 0x07, 0x0F,
  0x81, 0xE0, 0x78, 0xF0, 0x3E, 0x07, 0x8F, 0x03, 0xE0, 0x38, 0xF0, 0x3C,
  0x03, 0xCF, 0x03, 0xC0, 0x3D, 0xF0, 0x3C, 0x01, 0xDE, 0x03, 0xC0, 0x1F,
  0xE0, 0x7C, 0x01, 0xFE, 0x07, 0x80, 0x0F, 0xE0, 0x78, 0x00, 0xFE, 0x07,
  0x80, 0x0F, 0xE0, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0x7C, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x07, 0x87, 0xC0,
  0x0F, 0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x7B, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07,
  0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF7,
  0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0x78,
  0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0xC0,
  0x0F, 0x87, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x78, 0x01, 0xF0, 0x3C,
  0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x87,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x7E,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x1E,
  0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x3E,
  0x0F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3E, 0x07, 0x80, 0x3E, 0x07, 0x80,
  0x3C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0x78, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x7E, 0x07, 0xC0, 0xF8, 0x07, 0x83, 0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0xF1,
  0xE0, 0x01, 0xE3, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x3E, 0x0F,
  0xC0, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3C, 0x00,
  0x3E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x87, 0xC0,
  0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x3C,
  0x1F, 0x00, 0x3E, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x3C,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x7C, 0x00, 0x0E,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0,
  0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1E, 0xF0, 0x07, 0xC0,
  0x1E, 0xF0, 0x0F, 0xC0, 0x3E, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x0F, 0xC0,
  0x3C, 0xF0, 0x1F, 0xC0, 0x78, 0xF0, 0x1D, 0xC0, 0x78, 0xF0, 0x3D, 0xC0,
  0x78, 0xF0, 0x3D, 0xE0, 0xF0, 0xF0, 0x39, 0xE0, 0xF0, 0xF0, 0x79, 0xE0,
  0xF0, 0xF0, 0x71, 0xE1, 0xE0, 0xF0, 0xF0, 0xE1, 0xE0, 0xF0, 0xF0, 0xE1,
  0xE0, 0xF0, 0xE0, 0xE3, 0xC0, 0xF1, 0xE0, 0xE3, 0xC0, 0x71, 0xC0, 0xE3,
  0xC0, 0x71, 0xC0, 0xE7, 0x80, 0x73, 0xC0, 0xE7, 0x80, 0x73, 0x80, 0xE7,
  0x80, 0x77, 0x80, 0xEF, 0x00, 0x77, 0x80, 0xEF, 0x00, 0x77, 0x00, 0xEF,
  0x00, 0x7F, 0x00, 0xEE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x1E, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C, 0xF8, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x80, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0xC0, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0xF0,
  0x00, 0xF9, 0xE0, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x87, 0x80,
  0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x1E, 0x07, 0xC0, 0x3C, 0x0F,
  0x00, 0x78, 0x3E, 0x00, 0xF0, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xC0,
  0x03, 0xCF, 0x00, 0x07, 0xBE, 0x00, 0x07, 0x78, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x00,
  0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0,
  0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x78, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xE0, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xDE, 0x0F,
  0x38, 0x38, 0xE1, 0xE3, 0x87, 0x8E, 0x3C, 0x38, 0xF0, 0xF7, 0x83, 0xDE,
  0x0F, 0xF0, 0x1C, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F, 0x00, 0x7E, 0x00, 0x3F,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x3C, 0x3E, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x07, 0xFF, 0x03, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0x07, 0x8F, 0x80, 0xF3, 0xE0, 0x3C, 0x78, 0x07,
  0x9F, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x80, 0xF8, 0xF0, 0x7F,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xEF, 0x81, 0xF1, 0xF0, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x3F, 0x00, 0xF7, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x81, 0xE1,
  0xF0, 0x1F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0x80,
  0x3C, 0x7C, 0x07, 0xCF, 0xE0, 0xF8, 0xFF, 0xFF, 0x8F, 0x7F, 0xF0, 0xF3,
  0xFE, 0x0E, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1E, 0x07, 0xCF, 0x00, 0xF7, 0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x01,
  0xDE, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xEF, 0x00, 0x73, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3E, 0x07, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0x0F, 0x01, 0xFF, 0x3C,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF0, 0x7E, 0x0F, 0x00, 0xF8, 0x7C,
  0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0,
  0x3C, 0x0F, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC,
  0x03, 0xFE, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1E, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x3D, 0xE0, 0x0F,
  0x78, 0x03, 0xDE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x06, 0x3E, 0x03, 0x87, 0xFF, 0xF0, 0xFF, 0xF8,
  0x1F, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x01,
  0xFF, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x3C, 0x07, 0xFC, 0xF0, 0x3F,
  0xFB, 0xC1, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x07,
  0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0x00,
  0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78,
  0x3C, 0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFB, 0xC0, 0x0F, 0x8F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x02, 0x00, 0xF0, 0x1C, 0x07, 0xC0, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0xFC, 0x07, 0xBF,
  0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xE0, 0xF8, 0xF8, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07,
  0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F,
  0x3C, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x3C,
  0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x80, 0x03, 0x81,
  0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x7C, 0x1E, 0x07, 0xC0, 0xF0, 0x7C, 0x0F, 0x87,
  0xE0, 0x78, 0x3E, 0x03, 0xC3, 0xE0, 0x1E, 0x3E, 0x00, 0xF3, 0xE0, 0x07,
  0xBE, 0x00, 0x7F, 0xE0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0x1E, 0x00, 0xF0,
  0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF8, 0x1E, 0x03, 0xC0,
  0xF0, 0x1F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1F, 0x00, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0x0F, 0x3F, 0x03, 0xF0,
  0x0F, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xCF, 0xFC, 0x1F, 0xFF, 0xDF, 0xFE,
  0x1F, 0x83, 0xF8, 0x3E, 0x1F, 0x01, 0xF8, 0x1E, 0x1E, 0x01, 0xF0, 0x1E,
  0x1E, 0x01, 0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0x1E, 0x3C, 0x01, 0xE0, 0x1E,
  0x3C, 0x01, 0xE0, 0x1E, 0x3C, 0x03, 0xE0, 0x1E, 0x3C, 0x03, 0xC0, 0x1E,
  0x3C, 0x03, 0xC0, 0x1E, 0x3C, 0x03, 0xC0, 0x3E, 0x78, 0x03, 0xC0, 0x3C,
  0x78, 0x03, 0xC0, 0x3C, 0x78, 0x07, 0xC0, 0x3C, 0x78, 0x07, 0x80, 0x3C,
  0x78, 0x07, 0x80, 0x3C, 0x78, 0x07, 0x80, 0x7C, 0xF0, 0x07, 0x80, 0x78,
  0xF0, 0x07, 0x80, 0x78, 0xF0, 0x0F, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0x78,
  0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x3F, 0x01, 0xEF, 0xF0, 0x3B, 0xFF, 0x0F,
  0xFF, 0xE1, 0xF8, 0x3E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0x78,
  0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF9, 0xE0,
  0x1E, 0x3C, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80,
  0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x3C, 0x7C, 0x07, 0xCF, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xDE, 0x00,
  0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x80, 0xF8, 0xF0, 0x3E, 0x1F, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xCF, 0xC0, 0x0F,
  0x7F, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xE0, 0xF8, 0x1F, 0x01,
  0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xF1, 0xF0,
  0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F,
  0x07, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0x83, 0xFF, 0xFE, 0x0F,
  0x7F, 0xF0, 0x3C, 0xFF, 0x80, 0xF1, 0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0xF0, 0x7F, 0xCF, 0x0F, 0xFE, 0xE1, 0xFF, 0xFE, 0x3F, 0x07, 0xE3,
  0xC0, 0x3E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xCF, 0x80, 0x3C,
  0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0x78, 0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xEF, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x3C, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF,
  0x1F, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE1, 0xF0, 0x7C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF3, 0xC0, 0x1E,
  0x78, 0x03, 0xCF, 0x80, 0xF0, 0xF0, 0x3E, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7F,
  0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x1E,
  0x7C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x7E, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xF0, 0x00, 0xF0, 0x07, 0xBC, 0x01, 0xEF,
  0x00, 0xFB, 0xC0, 0x3C, 0xF0, 0x0F, 0x1C, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x38, 0xF0,
  0x0E, 0x3C, 0x03, 0x8E, 0x00, 0xE7, 0x80, 0x39, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0,
  0x1F, 0xF0, 0x1F, 0x01, 0xEF, 0x01, 0xF0, 0x1E, 0xF0, 0x3F, 0x03, 0xCF,
  0x03, 0xF0, 0x3C, 0x70, 0x3F, 0x03, 0xC7, 0x07, 0xF0, 0x78, 0x70, 0x77,
  0x07, 0x87, 0x0F, 0x70, 0xF0, 0x70, 0xF7, 0x0F, 0x07, 0x8E, 0x78, 0xF0,
  0x79, 0xE7, 0x9E, 0x07, 0x9C, 0x79, 0xE0, 0x7B, 0xC7, 0x9C, 0x07, 0xB8,
  0x3B, 0xC0, 0x7F, 0x83, 0xBC, 0x07, 0xF8, 0x3B, 0x80, 0x7F, 0x03, 0xF8,
  0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3E,
  0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80, 0x3C,
  0x00, 0x0F, 0x80, 0x7C, 0x1E, 0x03, 0xE0, 0x78, 0x1F, 0x00, 0xF0, 0x7C,
  0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x1E, 0x7C, 0x00, 0x7B, 0xE0, 0x01,
  0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xDC, 0x00,
  0x0F, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xE3, 0x80, 0x0F, 0x0F, 0x00, 0x78,
  0x3C, 0x03, 0xE0, 0xF8, 0x0F, 0x01, 0xE0, 0x7C, 0x07, 0x83, 0xE0, 0x1F,
  0x00, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x1E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF0,
  0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x00, 0xE7, 0x80, 0x01,
  0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x78, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80,
  0x01, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0xFE, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00,
  0x18, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x1C, 0xFF, 0xE0, 0x79,
  0xFF, 0xC0, 0xF7, 0x87, 0xC3, 0xCF, 0x07, 0xFF, 0x9C, 0x07, 0xFE, 0x78,
  0x07, 0xF8, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_Italic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 34, 11, 1, -34 },
  { 44, 11, 12, 15, 5, -36 },
  { 61, 24, 34, 26, 2, -34 },
  { 163, 20, 43, 23, 2, -39 },
  { 271, 22, 34, 29, 4, -34 },
  { 365, 22, 34, 25, 1, -34 },
  { 459, 5, 11, 8, 4, -36 },
  { 466, 15, 50, 15, 2, -39 },
  { 560, 14, 49, 15, -2, -38 },
  { 646, 18, 20, 20, 3, -34 },
  { 691, 20, 25, 23, 2, -28 },
  { 754, 9, 12, 9, -3, -5 },
  { 768, 10, 4, 12, 1, -17 },
  { 773, 6, 5, 12, 1, -5 },
  { 777, 21, 37, 17, -2, -34 },
  { 875, 20, 34, 23, 2, -34 },
  { 960, 12, 34, 23, 6, -34 },
  { 1011, 22, 34, 23, 0, -34 },
  { 1105, 21, 34, 23, 1, -34 },
  { 1195, 21, 34, 23, 0, -34 },
  { 1285, 21, 34, 23, 2, -34 },
  { 1375, 17, 34, 23, 3, -34 },
  { 1448, 21, 34, 23, 3, -34 },
  { 1538, 20, 34, 23, 2, -34 },
  { 1623, 17, 34, 23, 4, -34 },
  { 1696, 9, 26, 11, 1, -26 },
  { 1726, 11, 33, 10, -2, -26 },
  { 1772, 17, 21, 21, 2, -26 },
  { 1817, 18, 14, 22, 3, -23 },
  { 1849, 19, 22, 21, 1, -26 },
  { 1902, 16, 34, 20, 4, -34 },
  { 1970, 32, 45, 36, 2, -34 },
  { 2150, 25, 34, 27, -2, -34 },
  { 2257, 23, 34, 25, 1, -34 },
  { 2355, 23, 34, 26, 3, -34 },
  { 2453, 24, 34, 27, 1, -34 },
  { 2555, 24, 34, 23, 1, -34 },
  { 2657, 23, 34, 22, 1, -34 },
  { 2755, 23, 34, 28, 3, -34 },
  { 2853, 28, 34, 29, 1, -34 },
  { 2972, 10, 34, 12, 1, -34 },
  { 3015, 23, 34, 23, 0, -34 },
  { 3113, 27, 34, 25, 1, -34 },
  { 3228, 18, 34, 22, 1, -34 },
  { 3305, 34, 34, 35, 1, -34 },
  { 3450, 28, 34, 29, 1, -34 },
  { 3569, 23, 34, 28, 3, -34 },
  { 3667, 25, 34, 26, 1, -34 },
  { 3774, 24, 40, 28, 2, -34 },
  { 3894, 24, 34, 25, 1, -34 },
  { 3996, 23, 34, 24, 1, -34 },
  { 4094, 22, 34, 24, 4, -34 },
  { 4188, 25, 34, 26, 2, -34 },
  { 4295, 24, 34, 26, 4, -34 },
  { 4397, 32, 34, 35, 5, -34 },
  { 4533, 28, 34, 26, -1, -34 },
  { 4652, 23, 34, 24, 4, -34 },
  { 4750, 25, 34, 24, 0, -34 },
  { 4857, 15, 46, 12, 0, -39 },
  { 4944, 9, 37, 17, 5, -34 },
  { 4986, 15, 46, 12, -3, -39 },
  { 5073, 14, 17, 17, 2, -34 },
  { 5103, 19, 4, 19, -3, 0 },
  { 5113, 8, 7, 14, 5, -36 },
  { 5120, 19, 26, 22, 1, -26 },
  { 5182, 20, 36, 23, 1, -36 },
  { 5272, 18, 26, 22, 2, -26 },
  { 5331, 22, 36, 23, 2, -36 },
  { 5430, 18, 26, 22, 2, -26 },
  { 5489, 16, 36, 15, 2, -36 },
  { 5561, 22, 36, 23, 0, -26 },
  { 5660, 19, 36, 22, 1, -36 },
  { 5746, 10, 35, 11, 1, -35 },
  { 5790, 16, 45, 10, -5, -35 },
  { 5880, 21, 36, 21, 1, -36 },
  { 5975, 10, 36, 11, 1, -36 },
  { 6020, 32, 26, 35, 1, -26 },
  { 6124, 19, 26, 23, 1, -26 },
  { 6186, 19, 26, 23, 2, -26 },
  { 6248, 22, 36, 23, -1, -26 },
  { 6347, 20, 36, 23, 2, -26 },
  { 6437, 14, 26, 14, 1, -26 },
  { 6483, 19, 26, 21, 1, -26 },
  { 6545, 12, 32, 14, 2, -32 },
  { 6593, 19, 26, 23, 2, -26 },
  { 6655, 18, 26, 20, 3, -26 },
  { 6714, 28, 26, 30, 3, -26 },
  { 6805, 22, 26, 20, -1, -26 },
  { 6877, 23, 36, 19, -2, -26 },
  { 6981, 20, 26, 20, 0, -26 },
  { 7046, 16, 46, 14, 1, -37 },
  { 7138, 10, 40, 11, 1, -34 },
  { 7188, 15, 46, 14, -2, -37 },
  { 7275, 23, 9, 27, 2, -18 },
};

const GFXfont RobotoCondensed_Italic48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_ITALIC48PT7B_H_
