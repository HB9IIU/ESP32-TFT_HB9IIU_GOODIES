#ifndef _ROBOTOCONDENSED_ITALIC51PT7B_H_
#define _ROBOTOCONDENSED_ITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x38, 0xF3,
  0x8F, 0x38, 0xF7, 0x8E, 0x78, 0xE7, 0x0E, 0x71, 0xE7, 0x1C, 0x71, 0xCE,
  0x1C, 0xE1, 0xCE, 0x18, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07,
  0x00, 0x03, 0xC3, 0xC0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x38, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xC1, 0xC0,
  0x00, 0xF0, 0x70, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x78, 0x00,
  0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0x87,
  0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x3C, 0xF0, 0x03, 0xE7, 0x80, 0x1F, 0x3E, 0x01, 0xF0, 0xF0, 0x0F, 0x87,
  0xC1, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xC7,
  0x80, 0x07, 0x07, 0x01, 0x1E, 0x0E, 0x03, 0xB8, 0x1C, 0x0E, 0x70, 0x38,
  0x3C, 0xE0, 0x70, 0xF1, 0xC0, 0xE1, 0xC3, 0x81, 0xC7, 0x87, 0x07, 0x9E,
  0x0E, 0x0E, 0x38, 0x1E, 0x3C, 0xE0, 0x1F, 0xF3, 0xC0, 0x1F, 0xCF, 0x00,
  0x1F, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x8F, 0x80,
  0x0E, 0x7F, 0x80, 0x3C, 0xFF, 0x80, 0xF3, 0xC7, 0x01, 0xCF, 0x07, 0x07,
  0x9C, 0x0E, 0x1E, 0x38, 0x1C, 0x38, 0x70, 0x38, 0xE0, 0xE0, 0x73, 0xC3,
  0xC0, 0xEF, 0x07, 0x83, 0xDC, 0x07, 0x07, 0x38, 0x0E, 0x0E, 0x00, 0x1E,
  0x3C, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xF0,
  0xF8, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0,
  0x78, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC1, 0xF0, 0x03, 0xE7,
  0xE0, 0x01, 0xEF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0x0F, 0xBE,
  0x0F, 0x1F, 0x1E, 0x1E, 0x3E, 0x1F, 0x1E, 0x7C, 0x0F, 0x1E, 0x7C, 0x0F,
  0x9E, 0x78, 0x07, 0xBC, 0x78, 0x07, 0xFC, 0x78, 0x03, 0xF8, 0x78, 0x03,
  0xF8, 0x78, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF8, 0x3F, 0x0F,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0x7C, 0x07, 0xFC, 0x3E, 0x00, 0x40,
  0x00, 0x3C, 0xF3, 0x8E, 0x79, 0xE7, 0x9C, 0x71, 0xC7, 0x3C, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x06, 0x00, 0x08, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x60, 0x70, 0x67,
  0xCF, 0x3E, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0x3F, 0xC0,
  0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0x78, 0x01, 0xF3, 0xC0, 0x3E, 0x3C,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x03, 0x00, 0xC0, 0x10, 0x08, 0x00, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0xC3, 0xC1,
  0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x3E, 0x1E, 0x0E, 0x02, 0x00, 0xFF,
  0xFF, 0xFB, 0xFF, 0x7F, 0xE0, 0x11, 0xEF, 0xFF, 0x7D, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x0F,
  0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xC0,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xE7, 0x80, 0x1F, 0x3C, 0x00, 0xF3,
  0xE0, 0x07, 0x9F, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00,
  0xF9, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0xF8, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x3E,
  0x0F, 0x83, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x1F, 0xF7, 0xFF, 0x3F, 0xFB,
  0xF3, 0xDE, 0x1E, 0xC0, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0x07, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x0F,
  0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xE0, 0xF8, 0x1F,
  0x01, 0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x1E, 0x3E,
  0x00, 0x78, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x07, 0xC0, 0x7C, 0x1F, 0x83,
  0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0xC0, 0x07,
  0xCF, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xE0,
  0xF0, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x1E,
  0x03, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xF0, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x3C, 0x3C, 0x00,
  0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xCF, 0xC0, 0x7B, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x0F, 0x7C, 0x01, 0xEF, 0x80,
  0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xDE, 0x00,
  0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xEF, 0x00, 0x79, 0xF0, 0x1F, 0x1E, 0x03,
  0xC3, 0xE0, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7E, 0x1F, 0x03, 0xC0,
  0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3,
  0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x1E, 0x0F,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3E,
  0x1F, 0x03, 0xE0, 0x7C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x7C,
  0xF8, 0x03, 0xE7, 0x80, 0x1F, 0x3C, 0x00, 0xF9, 0xE0, 0x07, 0x8F, 0x00,
  0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x0F, 0x83, 0xF0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xF0, 0xF8, 0x7C, 0x0F, 0x9F, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01,
  0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x3F, 0x3E, 0x1F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF,
  0x07, 0xFD, 0xE0, 0x7E, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x02, 0x01,
  0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0x81, 0xE0, 0x00, 0x40, 0x1E,
  0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80,
  0xF0, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x07,
  0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00,
  0x04, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3,
  0xE1, 0xF3, 0xE0, 0x7D, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x38, 0x3C, 0x01, 0xF0, 0x06, 0x0F,
  0x01, 0xFF, 0x01, 0xC7, 0x80, 0xFF, 0xF0, 0x71, 0xE0, 0x7C, 0x78, 0x1C,
  0x70, 0x1E, 0x0E, 0x07, 0x3C, 0x0F, 0x07, 0x81, 0xCE, 0x07, 0x81, 0xE0,
  0x73, 0x81, 0xE0, 0x70, 0x1D, 0xE0, 0xF0, 0x1C, 0x07, 0x70, 0x3C, 0x07,
  0x01, 0xDC, 0x0E, 0x03, 0xC0, 0x7F, 0x07, 0x80, 0xF0, 0x3B, 0xC1, 0xE0,
  0x38, 0x0E, 0xE0, 0x78, 0x0E, 0x03, 0xB8, 0x1E, 0x07, 0x80, 0xEE, 0x07,
  0x01, 0xE0, 0x3B, 0x81, 0xC0, 0x70, 0x1C, 0xE0, 0xF0, 0x1C, 0x07, 0x38,
  0x3C, 0x0F, 0x01, 0xCE, 0x0F, 0x03, 0xC0, 0xE3, 0x81, 0xC1, 0xF0, 0x78,
  0xE0, 0x78, 0xFC, 0x1C, 0x38, 0x1F, 0xF7, 0xDE, 0x0E, 0x07, 0xF9, 0xFF,
  0x03, 0x80, 0xFC, 0x3F, 0x80, 0xF0, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xC7, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x07, 0xC0,
  0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3C, 0x03, 0xF0, 0x1E, 0x00,
  0xF8, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xC0,
  0x07, 0xC1, 0xE0, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x07, 0xC0,
  0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x3C,
  0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x07,
  0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x1E,
  0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0x80, 0x01,
  0xF3, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x81, 0xF0, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xC0, 0x7E, 0x00, 0xF0, 0x07, 0xC0,
  0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01,
  0xE0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xE0, 0x1F, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7E, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x03, 0xFF, 0x9F, 0x01,
  0xFF, 0xCF, 0x80, 0xFF, 0xE7, 0x80, 0x7F, 0xF3, 0xC0, 0x00, 0xF9, 0xE0,
  0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xF0, 0x03, 0xE0,
  0x7E, 0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0,
  0x3E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x0F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF0,
  0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0,
  0x78, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0x80, 0x1F, 0x80,
  0x3C, 0x01, 0xF8, 0x01, 0xE0, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x07, 0x80, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x3C, 0xFC, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0xF0,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x78,
  0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0,
  0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xDE, 0x07, 0xBC, 0x00, 0x7F, 0xC0,
  0xFB, 0xC0, 0x07, 0xBC, 0x0F, 0x3C, 0x00, 0xFB, 0xC0, 0xF3, 0xC0, 0x0F,
  0x3C, 0x0F, 0x3C, 0x01, 0xF7, 0xC0, 0xF3, 0xC0, 0x1E, 0x7C, 0x0F, 0x3C,
  0x03, 0xE7, 0x81, 0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0x81,
  0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x1E, 0x0F, 0x8F, 0x81, 0xE1, 0xE0, 0xF0,
  0xF8, 0x1E, 0x1E, 0x1F, 0x0F, 0x03, 0xE0, 0xE1, 0xE0, 0xF0, 0x3E, 0x0F,
  0x1E, 0x0F, 0x03, 0xC0, 0xF3, 0xC1, 0xF0, 0x3C, 0x0F, 0x3C, 0x1F, 0x03,
  0xC0, 0xF7, 0x81, 0xE0, 0x3C, 0x0F, 0x78, 0x1E, 0x07, 0xC0, 0xFF, 0x01,
  0xE0, 0x7C, 0x07, 0xF0, 0x3E, 0x07, 0x80, 0x7E, 0x03, 0xE0, 0x78, 0x07,
  0xE0, 0x3E, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0x3C, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0,
  0x3F, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8, 0x0F,
  0xE0, 0x03, 0xE0, 0x7F, 0x80, 0x0F, 0x01, 0xFE, 0x00, 0x3C, 0x07, 0xBC,
  0x00, 0xF0, 0x1E, 0xF0, 0x07, 0xC0, 0x7B, 0xC0, 0x1F, 0x03, 0xE7, 0x80,
  0x7C, 0x0F, 0x9E, 0x01, 0xE0, 0x3E, 0x78, 0x07, 0x80, 0xF0, 0xF0, 0x1E,
  0x03, 0xC3, 0xC0, 0xF8, 0x0F, 0x0F, 0x03, 0xE0, 0x7C, 0x1E, 0x0F, 0x01,
  0xF0, 0x78, 0x3C, 0x07, 0xC1, 0xE0, 0xF0, 0x1E, 0x03, 0xC7, 0xC0, 0x78,
  0x0F, 0x1F, 0x01, 0xE0, 0x3C, 0x7C, 0x0F, 0x80, 0x79, 0xE0, 0x3E, 0x01,
  0xE7, 0x80, 0xF8, 0x07, 0x9E, 0x03, 0xC0, 0x0F, 0xF8, 0x0F, 0x00, 0x3F,
  0xE0, 0x7C, 0x00, 0xFF, 0x81, 0xF0, 0x01, 0xFC, 0x07, 0xC0, 0x07, 0xF0,
  0x1E, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0xFC, 0x0F,
  0x80, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x07, 0xE0, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0xFB,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F,
  0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x01,
  0xF7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x8F, 0x80,
  0x07, 0x83, 0xC0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x3C, 0x01, 0xF8, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83,
  0xC0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x83, 0xE0, 0x0F,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0xCF, 0x00, 0x03,
  0xE7, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xE0, 0x00,
  0x3E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00,
  0x03, 0xDF, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x3C,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x07, 0xC1,
  0xF0, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x20, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x3C, 0x03, 0xF0, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3C, 0x00,
  0x7C, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xF0, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0x81,
  0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x3C,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x03, 0xE0, 0x3F,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x07,
  0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x87, 0x80,
  0x07, 0x83, 0xC0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00,
  0x3E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F,
  0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x1F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0x80,
  0x07, 0x80, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x3F, 0x80,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xF7, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x03,
  0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0,
  0x07, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xE0, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0xF0,
  0x01, 0xE0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC3,
  0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0x78, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x7B, 0xC0, 0x07, 0x80, 0x1F,
  0x7C, 0x01, 0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x00, 0x79, 0xF0, 0x0F, 0xE0,
  0x1F, 0x3E, 0x01, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x80, 0x78, 0xF8, 0x0F,
  0xF0, 0x1F, 0x1F, 0x01, 0xFE, 0x03, 0xC3, 0xE0, 0x3B, 0xC0, 0x78, 0x3C,
  0x0F, 0x78, 0x1F, 0x07, 0x81, 0xE7, 0x03, 0xC0, 0xF0, 0x78, 0xE0, 0x78,
  0x1E, 0x0F, 0x1C, 0x1F, 0x03, 0xC1, 0xC3, 0x83, 0xC0, 0x78, 0x78, 0x70,
  0x78, 0x0F, 0x0F, 0x0E, 0x1F, 0x01, 0xE1, 0xC1, 0xC3, 0xC0, 0x3C, 0x78,
  0x38, 0x78, 0x07, 0x8F, 0x07, 0x9F, 0x00, 0xF3, 0xC0, 0xF3, 0xC0, 0x1E,
  0x78, 0x1E, 0x78, 0x03, 0xCE, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x7B, 0xC0,
  0x0F, 0x78, 0x0F, 0x78, 0x01, 0xFE, 0x01, 0xEE, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00,
  0x07, 0x80, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0xF0, 0xFC, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1E,
  0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0,
  0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x00, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x00, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xFE, 0x03, 0xDC, 0x07, 0xBC, 0x1E, 0x78, 0x3C, 0xF0, 0xF0, 0xE1, 0xE1,
  0xC7, 0x83, 0x8F, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x3C, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x7C, 0x3E, 0x0F, 0x83,
  0xC1, 0xF0, 0x78, 0x1E, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xC1, 0xF0, 0xF0, 0x1F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xC1, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0x80,
  0x3C, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xC7, 0x80, 0xFC, 0x7C,
  0x1F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0x7C, 0x0F, 0xC7, 0xC0,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0xF7, 0xFE, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xF8, 0x3F, 0x1F, 0x80, 0xF8, 0xF8, 0x03, 0xC7,
  0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9F, 0x00, 0x3C, 0xF8, 0x01,
  0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07, 0xCF, 0x00, 0x3E, 0xF8,
  0x01, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07, 0xCF, 0x80, 0x3C,
  0x7C, 0x03, 0xE7, 0xF0, 0x3E, 0x3D, 0xFF, 0xF1, 0xEF, 0xFF, 0x0F, 0x3F,
  0xF0, 0x78, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0x03, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1F,
  0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x80, 0xF8, 0x7C,
  0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0xC3, 0xC0, 0x7F,
  0xE7, 0x81, 0xFF, 0xEF, 0x07, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3E, 0x01,
  0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F,
  0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8,
  0x3F, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x78, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xF0, 0x3E, 0x7C, 0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x0F, 0x78, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x06, 0x1F, 0x03, 0xE3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xC8, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x1E, 0x03, 0xFF, 0x3C,
  0x0F, 0xFF, 0x78, 0x3F, 0xFE, 0xF0, 0x7E, 0x0F, 0xE1, 0xF0, 0x0F, 0x83,
  0xC0, 0x1F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x78,
  0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x3E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03,
  0xC1, 0xE0, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x07, 0xC1, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFB, 0xC0, 0x0F, 0xCF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x30,
  0x07, 0xC0, 0x78, 0x1F, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF9, 0xF8, 0x0F,
  0x7F, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x1F, 0x1F, 0x81, 0xF1,
  0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xE0, 0x0F,
  0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE7, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x00, 0x7C, 0xF0,
  0x07, 0x8F, 0x00, 0x78, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x3F, 0x0F, 0x01, 0xF8, 0x3C, 0x0F, 0xC0, 0xF0, 0x7E, 0x03, 0xC1,
  0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xE3, 0xE0, 0x07, 0x9F, 0x00,
  0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0x80, 0x1F, 0x9F, 0x00, 0x7C, 0x3C,
  0x01, 0xE0, 0xF8, 0x07, 0x83, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1F, 0x03,
  0xE0, 0x3C, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xE0, 0xF0, 0x07, 0xC3, 0xC0,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x1F, 0x80, 0xFC, 0x03,
  0xDF, 0xF0, 0xFF, 0x80, 0xFF, 0xFE, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xC1, 0xFE, 0x0F, 0x87, 0xC0, 0x7F, 0x01, 0xE1, 0xF0, 0x0F, 0x80,
  0x78, 0x78, 0x03, 0xE0, 0x1E, 0x1E, 0x00, 0xF8, 0x07, 0x87, 0x80, 0x3C,
  0x01, 0xE3, 0xE0, 0x0F, 0x00, 0x78, 0xF8, 0x07, 0xC0, 0x1E, 0x3C, 0x01,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0x03, 0xE3, 0xC0, 0x1E, 0x00, 0xF8, 0xF0,
  0x07, 0x80, 0x3C, 0x7C, 0x01, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0x03, 0xC7,
  0x80, 0x3E, 0x00, 0xF1, 0xE0, 0x0F, 0x00, 0x7C, 0x78, 0x03, 0xC0, 0x1F,
  0x1E, 0x00, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x01, 0xE3, 0xE0, 0x1F, 0x00,
  0x78, 0xF0, 0x07, 0xC0, 0x1E, 0x3C, 0x01, 0xE0, 0x0F, 0x8F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x1F, 0x80, 0xF7, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x1F, 0xC1, 0xF1, 0xF8, 0x1F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00,
  0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xF3, 0xC0,
  0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x78,
  0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xCF,
  0x80, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x80, 0x00, 0xFE,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF8, 0x3E, 0x0F,
  0x00, 0xF8, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xC0, 0x07,
  0xDE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x78, 0x00, 0x7B, 0xC0,
  0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x79,
  0xE0, 0x07, 0xCF, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xF0, 0x3E, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xC7, 0xE0,
  0x07, 0xBF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0x07, 0xE0,
  0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x3E, 0x00,
  0x78, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0x83, 0xE0, 0x1F,
  0x0F, 0xE0, 0x7C, 0x1E, 0xFF, 0xF8, 0x3D, 0xFF, 0xE0, 0x79, 0xFF, 0x80,
  0xF0, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x78, 0x3F,
  0xF3, 0xC3, 0xFF, 0xDE, 0x3F, 0xFF, 0xF1, 0xF0, 0x3F, 0x1F, 0x00, 0xF8,
  0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0xBE, 0x00,
  0x79, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x9E,
  0x00, 0x7C, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x8F, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xF0, 0x7E, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xF3, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x3E,
  0x1E, 0xFC, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0x63, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0x83, 0xE1, 0xF0, 0x1E, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xC7, 0x80, 0x78, 0x7C, 0x1F, 0x87, 0xFF,
  0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFC, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xFE, 0x07,
  0xF0, 0x3F, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80,
  0x3C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xC7,
  0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x07,
  0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF8,
  0x03, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC1, 0xF0, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF,
  0x78, 0x03, 0xF0, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xE0, 0x1F, 0x3C,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x78,
  0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x1C, 0x1E, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0x77,
  0x80, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x7F, 0xE0, 0x1E, 0x01, 0xE7, 0x80, 0xF8, 0x07, 0x9E, 0x03, 0xE0, 0x3E,
  0x78, 0x1F, 0x80, 0xF1, 0xE0, 0x7E, 0x03, 0xC7, 0x81, 0xF8, 0x1E, 0x1E,
  0x0F, 0xE0, 0x78, 0x78, 0x3B, 0x83, 0xE1, 0xE1, 0xEF, 0x0F, 0x07, 0x87,
  0xBC, 0x3C, 0x1E, 0x3C, 0xF1, 0xE0, 0x78, 0xF3, 0xC7, 0x81, 0xE7, 0x8F,
  0x1E, 0x07, 0x9E, 0x3C, 0xF0, 0x1E, 0x70, 0xF3, 0xC0, 0x7B, 0xC1, 0xDE,
  0x01, 0xEF, 0x07, 0x78, 0x03, 0xF8, 0x1D, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x0F,
  0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0,
  0x1E, 0x07, 0xC0, 0x3C, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x00,
  0xF3, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x3C, 0x00, 0x3E, 0x78,
  0x00, 0xF8, 0xF0, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x1F, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0xF8, 0x07, 0x83, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x03, 0xC0, 0x78, 0x03, 0xC0, 0xF8, 0x03, 0xC0, 0xF0, 0x03, 0xC1, 0xF0,
  0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xE3, 0xC0,
  0x01, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xEF, 0x00,
  0x01, 0xEF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x00,
  0x02, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x01,
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xF8, 0x03, 0xC7, 0xFE, 0x01, 0xC7, 0xFF, 0x80, 0xE3, 0xC7, 0xE0,
  0xF3, 0xC1, 0xF8, 0xF1, 0xE0, 0x7F, 0xF8, 0xE0, 0x1F, 0xF8, 0x70, 0x07,
  0xF8, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_Italic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 36, 12, 2, -36 },
  { 46, 12, 12, 16, 5, -38 },
  { 64, 26, 36, 27, 2, -36 },
  { 181, 21, 46, 24, 2, -41 },
  { 302, 23, 36, 31, 5, -36 },
  { 406, 24, 37, 27, 1, -36 },
  { 517, 6, 12, 9, 4, -38 },
  { 526, 15, 53, 16, 3, -41 },
  { 626, 15, 53, 16, -2, -41 },
  { 726, 20, 21, 21, 3, -36 },
  { 779, 21, 26, 25, 2, -30 },
  { 848, 9, 13, 10, -3, -5 },
  { 863, 11, 4, 12, 1, -18 },
  { 869, 6, 6, 13, 1, -6 },
  { 874, 23, 39, 18, -2, -36 },
  { 987, 21, 36, 24, 2, -36 },
  { 1082, 13, 36, 24, 6, -36 },
  { 1141, 23, 36, 24, 0, -36 },
  { 1245, 22, 36, 24, 1, -36 },
  { 1344, 23, 36, 24, 0, -36 },
  { 1448, 22, 36, 24, 3, -36 },
  { 1547, 19, 36, 24, 3, -36 },
  { 1633, 23, 36, 24, 3, -36 },
  { 1737, 21, 36, 24, 2, -36 },
  { 1832, 19, 36, 24, 4, -36 },
  { 1918, 10, 28, 12, 1, -28 },
  { 1953, 12, 36, 10, -2, -28 },
  { 2007, 19, 23, 22, 2, -28 },
  { 2062, 19, 14, 24, 3, -24 },
  { 2096, 20, 22, 23, 1, -27 },
  { 2151, 17, 36, 21, 4, -36 },
  { 2228, 34, 47, 38, 2, -36 },
  { 2428, 27, 36, 29, -2, -36 },
  { 2550, 25, 36, 27, 1, -36 },
  { 2663, 25, 36, 28, 3, -36 },
  { 2776, 26, 36, 28, 1, -36 },
  { 2893, 25, 36, 25, 1, -36 },
  { 3006, 25, 36, 24, 1, -36 },
  { 3119, 25, 36, 29, 3, -36 },
  { 3232, 30, 36, 31, 1, -36 },
  { 3367, 11, 36, 12, 1, -36 },
  { 3417, 24, 36, 24, 0, -36 },
  { 3525, 29, 36, 27, 1, -36 },
  { 3656, 19, 36, 24, 1, -36 },
  { 3742, 36, 36, 37, 1, -36 },
  { 3904, 30, 36, 31, 1, -36 },
  { 4039, 25, 36, 30, 3, -36 },
  { 4152, 27, 36, 27, 1, -36 },
  { 4274, 25, 42, 30, 3, -36 },
  { 4406, 25, 36, 26, 1, -36 },
  { 4519, 25, 36, 26, 1, -36 },
  { 4632, 24, 36, 26, 4, -36 },
  { 4740, 27, 36, 28, 2, -36 },
  { 4862, 26, 36, 28, 4, -36 },
  { 4979, 35, 36, 38, 5, -36 },
  { 5137, 30, 36, 27, -1, -36 },
  { 5272, 24, 36, 26, 5, -36 },
  { 5380, 27, 36, 26, 0, -36 },
  { 5502, 15, 49, 12, 0, -41 },
  { 5594, 9, 39, 18, 5, -36 },
  { 5638, 16, 49, 12, -3, -41 },
  { 5736, 15, 18, 18, 2, -36 },
  { 5770, 20, 4, 20, -3, 0 },
  { 5780, 9, 7, 15, 5, -38 },
  { 5788, 20, 27, 24, 1, -27 },
  { 5856, 21, 38, 24, 1, -38 },
  { 5956, 20, 27, 23, 2, -27 },
  { 6024, 23, 38, 25, 2, -38 },
  { 6134, 19, 27, 23, 2, -27 },
  { 6199, 17, 39, 16, 2, -39 },
  { 6282, 23, 37, 24, 0, -27 },
  { 6389, 20, 38, 24, 1, -38 },
  { 6484, 11, 37, 11, 1, -37 },
  { 6535, 16, 47, 11, -5, -37 },
  { 6629, 22, 38, 22, 1, -38 },
  { 6734, 11, 38, 11, 1, -38 },
  { 6787, 34, 27, 37, 1, -27 },
  { 6902, 20, 27, 24, 1, -27 },
  { 6970, 21, 27, 25, 2, -27 },
  { 7041, 23, 37, 24, -1, -27 },
  { 7148, 21, 37, 25, 2, -27 },
  { 7246, 15, 27, 15, 1, -27 },
  { 7297, 20, 27, 23, 1, -27 },
  { 7365, 13, 34, 15, 2, -34 },
  { 7421, 21, 27, 24, 2, -27 },
  { 7492, 19, 27, 21, 3, -27 },
  { 7557, 30, 27, 32, 3, -27 },
  { 7659, 23, 27, 22, -1, -27 },
  { 7737, 24, 37, 21, -2, -27 },
  { 7848, 21, 27, 22, 0, -27 },
  { 7919, 16, 49, 15, 2, -40 },
  { 8017, 10, 43, 12, 1, -36 },
  { 8071, 16, 49, 15, -2, -40 },
  { 8169, 25, 10, 29, 2, -20 },
};

const GFXfont RobotoCondensed_Italic51pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic51pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic51pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _ROBOTOCONDENSED_ITALIC51PT7B_H_
