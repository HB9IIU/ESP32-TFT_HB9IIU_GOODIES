#ifndef _ROBOTOCONDENSED_ITALIC6PT7B_H_
#define _ROBOTOCONDENSED_ITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0x40, 0x0F, 0x80, 0x55, 0x1C, 0x00, 0xED, 0x6B, 0xF0, 0x00,
  0x1A, 0x80, 0x15, 0xA0, 0xE8, 0x49, 0x00, 0x80, 0x00, 0x80, 0x1A, 0xF6,
  0xE0, 0xF0, 0x65, 0x40, 0x2C, 0x60, 0x2B, 0x20, 0x48, 0xE0, 0x4A, 0xE0,
  0x29, 0x40, 0xEA, 0xE0, 0xF5, 0x20, 0x20, 0x20, 0x70, 0x78, 0x58, 0x50,
  0x7B, 0xFF, 0xC0, 0x4D, 0xD0, 0x76, 0xF0, 0x72, 0x70, 0x76, 0xE0, 0x52,
  0x40, 0x52, 0x40, 0x72, 0xF0, 0x59, 0xAA, 0xF0, 0x24, 0xE0, 0x64, 0xCA,
  0x6A, 0x55, 0xFD, 0x5D, 0xAA, 0x76, 0xF0, 0x76, 0x40, 0x76, 0xF2, 0x76,
  0x50, 0xE8, 0xF0, 0xAA, 0xB6, 0xF0, 0xDA, 0x40, 0xDE, 0xA0, 0x69, 0x50,
  0xEA, 0x29, 0x60, 0x6A, 0xA0, 0x70, 0x1A, 0xA0, 0x60, 0x00, 0x00, 0x7C,
  0x13, 0xDC, 0xF3, 0x00, 0x27, 0xDC, 0xFA, 0x00, 0x1A, 0x80, 0xF7, 0x20,
  0x12, 0xDC, 0x70, 0x15, 0x40, 0x11, 0x6C, 0x78, 0xBB, 0xD0, 0x37, 0x00,
  0xF7, 0x00, 0xF7, 0x40, 0xF7, 0x20, 0xA8, 0x9C, 0x2A, 0xB6, 0x00, 0xA8,
  0x00, 0x9E, 0x20, 0x4B, 0x00, 0xC9, 0x40, 0x4A, 0x00, 0x16, 0x80, 0x78,
  0x10, 0xA0, 0xE0,
};

const GFXglyph RobotoCondensed_Italic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 2, 2, 1, -5 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 6, 3, 0, -5 },
  { 8, 2, 4, 4, 1, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 2, 1, 0, -5 },
  { 12, 2, 6, 2, 0, -5 },
  { 14, 2, 6, 2, 0, -5 },
  { 16, 3, 2, 3, 0, -4 },
  { 17, 3, 4, 3, 0, -4 },
  { 19, 1, 2, 1, 0, -1 },
  { 20, 1, 1, 1, 0, -2 },
  { 21, 1, 1, 2, 0, -1 },
  { 22, 2, 4, 2, 0, -4 },
  { 23, 3, 4, 3, 0, -4 },
  { 25, 1, 4, 3, 1, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 1, 3, 1, 0, -3 },
  { 43, 1, 4, 1, 0, -3 },
  { 44, 2, 2, 3, 0, -3 },
  { 45, 3, 2, 3, 0, -3 },
  { 46, 3, 2, 3, 0, -3 },
  { 47, 2, 4, 2, 0, -4 },
  { 48, 4, 5, 4, 0, -4 },
  { 51, 3, 4, 3, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 3, 4, 3, 0, -4 },
  { 61, 3, 4, 3, 0, -4 },
  { 63, 3, 4, 3, 0, -4 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 1, 4, 1, 0, -4 },
  { 68, 3, 4, 3, 0, -4 },
  { 70, 4, 4, 3, 0, -4 },
  { 72, 2, 4, 3, 0, -4 },
  { 73, 4, 4, 4, 0, -4 },
  { 75, 4, 4, 4, 0, -4 },
  { 77, 3, 4, 4, 0, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 3, 5, 4, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 2, 4, 3, 1, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 3, 4, 3, 1, -4 },
  { 92, 4, 4, 4, 1, -4 },
  { 94, 3, 4, 3, 0, -4 },
  { 96, 2, 4, 3, 1, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 2, 6, 1, 0, -5 },
  { 101, 1, 4, 2, 1, -4 },
  { 102, 2, 6, 1, 0, -5 },
  { 104, 2, 2, 2, 0, -4 },
  { 105, 2, 1, 2, 0, 0 },
  { 106, 1, 1, 2, 1, -5 },
  { 107, 2, 3, 3, 0, -3 },
  { 108, 3, 5, 3, 0, -5 },
  { 110, 3, 3, 3, 0, -3 },
  { 112, 3, 5, 3, 0, -5 },
  { 114, 3, 3, 3, 0, -3 },
  { 116, 2, 5, 2, 0, -5 },
  { 118, 3, 4, 3, 0, -3 },
  { 120, 3, 5, 3, 0, -5 },
  { 122, 1, 4, 1, 0, -4 },
  { 123, 2, 5, 1, -1, -4 },
  { 125, 3, 5, 3, 0, -5 },
  { 127, 1, 5, 1, 0, -5 },
  { 128, 4, 3, 4, 0, -3 },
  { 130, 3, 3, 3, 0, -3 },
  { 132, 3, 3, 3, 0, -3 },
  { 134, 3, 4, 3, 0, -3 },
  { 136, 3, 4, 3, 0, -3 },
  { 138, 2, 3, 2, 0, -3 },
  { 139, 2, 3, 3, 0, -3 },
  { 140, 2, 4, 2, 0, -4 },
  { 141, 3, 3, 3, 0, -3 },
  { 143, 3, 3, 2, 0, -3 },
  { 145, 4, 3, 4, 0, -3 },
  { 147, 3, 3, 3, 0, -3 },
  { 149, 3, 4, 2, 0, -3 },
  { 151, 3, 3, 3, 0, -3 },
  { 153, 2, 6, 2, 0, -5 },
  { 155, 1, 5, 1, 0, -4 },
  { 156, 2, 6, 2, 0, -5 },
  { 158, 3, 1, 3, 0, -2 },
};

const GFXfont RobotoCondensed_Italic6pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic6pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _ROBOTOCONDENSED_ITALIC6PT7B_H_
