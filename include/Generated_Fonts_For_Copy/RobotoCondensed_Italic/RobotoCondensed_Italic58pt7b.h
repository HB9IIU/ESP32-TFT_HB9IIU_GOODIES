#ifndef _ROBOTOCONDENSED_ITALIC58PT7B_H_
#define _ROBOTOCONDENSED_ITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x02, 0x00, 0x3C, 0x79, 0xE3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87,
  0xBC, 0x79, 0xE3, 0xCE, 0x1E, 0x70, 0xF7, 0x87, 0x3C, 0x39, 0xC3, 0xCE,
  0x1E, 0x70, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x80, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x07,
  0x80, 0xE3, 0xC0, 0xF0, 0x3C, 0x70, 0x1E, 0x07, 0x8E, 0x03, 0xC1, 0xE1,
  0xC0, 0x78, 0x78, 0x78, 0x0E, 0x0F, 0x0F, 0x01, 0xC3, 0xC0, 0xE0, 0x78,
  0xF0, 0x1E, 0x0F, 0x1E, 0x03, 0xC3, 0xC7, 0x80, 0x3F, 0xF9, 0xE0, 0x07,
  0xFE, 0x78, 0x00, 0x7F, 0x0F, 0x00, 0x01, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x7F, 0x00, 0x0F, 0x1F, 0xF0, 0x03, 0xC7, 0xFF, 0x00, 0x79, 0xF1,
  0xE0, 0x1E, 0x3C, 0x1E, 0x07, 0x8F, 0x03, 0xC1, 0xE1, 0xE0, 0x78, 0x3C,
  0x3C, 0x0F, 0x0F, 0x07, 0x01, 0xE3, 0xC0, 0xE0, 0x3C, 0x78, 0x1C, 0x07,
  0x9E, 0x03, 0x80, 0xE7, 0x80, 0x70, 0x3C, 0x70, 0x0F, 0x07, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x1F, 0x00,
  0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F,
  0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x0F, 0x1F, 0x9F,
  0x03, 0xCF, 0xC7, 0xE1, 0xF7, 0xE0, 0xF8, 0x7D, 0xF0, 0x3F, 0x1E, 0xFC,
  0x07, 0xCF, 0xBE, 0x01, 0xFB, 0xEF, 0x80, 0x3E, 0xF3, 0xE0, 0x0F, 0xFC,
  0xF8, 0x01, 0xFE, 0x3E, 0x00, 0x7F, 0x8F, 0x80, 0x0F, 0xC3, 0xE0, 0x03,
  0xF0, 0x7C, 0x01, 0xFC, 0x1F, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x7C, 0x0F, 0xFF, 0x9F, 0x81, 0xFF, 0x83, 0xE0, 0x04, 0x00, 0x00,
  0x3C, 0xF3, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xCF, 0x3C, 0xF3, 0xC0, 0x00,
  0x00, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x18, 0x1E, 0x06, 0x7E, 0x3C, 0x7C,
  0xFF, 0x7F, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xDE, 0x00, 0x1F,
  0x3E, 0x00, 0x7C, 0x3C, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0x78, 0x07, 0x80,
  0xF8, 0x06, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x87, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x38, 0xF9, 0xFF, 0xF7, 0xEF, 0x84, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF0, 0x00, 0xF3, 0xE0, 0x03,
  0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x3E,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xCF,
  0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x78, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0xC1, 0xF8,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x03, 0xF0, 0x3F, 0xE1, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFF, 0x7F, 0x3E, 0xF0, 0x79, 0x81, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xC1, 0xF8, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07,
  0xF0, 0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x03, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x0F, 0xC0, 0x1E, 0x03, 0xE0, 0x0F, 0x81, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07,
  0xE0, 0x7E, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE3, 0xF0,
  0x0F, 0xBF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0x1F,
  0xE0, 0x7E, 0x7F, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00,
  0x1E, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1E,
  0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0x78,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x80, 0xF8, 0x3E, 0x0F,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x3E, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x1F,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x07, 0x80, 0x3E,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x03, 0xF1, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xC3, 0xF0,
  0x1F, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x78,
  0x7C, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F,
  0x0F, 0xC1, 0xF0, 0x1F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xE7, 0xC0, 0x07, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xF7,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x01, 0xF9, 0xF0, 0x0F, 0xE7, 0xE0, 0x7F,
  0x8F, 0xE7, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0x9F, 0x00,
  0xFC, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x01, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x00,
  0x00, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00,
  0x38, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0xF8,
  0x01, 0xC0, 0xF0, 0x07, 0xFC, 0x03, 0x81, 0xE0, 0x1F, 0xFE, 0x07, 0x07,
  0x80, 0x7F, 0xFC, 0x0F, 0x0F, 0x01, 0xF0, 0x78, 0x1E, 0x3C, 0x07, 0xC0,
  0xF0, 0x3C, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0xE0, 0x3C, 0x07, 0x80, 0xF3,
  0xC0, 0x78, 0x0F, 0x01, 0xE7, 0x81, 0xE0, 0x1E, 0x03, 0xCE, 0x03, 0xC0,
  0x3C, 0x07, 0xBC, 0x07, 0x80, 0xF0, 0x0F, 0x78, 0x1E, 0x01, 0xE0, 0x1C,
  0xF0, 0x3C, 0x03, 0xC0, 0x39, 0xC0, 0x78, 0x07, 0x80, 0x77, 0x80, 0xF0,
  0x0F, 0x00, 0xEF, 0x03, 0xE0, 0x3C, 0x03, 0xDE, 0x07, 0x80, 0x78, 0x07,
  0x3C, 0x0F, 0x00, 0xF0, 0x0E, 0x78, 0x1E, 0x01, 0xE0, 0x1C, 0xF0, 0x3C,
  0x07, 0x80, 0x79, 0xE0, 0x78, 0x0F, 0x00, 0xE3, 0xC0, 0xF0, 0x3E, 0x03,
  0xC7, 0x81, 0xE0, 0x7C, 0x07, 0x0F, 0x03, 0xE1, 0xF8, 0x1E, 0x1E, 0x07,
  0xFF, 0x78, 0x78, 0x3C, 0x07, 0xFC, 0xFF, 0xE0, 0x78, 0x0F, 0xF8, 0xFF,
  0x80, 0xF0, 0x0F, 0xC1, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x02, 0x00, 0x00, 0x1F, 0x80, 0x1C,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xF3,
  0xFF, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7E,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x07, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xC0,
  0x07, 0xE0, 0x7C, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00,
  0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xC0,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0x7F, 0xFC, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00,
  0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3E,
  0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0xC0, 0xF8, 0x01, 0xFC, 0x07, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x0F, 0xFF, 0x8F, 0x80, 0x7F, 0xFC, 0x7C, 0x03, 0xFF,
  0xE7, 0xE0, 0x1F, 0xFE, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x80,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x7C, 0x00,
  0x3F, 0x80, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x3F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0xE0,
  0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0xC0, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xEF, 0xC0, 0x00, 0x1F, 0xE3, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x80,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xEF, 0x00, 0x01, 0xFF, 0x80,
  0xF7, 0x80, 0x00, 0xFF, 0xC0, 0x7B, 0xE0, 0x00, 0xFB, 0xC0, 0x7D, 0xF0,
  0x00, 0x7F, 0xE0, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x1F, 0x7C, 0x00, 0x3E,
  0xF8, 0x0F, 0x9E, 0x00, 0x3E, 0x7C, 0x07, 0x8F, 0x00, 0x1F, 0x3E, 0x07,
  0xC7, 0x80, 0x1F, 0x3E, 0x03, 0xE3, 0xC0, 0x0F, 0x9F, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x1E, 0x03, 0xE3, 0xE0, 0x3E, 0x0F, 0x03, 0xE1, 0xF0, 0x1F,
  0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x07, 0xC1, 0xF0,
  0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0xF8, 0x1F, 0x01, 0xF0, 0x3C, 0x7C, 0x1F,
  0x01, 0xF0, 0x1E, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0xBE, 0x03, 0xE0, 0x3E, 0x03, 0xDF, 0x01, 0xF0, 0x1F, 0x01, 0xFF,
  0x01, 0xF8, 0x1F, 0x80, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0x3F, 0x80, 0x7C,
  0x07, 0xC0, 0x1F, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x0F,
  0x80, 0x7F, 0x00, 0x03, 0xE0, 0x3F, 0xE0, 0x00, 0xF8, 0x0F, 0xF8, 0x00,
  0x7C, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x3F, 0xF0,
  0x01, 0xF0, 0x1F, 0xBC, 0x00, 0x7C, 0x07, 0xCF, 0x80, 0x3F, 0x01, 0xF3,
  0xE0, 0x0F, 0x80, 0x7C, 0x78, 0x03, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x03, 0xF0, 0xF0, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xC0,
  0x3E, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x1F,
  0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x7E, 0x03, 0xC1, 0xF0, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xC0, 0x3E, 0x3E, 0x01, 0xF0, 0x07, 0x8F, 0x80, 0x7C, 0x01,
  0xF3, 0xE0, 0x1F, 0x00, 0x7C, 0xF8, 0x0F, 0x80, 0x0F, 0x7E, 0x03, 0xE0,
  0x03, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x1F, 0xF0, 0x0F,
  0x80, 0x07, 0xFC, 0x07, 0xE0, 0x01, 0xFF, 0x01, 0xF0, 0x00, 0x3F, 0xC0,
  0x7C, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xF0, 0xFF, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0,
  0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x01,
  0xFC, 0x0F, 0x80, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00,
  0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x1F,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xC0,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0E, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0x3F, 0xFE,
  0x00, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03,
  0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0,
  0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03,
  0xE0, 0x07, 0xF0, 0x1F, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F,
  0x80, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x03, 0xF8, 0x1F, 0xE0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0,
  0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0xFC, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00,
  0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x78, 0x3E,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xF7, 0xC0,
  0x07, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x80,
  0x1F, 0x3E, 0x00, 0x7F, 0x00, 0x3E, 0x7C, 0x00, 0xFE, 0x00, 0x7C, 0xF8,
  0x03, 0xFC, 0x01, 0xF1, 0xF0, 0x07, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0xF0,
  0x07, 0xC7, 0xC0, 0x3D, 0xE0, 0x1F, 0x0F, 0x80, 0x7B, 0xC0, 0x3E, 0x1F,
  0x01, 0xF7, 0x80, 0x7C, 0x3E, 0x03, 0xC7, 0x01, 0xF0, 0x7C, 0x07, 0x8F,
  0x03, 0xE0, 0xF8, 0x1E, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x3C, 0x1F, 0x03,
  0xE0, 0xF8, 0x78, 0x3E, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x07, 0x83, 0xC1,
  0xE1, 0xF0, 0x0F, 0x0F, 0x03, 0xC3, 0xE0, 0x1E, 0x1E, 0x07, 0x87, 0x80,
  0x3C, 0x7C, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0,
  0x3C, 0x78, 0x01, 0xE7, 0xC0, 0x79, 0xF0, 0x03, 0xCF, 0x00, 0xF3, 0xE0,
  0x07, 0x9E, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x01, 0xDF, 0x00, 0x1E, 0xF0,
  0x03, 0xBE, 0x00, 0x3F, 0xE0, 0x07, 0x78, 0x00, 0x7F, 0x80, 0x0E, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x03,
  0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x01, 0xF0, 0x00, 0xF8, 0x3F, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0x7C,
  0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0x3C, 0x0F, 0x03,
  0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xB8, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0,
  0x1F, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF0, 0xF0, 0x7C, 0x1E, 0x1E,
  0x07, 0x8F, 0x81, 0xE3, 0xC0, 0x79, 0xF0, 0x1E, 0x78, 0x07, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC,
  0x0F, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x80, 0xF8,
  0xFC, 0x01, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0,
  0x0F, 0xC3, 0xF0, 0x7F, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0x7C, 0x07, 0xF8, 0xF8, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xCF,
  0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0,
  0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7E, 0x00,
  0xFC, 0x7F, 0x00, 0xF8, 0xFF, 0x83, 0xF8, 0xFB, 0xFF, 0xF0, 0xFB, 0xFF,
  0xE0, 0xF9, 0xFF, 0xC0, 0xF0, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x81, 0xF8, 0x1F, 0x07, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3C,
  0x7C, 0x00, 0x79, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x78, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0x3F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x80, 0xF8, 0x01, 0xFE, 0x3E, 0x00, 0xFF, 0xE7, 0xC0,
  0x3F, 0xFE, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xF8, 0x1F, 0xE0, 0x7E, 0x01,
  0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x0F,
  0x81, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80,
  0x0F, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x7F, 0x80,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0x80, 0x07, 0xFC,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xE1, 0xF8, 0x07,
  0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xDF,
  0x00, 0x0F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x01, 0x07, 0xC0, 0x1E, 0x1F, 0x80, 0xF8, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x07, 0xF8, 0x78, 0x03, 0xFF, 0x8F, 0x00, 0xFF, 0xFB,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0x81, 0xF8, 0x07, 0xF0, 0x3E,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07,
  0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC1, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xDF, 0x00, 0x1F, 0xF7, 0xC0, 0x00,
  0x20, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x40, 0x07, 0xE0, 0x1E, 0x01, 0xF8, 0x07, 0xF0,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x08, 0x00, 0xF9, 0xFE, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xE0, 0xFC, 0x3F, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF0, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x78, 0xF8,
  0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x80, 0x00,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x09, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0x80,
  0xFC, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0xFC, 0x01, 0xF0,
  0xFC, 0x00, 0xF8, 0xFC, 0x00, 0x78, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x3E,
  0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x02, 0x00, 0x1F, 0x3F,
  0xC0, 0xFF, 0x80, 0x7B, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xFF, 0x3F, 0xFE,
  0x0F, 0xFF, 0xFD, 0xFF, 0xF8, 0x3F, 0x81, 0xFF, 0x83, 0xF0, 0xFC, 0x07,
  0xFC, 0x07, 0xC3, 0xE0, 0x0F, 0xE0, 0x1F, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x3C, 0x00, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x01, 0xF1,
  0xF0, 0x03, 0xE0, 0x07, 0xC7, 0x80, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0xF0, 0x03, 0xE0,
  0x03, 0xC7, 0xC0, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x80,
  0x1F, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0xF8, 0x01, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x80, 0x0F, 0x9F, 0xE0, 0x1E, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x1F,
  0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x00, 0x04, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xE0, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x3E, 0x07, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0xFF, 0x00, 0x1E, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFF, 0x03, 0xF8, 0x3E, 0xFF, 0xFC, 0x0F, 0xBF,
  0xFE, 0x03, 0xE7, 0xFF, 0x00, 0xF8, 0xFF, 0x80, 0x3E, 0x06, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0x0F, 0x03, 0xFF, 0x8F, 0x07, 0xFF, 0xDF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xC0, 0xFF, 0x1F, 0x80, 0x7F, 0x3F, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFB, 0xE0, 0x00,
  0x83, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xEF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFC, 0x1F,
  0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x78, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F,
  0xC3, 0xF0, 0x3F, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFB, 0xFF, 0xF0, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0x01,
  0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C,
  0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xF3, 0xE0, 0x01, 0x00, 0x00, 0x78, 0x00, 0x7D, 0xE0,
  0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x3C, 0x07, 0xC0, 0xF0, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x3E, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0xC0,
  0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xBE, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x00, 0xFB, 0xE0,
  0x1F, 0x80, 0x7C, 0xF8, 0x07, 0xE0, 0x1F, 0x3E, 0x03, 0xF8, 0x07, 0x8F,
  0x80, 0xFE, 0x03, 0xE3, 0xE0, 0x7F, 0x80, 0xF8, 0xF8, 0x1F, 0xE0, 0x7C,
  0x3E, 0x07, 0xF8, 0x1F, 0x0F, 0x83, 0xDE, 0x07, 0x81, 0xE0, 0xF7, 0x83,
  0xE0, 0x78, 0x7D, 0xF0, 0xF8, 0x1E, 0x1E, 0x3C, 0x3C, 0x07, 0x8F, 0x8F,
  0x1F, 0x01, 0xE3, 0xC3, 0xC7, 0x80, 0x78, 0xF0, 0xF3, 0xE0, 0x1E, 0x78,
  0x3C, 0xF0, 0x07, 0x9E, 0x0F, 0x3C, 0x01, 0xEF, 0x83, 0xDF, 0x00, 0x7B,
  0xC0, 0xF7, 0x80, 0x1F, 0xF0, 0x3D, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x01,
  0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x03, 0xC3, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x7E, 0x3C,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x0F,
  0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80,
  0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3C, 0x0F,
  0xC0, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x0F,
  0x7C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x0E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x3C, 0x7F, 0xF0, 0x07, 0x9F, 0xFF, 0x00, 0xF7, 0xFF, 0xF0, 0x3E,
  0xF8, 0x7F, 0x0F, 0x9E, 0x07, 0xFF, 0xF7, 0xC0, 0x7F, 0xFC, 0xF0, 0x07,
  0xFF, 0x1E, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_Italic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 12, 42, 14, 2, -41 },
  { 64, 13, 14, 18, 6, -44 },
  { 87, 29, 41, 31, 3, -41 },
  { 236, 24, 54, 28, 2, -48 },
  { 398, 27, 43, 36, 5, -42 },
  { 544, 26, 43, 31, 2, -42 },
  { 684, 6, 14, 10, 5, -44 },
  { 695, 17, 60, 18, 3, -47 },
  { 823, 18, 60, 18, -3, -47 },
  { 958, 23, 24, 24, 3, -41 },
  { 1027, 24, 30, 28, 2, -34 },
  { 1117, 10, 14, 11, -3, -6 },
  { 1135, 12, 4, 14, 1, -19 },
  { 1141, 7, 7, 15, 1, -6 },
  { 1148, 26, 45, 21, -3, -41 },
  { 1295, 23, 43, 28, 3, -42 },
  { 1419, 15, 41, 28, 7, -41 },
  { 1496, 25, 42, 28, 1, -42 },
  { 1628, 24, 43, 28, 2, -42 },
  { 1757, 26, 41, 28, 0, -41 },
  { 1891, 25, 42, 28, 3, -41 },
  { 2023, 22, 42, 28, 3, -41 },
  { 2139, 25, 41, 28, 4, -41 },
  { 2268, 24, 43, 28, 2, -42 },
  { 2397, 22, 42, 28, 4, -42 },
  { 2513, 11, 32, 13, 1, -31 },
  { 2557, 14, 39, 12, -3, -31 },
  { 2626, 21, 25, 25, 2, -31 },
  { 2692, 22, 17, 27, 3, -28 },
  { 2739, 22, 26, 26, 2, -31 },
  { 2811, 19, 43, 24, 5, -42 },
  { 2914, 39, 54, 43, 2, -41 },
  { 3178, 30, 41, 32, -2, -41 },
  { 3332, 28, 41, 31, 1, -41 },
  { 3476, 29, 43, 32, 3, -42 },
  { 3632, 29, 41, 32, 1, -41 },
  { 3781, 29, 41, 28, 1, -41 },
  { 3930, 28, 41, 27, 1, -41 },
  { 4074, 29, 43, 33, 3, -42 },
  { 4230, 34, 41, 35, 1, -41 },
  { 4405, 12, 41, 14, 2, -41 },
  { 4467, 27, 42, 27, 0, -41 },
  { 4609, 33, 41, 31, 1, -41 },
  { 4779, 22, 41, 27, 1, -41 },
  { 4892, 41, 41, 43, 1, -41 },
  { 5103, 34, 41, 35, 1, -41 },
  { 5278, 29, 43, 34, 3, -42 },
  { 5434, 30, 41, 31, 1, -41 },
  { 5588, 29, 49, 34, 3, -42 },
  { 5766, 29, 41, 30, 1, -41 },
  { 5915, 28, 43, 29, 1, -42 },
  { 6066, 27, 41, 29, 5, -41 },
  { 6205, 30, 42, 32, 2, -41 },
  { 6363, 29, 41, 32, 5, -41 },
  { 6512, 39, 41, 43, 6, -41 },
  { 6712, 34, 41, 31, -1, -41 },
  { 6887, 28, 41, 30, 5, -41 },
  { 7031, 31, 41, 29, 0, -41 },
  { 7190, 18, 56, 14, 0, -47 },
  { 7316, 10, 45, 21, 6, -41 },
  { 7373, 18, 56, 14, -3, -47 },
  { 7499, 18, 21, 21, 2, -41 },
  { 7547, 22, 4, 23, -3, 0 },
  { 7558, 10, 8, 17, 6, -43 },
  { 7568, 23, 33, 27, 1, -32 },
  { 7663, 24, 45, 28, 1, -44 },
  { 7798, 23, 33, 26, 2, -32 },
  { 7893, 27, 45, 28, 2, -44 },
  { 8045, 22, 33, 26, 2, -32 },
  { 8136, 19, 45, 18, 3, -45 },
  { 8243, 27, 44, 28, 0, -32 },
  { 8392, 23, 44, 27, 1, -44 },
  { 8519, 12, 42, 13, 1, -42 },
  { 8582, 19, 54, 13, -6, -42 },
  { 8711, 25, 44, 25, 1, -44 },
  { 8849, 13, 44, 13, 1, -44 },
  { 8921, 38, 32, 42, 1, -32 },
  { 9073, 23, 32, 27, 1, -32 },
  { 9165, 24, 33, 28, 2, -32 },
  { 9264, 26, 44, 28, -1, -32 },
  { 9407, 24, 44, 28, 2, -32 },
  { 9539, 17, 32, 17, 1, -32 },
  { 9607, 23, 33, 26, 1, -32 },
  { 9702, 15, 39, 17, 2, -38 },
  { 9776, 24, 32, 27, 2, -31 },
  { 9872, 22, 31, 24, 3, -31 },
  { 9958, 34, 31, 37, 4, -31 },
  { 10090, 26, 31, 25, -1, -31 },
  { 10191, 27, 43, 23, -2, -31 },
  { 10337, 24, 31, 25, 0, -31 },
  { 10430, 18, 55, 17, 2, -45 },
  { 10554, 12, 49, 14, 1, -41 },
  { 10628, 19, 55, 17, -3, -45 },
  { 10759, 27, 11, 33, 3, -22 },
};

const GFXfont RobotoCondensed_Italic58pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic58pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic58pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _ROBOTOCONDENSED_ITALIC58PT7B_H_
