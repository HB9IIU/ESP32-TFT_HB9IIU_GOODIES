#ifndef _ROBOTOCONDENSED_ITALIC47PT7B_H_
#define _ROBOTOCONDENSED_ITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x1E, 0x0F, 0x81, 0xE0, 0x70, 0x00, 0x71, 0xEE, 0x39, 0xC7, 0x38,
  0xE7, 0x1D, 0xE7, 0xB8, 0xE7, 0x1C, 0xE3, 0x9C, 0x73, 0x0C, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x70, 0x70, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x00, 0xE1, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC1, 0xC0, 0x01,
  0xC3, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x83, 0x80, 0x03, 0x87, 0x80, 0x03,
  0x87, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0E,
  0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x3C, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x78,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0,
  0xF0, 0x7C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xCF, 0x00, 0x79, 0xE0,
  0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x0F, 0x03, 0xE1, 0xFF,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x03,
  0xFE, 0x00, 0x0E, 0x3C, 0x00, 0x70, 0x70, 0x31, 0xC1, 0xC1, 0xE7, 0x07,
  0x07, 0x1C, 0x1C, 0x38, 0xE0, 0x71, 0xE3, 0x81, 0xC7, 0x0E, 0x07, 0x38,
  0x1C, 0x39, 0xC0, 0x71, 0xEF, 0x01, 0xFF, 0x38, 0x03, 0xF9, 0xC0, 0x07,
  0xCF, 0x00, 0x00, 0x38, 0x00, 0x01, 0xCF, 0x80, 0x0E, 0x7F, 0x00, 0x7B,
  0xFE, 0x01, 0xDE, 0x38, 0x0E, 0x70, 0x70, 0x71, 0xC1, 0xC1, 0xCE, 0x07,
  0x0E, 0x38, 0x1C, 0x70, 0xE0, 0x73, 0xC3, 0x81, 0xCE, 0x0E, 0x0E, 0x70,
  0x38, 0x38, 0x00, 0x71, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x03, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07,
  0x81, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xDF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xE0, 0xF1, 0xF7, 0xC3, 0xCF, 0x8F, 0x0E, 0x3C, 0x3E, 0x39, 0xF0,
  0x79, 0xE7, 0x81, 0xF7, 0x1E, 0x03, 0xFC, 0x78, 0x0F, 0xF1, 0xE0, 0x1F,
  0x87, 0x80, 0x7C, 0x1E, 0x00, 0xF0, 0x7C, 0x0F, 0xE0, 0xFC, 0xFF, 0x83,
  0xFF, 0xFF, 0x03, 0xFF, 0x3C, 0x07, 0xF0, 0xF8, 0x3B, 0xDE, 0xE7, 0x39,
  0xDE, 0xE7, 0x38, 0x00, 0x04, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0x80, 0x02, 0x00, 0x01, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x38, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x40, 0xE0, 0x1E, 0x1C, 0x7B,
  0xFF, 0x7F, 0x7F, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x1E, 0xF0, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x7C, 0x1E, 0x07,
  0x03, 0x80, 0x00, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E,
  0x3E, 0x3C, 0x78, 0x70, 0x20, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF, 0xF7,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xF7, 0xE0, 0xF8, 0x3E,
  0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x3C,
  0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDE, 0x00, 0x7B,
  0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7,
  0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E,
  0x00, 0xE1, 0xC0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0xFC, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x30, 0x1E, 0x07, 0xE3,
  0xFE, 0xFF, 0xEF, 0xFE, 0xF1, 0xEC, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xF7, 0xE0, 0x3C, 0x0F, 0x83, 0xC0,
  0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0x7E, 0x07, 0x81,
  0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF8, 0x07, 0x87, 0x80, 0xF8, 0x7C, 0x1F,
  0x03, 0xF7, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00, 0x1D, 0xE0, 0x01,
  0xEF, 0x00, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0xC0,
  0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0xF8, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xE1, 0xF0, 0x0C, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0x80, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x1F, 0x07, 0xC1, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x7F, 0xE0, 0x7E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xBF, 0x07, 0xBF, 0xC3, 0xFF, 0xF1, 0xFF,
  0xFC, 0xF8, 0x1E, 0xF8, 0x0F, 0x7C, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0x78, 0x07,
  0xBC, 0x03, 0xDE, 0x03, 0xC7, 0x83, 0xE3, 0xF7, 0xE0, 0xFF, 0xE0, 0x3F,
  0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x3E, 0x1E, 0x03, 0xC3, 0xC0, 0x78,
  0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF0,
  0xE0, 0x3C, 0x1E, 0x0F, 0x81, 0xF7, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0xC0, 0xF8, 0x7C, 0x3E, 0x07, 0x87, 0x80, 0x79, 0xE0, 0x0F, 0x3C,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x81, 0xF0, 0xFD, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x1E,
  0x0F, 0x8F, 0x01, 0xE3, 0xC0, 0x79, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00,
  0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x70, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x79,
  0xE0, 0x1E, 0x78, 0x0F, 0x9F, 0x07, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFF, 0x01, 0xF3, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x07, 0xC3, 0xE1, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x01, 0xC0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0x81, 0xF0, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00,
  0x80, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x07, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF7, 0xC3, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x06, 0x07, 0x00, 0xF8, 0x07, 0x0F, 0x01, 0xFE,
  0x07, 0x0E, 0x03, 0xFF, 0x07, 0x0E, 0x07, 0x87, 0x07, 0x1C, 0x0F, 0x07,
  0x07, 0x1C, 0x1E, 0x07, 0x07, 0x3C, 0x1C, 0x0E, 0x07, 0x38, 0x1C, 0x0E,
  0x07, 0x38, 0x3C, 0x0E, 0x07, 0x38, 0x38, 0x0E, 0x07, 0x70, 0x38, 0x1C,
  0x07, 0x70, 0x78, 0x1C, 0x06, 0x70, 0x78, 0x1C, 0x0E, 0x70, 0x70, 0x1C,
  0x0E, 0x70, 0x70, 0x3C, 0x0E, 0x70, 0x70, 0x38, 0x0C, 0x70, 0x70, 0x38,
  0x1C, 0x70, 0x70, 0x78, 0x18, 0x70, 0x70, 0xF8, 0x38, 0x70, 0x79, 0xF8,
  0x70, 0x70, 0x7F, 0xBF, 0xF0, 0x70, 0x3F, 0x1F, 0xE0, 0x70, 0x1E, 0x0F,
  0x80, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1,
  0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x07,
  0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x83, 0xC0, 0x1F,
  0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE0,
  0xF0, 0x07, 0x81, 0xE0, 0x1F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x78, 0x07, 0xC1, 0xF0, 0x07, 0x83, 0xC0,
  0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x3C, 0x00,
  0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x7E,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x3C, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x83,
  0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78,
  0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00,
  0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xF0, 0x01,
  0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0xF8, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x1F, 0x07,
  0x80, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E,
  0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x0F, 0xFC, 0x78, 0x0F, 0xFC, 0x78, 0x0F, 0xFC, 0x78, 0x0F, 0xFC,
  0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0xF8,
  0x3E, 0x03, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC1, 0xE0, 0x1F,
  0x07, 0x80, 0x78, 0x1E, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0xC0,
  0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x01, 0xE0, 0x3F, 0x00, 0x78, 0x1F, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x83,
  0xE0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x0F,
  0x3E, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x78,
  0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0xF0,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x03,
  0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0x70, 0x00, 0xFF,
  0x07, 0xB8, 0x00, 0xF7, 0x83, 0xDE, 0x00, 0x7B, 0xC1, 0xEF, 0x00, 0x7B,
  0xC0, 0xF7, 0x80, 0x3D, 0xE0, 0x73, 0xC0, 0x3C, 0xF0, 0x79, 0xE0, 0x1E,
  0x78, 0x3C, 0x70, 0x1E, 0x3C, 0x1E, 0x38, 0x0F, 0x3C, 0x0F, 0x1E, 0x0F,
  0x1E, 0x07, 0x8F, 0x07, 0x8F, 0x07, 0xC7, 0x87, 0x87, 0x83, 0xC3, 0xC3,
  0xC3, 0xC1, 0xE0, 0xE3, 0xC3, 0xE0, 0xF0, 0x71, 0xE1, 0xE0, 0x78, 0x39,
  0xE0, 0xF0, 0x3C, 0x1C, 0xF0, 0x78, 0x3E, 0x0F, 0xF0, 0x3C, 0x1E, 0x07,
  0xF8, 0x1E, 0x0F, 0x03, 0xF8, 0x1F, 0x07, 0x80, 0xFC, 0x0F, 0x03, 0xC0,
  0x7C, 0x07, 0x81, 0xE0, 0x3E, 0x03, 0xC1, 0xE0, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1F,
  0x80, 0x07, 0x83, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3C, 0x0F, 0xE0, 0x07,
  0x81, 0xFC, 0x00, 0xF0, 0x3F, 0x80, 0x1E, 0x0F, 0xF8, 0x03, 0xC1, 0xEF,
  0x00, 0xF0, 0x3C, 0xE0, 0x1E, 0x07, 0x9E, 0x03, 0xC0, 0xF3, 0xC0, 0x78,
  0x1E, 0x38, 0x0F, 0x07, 0x87, 0x83, 0xE0, 0xF0, 0xF0, 0x78, 0x1E, 0x0E,
  0x0F, 0x03, 0xC1, 0xE1, 0xE0, 0x78, 0x3C, 0x3C, 0x1F, 0x03, 0x87, 0x83,
  0xC0, 0x79, 0xF0, 0x78, 0x0F, 0x3C, 0x0F, 0x00, 0xE7, 0x81, 0xE0, 0x1E,
  0xF0, 0x3C, 0x03, 0xDE, 0x0F, 0x80, 0x3B, 0xC1, 0xE0, 0x07, 0xF0, 0x3C,
  0x00, 0xFE, 0x07, 0x80, 0x0F, 0xC0, 0xF0, 0x01, 0xF8, 0x1E, 0x00, 0x3F,
  0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x0F, 0x81, 0xF0,
  0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x07,
  0xDE, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0,
  0x07, 0x83, 0xC0, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0x80, 0x3E, 0x07, 0x80,
  0x1F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE0,
  0x7C, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00,
  0x1F, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x07,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x07,
  0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x00, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0xF8, 0x07, 0x81, 0xE0, 0x0F,
  0x03, 0xC0, 0x1F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7E, 0x07, 0xC0, 0xF0, 0x07, 0x83,
  0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0x83,
  0xC0, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C,
  0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x78, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8,
  0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x3C, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x3C, 0x07, 0x80,
  0x3C, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x0E, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x03, 0x80, 0x1F, 0xF0, 0x07,
  0x80, 0x1E, 0xF0, 0x07, 0xC0, 0x1E, 0xF0, 0x07, 0xC0, 0x3C, 0xF0, 0x0F,
  0xC0, 0x3C, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x1F, 0xC0, 0x78, 0xF0, 0x1F,
  0xC0, 0x78, 0xF0, 0x1D, 0xC0, 0x78, 0xF0, 0x3D, 0xC0, 0xF0, 0xF0, 0x39,
  0xC0, 0xF0, 0xF0, 0x39, 0xC0, 0xF0, 0xF0, 0x79, 0xC1, 0xE0, 0xF0, 0x71,
  0xC1, 0xE0, 0xF0, 0xF1, 0xC1, 0xE0, 0xF0, 0xF1, 0xC3, 0xC0, 0xF0, 0xE1,
  0xC3, 0xC0, 0xF1, 0xE1, 0xC3, 0x80, 0xF1, 0xC1, 0xE7, 0x80, 0xF3, 0xC1,
  0xE7, 0x80, 0xF3, 0xC1, 0xE7, 0x00, 0xF3, 0x80, 0xEF, 0x00, 0x77, 0x80,
  0xEF, 0x00, 0x77, 0x00, 0xEE, 0x00, 0x77, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00,
  0x3E, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80,
  0x0F, 0x01, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78,
  0x7C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xBC, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0xF9, 0xE0, 0x03, 0xE3, 0xC0,
  0x07, 0xC7, 0xC0, 0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF8, 0x1E, 0x01,
  0xE0, 0x3E, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF8,
  0x00, 0xE1, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xBC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x3F, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x00, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70,
  0x70, 0x78, 0x78, 0x78, 0x78, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x07, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xDC, 0x0F, 0x70, 0x39, 0xE1, 0xE3,
  0x87, 0x0E, 0x3C, 0x38, 0xE0, 0xE7, 0x83, 0x9C, 0x0F, 0xF0, 0x3C, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x1E,
  0x0F, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xF0,
  0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x7E, 0x0F, 0x1F, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x7C, 0x07,
  0x87, 0x83, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0x78, 0x0F, 0x8F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x3F, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0x83, 0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x00,
  0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x78, 0xFC, 0x0F, 0x8F, 0xFF, 0xF0, 0xF7, 0xFF, 0x0F,
  0x3F, 0xE0, 0xE1, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xF7, 0xE1, 0xF0, 0x3C, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F,
  0x3C, 0x01, 0xEF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x71,
  0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0xC0, 0xF0, 0x7E, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xFC, 0x78, 0x0F, 0xFB,
  0xC0, 0xFF, 0xDE, 0x0F, 0xFF, 0xF0, 0xF8, 0x1F, 0x87, 0x80, 0x7C, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C,
  0x78, 0x01, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80,
  0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83,
  0xE0, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0x70, 0x03, 0xE3,
  0x80, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xF7, 0xE1, 0xF0,
  0x3C, 0x3C, 0x07, 0x8F, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xEF, 0x00,
  0x3D, 0xE0, 0x07, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x01,
  0x07, 0xC0, 0x70, 0x7F, 0x7F, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x7F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00,
  0xFC, 0x38, 0x0F, 0xF9, 0xC0, 0xFF, 0xDE, 0x0F, 0xFF, 0xF0, 0xF8, 0x1F,
  0x87, 0x80, 0x7C, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xE0,
  0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00,
  0xF0, 0x78, 0x07, 0x83, 0xE0, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01,
  0xFF, 0x78, 0x03, 0xE7, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x10, 0x07, 0x81, 0xC0, 0x7C, 0x1F, 0xDF, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0xFC, 0x07, 0xFF, 0xC1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xE0, 0xF0, 0xF8, 0x1E, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C,
  0x03, 0xC7, 0x80, 0x78, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78, 0xF0,
  0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x7C, 0x1E,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xF0, 0xF0,
  0x3E, 0x0E, 0x07, 0xC1, 0xE0, 0xF8, 0x1E, 0x1F, 0x01, 0xE3, 0xE0, 0x1E,
  0x7C, 0x01, 0xE7, 0x80, 0x3C, 0xF8, 0x03, 0xDF, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7E, 0xF0, 0x07, 0xC7, 0x80,
  0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0xF0, 0x3E,
  0x0F, 0x01, 0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x03,
  0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x0F, 0x3E, 0x03, 0xF0, 0x1D,
  0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0,
  0x3F, 0x83, 0xE3, 0xC0, 0x7E, 0x07, 0xC7, 0x80, 0xF8, 0x07, 0x8F, 0x00,
  0xF0, 0x0F, 0x3C, 0x01, 0xE0, 0x1E, 0x78, 0x07, 0x80, 0x3C, 0xF0, 0x0F,
  0x00, 0xF1, 0xE0, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0x07, 0x9E, 0x00, 0xF0, 0x0F, 0x3C, 0x03, 0xC0, 0x1E, 0x78, 0x07, 0x80,
  0x78, 0xF0, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x01, 0xE3, 0x80, 0x3C, 0x03,
  0xCF, 0x00, 0x78, 0x07, 0x9E, 0x01, 0xE0, 0x0F, 0x3C, 0x03, 0xC0, 0x3C,
  0x78, 0x07, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x3F, 0x01, 0xDF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x3C, 0x3E, 0x07, 0x87, 0x80,
  0x78, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1E,
  0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xFE, 0x0F, 0xEF, 0xC1, 0xE0, 0x7C, 0x78, 0x07, 0x9F, 0x00,
  0xF3, 0xC0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03,
  0xDE, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xC7, 0x81, 0xF0, 0xFC, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0x8F, 0xC0, 0x0E,
  0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1E, 0x01,
  0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F,
  0x07, 0x80, 0x78, 0x3F, 0x03, 0xE0, 0xFF, 0x3F, 0x03, 0xDF, 0xFC, 0x0F,
  0x3F, 0xC0, 0x3C, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0xE0,
  0xFF, 0xBC, 0x3F, 0xF7, 0x8F, 0xFF, 0xF3, 0xE0, 0x7E, 0x78, 0x07, 0xDE,
  0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78,
  0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0,
  0x07, 0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x81, 0xF0, 0xFD,
  0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0x9E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x7C, 0x3B,
  0xF1, 0xFF, 0xC7, 0xFE, 0x1F, 0xC0, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x3C, 0x78, 0x1F, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x07,
  0xE0, 0x00, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0xFF,
  0xFF, 0xFE, 0xFF, 0xE0, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x1F,
  0x00, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xE3, 0xC0,
  0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F,
  0x8F, 0x83, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFE, 0xF0, 0x1F, 0x9E,
  0x00, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xE3,
  0x80, 0xF1, 0xC0, 0xF0, 0xE0, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x1E, 0x1E,
  0x0F, 0x1E, 0x03, 0x8F, 0x01, 0xC7, 0x00, 0xE7, 0x80, 0x73, 0x80, 0x3B,
  0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x0E, 0x01, 0xFE, 0x03,
  0xC0, 0x3F, 0xC0, 0x78, 0x0F, 0x78, 0x0F, 0x81, 0xEF, 0x03, 0xF0, 0x3D,
  0xE0, 0x7E, 0x0F, 0x3C, 0x1F, 0xC1, 0xE3, 0x83, 0xB8, 0x38, 0x70, 0xF7,
  0x0F, 0x0E, 0x1C, 0xE1, 0xE1, 0xC3, 0x9C, 0x78, 0x38, 0xF3, 0x8F, 0x07,
  0x1C, 0x71, 0xC0, 0xE7, 0x8E, 0x78, 0x1E, 0xE1, 0xCF, 0x03, 0xFC, 0x3D,
  0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF0,
  0x01, 0xC0, 0x1E, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x3C,
  0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x83, 0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xE0,
  0x07, 0x1E, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xDC, 0x00, 0x3C, 0xF0, 0x03, 0xE7, 0x80, 0x1E, 0x1C,
  0x01, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x80, 0xF0, 0xF8,
  0x07, 0x80, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0x78, 0x1E, 0x00, 0xF0, 0x78,
  0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x77, 0x80, 0x01, 0xDE,
  0x00, 0x07, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x1E,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0xF0,
  0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38,
  0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C,
  0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0F,
  0x07, 0x03, 0x80, 0x01, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x7E,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x38, 0xFF, 0xC0,
  0x71, 0xFF, 0xC0, 0xE7, 0x87, 0xC3, 0xCE, 0x07, 0xFF, 0x1C, 0x07, 0xFE,
  0x78, 0x07, 0xF8, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Italic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 33, 11, 1, -33 },
  { 43, 11, 11, 15, 5, -35 },
  { 59, 24, 33, 25, 2, -33 },
  { 158, 19, 42, 23, 2, -38 },
  { 258, 22, 33, 29, 4, -33 },
  { 349, 22, 33, 25, 1, -33 },
  { 440, 5, 11, 8, 4, -35 },
  { 447, 14, 49, 14, 2, -38 },
  { 533, 14, 49, 15, -2, -38 },
  { 619, 19, 19, 20, 2, -33 },
  { 665, 19, 25, 23, 2, -28 },
  { 725, 8, 12, 9, -3, -5 },
  { 737, 10, 3, 11, 1, -15 },
  { 741, 5, 5, 12, 1, -5 },
  { 745, 21, 36, 17, -2, -33 },
  { 840, 19, 33, 23, 2, -33 },
  { 919, 12, 33, 23, 6, -33 },
  { 969, 21, 33, 23, 0, -33 },
  { 1056, 20, 33, 23, 1, -33 },
  { 1139, 21, 33, 23, 0, -33 },
  { 1226, 21, 33, 23, 2, -33 },
  { 1313, 17, 33, 23, 3, -33 },
  { 1384, 21, 33, 23, 3, -33 },
  { 1471, 19, 33, 23, 2, -33 },
  { 1550, 18, 33, 23, 3, -33 },
  { 1625, 9, 25, 11, 1, -25 },
  { 1654, 11, 32, 9, -2, -25 },
  { 1698, 17, 20, 20, 2, -25 },
  { 1741, 18, 14, 22, 2, -23 },
  { 1773, 19, 21, 21, 1, -25 },
  { 1823, 15, 33, 19, 4, -33 },
  { 1885, 32, 43, 35, 1, -33 },
  { 2057, 25, 33, 26, -2, -33 },
  { 2161, 23, 33, 25, 1, -33 },
  { 2256, 24, 33, 26, 2, -33 },
  { 2355, 23, 33, 26, 1, -33 },
  { 2450, 23, 33, 23, 1, -33 },
  { 2545, 23, 33, 22, 1, -33 },
  { 2640, 24, 33, 27, 2, -33 },
  { 2739, 27, 33, 28, 1, -33 },
  { 2851, 10, 33, 11, 1, -33 },
  { 2893, 22, 33, 22, 0, -33 },
  { 2984, 26, 33, 25, 1, -33 },
  { 3092, 18, 33, 22, 1, -33 },
  { 3167, 33, 33, 34, 1, -33 },
  { 3304, 27, 33, 28, 1, -33 },
  { 3416, 23, 33, 27, 3, -33 },
  { 3511, 24, 33, 25, 1, -33 },
  { 3610, 24, 39, 27, 2, -33 },
  { 3727, 23, 33, 24, 1, -33 },
  { 3822, 23, 33, 24, 1, -33 },
  { 3917, 22, 33, 24, 4, -33 },
  { 4008, 24, 33, 26, 2, -33 },
  { 4107, 24, 33, 26, 4, -33 },
  { 4206, 32, 33, 35, 5, -33 },
  { 4338, 28, 33, 25, -1, -33 },
  { 4454, 23, 33, 24, 4, -33 },
  { 4549, 25, 33, 24, 0, -33 },
  { 4653, 14, 45, 11, 0, -38 },
  { 4732, 8, 36, 17, 5, -33 },
  { 4768, 15, 45, 11, -3, -38 },
  { 4853, 14, 17, 17, 2, -33 },
  { 4883, 18, 3, 18, -2, 0 },
  { 4890, 8, 7, 14, 5, -36 },
  { 4897, 19, 25, 22, 1, -25 },
  { 4957, 20, 35, 22, 1, -35 },
  { 5045, 19, 25, 21, 1, -25 },
  { 5105, 21, 35, 23, 2, -35 },
  { 5197, 19, 25, 21, 1, -25 },
  { 5257, 16, 35, 14, 2, -35 },
  { 5327, 21, 35, 22, 0, -25 },
  { 5419, 19, 35, 22, 1, -35 },
  { 5503, 10, 34, 10, 1, -34 },
  { 5546, 14, 44, 10, -4, -34 },
  { 5623, 20, 35, 21, 1, -35 },
  { 5711, 10, 35, 10, 1, -35 },
  { 5755, 31, 25, 34, 1, -25 },
  { 5852, 19, 25, 22, 1, -25 },
  { 5912, 19, 25, 23, 2, -25 },
  { 5972, 22, 35, 22, -1, -25 },
  { 6069, 19, 35, 23, 2, -25 },
  { 6153, 14, 25, 14, 1, -25 },
  { 6197, 18, 25, 21, 1, -25 },
  { 6254, 12, 31, 14, 2, -31 },
  { 6301, 19, 25, 22, 2, -25 },
  { 6361, 17, 25, 20, 3, -25 },
  { 6415, 27, 25, 30, 3, -25 },
  { 6500, 21, 25, 20, -1, -25 },
  { 6566, 22, 35, 19, -2, -25 },
  { 6663, 20, 25, 20, 0, -25 },
  { 6726, 15, 45, 14, 1, -37 },
  { 6811, 9, 39, 11, 1, -33 },
  { 6855, 15, 45, 14, -2, -37 },
  { 6940, 23, 9, 27, 2, -18 },
};

const GFXfont RobotoCondensed_Italic47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_ITALIC47PT7B_H_
