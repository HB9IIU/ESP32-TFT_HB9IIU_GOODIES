#ifndef _ROBOTOCONDENSED_ITALIC52PT7B_H_
#define _ROBOTOCONDENSED_ITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F,
  0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x83, 0xE0, 0xF0, 0x00,
  0x00, 0x3C, 0x73, 0x8F, 0x38, 0xF3, 0x8F, 0x78, 0xF7, 0x8E, 0x70, 0xE7,
  0x0E, 0x71, 0xE7, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xC0, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x07,
  0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00,
  0x1E, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0x80, 0x01, 0xC1,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x03,
  0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x1C, 0x01,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0,
  0xF0, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7E, 0x0F, 0x81, 0xF0, 0x1E, 0x0F, 0x80, 0x78, 0x3E, 0x01,
  0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xE1, 0xE0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x78, 0x70, 0x00, 0x70, 0x78, 0x08, 0xF0, 0x78, 0x1C, 0xE0, 0x78,
  0x3C, 0xE0, 0x78, 0x38, 0xE0, 0x78, 0x70, 0xE0, 0x70, 0xF0, 0xE0, 0x71,
  0xE0, 0xE0, 0xF1, 0xC0, 0xF0, 0xF3, 0xC0, 0x7F, 0xE7, 0x80, 0x7F, 0xC7,
  0x00, 0x3F, 0x8F, 0x00, 0x04, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF3, 0xF8, 0x01, 0xE7,
  0xFC, 0x01, 0xCF, 0xFE, 0x03, 0x8F, 0x0E, 0x07, 0x8E, 0x0E, 0x0F, 0x1E,
  0x0F, 0x0E, 0x1C, 0x0F, 0x1E, 0x1C, 0x0F, 0x3C, 0x1C, 0x0E, 0x38, 0x1C,
  0x0E, 0x78, 0x1C, 0x0E, 0x70, 0x1C, 0x1E, 0x20, 0x1E, 0x1C, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xF9,
  0xF8, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xC0,
  0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0xF8, 0x03, 0xC0, 0xF0, 0x03, 0xE1,
  0xF0, 0x03, 0xE3, 0xE0, 0x01, 0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFE, 0x0F, 0x1F, 0x1E, 0x0F, 0x3F, 0x1F, 0x0F, 0x3E, 0x0F,
  0x8F, 0x7C, 0x0F, 0x9E, 0x7C, 0x07, 0xDE, 0x78, 0x07, 0xDE, 0x78, 0x03,
  0xFC, 0x78, 0x03, 0xFC, 0x78, 0x01, 0xF8, 0x78, 0x01, 0xF0, 0x7C, 0x01,
  0xF8, 0x3E, 0x03, 0xF8, 0x3F, 0x9F, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0x3E, 0x07, 0xFC, 0x3E, 0x00, 0x40, 0x00, 0x3C, 0xF3, 0xCE, 0x39, 0xE7,
  0x9E, 0x71, 0xC7, 0x3C, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x60, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x01, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x40, 0x70, 0x17, 0x87, 0x0F,
  0xFE, 0x77, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0xF3, 0xC0, 0x1F, 0x3C, 0x03, 0xE3,
  0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xF0, 0x38, 0x0E, 0x01, 0x00, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E,
  0x3E, 0x1E, 0x0E, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0x79,
  0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xC0, 0x7E, 0x7E, 0x07, 0xC0, 0xF8, 0x3C, 0x03, 0xC3, 0xE0,
  0x1E, 0x1E, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x3E, 0x00, 0x79, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1E, 0x78,
  0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xE7, 0x80, 0x1F,
  0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0,
  0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0xC0, 0xF8, 0x1F, 0x9F, 0x80,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x01, 0xE0, 0x1F, 0x83, 0xFE, 0x3F, 0xF9, 0xFF, 0xE7, 0xEF, 0x3E,
  0x3C, 0xC0, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80,
  0x1E, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xF1, 0xF8,
  0x1F, 0x01, 0xE0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x3C, 0x3C,
  0x00, 0xF0, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0xF8, 0x7C, 0x03, 0xC1, 0xF0, 0x1F, 0x03, 0xF1, 0xF8, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xFC,
  0x00, 0x1E, 0xF8, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80,
  0x0F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x7C, 0x01, 0xE0, 0xF0, 0x07,
  0xC1, 0xE0, 0x1F, 0x03, 0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x79, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFE, 0x3F, 0x03, 0xE0,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3E, 0x01,
  0xE0, 0x7C, 0x0F, 0x81, 0xFC, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0xF8, 0x0F, 0x7F, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xE0,
  0xF9, 0xF8, 0x0F, 0x3E, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01,
  0xEF, 0x00, 0x3D, 0xF0, 0x0F, 0xBE, 0x01, 0xF3, 0xC0, 0x7C, 0x7C, 0x1F,
  0x87, 0xE7, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03,
  0xF3, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x83, 0xE0, 0x1E, 0x0F, 0x80,
  0x78, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0x78,
  0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x03, 0xE0, 0x7C, 0x07, 0xC3, 0xE0, 0x0F,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7C, 0x1F,
  0x03, 0xE0, 0x3C, 0x1F, 0x00, 0xF8, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F,
  0x80, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00,
  0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xF3, 0xF8,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xF9, 0xF8,
  0x3E, 0x0F, 0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xEF, 0x00, 0x7D,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xE0, 0x1F, 0x7C, 0x03, 0xE7,
  0x80, 0xFC, 0xF8, 0x3F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xF7, 0x80,
  0xF9, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F,
  0x07, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83,
  0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x7E, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x10,
  0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0x83, 0xE7, 0xC0,
  0xF9, 0xE0, 0x1E, 0x78, 0x07, 0xBE, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x0F, 0x80, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x3F, 0x00, 0xE0, 0xF0, 0x1F, 0xF0, 0x1C, 0x1C, 0x07,
  0xFF, 0x83, 0x87, 0x81, 0xF8, 0xF0, 0x30, 0xE0, 0x3C, 0x1E, 0x06, 0x3C,
  0x0F, 0x03, 0x80, 0xE7, 0x81, 0xC0, 0x70, 0x1C, 0xE0, 0x78, 0x1E, 0x03,
  0x3C, 0x0E, 0x03, 0xC0, 0xE7, 0x83, 0xC0, 0x78, 0x1C, 0xE0, 0x78, 0x0E,
  0x03, 0x9C, 0x0F, 0x03, 0xC0, 0x77, 0x83, 0xC0, 0x78, 0x0E, 0xF0, 0x78,
  0x0F, 0x01, 0xDE, 0x0F, 0x01, 0xC0, 0x7B, 0x81, 0xE0, 0x78, 0x0E, 0x70,
  0x3C, 0x0F, 0x01, 0xCE, 0x07, 0x01, 0xE0, 0x39, 0xC0, 0xE0, 0x78, 0x0E,
  0x38, 0x1E, 0x0F, 0x01, 0xC7, 0x03, 0xC3, 0xF0, 0x70, 0xE0, 0x7C, 0xFE,
  0x1E, 0x1C, 0x0F, 0xFB, 0xFF, 0x83, 0x80, 0xFF, 0x3F, 0xE0, 0x70, 0x1F,
  0x83, 0xF8, 0x0E, 0x00, 0x40, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x08,
  0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x1E, 0x00,
  0x3C, 0x03, 0xC0, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x7C, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F,
  0x00, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xF0, 0x0F, 0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF8,
  0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xC7, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xE0, 0x00,
  0x79, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0,
  0x7C, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03,
  0xC0, 0x7F, 0x00, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1E,
  0x07, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78,
  0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00,
  0xF8, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x07,
  0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x7C, 0x07, 0xF0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x3F, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xCF, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x7F, 0xF7, 0xC0, 0x3F, 0xFB, 0xE0, 0x3F, 0xF9, 0xF0, 0x1F, 0xFC, 0xF8,
  0x00, 0x1E, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x1F, 0x00, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x07,
  0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x7C, 0x0F, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xF8, 0x1F,
  0x00, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x0F, 0xC0,
  0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xE0, 0xFC, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x7E,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0xF0, 0x00, 0x0F,
  0xE7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x07, 0xC0,
  0x03, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x3D, 0xE0, 0x01, 0xFF, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x0F, 0x78,
  0x00, 0x7B, 0xC0, 0xFB, 0xC0, 0x07, 0x9E, 0x07, 0xDE, 0x00, 0x3D, 0xF0,
  0x3C, 0xF0, 0x03, 0xCF, 0x81, 0xE7, 0xC0, 0x1E, 0x78, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x07, 0xC7, 0x80, 0xF1, 0xF0, 0x3E,
  0x3C, 0x07, 0x8F, 0x81, 0xF1, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xC3,
  0xC0, 0x78, 0x38, 0x3C, 0x1E, 0x03, 0xC1, 0xE1, 0xE1, 0xF0, 0x3E, 0x0F,
  0x1E, 0x0F, 0x81, 0xF0, 0x78, 0xF0, 0x7C, 0x0F, 0x83, 0xCF, 0x03, 0xC0,
  0x78, 0x1E, 0x78, 0x1E, 0x03, 0xC0, 0xF7, 0x80, 0xF0, 0x1E, 0x03, 0xBC,
  0x0F, 0x81, 0xF0, 0x1F, 0xC0, 0x7C, 0x0F, 0x80, 0xFE, 0x03, 0xE0, 0x7C,
  0x07, 0xE0, 0x1E, 0x03, 0xC0, 0x3F, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x0F,
  0x81, 0xF0, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0x38, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x1F, 0x03, 0xF8, 0x00, 0x78, 0x0F, 0xE0, 0x01, 0xE0, 0x7F, 0x80,
  0x0F, 0x81, 0xFF, 0x00, 0x3E, 0x07, 0xFC, 0x00, 0xF8, 0x1F, 0xF0, 0x03,
  0xC0, 0x7B, 0xE0, 0x0F, 0x01, 0xE7, 0x80, 0x3C, 0x0F, 0x9E, 0x01, 0xF0,
  0x3E, 0x7C, 0x07, 0xC0, 0xF8, 0xF0, 0x1F, 0x03, 0xE3, 0xC0, 0x78, 0x0F,
  0x0F, 0x81, 0xE0, 0x3C, 0x1E, 0x07, 0x81, 0xF0, 0x78, 0x3E, 0x07, 0xC1,
  0xF0, 0xF8, 0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0x3E,
  0x3C, 0x07, 0x80, 0x79, 0xF0, 0x3E, 0x01, 0xE7, 0xC0, 0xF8, 0x07, 0x9F,
  0x03, 0xE0, 0x0F, 0x7C, 0x0F, 0x00, 0x3D, 0xE0, 0x3C, 0x00, 0xF7, 0x80,
  0xF0, 0x01, 0xFE, 0x07, 0xC0, 0x07, 0xF8, 0x1F, 0x00, 0x1F, 0xE0, 0x7C,
  0x00, 0x3F, 0x01, 0xE0, 0x00, 0xFC, 0x07, 0x80, 0x03, 0xF0, 0x3E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x7C, 0x00,
  0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x3C,
  0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x78, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC1, 0xE0,
  0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0xFC, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x00,
  0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1E,
  0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x00, 0x1F, 0x81, 0xE0,
  0x07, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x01,
  0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xCF, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xE0,
  0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC,
  0x00, 0x07, 0xDE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF7,
  0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F,
  0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xCF, 0x00, 0x03,
  0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0x7C, 0x01,
  0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0x9F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x03, 0xC0, 0x3F, 0x00, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x1F,
  0x00, 0x1E, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x78,
  0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x3F, 0x03, 0xC0, 0x3F, 0x81, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01,
  0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x78,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x00,
  0x3C, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1E,
  0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x7C, 0x0F,
  0x80, 0x1F, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xE1,
  0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE1, 0xE0,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00,
  0x7C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x78,
  0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83,
  0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x1E,
  0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C,
  0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x3C, 0x03, 0xC0, 0x0F, 0x01,
  0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x07,
  0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00,
  0x07, 0x8F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xEF, 0x80, 0x1F, 0x00,
  0x3E, 0xF8, 0x01, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x00, 0x3C, 0xF8, 0x03,
  0xF0, 0x07, 0xCF, 0x80, 0x3F, 0x00, 0x7C, 0xF8, 0x03, 0xF0, 0x07, 0x8F,
  0x80, 0x7F, 0x00, 0xF8, 0x78, 0x07, 0xF0, 0x0F, 0x87, 0x80, 0xF7, 0x00,
  0xF0, 0x78, 0x0F, 0x70, 0x1F, 0x07, 0x80, 0xF7, 0x01, 0xF0, 0x78, 0x1E,
  0x78, 0x1E, 0x07, 0x81, 0xE7, 0x83, 0xE0, 0x78, 0x3C, 0x78, 0x3E, 0x07,
  0x83, 0xC7, 0x83, 0xC0, 0x78, 0x3C, 0x78, 0x7C, 0x07, 0x87, 0x87, 0x87,
  0x80, 0x78, 0x78, 0x78, 0x78, 0x07, 0x87, 0x07, 0x8F, 0x80, 0x78, 0xF0,
  0x78, 0xF0, 0x07, 0x8F, 0x03, 0x8F, 0x00, 0x79, 0xE0, 0x38, 0xF0, 0x07,
  0x9E, 0x03, 0x9E, 0x00, 0x79, 0xC0, 0x39, 0xE0, 0x07, 0xBC, 0x03, 0x9E,
  0x00, 0x7B, 0xC0, 0x3B, 0xC0, 0x07, 0xB8, 0x03, 0xBC, 0x00, 0x7F, 0x80,
  0x3B, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF8, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01,
  0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F,
  0x8F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07,
  0xE0, 0x78, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x81,
  0xF0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xBE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xF0, 0x3C, 0x0F, 0x01,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xFC, 0x03, 0xBC, 0x07, 0xBC, 0x07, 0x9C, 0x0F, 0x1C,
  0x0F, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E,
  0xF8, 0x0E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7C, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7E, 0x3F, 0x07, 0xC0, 0xF8,
  0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0xFC, 0x3C, 0x3F, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07,
  0xC7, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x0F, 0x81, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFD, 0xF0, 0x3F, 0xCF, 0x80, 0x10, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xBF,
  0xC0, 0x3D, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFC, 0xFE, 0x0F, 0xC0, 0xF8,
  0x7E, 0x01, 0xE1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0x78,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0xE0,
  0x7E, 0x3F, 0xF7, 0xF0, 0xF7, 0xFF, 0xC3, 0xCF, 0xFE, 0x0F, 0x1F, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xC7, 0xE1, 0xF0, 0x1E, 0x3E, 0x01, 0xF3, 0xC0, 0x0F, 0x7C,
  0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF8, 0x07,
  0x87, 0x80, 0xF8, 0x7E, 0x3F, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x20, 0x7C, 0x03, 0xFC, 0x7C, 0x07, 0xFE, 0x78, 0x0F, 0xFF,
  0x78, 0x1F, 0xEF, 0xF8, 0x1F, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x3C, 0x00,
  0xF8, 0x7C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7F, 0x7F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xE7,
  0x80, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x7F, 0xFC, 0x0F, 0xCF, 0xE1, 0xF0, 0x3E, 0x3E, 0x01, 0xE3, 0xC0, 0x1F,
  0x7C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x03, 0x07, 0xC0, 0x78, 0x7F, 0x1F, 0x83, 0xFF, 0xF8, 0x1F, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x0F,
  0x01, 0xFF, 0xDF, 0x03, 0xFF, 0xDE, 0x07, 0xFB, 0xFE, 0x07, 0xC0, 0x7E,
  0x0F, 0x80, 0x7E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0,
  0x3E, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0xDF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x07, 0xF9, 0xE0, 0x00, 0x41, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x60, 0x0F, 0xC0,
  0x78, 0x1F, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFB,
  0xFC, 0x07, 0xBF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFE, 0x7E, 0x0F, 0xC1, 0xF0,
  0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00,
  0x7C, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x0F, 0x8F,
  0x00, 0x7C, 0x78, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x07,
  0x8F, 0x00, 0x7C, 0x78, 0x03, 0xE3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0,
  0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x00, 0x03, 0xC0,
  0x7C, 0x0F, 0x81, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x0F, 0xC1, 0xE0, 0x1F, 0x03, 0xC0, 0x7C, 0x07, 0x81, 0xF0, 0x0F,
  0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF1, 0xF8, 0x01, 0xE7,
  0xE0, 0x03, 0xDF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFB, 0xE0, 0x07, 0xE7, 0xC0,
  0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1F, 0x00,
  0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0x78, 0x1E,
  0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x03, 0xCF, 0xF0, 0x7F, 0x80, 0xF7, 0xFE, 0x3F,
  0xF0, 0x3F, 0xFF, 0xDF, 0xFE, 0x0F, 0xE7, 0xFF, 0x9F, 0xC3, 0xE0, 0x7F,
  0x81, 0xF1, 0xF0, 0x0F, 0xC0, 0x7C, 0x7C, 0x03, 0xF0, 0x0F, 0x1E, 0x00,
  0xF8, 0x03, 0xC7, 0x80, 0x3E, 0x00, 0xF1, 0xE0, 0x0F, 0x80, 0x3C, 0x78,
  0x03, 0xC0, 0x1F, 0x3E, 0x00, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x01, 0xF3,
  0xC0, 0x1F, 0x00, 0x78, 0xF0, 0x07, 0xC0, 0x1E, 0x3C, 0x01, 0xE0, 0x07,
  0x9F, 0x00, 0x78, 0x03, 0xE7, 0xC0, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0x80,
  0x3E, 0x78, 0x03, 0xE0, 0x0F, 0x1E, 0x00, 0xF8, 0x03, 0xC7, 0x80, 0x3C,
  0x00, 0xF3, 0xE0, 0x0F, 0x00, 0x7C, 0xF8, 0x03, 0xC0, 0x1F, 0x3C, 0x00,
  0xF0, 0x07, 0x8F, 0x00, 0x7C, 0x01, 0xE3, 0xC0, 0x1F, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x79, 0xFE, 0x03, 0xDF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x7F,
  0x07, 0xE0, 0xF8, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0,
  0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78,
  0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00,
  0x78, 0xF8, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x1F,
  0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F,
  0x80, 0x00, 0x08, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFC, 0x7E, 0x0F, 0x80, 0xF8, 0xF8, 0x03, 0xC7, 0xC0, 0x1F, 0x7C, 0x00,
  0xFB, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x07,
  0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x00, 0x1E, 0x7C, 0x01, 0xF1, 0xE0,
  0x0F, 0x0F, 0x80, 0xF8, 0x7F, 0x1F, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x03, 0xCF, 0xF0,
  0x03, 0xDF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFD, 0xFE, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F,
  0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x7C,
  0x1F, 0x00, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0xE7, 0xF0, 0x3F, 0xFF, 0xE0,
  0x3C, 0xFF, 0xC0, 0x3C, 0x7F, 0x80, 0x3C, 0x0C, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0xF0, 0x7F, 0xF7, 0x83,
  0xFF, 0xDE, 0x1F, 0xC7, 0xF8, 0x7C, 0x07, 0xE3, 0xE0, 0x0F, 0x8F, 0x00,
  0x3E, 0x7C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0x7E, 0x3F, 0xC1,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xF9, 0xE0, 0x01, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x04, 0x1F, 0x7C, 0x3D, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE1, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x08, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xF7, 0xE0, 0xF8, 0x1F, 0x1F,
  0x01, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0xF8, 0x03,
  0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xC7, 0xC0, 0xF8, 0x7F, 0x7F, 0x83, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x01, 0x00, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x03,
  0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0xF8,
  0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x7C,
  0x78, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0x7C, 0x07, 0xC1, 0xE0, 0x7E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xBC, 0x07, 0xFB, 0xE0, 0x04, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03,
  0xC3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xC0, 0xE0, 0xF8, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x3C, 0xF0,
  0x03, 0x9C, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0xF0, 0x0F, 0x00, 0x79, 0xE0, 0x1E, 0x01,
  0xF3, 0xC0, 0x7C, 0x03, 0xC7, 0x80, 0xFC, 0x0F, 0x8F, 0x03, 0xF8, 0x1E,
  0x1E, 0x07, 0xF0, 0x3C, 0x3C, 0x1F, 0xE0, 0xF8, 0x78, 0x3F, 0xC1, 0xE0,
  0xF0, 0xF7, 0x83, 0xC1, 0xE1, 0xEF, 0x0F, 0x03, 0xC3, 0x9E, 0x1E, 0x07,
  0x8F, 0x1C, 0x78, 0x0F, 0x1E, 0x38, 0xF0, 0x1E, 0x78, 0x71, 0xE0, 0x3C,
  0xF0, 0xE7, 0x80, 0x7B, 0xC1, 0xEF, 0x00, 0x77, 0x83, 0xFC, 0x00, 0xFE,
  0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0,
  0x3F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x3E, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0xF8, 0x03, 0xE1,
  0xF0, 0x01, 0xE1, 0xF0, 0x01, 0xE3, 0xE0, 0x01, 0xF3, 0xC0, 0x00, 0xF7,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xEF, 0x00, 0x03, 0xCF, 0x00, 0x07, 0xCF, 0x00, 0x0F, 0x87,
  0x80, 0x0F, 0x87, 0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x03,
  0xC0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0xF8, 0x03, 0xC0, 0xF0, 0x03, 0xC1,
  0xF0, 0x03, 0xC1, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xE3, 0xE0, 0x01, 0xE3,
  0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xEF,
  0x00, 0x01, 0xEF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x01, 0x00, 0x01, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0,
  0x07, 0x3F, 0xF0, 0x0F, 0x7F, 0xF8, 0x0F, 0x7C, 0xFC, 0x1E, 0xF8, 0x3E,
  0x3E, 0xF0, 0x3F, 0xFC, 0xF0, 0x1F, 0xFC, 0xE0, 0x0F, 0xF8, 0x00, 0x03,
  0xE0,
};

const GFXglyph RobotoCondensed_Italic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 38, 12, 2, -37 },
  { 49, 12, 13, 16, 5, -39 },
  { 69, 26, 37, 28, 2, -37 },
  { 190, 22, 49, 25, 2, -43 },
  { 325, 24, 39, 32, 5, -38 },
  { 442, 24, 39, 27, 1, -38 },
  { 559, 6, 12, 9, 4, -39 },
  { 568, 15, 54, 16, 3, -42 },
  { 670, 15, 54, 16, -2, -42 },
  { 772, 20, 22, 22, 3, -37 },
  { 827, 22, 27, 25, 2, -30 },
  { 902, 9, 13, 10, -3, -6 },
  { 917, 11, 4, 13, 1, -18 },
  { 923, 6, 6, 13, 1, -5 },
  { 928, 24, 40, 19, -3, -37 },
  { 1048, 21, 39, 25, 3, -38 },
  { 1151, 14, 37, 25, 6, -37 },
  { 1216, 24, 38, 25, 0, -38 },
  { 1330, 22, 39, 25, 1, -38 },
  { 1438, 23, 37, 25, 0, -37 },
  { 1545, 22, 38, 25, 3, -37 },
  { 1650, 19, 38, 25, 3, -37 },
  { 1741, 23, 37, 25, 3, -37 },
  { 1848, 22, 39, 25, 2, -38 },
  { 1956, 19, 38, 25, 4, -38 },
  { 2047, 10, 28, 12, 1, -27 },
  { 2082, 13, 34, 10, -3, -27 },
  { 2138, 19, 23, 23, 2, -28 },
  { 2193, 20, 15, 24, 3, -25 },
  { 2231, 20, 23, 23, 2, -28 },
  { 2289, 18, 39, 21, 4, -38 },
  { 2377, 35, 48, 39, 2, -36 },
  { 2587, 27, 37, 29, -2, -37 },
  { 2712, 25, 37, 28, 1, -37 },
  { 2828, 25, 39, 29, 3, -38 },
  { 2950, 26, 37, 29, 1, -37 },
  { 3071, 26, 37, 25, 1, -37 },
  { 3192, 25, 37, 24, 1, -37 },
  { 3308, 25, 39, 30, 3, -38 },
  { 3430, 30, 37, 31, 1, -37 },
  { 3569, 11, 37, 13, 1, -37 },
  { 3620, 25, 38, 24, 0, -37 },
  { 3739, 29, 37, 28, 1, -37 },
  { 3874, 20, 37, 24, 1, -37 },
  { 3967, 37, 37, 38, 1, -37 },
  { 4139, 30, 37, 31, 1, -37 },
  { 4278, 26, 39, 30, 3, -38 },
  { 4405, 27, 37, 28, 1, -37 },
  { 4530, 25, 44, 30, 3, -38 },
  { 4668, 26, 37, 27, 1, -37 },
  { 4789, 25, 39, 26, 1, -38 },
  { 4911, 24, 37, 26, 5, -37 },
  { 5022, 27, 38, 28, 2, -37 },
  { 5151, 26, 37, 28, 5, -37 },
  { 5272, 36, 37, 38, 5, -37 },
  { 5439, 31, 37, 28, -1, -37 },
  { 5583, 25, 37, 26, 5, -37 },
  { 5699, 27, 37, 26, 0, -37 },
  { 5824, 16, 50, 13, 0, -42 },
  { 5924, 10, 40, 19, 5, -37 },
  { 5974, 16, 50, 13, -3, -42 },
  { 6074, 16, 18, 19, 2, -37 },
  { 6110, 20, 4, 20, -3, 0 },
  { 6120, 9, 7, 16, 5, -39 },
  { 6128, 21, 29, 24, 1, -28 },
  { 6205, 22, 40, 25, 1, -39 },
  { 6315, 20, 29, 23, 2, -28 },
  { 6388, 24, 40, 25, 2, -39 },
  { 6508, 20, 29, 24, 2, -28 },
  { 6581, 17, 40, 16, 3, -40 },
  { 6666, 24, 39, 25, 0, -28 },
  { 6783, 21, 39, 24, 1, -39 },
  { 6886, 11, 37, 12, 1, -37 },
  { 6937, 16, 48, 11, -5, -37 },
  { 7033, 23, 39, 23, 1, -39 },
  { 7146, 11, 39, 12, 1, -39 },
  { 7200, 34, 28, 38, 1, -28 },
  { 7319, 21, 28, 24, 1, -28 },
  { 7393, 21, 29, 25, 2, -28 },
  { 7470, 24, 39, 25, -1, -28 },
  { 7587, 22, 39, 25, 2, -28 },
  { 7695, 15, 28, 15, 1, -28 },
  { 7748, 20, 29, 23, 1, -28 },
  { 7821, 13, 35, 15, 2, -34 },
  { 7878, 21, 28, 24, 2, -27 },
  { 7952, 19, 27, 22, 3, -27 },
  { 8017, 31, 27, 33, 3, -27 },
  { 8122, 24, 27, 22, -1, -27 },
  { 8203, 24, 38, 21, -2, -27 },
  { 8317, 22, 27, 22, 0, -27 },
  { 8392, 16, 50, 15, 2, -41 },
  { 8492, 10, 44, 12, 1, -37 },
  { 8547, 16, 50, 15, -2, -41 },
  { 8647, 24, 10, 30, 3, -20 },
};

const GFXfont RobotoCondensed_Italic52pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic52pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic52pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOCONDENSED_ITALIC52PT7B_H_
