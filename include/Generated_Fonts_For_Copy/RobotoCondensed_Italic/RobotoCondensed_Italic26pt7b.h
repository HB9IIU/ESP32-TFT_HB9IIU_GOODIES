#ifndef _ROBOTOCONDENSED_ITALIC26PT7B_H_
#define _ROBOTOCONDENSED_ITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x73, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x00, 0x00, 0xC6,
  0x30, 0xCF, 0x2D, 0xB6, 0x9A, 0x40, 0x01, 0x98, 0x08, 0x80, 0xCC, 0x06,
  0x60, 0x22, 0x1F, 0xFC, 0xFF, 0xE0, 0x8C, 0x0C, 0xC0, 0x66, 0x02, 0x30,
  0x33, 0x0F, 0xFE, 0x7F, 0xF0, 0xCC, 0x06, 0x60, 0x23, 0x03, 0x30, 0x19,
  0x80, 0x01, 0x00, 0x20, 0x0C, 0x03, 0xC1, 0xFC, 0x31, 0x8E, 0x39, 0x83,
  0x30, 0x66, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0x0E, 0xC1,
  0xD8, 0x3B, 0x06, 0x31, 0xC7, 0xF0, 0x7C, 0x06, 0x00, 0xC0, 0x3C, 0x07,
  0xC0, 0x66, 0x24, 0x62, 0xC6, 0x6C, 0x6C, 0x44, 0x87, 0xD8, 0x3B, 0x00,
  0x60, 0x06, 0xE0, 0xDF, 0x1B, 0x11, 0xB1, 0x33, 0x16, 0x33, 0x43, 0x30,
  0x3E, 0x01, 0xC0, 0x07, 0x80, 0xFC, 0x18, 0xC1, 0x8C, 0x38, 0xC3, 0x9C,
  0x1B, 0x81, 0xF0, 0x0E, 0x01, 0xC0, 0x76, 0x36, 0x66, 0xE3, 0x6C, 0x36,
  0xC1, 0xCC, 0x1C, 0xE3, 0xC7, 0xFC, 0x3E, 0x60, 0x6D, 0xAD, 0x80, 0x01,
  0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60,
  0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x30,
  0x30, 0x10, 0x08, 0x08, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x06, 0x07,
  0x07, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x30, 0x60, 0xC0, 0x80, 0x06, 0x00, 0xC0, 0x18, 0x23, 0x27, 0xFC,
  0x7F, 0x07, 0x80, 0xF0, 0x33, 0x0C, 0x60, 0x88, 0x00, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x61, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0x80, 0x37, 0x66, 0xC8, 0x7D, 0xF0, 0xDB, 0x00, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x00, 0x07, 0x83, 0xF8, 0x63, 0x18, 0x73, 0x06, 0xE0, 0xD8,
  0x1B, 0x07, 0x60, 0xCC, 0x19, 0x83, 0x70, 0x6E, 0x0D, 0x83, 0xB0, 0x67,
  0x0C, 0x63, 0x0F, 0xE0, 0xF8, 0x00, 0x06, 0x3D, 0xF7, 0x68, 0xC1, 0x83,
  0x0E, 0x18, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC0, 0x07,
  0xC0, 0xFE, 0x1C, 0x61, 0x87, 0x38, 0x33, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0x83, 0xF8, 0xE3, 0x18, 0x67, 0x0E, 0x01,
  0x80, 0x30, 0x0E, 0x0F, 0x83, 0xE0, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x30,
  0x66, 0x0C, 0xE3, 0x0F, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x1E, 0x03, 0x60, 0x3E, 0x06, 0xE0, 0xCC, 0x0C, 0xC1, 0x8C, 0x38, 0xC3,
  0x1C, 0x61, 0xCF, 0xFE, 0xFF, 0xE0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x0F, 0xF1, 0xFE, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x37, 0x03, 0xF8,
  0x31, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xC1, 0xC6, 0x18,
  0x63, 0x87, 0xF0, 0x1E, 0x00, 0x01, 0xC1, 0xF0, 0xE0, 0x70, 0x38, 0x0C,
  0x03, 0xF1, 0xFE, 0x71, 0xD8, 0x36, 0x0D, 0x83, 0xE0, 0xF8, 0x36, 0x1D,
  0x86, 0x63, 0x8F, 0xC1, 0xE0, 0x7F, 0xEF, 0xFC, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x00, 0x07, 0x83, 0xF8, 0x63,
  0x18, 0x73, 0x06, 0x61, 0xCC, 0x31, 0xCE, 0x1F, 0x87, 0xE1, 0xC6, 0x30,
  0xCC, 0x1D, 0x83, 0xB0, 0x66, 0x0C, 0xE3, 0x8F, 0xE0, 0xF0, 0x00, 0x1E,
  0x0F, 0xC7, 0x19, 0x86, 0xE1, 0xB0, 0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0x6E,
  0x39, 0xFE, 0x3F, 0x00, 0xC0, 0x70, 0x18, 0x1C, 0x3E, 0x0F, 0x00, 0x33,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0xCC, 0x0C, 0x70, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x31, 0xC6, 0x38, 0xC0, 0x00, 0x80, 0xE0, 0xF8, 0xF8,
  0xF8, 0x38, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xC0, 0x10, 0x3F, 0xDF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x20, 0x0C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x70, 0x3C, 0x3C, 0x3E, 0x3E, 0x0E, 0x02, 0x00, 0x1E, 0x1F, 0x9C,
  0xDC, 0x7C, 0x38, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x30, 0x18, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01,
  0x80, 0xC1, 0x80, 0x21, 0x80, 0x18, 0x80, 0x04, 0xC3, 0xC2, 0x43, 0xF1,
  0x63, 0x18, 0xB1, 0x8C, 0x71, 0x8C, 0x38, 0xC6, 0x3C, 0x63, 0x1E, 0x61,
  0x0B, 0x31, 0x85, 0x98, 0xC6, 0xC7, 0xBE, 0x63, 0x9E, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x7C, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x00, 0xCC,
  0x06, 0x30, 0x18, 0xC0, 0xC3, 0x83, 0x06, 0x1F, 0xF8, 0x7F, 0xE3, 0x81,
  0x8C, 0x06, 0x70, 0x19, 0x80, 0x6E, 0x01, 0xC0, 0x1F, 0xC1, 0xFE, 0x38,
  0x73, 0x83, 0x30, 0x33, 0x03, 0x30, 0x73, 0x0E, 0x7F, 0xC7, 0xFC, 0x60,
  0xC6, 0x06, 0x60, 0x66, 0x06, 0xE0, 0xEC, 0x0C, 0xC1, 0xCF, 0xF8, 0xFF,
  0x00, 0x03, 0xE0, 0x7F, 0x87, 0x0C, 0x30, 0x73, 0x01, 0x98, 0x0D, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x39,
  0x81, 0x8C, 0x0C, 0x70, 0xC1, 0xFE, 0x07, 0xC0, 0x1F, 0x80, 0xFF, 0x0E,
  0x1C, 0x70, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x70, 0x33, 0x81,
  0x98, 0x0C, 0xC0, 0x66, 0x07, 0x30, 0x33, 0x81, 0x98, 0x18, 0xC3, 0xC7,
  0xFC, 0x3F, 0x80, 0x1F, 0xF1, 0xFF, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x7F, 0xC7, 0xFC, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x38,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0xFC, 0x7F,
  0x86, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x00, 0x03, 0xC0, 0x7F, 0x87, 0x0C, 0x70, 0x73, 0x01, 0x98, 0x0D, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x7D, 0xC3, 0xEE, 0x03, 0x70, 0x19,
  0x81, 0xCC, 0x0E, 0x70, 0xE1, 0xFE, 0x07, 0xE0, 0x18, 0x0C, 0x30, 0x18,
  0xE0, 0x31, 0xC0, 0x63, 0x00, 0xC6, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x7F,
  0xF8, 0xFF, 0xF1, 0x80, 0xE3, 0x01, 0xC6, 0x03, 0x0C, 0x06, 0x38, 0x0C,
  0x60, 0x18, 0xC0, 0x71, 0x80, 0xE3, 0x01, 0x80, 0x18, 0xCE, 0x73, 0x18,
  0xC6, 0x73, 0x98, 0xC6, 0x33, 0x9C, 0xC6, 0x30, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0xE1, 0xCE, 0x18, 0x63, 0x87, 0xF0, 0x3E,
  0x00, 0x18, 0x1C, 0x60, 0xE3, 0x87, 0x0E, 0x38, 0x31, 0xC0, 0xC6, 0x03,
  0x38, 0x0D, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1C, 0xC0, 0x63, 0x81,
  0x8E, 0x0E, 0x18, 0x30, 0x70, 0xC0, 0xC3, 0x03, 0x8C, 0x06, 0x00, 0x18,
  0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x7F, 0xFF, 0xE0, 0x1C, 0x01, 0xC7,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0x60,
  0xD8, 0xD8, 0x76, 0x76, 0x1B, 0x99, 0x86, 0xC6, 0x63, 0x31, 0x98, 0xCC,
  0x66, 0x63, 0x18, 0x99, 0xCE, 0x3C, 0x73, 0x0F, 0x18, 0xC3, 0x86, 0x30,
  0xE1, 0x8C, 0x30, 0x60, 0x18, 0x0C, 0x38, 0x18, 0xF0, 0x31, 0xE0, 0x63,
  0xC0, 0xC6, 0xC3, 0x8D, 0x86, 0x1B, 0x0C, 0x73, 0x18, 0xE6, 0x31, 0x8C,
  0x63, 0x0D, 0xC6, 0x1B, 0x0C, 0x36, 0x38, 0x3C, 0x60, 0x78, 0xC0, 0xF1,
  0x80, 0xE3, 0x01, 0x80, 0x03, 0xE0, 0x7F, 0x87, 0x0C, 0x70, 0x33, 0x01,
  0x98, 0x0D, 0xC0, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x0E, 0xC0, 0x7E,
  0x03, 0x70, 0x19, 0x81, 0xCC, 0x0C, 0x70, 0xE1, 0xFE, 0x07, 0xC0, 0x1F,
  0xC0, 0xFF, 0x8E, 0x0C, 0x70, 0x73, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x07,
  0x70, 0x33, 0x83, 0x9F, 0xF8, 0xFF, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0x0C, 0x70,
  0x73, 0x01, 0x98, 0x0D, 0xC0, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x0F,
  0xC0, 0x6E, 0x03, 0x70, 0x19, 0x81, 0xCC, 0x0C, 0x71, 0xC1, 0xFE, 0x07,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x20, 0x1F, 0xC1, 0xFE, 0x38, 0x73, 0x83,
  0x30, 0x33, 0x03, 0x30, 0x33, 0x07, 0x70, 0xE7, 0xFC, 0x7F, 0x86, 0x38,
  0x61, 0x86, 0x18, 0xE1, 0xCE, 0x1C, 0xC0, 0xCC, 0x0C, 0xC0, 0xE0, 0x07,
  0x81, 0xFE, 0x38, 0x63, 0x07, 0x30, 0x33, 0x03, 0x30, 0x03, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1C, 0x00, 0xCC, 0x0E, 0xC0, 0xCC, 0x0C, 0xE1,
  0xC7, 0xF8, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x00, 0x38, 0x18, 0xE0,
  0x63, 0x01, 0x8C, 0x06, 0x30, 0x38, 0xC0, 0xE7, 0x03, 0x1C, 0x0C, 0x60,
  0x31, 0x80, 0xC6, 0x07, 0x18, 0x1C, 0xE0, 0x63, 0x81, 0x8E, 0x06, 0x38,
  0x38, 0x61, 0xC1, 0xFE, 0x01, 0xF0, 0x00, 0xE0, 0x1F, 0x01, 0xD8, 0x0C,
  0xC0, 0xE6, 0x06, 0x30, 0x31, 0x83, 0x8E, 0x18, 0x71, 0xC1, 0x8C, 0x0C,
  0xE0, 0x66, 0x03, 0x30, 0x1B, 0x00, 0xD8, 0x07, 0xC0, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0xC1, 0x81, 0xE0, 0xC1, 0xF0, 0x70, 0xD8, 0x78, 0x6C, 0x3C,
  0x36, 0x36, 0x33, 0x1B, 0x19, 0x8D, 0x8C, 0xCC, 0xCC, 0x66, 0x66, 0x33,
  0x33, 0x1B, 0x1B, 0x0D, 0x8D, 0x86, 0x86, 0xC3, 0xC3, 0xC1, 0xE0, 0xE0,
  0xE0, 0x70, 0x70, 0x30, 0x38, 0x18, 0x00, 0x18, 0x0C, 0x38, 0x38, 0x30,
  0xE0, 0x61, 0xC0, 0xE7, 0x00, 0xCC, 0x01, 0xB8, 0x03, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xDC, 0x03, 0x98, 0x06, 0x30, 0x1C,
  0x70, 0x70, 0x60, 0xC0, 0xC3, 0x81, 0xC0, 0xE0, 0x3B, 0x03, 0x98, 0x18,
  0xE1, 0xC7, 0x0C, 0x18, 0xE0, 0xCE, 0x06, 0x60, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0xFF, 0x8F, 0xFE, 0x00,
  0x0F, 0x0F, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xF0,
  0xF0, 0xCC, 0xCC, 0xCC, 0xC6, 0x66, 0x66, 0x66, 0x23, 0x33, 0x33, 0x30,
  0x1F, 0x1E, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0xF0,
  0xF0, 0x04, 0x0E, 0x1E, 0x1E, 0x36, 0x36, 0x66, 0x62, 0xC3, 0xFF, 0xFF,
  0xE0, 0xC6, 0x63, 0x0F, 0x0F, 0xE3, 0x1D, 0x87, 0x01, 0xC0, 0x61, 0xF9,
  0xFE, 0xE1, 0xB0, 0x6C, 0x3B, 0x1C, 0xFF, 0x1E, 0xE0, 0x0C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0xF1, 0xFF, 0x38, 0xE6, 0x0C, 0xC1,
  0x98, 0x33, 0x06, 0xE0, 0xD8, 0x1B, 0x07, 0x60, 0xCE, 0x39, 0xFE, 0x67,
  0x80, 0x0F, 0x0F, 0xE7, 0x1D, 0x83, 0x60, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x6C, 0x1B, 0x8C, 0x7F, 0x0F, 0x00, 0x00, 0x30, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x1E, 0x63, 0xFE, 0x71, 0xC6, 0x0C, 0xE0, 0xCC,
  0x0C, 0xC0, 0xCC, 0x1C, 0xC1, 0x8C, 0x18, 0xC1, 0x8E, 0x38, 0x7F, 0x83,
  0xD8, 0x0F, 0x0F, 0xE7, 0x1D, 0x83, 0x60, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x30, 0x0C, 0x03, 0x84, 0x7F, 0x0F, 0x80, 0x07, 0x87, 0xC7, 0x03, 0x01,
  0x80, 0xC1, 0xF8, 0xFC, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x38, 0x1C, 0x00, 0x0F, 0x31, 0xFB, 0x38, 0xE3, 0x06,
  0x30, 0x66, 0x06, 0x60, 0x66, 0x0E, 0x60, 0xC6, 0x0C, 0x60, 0xC7, 0x1C,
  0x3F, 0xC1, 0xFC, 0x01, 0x80, 0x18, 0x43, 0x8F, 0xF0, 0x3E, 0x00, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0xF1, 0xFE, 0x38, 0xE6,
  0x0C, 0xC1, 0x98, 0x73, 0x0E, 0xE1, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x39,
  0x87, 0x70, 0xC0, 0x08, 0x70, 0xC0, 0x00, 0x61, 0x8E, 0x30, 0xC3, 0x0C,
  0x31, 0xC6, 0x18, 0x61, 0x86, 0x00, 0x02, 0x07, 0x06, 0x00, 0x00, 0x06,
  0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x38, 0x30, 0x30, 0x30, 0xF0, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0xE3, 0x8C, 0x31, 0xC3, 0x38, 0x37, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x76, 0x06, 0x30, 0x63, 0x06, 0x38, 0x61, 0x8E, 0x1C,
  0x0C, 0x31, 0xC6, 0x18, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x30, 0xC7, 0x18,
  0x61, 0x86, 0x18, 0x1B, 0x8F, 0x0F, 0xF7, 0xE3, 0x8F, 0x18, 0xC1, 0x87,
  0x30, 0x61, 0xCC, 0x38, 0x63, 0x0E, 0x19, 0xC3, 0x06, 0x60, 0xC1, 0x98,
  0x30, 0x66, 0x0C, 0x39, 0x87, 0x0C, 0x61, 0xC3, 0x38, 0x60, 0xC0, 0x1B,
  0xC7, 0xF8, 0xE3, 0x98, 0x33, 0x06, 0x61, 0xCC, 0x3B, 0x86, 0x60, 0xCC,
  0x19, 0x83, 0x30, 0xE6, 0x1D, 0xC3, 0x00, 0x0F, 0x07, 0xF0, 0xC7, 0x30,
  0x66, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x1B, 0x06, 0x71, 0xC7,
  0xF0, 0x7C, 0x00, 0x0D, 0xE1, 0xFF, 0x1C, 0x71, 0x83, 0x18, 0x31, 0x83,
  0x18, 0x33, 0x83, 0x30, 0x33, 0x07, 0x30, 0x63, 0x8E, 0x3F, 0xC7, 0x78,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x1E, 0x67, 0xFD, 0xC7,
  0x30, 0x6E, 0x0D, 0x81, 0xB0, 0x36, 0x0E, 0xC1, 0x98, 0x33, 0x06, 0x71,
  0xC7, 0xF8, 0x7F, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x00, 0x1F,
  0x3F, 0x3C, 0x38, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0x60,
  0xE0, 0x1F, 0x0F, 0xE7, 0x19, 0x87, 0x60, 0x1C, 0x03, 0xC0, 0x3C, 0x07,
  0x00, 0xEC, 0x3B, 0x0C, 0xFF, 0x0F, 0x00, 0x18, 0x30, 0x67, 0xEF, 0xC6,
  0x0C, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x70, 0x30, 0xEE,
  0x19, 0x83, 0x30, 0x66, 0x0C, 0xC3, 0x98, 0x77, 0x0C, 0xC1, 0x98, 0x33,
  0x0E, 0x71, 0xC7, 0xF8, 0xF6, 0x00, 0xC1, 0xE1, 0xF0, 0xD8, 0xEC, 0x66,
  0x33, 0x30, 0x98, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x00, 0xC3, 0x0F,
  0x86, 0x1B, 0x1C, 0x36, 0x38, 0xCC, 0xD1, 0x99, 0xB3, 0x33, 0x6C, 0x6C,
  0xD8, 0xD9, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x0E, 0x0E, 0x1C, 0x0C, 0x30,
  0x00, 0x18, 0x71, 0xC6, 0x0C, 0xE0, 0xCC, 0x0D, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0F, 0x01, 0xF0, 0x19, 0x83, 0x98, 0x71, 0xC6, 0x0C, 0x18, 0x71,
  0x86, 0x18, 0x61, 0x8E, 0x18, 0xC1, 0x9C, 0x19, 0x81, 0x98, 0x0B, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x0F,
  0x00, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0F, 0xF9, 0xFF, 0x00, 0x03,
  0x07, 0x0E, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0xE0, 0xE0,
  0x60, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60, 0x60, 0x60, 0x70, 0x30, 0x10,
  0x0C, 0x21, 0x86, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x30, 0xC2, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x00, 0x08, 0x1C, 0x0C, 0x06, 0x06, 0x06, 0x0E,
  0x0C, 0x0C, 0x0C, 0x0E, 0x07, 0x07, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18,
  0x38, 0x30, 0x30, 0x60, 0xE0, 0x80, 0x3C, 0x1B, 0xF1, 0x99, 0xCC, 0x87,
  0xCC, 0x1C, 0x00,
};

const GFXglyph RobotoCondensed_Italic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 6, 1, -19 },
  { 13, 6, 6, 8, 3, -20 },
  { 18, 13, 19, 14, 1, -19 },
  { 49, 11, 24, 12, 1, -22 },
  { 82, 12, 19, 16, 2, -19 },
  { 111, 12, 19, 14, 1, -19 },
  { 140, 3, 6, 4, 2, -20 },
  { 143, 8, 27, 8, 1, -21 },
  { 170, 8, 27, 8, -1, -21 },
  { 197, 11, 11, 11, 1, -19 },
  { 213, 11, 13, 13, 1, -15 },
  { 231, 4, 6, 5, -1, -3 },
  { 234, 6, 2, 6, 0, -9 },
  { 236, 3, 3, 7, 1, -3 },
  { 238, 11, 21, 9, -1, -19 },
  { 267, 11, 19, 12, 1, -19 },
  { 294, 7, 19, 12, 3, -19 },
  { 311, 12, 19, 12, 0, -19 },
  { 340, 11, 19, 12, 1, -19 },
  { 367, 12, 19, 12, 0, -19 },
  { 396, 12, 19, 12, 1, -19 },
  { 425, 10, 19, 12, 1, -19 },
  { 449, 11, 19, 12, 2, -19 },
  { 476, 11, 19, 12, 1, -19 },
  { 503, 10, 19, 12, 2, -19 },
  { 527, 4, 14, 6, 1, -14 },
  { 534, 6, 17, 5, -1, -14 },
  { 547, 10, 11, 11, 1, -14 },
  { 561, 10, 7, 12, 1, -12 },
  { 570, 10, 12, 12, 1, -14 },
  { 585, 9, 19, 11, 2, -19 },
  { 607, 17, 24, 19, 1, -18 },
  { 658, 14, 19, 15, -1, -19 },
  { 692, 12, 19, 14, 1, -19 },
  { 721, 13, 19, 14, 1, -19 },
  { 752, 13, 19, 14, 1, -19 },
  { 783, 12, 19, 13, 1, -19 },
  { 812, 12, 19, 12, 1, -19 },
  { 841, 13, 19, 15, 1, -19 },
  { 872, 15, 19, 16, 1, -19 },
  { 908, 5, 19, 6, 1, -19 },
  { 920, 12, 19, 12, 0, -19 },
  { 949, 14, 19, 14, 1, -19 },
  { 983, 9, 19, 12, 1, -19 },
  { 1005, 18, 19, 19, 1, -19 },
  { 1048, 15, 19, 16, 1, -19 },
  { 1084, 13, 19, 15, 1, -19 },
  { 1115, 13, 19, 14, 1, -19 },
  { 1146, 13, 22, 15, 1, -19 },
  { 1182, 12, 19, 13, 1, -19 },
  { 1211, 12, 19, 13, 1, -19 },
  { 1240, 12, 19, 13, 2, -19 },
  { 1269, 14, 19, 14, 1, -19 },
  { 1303, 13, 19, 14, 2, -19 },
  { 1334, 17, 19, 19, 3, -19 },
  { 1375, 15, 19, 14, 0, -19 },
  { 1411, 13, 19, 13, 2, -19 },
  { 1442, 14, 19, 13, 0, -19 },
  { 1476, 8, 25, 6, 0, -21 },
  { 1501, 4, 21, 9, 3, -19 },
  { 1512, 8, 25, 6, -1, -21 },
  { 1537, 8, 9, 9, 1, -19 },
  { 1546, 10, 2, 10, -1, 0 },
  { 1549, 4, 4, 8, 3, -20 },
  { 1551, 10, 14, 12, 1, -14 },
  { 1569, 11, 20, 12, 0, -20 },
  { 1597, 10, 14, 12, 1, -14 },
  { 1615, 12, 20, 13, 1, -20 },
  { 1645, 10, 14, 12, 1, -14 },
  { 1663, 9, 20, 8, 1, -20 },
  { 1686, 12, 19, 12, 0, -14 },
  { 1715, 11, 20, 12, 0, -20 },
  { 1743, 6, 19, 6, 0, -19 },
  { 1758, 8, 24, 6, -2, -19 },
  { 1782, 12, 20, 11, 0, -20 },
  { 1812, 6, 20, 6, 0, -20 },
  { 1827, 18, 14, 19, 0, -14 },
  { 1859, 11, 14, 12, 0, -14 },
  { 1879, 11, 14, 13, 1, -14 },
  { 1899, 12, 19, 12, -1, -14 },
  { 1928, 11, 19, 13, 1, -14 },
  { 1955, 8, 14, 8, 0, -14 },
  { 1969, 10, 14, 12, 1, -14 },
  { 1987, 7, 17, 7, 1, -17 },
  { 2002, 11, 14, 12, 1, -14 },
  { 2022, 9, 14, 11, 2, -14 },
  { 2038, 15, 14, 16, 2, -14 },
  { 2065, 12, 14, 11, -1, -14 },
  { 2086, 12, 19, 11, -1, -14 },
  { 2115, 11, 14, 11, 0, -14 },
  { 2135, 8, 25, 8, 1, -20 },
  { 2160, 6, 22, 6, 0, -19 },
  { 2177, 8, 25, 8, -1, -20 },
  { 2202, 13, 5, 15, 1, -10 },
};

const GFXfont RobotoCondensed_Italic26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_ITALIC26PT7B_H_
