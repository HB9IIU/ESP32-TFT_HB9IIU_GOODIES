#ifndef _ROBOTOCONDENSED_ITALIC33PT7B_H_
#define _ROBOTOCONDENSED_ITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0xC3,
  0x86, 0x0C, 0x38, 0x70, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x00, 0x73, 0x67,
  0x67, 0x66, 0x66, 0x66, 0xC6, 0xC4, 0x00, 0x63, 0x80, 0x31, 0x80, 0x38,
  0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x3F, 0xFF, 0x1F,
  0xFF, 0x81, 0x8C, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x31, 0x81,
  0xFF, 0xF8, 0xFF, 0xF8, 0x0C, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x18,
  0x03, 0x1C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0x60,
  0x71, 0xC1, 0xC7, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0xB8, 0x0E, 0xE0, 0x33, 0x81, 0xC7, 0x0F, 0x1F,
  0xF8, 0x3F, 0xC0, 0x7C, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x7C, 0x01, 0x8C, 0x07, 0x18, 0x6C, 0x30, 0xD8, 0x63, 0x30, 0xCC, 0x61,
  0xB8, 0xE6, 0x60, 0xFD, 0x80, 0xF7, 0x00, 0x1C, 0x00, 0x33, 0x80, 0xDF,
  0x83, 0xB1, 0x86, 0xE3, 0x19, 0x86, 0x63, 0x0D, 0xC6, 0x1B, 0x0C, 0x30,
  0x1C, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x3D, 0xE0,
  0x71, 0xC0, 0xC1, 0x83, 0x87, 0x07, 0x0E, 0x06, 0x38, 0x0E, 0xE0, 0x1F,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xF8, 0xEF, 0x79, 0xDC, 0x73, 0xF0, 0x76,
  0xE0, 0xFD, 0xC0, 0xF3, 0x81, 0xE7, 0x83, 0xC7, 0x9F, 0x87, 0xFB, 0x87,
  0xC7, 0x00, 0x6D, 0xFF, 0xB6, 0x00, 0x80, 0x60, 0x38, 0x1C, 0x06, 0x03,
  0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x04, 0x00,
  0x02, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C,
  0x06, 0x03, 0x81, 0xC0, 0xE0, 0x10, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x04, 0x71, 0x7F, 0x7B, 0xFF, 0xE3, 0xF0, 0x0F, 0x00, 0xF8, 0x0E,
  0xE0, 0xE3, 0x06, 0x1C, 0x00, 0x40, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x1C, 0x73, 0x8E, 0x39, 0xCE, 0x10, 0xFD, 0xF8, 0x5F, 0xF0, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x7F,
  0x87, 0xBC, 0x70, 0x73, 0x83, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x60, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x6E, 0x07, 0x70, 0x3B, 0x81, 0xD8, 0x0E, 0xC0,
  0x66, 0x07, 0x30, 0x39, 0xC3, 0x8F, 0x3C, 0x3F, 0xC0, 0xF8, 0x00, 0x01,
  0x0F, 0x3F, 0xFF, 0xE7, 0x86, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x01, 0xF0,
  0x0F, 0xF8, 0x3E, 0xF0, 0x70, 0x71, 0xC0, 0xE3, 0x81, 0xC6, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xF7, 0x87,
  0x0E, 0x38, 0x1C, 0xE0, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x07, 0xC0,
  0x7E, 0x01, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0xE0, 0x73,
  0x81, 0xCE, 0x07, 0x38, 0x38, 0x7B, 0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x77,
  0x01, 0xCC, 0x03, 0xB8, 0x0E, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xC3, 0x87,
  0x06, 0x0E, 0x1C, 0x38, 0x38, 0xFF, 0xFD, 0xFF, 0xF8, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF,
  0xC7, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xC0, 0xFF,
  0x87, 0xFE, 0x1C, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0xC0,
  0x73, 0x01, 0xCE, 0x0E, 0x38, 0x38, 0x7B, 0xC0, 0xFE, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x3E, 0x0F, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x77, 0x87, 0xFE, 0x7D, 0xEF, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x0E, 0x7B, 0xC7, 0xF8, 0x1F, 0x00, 0x7F,
  0xFC, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0xF7,
  0x87, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0xC6, 0x07, 0x1C, 0x38, 0x79,
  0xC0, 0xFE, 0x07, 0xF8, 0x38, 0xF1, 0xC1, 0xC7, 0x03, 0x38, 0x0C, 0xE0,
  0x33, 0x81, 0xCE, 0x07, 0x1C, 0x38, 0x7B, 0xE0, 0xFF, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0xFF, 0x0F, 0xBC, 0x70, 0xE7, 0x07, 0x38, 0x19, 0x80, 0xEC,
  0x07, 0xE0, 0x3B, 0x03, 0x98, 0x1C, 0xE1, 0xE7, 0xFF, 0x1F, 0xF8, 0x79,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0F, 0x07, 0xF0, 0x3F, 0x01,
  0xE0, 0x00, 0x18, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x38, 0xE3, 0x80, 0x02, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70,
  0x70, 0x60, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C,
  0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xC0, 0x0C, 0x00,
  0x40, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0xFF, 0xEF, 0xFE, 0x20, 0x01, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F,
  0x80, 0x70, 0x02, 0x00, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x78, 0xEE, 0x0F,
  0xC1, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x70,
  0x0E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0xE0, 0x18,
  0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x0E,
  0x07, 0x00, 0x18, 0x38, 0x00, 0x60, 0xC0, 0x00, 0xC6, 0x07, 0x83, 0x18,
  0x7F, 0x0C, 0xC1, 0x8E, 0x33, 0x0C, 0x30, 0xDC, 0x70, 0xC3, 0x61, 0x83,
  0x0D, 0x86, 0x1C, 0x36, 0x38, 0x60, 0xF8, 0xE1, 0x83, 0xC3, 0x06, 0x1B,
  0x0C, 0x38, 0x6C, 0x30, 0xE1, 0xB0, 0xC7, 0x0C, 0xC3, 0xBE, 0x73, 0x0F,
  0xDF, 0x8C, 0x1E, 0x3C, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x06, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0x70, 0x03, 0xB8, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xC3, 0x00, 0xE1, 0x80,
  0x60, 0xC0, 0x70, 0x70, 0x38, 0x38, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF,
  0x0E, 0x01, 0x8E, 0x00, 0xC7, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1F, 0x80,
  0x0E, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1C, 0x0E, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xF8, 0x38, 0x38, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0x60, 0x3C, 0xE0, 0x38, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x01,
  0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x0E, 0x38, 0x06, 0x38, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x38, 0x70, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0xF0, 0x0F,
  0xFC, 0x1F, 0xFE, 0x1C, 0x0E, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38,
  0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x60, 0x3C, 0xE0,
  0x78, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFF, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1C, 0x0E, 0x38,
  0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0xFE, 0xE0, 0xFE, 0xE0, 0xFE, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x70, 0x3C, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xC0, 0x0E, 0x00, 0xE1, 0x80, 0x18, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x03, 0x87, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0x80, 0x38, 0xE0, 0x0E, 0x1C, 0x01,
  0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0x80, 0x18, 0x70, 0x07,
  0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x80, 0x0E, 0x1C, 0x30, 0xE1,
  0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x70, 0x70, 0xF0, 0x7F, 0xE0, 0x3F,
  0xC0, 0x1F, 0x80, 0x0E, 0x03, 0xC3, 0x01, 0xE1, 0xC0, 0xF0, 0x70, 0x78,
  0x1C, 0x1C, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0xE3, 0xC0, 0x39, 0xE0, 0x0E,
  0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0x70, 0x07, 0x8E,
  0x01, 0xC3, 0x80, 0x70, 0x70, 0x1C, 0x1C, 0x06, 0x07, 0x83, 0x80, 0xE0,
  0xE0, 0x38, 0x38, 0x07, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0x60, 0x0D, 0x86,
  0xC0, 0x3F, 0x0D, 0xC0, 0x6E, 0x3B, 0x81, 0xDC, 0x77, 0x03, 0x30, 0xEE,
  0x0E, 0xE1, 0xCC, 0x19, 0xC3, 0x18, 0x73, 0x8E, 0x30, 0xC7, 0x1C, 0x73,
  0x8E, 0x38, 0xE6, 0x38, 0x71, 0xDC, 0x70, 0xE1, 0xB0, 0xE1, 0x83, 0xE1,
  0xC7, 0x07, 0x83, 0x8E, 0x0F, 0x07, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0x00, 0x0E, 0x00, 0xE1, 0xC0, 0x18, 0x7C, 0x07, 0x0F, 0x80, 0xE1, 0xF0,
  0x1C, 0x3F, 0x03, 0x87, 0xE0, 0x71, 0xCC, 0x0C, 0x39, 0xC3, 0x87, 0x38,
  0x70, 0xE3, 0x0E, 0x1C, 0x71, 0xC3, 0x8E, 0x38, 0xE0, 0xCE, 0x1C, 0x1D,
  0xC3, 0x83, 0xB8, 0x70, 0x37, 0x0E, 0x07, 0xE1, 0x80, 0xF8, 0x70, 0x0F,
  0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x03, 0x80, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x1E, 0x0E, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07,
  0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0x70, 0x78,
  0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0x07, 0xFF,
  0xC3, 0x80, 0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x70, 0x07, 0x38,
  0x07, 0x1C, 0x03, 0x8E, 0x03, 0xC7, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x81,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x1C, 0x0E, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xF0, 0x78, 0x7F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x10, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1C, 0x0E, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x1E, 0x3F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0x70, 0x60, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x60, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0x01,
  0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1E, 0x0E, 0x1C, 0x0E, 0x38, 0x07, 0x38,
  0x07, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x38, 0xF0, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x71, 0xC0, 0x39, 0xC0, 0x18, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07,
  0x1C, 0x03, 0x8C, 0x01, 0xCE, 0x00, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0,
  0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x30, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x07,
  0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03,
  0x9C, 0x01, 0xC6, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0x70, 0x70,
  0x38, 0x38, 0x38, 0x1C, 0x1C, 0x06, 0x1C, 0x03, 0x0E, 0x01, 0xCE, 0x00,
  0xE7, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x38, 0x0F, 0xC0, 0x70,
  0x3B, 0x81, 0xE0, 0x77, 0x03, 0xC0, 0xEE, 0x07, 0x83, 0x9C, 0x1F, 0x07,
  0x18, 0x36, 0x0C, 0x30, 0xEC, 0x38, 0x61, 0xD8, 0x70, 0xC3, 0x30, 0xC1,
  0x8E, 0x63, 0x83, 0x18, 0xC7, 0x06, 0x71, 0x8C, 0x0C, 0xE3, 0xB8, 0x19,
  0x87, 0x70, 0x37, 0x0E, 0xC0, 0x6C, 0x0F, 0x80, 0xD8, 0x1F, 0x01, 0xF0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x00, 0x07, 0x00, 0xE0, 0x70, 0x1E, 0x07, 0x01, 0xC0, 0x38, 0x38,
  0x03, 0x87, 0x80, 0x38, 0x70, 0x01, 0xCE, 0x00, 0x1D, 0xE0, 0x00, 0xDC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3B, 0x80, 0x07, 0x1C, 0x00, 0xF1, 0xC0, 0x0E,
  0x1C, 0x01, 0xC0, 0xE0, 0x3C, 0x0E, 0x07, 0x80, 0xE0, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0xE0, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x70,
  0x38, 0x70, 0x38, 0xE0, 0x39, 0xC0, 0x19, 0xC0, 0x1B, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x0F, 0xFF,
  0x87, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x07,
  0xC1, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38,
  0x0F, 0x83, 0xE0, 0xE3, 0x86, 0x18, 0x61, 0xC7, 0x1C, 0x70, 0xC3, 0x0C,
  0x38, 0xE3, 0x8E, 0x18, 0x61, 0x87, 0x1C, 0x71, 0xC3, 0x0C, 0x07, 0xC1,
  0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x0F,
  0xC3, 0xE0, 0x03, 0x00, 0xC0, 0x78, 0x1E, 0x0F, 0x83, 0x61, 0xD8, 0x66,
  0x39, 0xCC, 0x77, 0x1D, 0x83, 0x7F, 0xFF, 0xFF, 0xC0, 0x71, 0xC3, 0x86,
  0x1C, 0x07, 0xC0, 0x7F, 0x87, 0xBC, 0x70, 0x63, 0x83, 0x80, 0x18, 0x00,
  0xC1, 0xFE, 0x3F, 0xF3, 0xC3, 0xBC, 0x1D, 0xC0, 0xCE, 0x0E, 0x70, 0x73,
  0xFF, 0x8F, 0xFC, 0x3C, 0xE0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1D, 0xF0, 0x7F, 0xE1, 0xFF,
  0xC7, 0x07, 0x18, 0x0C, 0xE0, 0x33, 0x80, 0xCE, 0x07, 0x38, 0x1C, 0xC0,
  0x73, 0x01, 0xDC, 0x07, 0x70, 0x39, 0xE0, 0xE7, 0xFF, 0x1B, 0xF8, 0xE7,
  0xC0, 0x07, 0xC0, 0xFF, 0x8F, 0xBC, 0x70, 0x77, 0x03, 0xB8, 0x1D, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xEE, 0x07, 0x70, 0x71,
  0xE7, 0x07, 0xF8, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x07, 0x9C, 0x3F, 0xB8,
  0xFF, 0xF1, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x18, 0x0E, 0x70, 0x1C, 0xE0,
  0x31, 0xC0, 0x63, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1E, 0x60, 0x07, 0xC0, 0xFF, 0x87, 0xBC, 0x70, 0x77, 0x03,
  0xB8, 0x1D, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x78, 0x31, 0xF7, 0x87, 0xF8, 0x1F, 0x80, 0x03, 0xC1, 0xF0, 0xFC,
  0x78, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0xFF, 0x3F, 0xC3, 0x80, 0xE0, 0x38,
  0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x00, 0x03, 0xCE, 0x1F, 0xDC, 0x7D, 0xF8, 0xE0, 0xE3,
  0x81, 0xC7, 0x03, 0x8C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x31, 0xC0,
  0xE3, 0x81, 0xC7, 0x03, 0x8F, 0x0F, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x84, 0x0E, 0x1E, 0x7C, 0x1F, 0xF0, 0x0F,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x1D, 0xF0, 0x7F, 0xE1, 0xF7, 0x87, 0x07, 0x1C, 0x1C,
  0xE0, 0x73, 0x81, 0xCE, 0x06, 0x38, 0x38, 0xC0, 0xE3, 0x03, 0x9C, 0x0E,
  0x70, 0x39, 0xC0, 0xC7, 0x07, 0x18, 0x1C, 0xE0, 0x70, 0x1C, 0x70, 0xC0,
  0x00, 0x01, 0x8E, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x1C, 0x71, 0x8E, 0x38,
  0xE3, 0x8C, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC3, 0xE0, 0xF8, 0x3C, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x1C, 0x38, 0x78,
  0x71, 0xE0, 0xE7, 0x81, 0x9E, 0x07, 0x78, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x1C, 0x1C, 0x38,
  0x30, 0x38, 0xE0, 0x70, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x38,
  0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38,
  0x70, 0xC0, 0x1D, 0xF0, 0xF0, 0x7F, 0xEF, 0xE1, 0xF7, 0xFF, 0xC7, 0x07,
  0x87, 0x18, 0x1C, 0x1C, 0xE0, 0x70, 0x73, 0x81, 0xC1, 0xCE, 0x06, 0x07,
  0x38, 0x38, 0x1C, 0xE0, 0xE0, 0x73, 0x03, 0x81, 0x9C, 0x0E, 0x06, 0x70,
  0x38, 0x39, 0xC0, 0xC0, 0xE7, 0x07, 0x03, 0x98, 0x1C, 0x0E, 0xE0, 0x70,
  0x30, 0x1D, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0x07, 0x1C, 0x1C, 0xE0, 0x73,
  0x81, 0xCE, 0x06, 0x38, 0x38, 0xE0, 0xE3, 0x03, 0x9C, 0x0E, 0x70, 0x39,
  0xC0, 0xC7, 0x07, 0x18, 0x1C, 0xE0, 0x70, 0x07, 0xE0, 0x3F, 0xC1, 0xEF,
  0x8E, 0x0E, 0x70, 0x19, 0xC0, 0x76, 0x01, 0xF8, 0x07, 0xE0, 0x1B, 0x80,
  0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x71, 0xC1, 0xC7, 0x9E, 0x0F, 0xF0, 0x1F,
  0x00, 0x0E, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0x70, 0xC0, 0xE3, 0x80,
  0xC7, 0x01, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x60, 0x39, 0xC0, 0x73,
  0x81, 0xC7, 0x03, 0x8F, 0x9E, 0x1F, 0xF8, 0x33, 0xE0, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x9C,
  0x7F, 0x73, 0xEF, 0xCE, 0x0E, 0x70, 0x39, 0xC0, 0xE6, 0x03, 0xB8, 0x0E,
  0xE0, 0x3B, 0x80, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0xC7, 0xBF,
  0x1F, 0xF8, 0x1E, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x1D, 0xC7, 0xF1, 0xFC, 0x78, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0xE0, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0x87, 0x30, 0x33, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xFF,
  0xC7, 0xFC, 0x1F, 0x00, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC3, 0xFF, 0xFC,
  0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0F, 0x87, 0xC1, 0xE0, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0x8E, 0x0E,
  0x30, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0C, 0x70, 0x71, 0x81, 0xC6, 0x07,
  0x38, 0x1C, 0xE0, 0x71, 0x83, 0x87, 0xFE, 0x1F, 0xF8, 0x3E, 0xE0, 0xE0,
  0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0x61, 0xC6, 0x1C, 0x61, 0x86, 0x38, 0x73,
  0x07, 0x70, 0x76, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x87, 0x83, 0x70, 0xF0, 0xEE, 0x1E,
  0x1C, 0xC7, 0xC7, 0x18, 0xD8, 0xE3, 0x3B, 0x18, 0x66, 0x77, 0x0D, 0xCE,
  0xC1, 0xB1, 0xF8, 0x3E, 0x3F, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x30, 0x00, 0x1C, 0x0E, 0x1C, 0x38, 0x38, 0xF0,
  0x31, 0xC0, 0x77, 0x00, 0xEC, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x80, 0x1F, 0x00, 0x76, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x1C, 0x3C, 0x38,
  0x70, 0x70, 0x1C, 0x0E, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE1, 0xC3, 0x81,
  0x87, 0x03, 0x1C, 0x06, 0x38, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1F,
  0xFC, 0x7F, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x40, 0x70, 0x38, 0x1C, 0x07, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x07, 0x83,
  0xC0, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x30, 0x0C, 0x31, 0xC7,
  0x1C, 0x61, 0x86, 0x18, 0xE3, 0x8C, 0x30, 0xC3, 0x1C, 0x71, 0x86, 0x18,
  0x63, 0x8E, 0x30, 0xC3, 0x0C, 0x00, 0x04, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x01, 0xE0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C,
  0x02, 0x00, 0x3C, 0x06, 0xFE, 0x0F, 0xFE, 0x3F, 0x1F, 0xEC, 0x1F, 0xC0,
  0x1E, 0x00,
};

const GFXglyph RobotoCondensed_Italic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 23, 8, 1, -23 },
  { 22, 8, 8, 10, 3, -25 },
  { 30, 17, 23, 18, 1, -23 },
  { 79, 14, 29, 16, 1, -26 },
  { 130, 15, 23, 20, 3, -23 },
  { 174, 15, 23, 17, 1, -23 },
  { 218, 3, 8, 6, 3, -25 },
  { 221, 10, 34, 10, 2, -26 },
  { 264, 10, 34, 10, -2, -26 },
  { 307, 13, 14, 14, 2, -23 },
  { 330, 14, 17, 16, 1, -20 },
  { 360, 6, 8, 6, -2, -4 },
  { 366, 7, 2, 8, 1, -11 },
  { 368, 3, 4, 8, 1, -4 },
  { 370, 15, 25, 12, -2, -23 },
  { 417, 13, 23, 16, 2, -23 },
  { 455, 8, 23, 16, 4, -23 },
  { 478, 15, 23, 16, 0, -23 },
  { 522, 14, 23, 16, 1, -23 },
  { 563, 15, 23, 16, 0, -23 },
  { 607, 14, 23, 16, 2, -23 },
  { 648, 12, 23, 16, 2, -23 },
  { 683, 15, 23, 16, 2, -23 },
  { 727, 14, 23, 16, 1, -23 },
  { 768, 13, 23, 16, 2, -23 },
  { 806, 6, 18, 8, 1, -18 },
  { 820, 8, 22, 7, -2, -18 },
  { 842, 12, 15, 14, 1, -18 },
  { 865, 12, 10, 15, 2, -16 },
  { 880, 13, 15, 15, 1, -18 },
  { 905, 11, 23, 14, 3, -23 },
  { 937, 22, 30, 25, 1, -23 },
  { 1020, 17, 23, 18, -1, -23 },
  { 1069, 16, 23, 17, 1, -23 },
  { 1115, 16, 23, 18, 2, -23 },
  { 1161, 16, 23, 18, 1, -23 },
  { 1207, 16, 23, 16, 1, -23 },
  { 1253, 16, 23, 15, 1, -23 },
  { 1299, 16, 23, 19, 2, -23 },
  { 1345, 19, 23, 20, 1, -23 },
  { 1400, 7, 23, 8, 1, -23 },
  { 1421, 16, 23, 15, 0, -23 },
  { 1467, 18, 23, 17, 1, -23 },
  { 1519, 12, 23, 15, 1, -23 },
  { 1554, 23, 23, 24, 1, -23 },
  { 1621, 19, 23, 20, 1, -23 },
  { 1676, 16, 23, 19, 2, -23 },
  { 1722, 17, 23, 18, 1, -23 },
  { 1771, 16, 27, 19, 2, -23 },
  { 1825, 16, 23, 17, 1, -23 },
  { 1871, 16, 23, 17, 1, -23 },
  { 1917, 15, 23, 17, 3, -23 },
  { 1961, 17, 23, 18, 1, -23 },
  { 2010, 17, 23, 18, 3, -23 },
  { 2059, 23, 23, 24, 3, -23 },
  { 2126, 20, 23, 18, -1, -23 },
  { 2184, 16, 23, 17, 3, -23 },
  { 2230, 17, 23, 17, 0, -23 },
  { 2279, 10, 32, 8, 0, -27 },
  { 2319, 6, 25, 12, 3, -23 },
  { 2338, 10, 32, 8, -2, -27 },
  { 2378, 10, 12, 12, 1, -23 },
  { 2393, 13, 2, 13, -2, 0 },
  { 2397, 6, 5, 10, 3, -25 },
  { 2401, 13, 17, 15, 1, -17 },
  { 2429, 14, 25, 16, 0, -25 },
  { 2473, 13, 17, 15, 1, -17 },
  { 2501, 15, 25, 16, 1, -25 },
  { 2548, 13, 17, 15, 1, -17 },
  { 2576, 10, 25, 10, 2, -25 },
  { 2608, 15, 24, 16, 0, -17 },
  { 2653, 14, 25, 15, 0, -25 },
  { 2697, 6, 23, 7, 1, -23 },
  { 2715, 10, 30, 7, -3, -23 },
  { 2753, 15, 25, 14, 0, -25 },
  { 2800, 7, 25, 7, 1, -25 },
  { 2822, 22, 17, 24, 0, -17 },
  { 2869, 14, 17, 16, 0, -17 },
  { 2899, 14, 17, 16, 1, -17 },
  { 2929, 15, 24, 16, -1, -17 },
  { 2974, 14, 24, 16, 1, -17 },
  { 3016, 10, 17, 10, 0, -17 },
  { 3038, 12, 17, 15, 1, -17 },
  { 3064, 9, 22, 9, 1, -22 },
  { 3089, 14, 17, 15, 1, -17 },
  { 3119, 12, 17, 14, 2, -17 },
  { 3145, 19, 17, 21, 2, -17 },
  { 3186, 15, 17, 14, -1, -17 },
  { 3218, 15, 24, 13, -1, -17 },
  { 3263, 14, 17, 14, 0, -17 },
  { 3293, 10, 32, 10, 1, -26 },
  { 3333, 6, 27, 8, 1, -23 },
  { 3354, 11, 32, 10, -2, -26 },
  { 3398, 15, 6, 19, 2, -12 },
};

const GFXfont RobotoCondensed_Italic33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_ITALIC33PT7B_H_
