#ifndef _ROBOTOCONDENSED_ITALIC10PT7B_H_
#define _ROBOTOCONDENSED_ITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x48, 0xF0, 0x19, 0x5E, 0x6F, 0xA9, 0x80, 0x11, 0x92, 0x82,
  0x0A, 0x4C, 0x40, 0xC5, 0xB8, 0x47, 0x54, 0xC0, 0x32, 0x94, 0xCA, 0xC9,
  0xC0, 0xC0, 0x2A, 0x49, 0x24, 0x90, 0x48, 0x92, 0x92, 0x90, 0x5D, 0x50,
  0x21, 0x1C, 0x42, 0x00, 0x58, 0xC0, 0x80, 0x12, 0x24, 0x44, 0x88, 0x32,
  0x52, 0xA9, 0x49, 0x80, 0x75, 0x24, 0x90, 0x32, 0x44, 0x22, 0x23, 0xC0,
  0x35, 0x13, 0x19, 0x60, 0x13, 0x35, 0xF1, 0x20, 0x78, 0xE2, 0x2A, 0xC0,
  0x73, 0xDB, 0x70, 0xF1, 0x24, 0x48, 0x80, 0x32, 0x54, 0x65, 0x49, 0x80,
  0x76, 0xDE, 0x70, 0x40, 0x80, 0x40, 0xA8, 0x16, 0x42, 0xE3, 0x80, 0x43,
  0x3C, 0xF4, 0xA8, 0x20, 0x1C, 0x45, 0x6B, 0x5A, 0xB5, 0x6F, 0x40, 0x70,
  0x11, 0x8C, 0xA7, 0xC6, 0x20, 0x7A, 0x52, 0xE4, 0xC7, 0xC0, 0x79, 0x88,
  0x89, 0xE0, 0x72, 0x52, 0x94, 0xC7, 0xC0, 0x7A, 0x10, 0xE4, 0x43, 0xC0,
  0x7A, 0x10, 0xE4, 0x42, 0x00, 0x79, 0x8B, 0x99, 0xE0, 0x45, 0x14, 0x5E,
  0x4A, 0x28, 0x80, 0x55, 0x68, 0x08, 0x44, 0x21, 0x49, 0x80, 0x49, 0x45,
  0x18, 0x52, 0x48, 0x80, 0x44, 0x44, 0x48, 0xF0, 0x62, 0xCD, 0x9B, 0x56,
  0xB2, 0xA5, 0x00, 0x45, 0x96, 0x56, 0x5A, 0x68, 0x80, 0x74, 0xA3, 0x29,
  0x4B, 0x80, 0x7A, 0x52, 0xF4, 0x42, 0x00, 0x3A, 0x52, 0x98, 0xA5, 0xC1,
  0x7A, 0x52, 0xE5, 0x4A, 0x40, 0x3A, 0x50, 0x61, 0x49, 0xC0, 0xF2, 0x10,
  0x84, 0x21, 0x00, 0x45, 0x24, 0x92, 0x8A, 0x27, 0x00, 0x8C, 0xA5, 0x4A,
  0x21, 0x00, 0x93, 0x6A, 0xD5, 0xAD, 0x9B, 0x24, 0x00, 0x48, 0xA3, 0x08,
  0x31, 0x49, 0x00, 0x94, 0xA8, 0xC4, 0x21, 0x00, 0x78, 0x44, 0x44, 0x23,
  0xC0, 0x69, 0x24, 0xA4, 0x98, 0xAA, 0x95, 0x22, 0x22, 0x22, 0x24, 0x44,
  0x25, 0xB0, 0x70, 0x90, 0x75, 0x79, 0x70, 0x44, 0x47, 0x59, 0x9F, 0x75,
  0x89, 0x60, 0x08, 0x42, 0xE5, 0x4A, 0x4E, 0x75, 0xF8, 0x60, 0x34, 0x46,
  0x44, 0x48, 0x6A, 0xA5, 0x27, 0x0B, 0x80, 0x44, 0x47, 0x59, 0x99, 0x45,
  0x68, 0x20, 0x92, 0x92, 0xC0, 0x42, 0x10, 0xA6, 0x32, 0x92, 0x55, 0x5A,
  0x7E, 0xA6, 0x4C, 0x99, 0x40, 0x75, 0x99, 0x90, 0x75, 0x99, 0x60, 0x75,
  0x99, 0xF8, 0x80, 0x72, 0xA5, 0x27, 0x08, 0x80, 0x6A, 0x48, 0x75, 0x69,
  0x60, 0x4B, 0xA4, 0x90, 0x55, 0x99, 0x70, 0xB7, 0x68, 0xAD, 0x7B, 0x69,
  0x00, 0x56, 0x26, 0xA0, 0x55, 0x66, 0x44, 0x80, 0x72, 0x24, 0xE0, 0x25,
  0x2C, 0x92, 0x48, 0x55, 0x6A, 0x49, 0x22, 0x92, 0x90, 0x6C, 0xC0,
};

const GFXglyph RobotoCondensed_Italic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -8 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 5, 7, 6, 1, -7 },
  { 20, 5, 7, 5, 0, -7 },
  { 25, 1, 2, 2, 1, -8 },
  { 26, 3, 10, 3, 1, -8 },
  { 30, 3, 10, 3, 0, -8 },
  { 34, 3, 4, 4, 1, -7 },
  { 36, 5, 5, 5, 0, -6 },
  { 40, 2, 3, 2, -1, -1 },
  { 41, 2, 1, 2, 0, -4 },
  { 42, 1, 1, 3, 0, -1 },
  { 43, 4, 8, 4, 0, -7 },
  { 47, 5, 7, 5, 0, -7 },
  { 52, 3, 7, 5, 1, -7 },
  { 55, 5, 7, 5, 0, -7 },
  { 60, 4, 7, 5, 0, -7 },
  { 64, 4, 7, 5, 0, -7 },
  { 68, 4, 7, 5, 1, -7 },
  { 72, 3, 7, 5, 1, -7 },
  { 75, 4, 7, 5, 1, -7 },
  { 79, 5, 7, 5, 0, -7 },
  { 84, 3, 7, 5, 1, -7 },
  { 87, 2, 5, 2, 0, -5 },
  { 89, 2, 7, 2, 0, -5 },
  { 91, 4, 4, 4, 0, -5 },
  { 93, 3, 3, 5, 1, -5 },
  { 95, 4, 4, 4, 0, -5 },
  { 97, 3, 7, 4, 1, -7 },
  { 100, 7, 9, 7, 0, -7 },
  { 108, 5, 7, 6, 0, -7 },
  { 113, 5, 7, 5, 0, -7 },
  { 118, 4, 7, 6, 1, -7 },
  { 122, 5, 7, 6, 0, -7 },
  { 127, 5, 7, 5, 0, -7 },
  { 132, 5, 7, 5, 0, -7 },
  { 137, 4, 7, 6, 1, -7 },
  { 141, 6, 7, 6, 0, -7 },
  { 147, 2, 7, 2, 0, -7 },
  { 149, 5, 7, 5, 0, -7 },
  { 154, 6, 7, 5, 0, -7 },
  { 160, 4, 7, 5, 0, -7 },
  { 164, 7, 7, 7, 0, -7 },
  { 171, 6, 7, 6, 0, -7 },
  { 177, 5, 7, 6, 1, -7 },
  { 182, 5, 7, 5, 0, -7 },
  { 187, 5, 8, 6, 0, -7 },
  { 192, 5, 7, 5, 0, -7 },
  { 197, 5, 7, 5, 0, -7 },
  { 202, 5, 7, 5, 1, -7 },
  { 207, 6, 7, 5, 0, -7 },
  { 213, 5, 7, 5, 1, -7 },
  { 218, 7, 7, 7, 1, -7 },
  { 225, 6, 7, 5, 0, -7 },
  { 231, 5, 7, 5, 1, -7 },
  { 236, 5, 7, 5, 0, -7 },
  { 241, 3, 10, 2, 0, -8 },
  { 245, 2, 8, 4, 1, -7 },
  { 247, 4, 10, 2, -1, -8 },
  { 252, 3, 4, 4, 0, -7 },
  { 254, 4, 1, 4, -1, 0 },
  { 255, 2, 2, 3, 1, -8 },
  { 256, 4, 5, 5, 0, -5 },
  { 259, 4, 8, 5, 0, -8 },
  { 263, 4, 5, 4, 0, -5 },
  { 266, 5, 8, 5, 0, -8 },
  { 271, 4, 5, 5, 0, -5 },
  { 274, 4, 8, 3, 0, -8 },
  { 278, 5, 7, 5, 0, -5 },
  { 283, 4, 8, 5, 0, -8 },
  { 287, 2, 7, 2, 0, -7 },
  { 289, 3, 9, 2, -1, -7 },
  { 293, 5, 8, 4, 0, -8 },
  { 298, 2, 8, 2, 0, -8 },
  { 300, 7, 5, 7, 0, -5 },
  { 305, 4, 5, 5, 0, -5 },
  { 308, 4, 5, 5, 0, -5 },
  { 311, 4, 7, 5, 0, -5 },
  { 315, 5, 7, 5, 0, -5 },
  { 320, 3, 5, 3, 0, -5 },
  { 322, 4, 5, 4, 0, -5 },
  { 325, 3, 7, 3, 0, -7 },
  { 328, 4, 5, 5, 0, -5 },
  { 331, 3, 5, 4, 1, -5 },
  { 333, 5, 5, 6, 1, -5 },
  { 337, 4, 5, 4, 0, -5 },
  { 340, 4, 7, 4, 0, -5 },
  { 344, 4, 5, 4, 0, -5 },
  { 347, 3, 10, 3, 0, -8 },
  { 351, 2, 8, 2, 0, -7 },
  { 353, 3, 10, 3, 0, -8 },
  { 357, 5, 2, 6, 0, -4 },
};

const GFXfont RobotoCondensed_Italic10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_ITALIC10PT7B_H_
