#ifndef _ROBOTOCONDENSED_ITALIC45PT7B_H_
#define _ROBOTOCONDENSED_ITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x78, 0x3E, 0x07, 0x81, 0xC0, 0x38, 0xE7, 0x1C, 0xE7, 0x9C, 0xE7, 0x1C,
  0xE3, 0x9C, 0x73, 0x8C, 0x61, 0x8C, 0x73, 0x8E, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00,
  0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x38,
  0x70, 0x01, 0xC1, 0xC0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3, 0x80, 0x07,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xF0,
  0x78, 0x3C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x80,
  0x70, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x78, 0x03, 0x8F, 0x00, 0x71, 0xE0, 0x1E,
  0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF8, 0x3E, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x06, 0x30, 0x70, 0x7B, 0x83, 0x83, 0x9C, 0x1C, 0x38,
  0xE0, 0xE3, 0x87, 0x07, 0x1C, 0x38, 0x39, 0xC0, 0xE3, 0x9C, 0x07, 0xFD,
  0xE0, 0x1F, 0xCE, 0x00, 0x7C, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x3E, 0x00, 0x73, 0xF8, 0x07, 0xBF, 0xE0, 0x39, 0xC7, 0x03, 0x9C,
  0x1C, 0x38, 0xE0, 0xE1, 0xC7, 0x07, 0x1C, 0x38, 0x39, 0xC1, 0x81, 0xCE,
  0x0C, 0x1C, 0xE0, 0x70, 0xE2, 0x03, 0x8F, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07,
  0xCF, 0x80, 0x3C, 0x3C, 0x03, 0xC0, 0xE0, 0x1E, 0x07, 0x00, 0xF0, 0x38,
  0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xE0, 0x07, 0xBE, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0xFB, 0xC3, 0xC7, 0x9E, 0x1E, 0x78, 0x78, 0xE7, 0xC3, 0xC7, 0x3C, 0x0F,
  0x79, 0xE0, 0x7B, 0x9E, 0x01, 0xFC, 0xF0, 0x0F, 0xC3, 0x80, 0x3E, 0x1E,
  0x01, 0xE0, 0xF0, 0x1F, 0x83, 0xE3, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xE7,
  0x80, 0xFC, 0x1E, 0x7B, 0x9C, 0xE7, 0x3B, 0x9C, 0xE7, 0x38, 0x00, 0x08,
  0x00, 0x60, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x08, 0x00, 0x01, 0x00, 0x0C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x40, 0x00, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x17,
  0x8E, 0x3D, 0xFB, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xF0, 0x03, 0xDC, 0x01, 0xE7, 0x80, 0xF0, 0xE0, 0x78, 0x3C,
  0x0E, 0x07, 0x01, 0x01, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x3C, 0x78,
  0xF3, 0xC7, 0x8F, 0x3C, 0xF1, 0xC1, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x77,
  0xFF, 0xF7, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xC0,
  0x7F, 0xF8, 0x1F, 0x3E, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x1C, 0x70,
  0x07, 0x3C, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x1C, 0xE0, 0x0F, 0x78, 0x03,
  0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xE7,
  0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x73, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x87, 0x01, 0xE1, 0xE0, 0xF0, 0x7C, 0x7C,
  0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x0F, 0x07, 0xF1,
  0xFE, 0x7F, 0xE7, 0xFE, 0x71, 0xEC, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xE7, 0xC0, 0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x3C,
  0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x70, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xE0,
  0x0F, 0xFE, 0x03, 0xE3, 0xE0, 0xF8, 0x3E, 0x1E, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xE1, 0xE0, 0x3C, 0x3C,
  0x0F, 0x07, 0xE7, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xDE, 0x00, 0x3D, 0xE0, 0x07, 0x9C,
  0x00, 0x73, 0xC0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xC3,
  0xC0, 0x78, 0x38, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3C, 0x07, 0x87, 0x80, 0x70, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xEF,
  0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xE0, 0xF8, 0x04,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x87, 0x00, 0xF0,
  0x78, 0x0F, 0x07, 0x81, 0xE0, 0x3E, 0x7E, 0x03, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x9F, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0xFE, 0x7C, 0xFC,
  0x1E, 0x7C, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x00, 0x7B,
  0x80, 0x3D, 0xC0, 0x1E, 0xE0, 0x0F, 0x70, 0x0F, 0x3C, 0x07, 0x9E, 0x03,
  0xCF, 0x03, 0xC3, 0xE7, 0xC1, 0xFF, 0xE0, 0x7F, 0xC0, 0x0F, 0xC0, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0,
  0x0F, 0xFE, 0x03, 0xE7, 0xC0, 0xF8, 0x3C, 0x1E, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x0E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xC0,
  0xE0, 0x78, 0x1F, 0x3E, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07,
  0xC3, 0xC1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x0E, 0x3C,
  0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x78,
  0x1F, 0x07, 0xC7, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xE7, 0xE3, 0xE0, 0xF1, 0xE0, 0x79,
  0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xB8, 0x03, 0xDC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3D, 0xC0, 0x3C, 0xF0, 0x3E, 0x78, 0x3F, 0x3F,
  0x3F, 0x8F, 0xFF, 0xC3, 0xFD, 0xC0, 0xF9, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7E, 0x03, 0xFE,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x0E, 0x0F, 0x1F, 0x1F, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0x70, 0x01, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x08, 0x1F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF,
  0x80, 0x08, 0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xDE, 0x07, 0xBC, 0x07, 0x78,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xF0,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x18, 0x3C, 0x07, 0xC0, 0x30, 0x70, 0x1F, 0xE0, 0x61, 0xE0, 0x7F, 0xE0,
  0xE3, 0x81, 0xE1, 0xC1, 0xC7, 0x07, 0x83, 0x83, 0x9C, 0x0E, 0x0F, 0x07,
  0x38, 0x3C, 0x1C, 0x0E, 0x70, 0x70, 0x38, 0x19, 0xC1, 0xE0, 0x70, 0x33,
  0x83, 0x81, 0xE0, 0x67, 0x07, 0x03, 0x81, 0xCE, 0x0E, 0x07, 0x03, 0x9C,
  0x3C, 0x0E, 0x06, 0x38, 0x78, 0x38, 0x0C, 0xE0, 0xF0, 0x70, 0x39, 0xC1,
  0xE1, 0xE0, 0x63, 0x83, 0xC3, 0xC1, 0xC7, 0x07, 0x8F, 0x87, 0x06, 0x07,
  0xFB, 0xFC, 0x0C, 0x0F, 0xE7, 0xF0, 0x1C, 0x0F, 0x07, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x18,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xC3, 0x80,
  0x07, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x3C, 0x01,
  0xE0, 0x78, 0x03, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x78,
  0x03, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xE7, 0x80, 0x01,
  0xCF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0x80, 0x78, 0x1E,
  0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01,
  0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0x78, 0x1F, 0x81,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x78, 0x0F, 0x83, 0xC0,
  0x1E, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x0E, 0x00, 0x38, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1E,
  0x01, 0xF0, 0x78, 0x3F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFE, 0xFE,
  0x07, 0xC0, 0x78, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E,
  0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x03, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x3C, 0x0F, 0x01, 0xF0, 0x3F, 0x9F, 0x80, 0x7F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xFC, 0x07, 0x80, 0xF8, 0x1E, 0x01, 0xE0, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x78,
  0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x03, 0xF0, 0x78, 0x7F,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x1F, 0xDF, 0xC0, 0x7C, 0x07, 0x81, 0xF0, 0x07, 0x83, 0xC0,
  0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x38, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x1F, 0xF8, 0xF0, 0x3F, 0xF1, 0xE0, 0x7F, 0xE3,
  0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xF0, 0x07, 0xC1, 0xE0,
  0x1F, 0x03, 0xF9, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0x03, 0xC1, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xC0,
  0xF0, 0x3E, 0x07, 0xF7, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFC,
  0x00, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0x80, 0xF0,
  0x0F, 0x80, 0x78, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x1E,
  0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x03, 0xC7, 0xC0, 0x01,
  0xE7, 0xC0, 0x01, 0xE7, 0xC0, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xEF, 0x00,
  0x07, 0xE3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x3C,
  0x00, 0x70, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFE, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFC, 0x0F, 0xF0, 0x03, 0xDC, 0x0E, 0xF0, 0x03, 0xFC, 0x0E, 0x70, 0x07,
  0xBC, 0x1E, 0x70, 0x07, 0xBC, 0x1E, 0x70, 0x0F, 0x3C, 0x1E, 0x78, 0x0F,
  0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x3C,
  0x78, 0x3C, 0x38, 0x3C, 0x78, 0x3C, 0x38, 0x78, 0x78, 0x3C, 0x38, 0x78,
  0xF0, 0x3C, 0x3C, 0xF0, 0xF0, 0x3C, 0x3C, 0xF0, 0xF0, 0x38, 0x3D, 0xE0,
  0xF0, 0x78, 0x1D, 0xE0, 0xF0, 0x78, 0x1F, 0xC0, 0xE0, 0x78, 0x1F, 0xC1,
  0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0xF0, 0x1F, 0x01,
  0xE0, 0xF0, 0x0F, 0x01, 0xE0, 0xF0, 0x0E, 0x03, 0xC0, 0x07, 0xC0, 0x03,
  0xC1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x38, 0x1F, 0x80, 0x1E, 0x07, 0xE0,
  0x07, 0x81, 0xF8, 0x01, 0xE0, 0xFF, 0x00, 0x78, 0x3F, 0xC0, 0x1E, 0x0F,
  0x70, 0x07, 0x03, 0xDE, 0x03, 0xC0, 0xF7, 0x80, 0xF0, 0x3C, 0xE0, 0x3C,
  0x1E, 0x3C, 0x0F, 0x07, 0x8F, 0x03, 0xC1, 0xE1, 0xC1, 0xE0, 0x78, 0x78,
  0x78, 0x1E, 0x1E, 0x1E, 0x07, 0x83, 0x87, 0x83, 0xC0, 0xF1, 0xE0, 0xF0,
  0x3C, 0x78, 0x3C, 0x07, 0x3C, 0x0F, 0x01, 0xEF, 0x03, 0xC0, 0x7B, 0xC0,
  0xF0, 0x0E, 0xF0, 0x78, 0x03, 0xFC, 0x1E, 0x00, 0xFF, 0x07, 0x80, 0x1F,
  0x81, 0xE0, 0x07, 0xE0, 0x78, 0x01, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00,
  0x0F, 0x83, 0xC0, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0x81, 0xF0, 0x07, 0x83, 0xC0,
  0x0F, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x00, 0x03, 0x9E, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3,
  0xC0, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xF0, 0x0F, 0x81, 0xE0,
  0x3E, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x3E, 0x0F, 0x03, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0x81,
  0xF0, 0x0F, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x78,
  0x00, 0x38, 0xF0, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0xCF, 0x00,
  0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1,
  0xE0, 0x0F, 0x81, 0xE0, 0x3E, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0x80, 0x78, 0x1E, 0x01,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x1F, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xE0,
  0x1F, 0x07, 0x83, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1F, 0x07, 0x80, 0x3C, 0x1E, 0x00,
  0xF0, 0x78, 0x03, 0xC1, 0xC0, 0x0F, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x0E, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x87,
  0x80, 0x3C, 0x1F, 0x01, 0xF0, 0x3F, 0xBF, 0x80, 0x7F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x3C,
  0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0xE0, 0x0F, 0x03, 0xC0, 0x3C,
  0x07, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xC7,
  0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xE0, 0x01, 0xC7, 0x80,
  0x03, 0xCF, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0xE0, 0x07, 0x80, 0x3D, 0xC0, 0x1F, 0x00, 0xF3, 0x80, 0x3E, 0x01, 0xE7,
  0x00, 0xFC, 0x03, 0xCE, 0x01, 0xF8, 0x0F, 0x1C, 0x03, 0xF0, 0x1E, 0x38,
  0x0F, 0xE0, 0x3C, 0x78, 0x1D, 0xC0, 0xF0, 0xF0, 0x3B, 0x81, 0xE1, 0xE0,
  0xF7, 0x03, 0x83, 0xC1, 0xCE, 0x0F, 0x07, 0x87, 0x9C, 0x1E, 0x0F, 0x0E,
  0x38, 0x38, 0x1E, 0x1C, 0x70, 0xF0, 0x3C, 0x78, 0xE1, 0xE0, 0x78, 0xE1,
  0xC3, 0x80, 0xF1, 0xC3, 0x8F, 0x01, 0xE7, 0x03, 0x9E, 0x03, 0xCE, 0x07,
  0x38, 0x07, 0xBC, 0x0E, 0xF0, 0x0F, 0x70, 0x1D, 0xE0, 0x1E, 0xE0, 0x3B,
  0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0x80,
  0x07, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0,
  0xF0, 0x00, 0x7B, 0xE0, 0x03, 0xE7, 0x80, 0x1F, 0x1E, 0x00, 0x78, 0x78,
  0x03, 0xE1, 0xE0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x00, 0x70, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3C, 0x00,
  0x39, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC1,
  0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC1,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xB0, 0x1D,
  0xC1, 0xEE, 0x0E, 0x70, 0xF3, 0x87, 0x1C, 0x78, 0xE3, 0x87, 0xBC, 0x3D,
  0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF1,
  0xE1, 0xE1, 0xC1, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3E,
  0x3E, 0x1F, 0x07, 0x87, 0x80, 0xE1, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x1F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0x81, 0xC7,
  0xC0, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xE0,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFD, 0xE0, 0x7E, 0x38, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0xF8,
  0x0F, 0x7F, 0xC1, 0xFF, 0xF8, 0x3F, 0x9F, 0x87, 0xC0, 0xF0, 0xF0, 0x1E,
  0x1C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E,
  0x70, 0x03, 0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79,
  0xE0, 0x0E, 0x38, 0x03, 0xCF, 0x80, 0x79, 0xF8, 0x1E, 0x3F, 0xCF, 0xC7,
  0xBF, 0xF0, 0xE7, 0xFC, 0x1C, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3E, 0x3E, 0x1E, 0x07, 0x8F, 0x80, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x78, 0x01, 0xDE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x9C, 0x01, 0xC7,
  0x80, 0xF1, 0xE0, 0x78, 0x3E, 0x3E, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x7E, 0x38, 0x0F, 0xFB, 0xC0, 0xFF, 0xFE, 0x0F,
  0xE7, 0xF0, 0x7C, 0x0F, 0x87, 0xC0, 0x7C, 0x3C, 0x01, 0xC1, 0xE0, 0x1E,
  0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0,
  0x0E, 0x0E, 0x00, 0xF0, 0x70, 0x07, 0x83, 0x80, 0x3C, 0x1C, 0x01, 0xE0,
  0xE0, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x81, 0xFD, 0xFC, 0x07, 0xFF,
  0xE0, 0x1F, 0xEF, 0x00, 0x7E, 0x70, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3E, 0x3E, 0x1E, 0x07, 0x87, 0x80, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0x9C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x41, 0xF0, 0x38, 0x3E, 0x3F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0x80, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xA0, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x01, 0xFF, 0xC3, 0xFF, 0x87,
  0xFF, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x70, 0x1F, 0xF3, 0x81, 0xFF,
  0xDC, 0x1F, 0xCF, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x03, 0x83,
  0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03,
  0xC3, 0xC0, 0x1C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x78, 0x38,
  0x03, 0xC1, 0xC0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xFB, 0xF8,
  0x0F, 0xFF, 0xC0, 0x3F, 0xDE, 0x00, 0xFC, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x06, 0x03, 0xE0, 0x7E, 0x7E, 0x01,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE3, 0xE0, 0x7B, 0xFC, 0x1F,
  0xFF, 0x87, 0xF3, 0xE1, 0xF0, 0x7C, 0x78, 0x0F, 0x1C, 0x03, 0xCF, 0x00,
  0xF3, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x03, 0x8E, 0x01, 0xE3, 0x80, 0x79,
  0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x1E, 0x38, 0x07,
  0x80, 0x03, 0x03, 0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x0B, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0x8F, 0x03, 0xE1, 0xE0, 0xF8,
  0x3C, 0x3E, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1C, 0x78, 0x07, 0x9F, 0x00,
  0xF7, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03,
  0xF7, 0x00, 0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x38, 0x3C, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x1E, 0x1C,
  0x01, 0xE0, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x0E, 0x7E, 0x07, 0xC0, 0x7B, 0xFC, 0x7F,
  0xC1, 0xFF, 0xFB, 0xFF, 0x07, 0xF7, 0xFF, 0x7E, 0x1F, 0x07, 0xF0, 0x78,
  0x78, 0x0F, 0x81, 0xE1, 0xC0, 0x3C, 0x03, 0x8F, 0x00, 0xF0, 0x0E, 0x3C,
  0x03, 0xC0, 0x38, 0xF0, 0x0E, 0x01, 0xE3, 0xC0, 0x78, 0x07, 0x8F, 0x01,
  0xE0, 0x1E, 0x38, 0x07, 0x80, 0x79, 0xE0, 0x1E, 0x01, 0xE7, 0x80, 0x78,
  0x07, 0x1E, 0x01, 0xC0, 0x3C, 0x78, 0x0F, 0x00, 0xF1, 0xC0, 0x3C, 0x03,
  0xCF, 0x00, 0xF0, 0x0F, 0x3C, 0x03, 0xC0, 0x3C, 0xF0, 0x0F, 0x00, 0xE3,
  0xC0, 0x38, 0x07, 0x8F, 0x01, 0xE0, 0x1E, 0x38, 0x07, 0x80, 0x78, 0x0E,
  0x3E, 0x07, 0xBF, 0xC1, 0xFF, 0xF8, 0x7F, 0x3E, 0x1F, 0x07, 0xC7, 0x80,
  0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x38,
  0xE0, 0x1E, 0x38, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x78,
  0x0F, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03,
  0x8F, 0x01, 0xE3, 0x80, 0x78, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xE7, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x00, 0x79, 0xE0, 0x0F,
  0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E,
  0xE0, 0x03, 0x9C, 0x00, 0xF3, 0x80, 0x1E, 0x70, 0x03, 0xCF, 0x00, 0xF1,
  0xE0, 0x1E, 0x3E, 0x07, 0x83, 0xE3, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00,
  0x3F, 0x80, 0x03, 0x9F, 0x80, 0x3D, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xE7,
  0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x1C, 0x01, 0xC1, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0xE0,
  0x0F, 0x0F, 0x80, 0x78, 0x7C, 0x07, 0x83, 0xF8, 0xFC, 0x1F, 0xFF, 0xC0,
  0xF7, 0xFC, 0x07, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0xE0, 0x7F, 0xCE, 0x0F, 0xFF,
  0xE1, 0xF8, 0xFE, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x01, 0xC3, 0xC0,
  0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x03, 0x87, 0x00, 0x78, 0x70, 0x07, 0x87, 0x00, 0x78, 0x70, 0x07, 0x87,
  0x00, 0x70, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0x7E, 0x3F, 0x03, 0xFF, 0xF0,
  0x1F, 0xEF, 0x00, 0xFC, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x0E, 0x78, 0xF7, 0xC7, 0xFE, 0x3F, 0xF1, 0xF8,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x03,
  0xFF, 0xC1, 0xFB, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x1E, 0x38, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0x9F,
  0x03, 0xC7, 0xCF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF8, 0x3F,
  0x03, 0xE0, 0x3C, 0x00, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0x8E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07,
  0x9E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0xF8, 0xFD, 0xFE, 0x1F, 0xFF, 0x03, 0xFD, 0xC0, 0x7C, 0xF0, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0x70, 0x38,
  0x70, 0x78, 0x70, 0x78, 0x70, 0x70, 0x70, 0xF0, 0x78, 0xE0, 0x79, 0xE0,
  0x39, 0xC0, 0x39, 0xC0, 0x3B, 0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xF0, 0x1E,
  0x03, 0xFC, 0x07, 0x80, 0xFF, 0x03, 0xE0, 0x7B, 0xC0, 0xF8, 0x1E, 0xF0,
  0x7E, 0x07, 0x3C, 0x1F, 0x83, 0xCF, 0x07, 0xE0, 0xF3, 0xC3, 0xF8, 0x78,
  0xF0, 0xEE, 0x1E, 0x1C, 0x7B, 0x87, 0x07, 0x1C, 0xE3, 0xC1, 0xCF, 0x38,
  0xE0, 0x73, 0x8F, 0x38, 0x1C, 0xE3, 0xDE, 0x07, 0x78, 0x77, 0x01, 0xDC,
  0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01,
  0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x07, 0x80, 0x78,
  0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0xF8,
  0x0F, 0x07, 0x80, 0x38, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0x3B,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xBC,
  0x00, 0x7C, 0xE0, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xE0, 0xF0, 0x1E,
  0x07, 0x81, 0xE0, 0x3C, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x3C, 0x07,
  0xC1, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x0F, 0x00, 0x70, 0x78, 0x03, 0x83, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xE0,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x38, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x80,
  0x0E, 0x00, 0x04, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x00, 0x01,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x03, 0xC0,
  0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0xE3, 0xFE, 0x03, 0x8F,
  0xFC, 0x0E, 0x78, 0x78, 0x79, 0xC1, 0xFF, 0xCF, 0x03, 0xFF, 0x3C, 0x07,
  0xF8, 0x00, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_Italic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 32, 11, 1, -32 },
  { 41, 11, 11, 14, 4, -34 },
  { 57, 22, 32, 24, 2, -32 },
  { 145, 19, 41, 22, 2, -37 },
  { 243, 21, 32, 28, 4, -32 },
  { 327, 21, 32, 24, 1, -32 },
  { 411, 5, 11, 8, 4, -34 },
  { 418, 14, 46, 14, 2, -36 },
  { 499, 13, 46, 14, -2, -36 },
  { 574, 18, 19, 19, 2, -32 },
  { 617, 18, 23, 22, 2, -26 },
  { 669, 7, 11, 9, -2, -5 },
  { 679, 9, 3, 11, 1, -15 },
  { 683, 5, 5, 12, 1, -5 },
  { 687, 20, 35, 16, -2, -32 },
  { 775, 18, 32, 22, 2, -32 },
  { 847, 12, 32, 22, 5, -32 },
  { 895, 21, 32, 22, 0, -32 },
  { 979, 19, 32, 22, 1, -32 },
  { 1055, 20, 32, 22, 0, -32 },
  { 1135, 20, 32, 22, 2, -32 },
  { 1215, 17, 32, 22, 2, -32 },
  { 1283, 20, 32, 22, 3, -32 },
  { 1363, 19, 32, 22, 2, -32 },
  { 1439, 17, 32, 22, 3, -32 },
  { 1507, 8, 24, 10, 1, -24 },
  { 1531, 11, 30, 9, -2, -24 },
  { 1573, 16, 20, 19, 2, -24 },
  { 1613, 18, 14, 21, 2, -22 },
  { 1645, 18, 20, 20, 1, -24 },
  { 1690, 15, 32, 18, 4, -32 },
  { 1750, 31, 41, 34, 1, -31 },
  { 1909, 23, 32, 25, -1, -32 },
  { 2001, 22, 32, 24, 1, -32 },
  { 2089, 22, 32, 25, 2, -32 },
  { 2177, 22, 32, 25, 1, -32 },
  { 2265, 22, 32, 22, 1, -32 },
  { 2353, 22, 32, 21, 1, -32 },
  { 2441, 23, 32, 26, 2, -32 },
  { 2533, 26, 32, 27, 1, -32 },
  { 2637, 10, 32, 11, 1, -32 },
  { 2677, 21, 32, 21, 0, -32 },
  { 2761, 25, 32, 24, 1, -32 },
  { 2861, 17, 32, 21, 1, -32 },
  { 2929, 32, 32, 33, 1, -32 },
  { 3057, 26, 32, 27, 1, -32 },
  { 3161, 23, 32, 26, 2, -32 },
  { 3253, 23, 32, 24, 1, -32 },
  { 3345, 23, 37, 26, 2, -32 },
  { 3452, 22, 32, 23, 1, -32 },
  { 3540, 22, 32, 23, 1, -32 },
  { 3628, 21, 32, 23, 4, -32 },
  { 3712, 23, 32, 25, 2, -32 },
  { 3804, 23, 32, 24, 4, -32 },
  { 3896, 31, 32, 33, 4, -32 },
  { 4020, 27, 32, 24, -1, -32 },
  { 4128, 22, 32, 23, 4, -32 },
  { 4216, 24, 32, 23, 0, -32 },
  { 4312, 14, 44, 11, 0, -37 },
  { 4389, 9, 35, 16, 4, -32 },
  { 4429, 13, 44, 11, -2, -37 },
  { 4501, 13, 16, 16, 2, -32 },
  { 4527, 17, 3, 18, -2, 0 },
  { 4534, 7, 6, 13, 5, -33 },
  { 4540, 18, 24, 21, 1, -24 },
  { 4594, 19, 34, 22, 1, -34 },
  { 4675, 18, 24, 20, 1, -24 },
  { 4729, 21, 34, 22, 1, -34 },
  { 4819, 18, 24, 20, 1, -24 },
  { 4873, 15, 34, 14, 2, -34 },
  { 4937, 21, 33, 22, 0, -24 },
  { 5024, 18, 34, 21, 1, -34 },
  { 5101, 9, 33, 10, 1, -33 },
  { 5139, 14, 42, 10, -4, -33 },
  { 5213, 19, 34, 20, 1, -34 },
  { 5294, 9, 34, 10, 1, -34 },
  { 5333, 30, 24, 33, 1, -24 },
  { 5423, 18, 24, 21, 1, -24 },
  { 5477, 19, 24, 22, 1, -24 },
  { 5534, 21, 33, 22, -1, -24 },
  { 5621, 20, 33, 22, 1, -24 },
  { 5704, 13, 24, 13, 1, -24 },
  { 5743, 17, 24, 20, 1, -24 },
  { 5794, 11, 30, 13, 2, -30 },
  { 5836, 18, 24, 21, 2, -24 },
  { 5890, 16, 24, 19, 3, -24 },
  { 5938, 26, 24, 28, 3, -24 },
  { 6016, 21, 24, 19, -1, -24 },
  { 6079, 21, 33, 18, -2, -24 },
  { 6166, 19, 24, 19, 0, -24 },
  { 6223, 15, 43, 13, 1, -35 },
  { 6304, 9, 38, 11, 1, -32 },
  { 6347, 14, 43, 13, -2, -35 },
  { 6423, 22, 9, 26, 2, -18 },
};

const GFXfont RobotoCondensed_Italic45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_ITALIC45PT7B_H_
