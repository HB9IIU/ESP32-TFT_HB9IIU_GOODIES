#ifndef _ROBOTOCONDENSED_ITALIC11PT7B_H_
#define _ROBOTOCONDENSED_ITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x84, 0xB7, 0x00, 0x14, 0x57, 0xCA, 0x29, 0xE5, 0x14,
  0x11, 0x92, 0x92, 0x08, 0x32, 0x71, 0x00, 0x45, 0x6D, 0xC3, 0xB6, 0xA3,
  0x31, 0x54, 0x46, 0xCE, 0x4F, 0xE0, 0x29, 0x49, 0x24, 0x92, 0x40, 0x22,
  0x11, 0x11, 0x12, 0x22, 0x48, 0x24, 0xEA, 0xA0, 0x11, 0x1E, 0x42, 0x00,
  0x58, 0xC0, 0x80, 0x08, 0x44, 0x22, 0x10, 0x88, 0x40, 0x69, 0x99, 0x99,
  0xAE, 0x3C, 0x94, 0x92, 0x3A, 0x42, 0x21, 0x11, 0x1E, 0x32, 0x42, 0x61,
  0x0A, 0x4C, 0x08, 0xCA, 0xA5, 0x7C, 0x42, 0x74, 0x8E, 0x11, 0xAE, 0x24,
  0x8E, 0x99, 0xAE, 0xF0, 0x84, 0x44, 0x22, 0x10, 0x3A, 0x52, 0x65, 0x4A,
  0x4E, 0x69, 0x99, 0xF2, 0x2C, 0x40, 0x20, 0x20, 0x00, 0x94, 0x13, 0xC6,
  0x10, 0xF0, 0xE0, 0x41, 0x86, 0xC8, 0x00, 0x69, 0x22, 0x44, 0x08, 0x1E,
  0x22, 0x4D, 0x55, 0xA5, 0xA9, 0xAA, 0xB6, 0x40, 0x38, 0x10, 0x8A, 0x54,
  0xBE, 0x31, 0x39, 0x14, 0x9C, 0x49, 0x28, 0xBC, 0x76, 0x63, 0x08, 0x4A,
  0x5C, 0x39, 0x14, 0x51, 0x49, 0x28, 0xBC, 0x3D, 0x04, 0x1E, 0x41, 0x08,
  0x3C, 0x39, 0x04, 0x1C, 0x41, 0x08, 0x20, 0x74, 0x61, 0x0B, 0xCA, 0x5E,
  0x22, 0x89, 0x13, 0xE4, 0x48, 0xA2, 0x44, 0x29, 0x24, 0x94, 0x08, 0x42,
  0x11, 0x0A, 0x4C, 0x25, 0x25, 0x18, 0x51, 0x48, 0xA2, 0x24, 0x44, 0x44,
  0x8F, 0x21, 0x63, 0x63, 0x66, 0x56, 0x5A, 0x9A, 0x92, 0x22, 0xC9, 0x92,
  0xA5, 0x4A, 0xA2, 0x44, 0x76, 0x63, 0x18, 0xC6, 0x5C, 0x39, 0x14, 0x51,
  0x79, 0x08, 0x20, 0x74, 0x63, 0x18, 0xC6, 0x5C, 0x10, 0x39, 0x14, 0x52,
  0x79, 0x48, 0xA2, 0x39, 0x24, 0x18, 0x18, 0x28, 0x9C, 0xF9, 0x08, 0x84,
  0x21, 0x08, 0x45, 0x14, 0x51, 0x49, 0x24, 0x9C, 0x8A, 0x29, 0x24, 0x51,
  0x86, 0x10, 0x92, 0x92, 0xB2, 0xAC, 0xAC, 0xCC, 0xC8, 0x88, 0x44, 0xA2,
  0x8C, 0x31, 0xC5, 0x22, 0x8C, 0x94, 0xC6, 0x21, 0x08, 0x7C, 0x21, 0x04,
  0x21, 0x04, 0x3E, 0x29, 0x24, 0x94, 0x93, 0x00, 0xAA, 0x55, 0x40, 0x31,
  0x22, 0x22, 0x22, 0x24, 0xC0, 0x22, 0x55, 0xF8, 0x90, 0x32, 0x5D, 0x29,
  0x38, 0x42, 0x10, 0xE4, 0xA6, 0x32, 0xF0, 0x32, 0x61, 0x09, 0x38, 0x08,
  0x42, 0xF4, 0xC6, 0x52, 0x70, 0x32, 0x5F, 0x08, 0x38, 0x69, 0x69, 0x24,
  0x80, 0x7A, 0x63, 0x29, 0x38, 0x5C, 0x42, 0x10, 0xE4, 0xA6, 0x52, 0x90,
  0x41, 0x24, 0xA4, 0x20, 0x92, 0x52, 0x58, 0x42, 0x10, 0xB5, 0x31, 0x92,
  0x90, 0x29, 0x24, 0x94, 0x80, 0x76, 0x95, 0x2A, 0x99, 0x32, 0x40, 0x72,
  0x52, 0xA9, 0x48, 0x32, 0x63, 0x19, 0x38, 0x72, 0x53, 0x19, 0x7A, 0x10,
  0x7A, 0x63, 0x29, 0x38, 0x42, 0x69, 0x29, 0x00, 0x74, 0x43, 0x96, 0x3D,
  0x24, 0x90, 0x4A, 0x52, 0xA9, 0x38, 0x9A, 0xAC, 0xC8, 0xA6, 0x9D, 0xB6,
  0x92, 0x40, 0x52, 0x88, 0xC6, 0x48, 0x52, 0x94, 0xC6, 0x21, 0x10, 0x78,
  0x88, 0x84, 0x78, 0x12, 0x22, 0x4C, 0x44, 0x44, 0x40, 0x55, 0x5A, 0x80,
  0x22, 0x22, 0x21, 0x22, 0x24, 0x40, 0xCD, 0x80,
};

const GFXglyph RobotoCondensed_Italic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 3, 3, 3, 1, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 10, 5, 0, -9 },
  { 19, 5, 8, 7, 1, -8 },
  { 24, 5, 8, 6, 0, -8 },
  { 29, 1, 3, 2, 1, -8 },
  { 30, 3, 12, 3, 1, -9 },
  { 35, 4, 12, 3, -1, -9 },
  { 41, 4, 5, 5, 1, -8 },
  { 44, 5, 5, 5, 0, -6 },
  { 48, 2, 3, 2, -1, -1 },
  { 49, 3, 1, 3, 0, -4 },
  { 50, 1, 1, 3, 0, -1 },
  { 51, 5, 9, 4, -1, -8 },
  { 57, 4, 8, 5, 1, -8 },
  { 61, 3, 8, 5, 1, -8 },
  { 64, 5, 8, 5, 0, -8 },
  { 69, 5, 8, 5, 0, -8 },
  { 74, 5, 8, 5, 0, -8 },
  { 79, 4, 8, 5, 1, -8 },
  { 83, 4, 8, 5, 1, -8 },
  { 87, 5, 8, 5, 1, -8 },
  { 92, 5, 8, 5, 0, -8 },
  { 97, 4, 8, 5, 1, -8 },
  { 101, 2, 6, 3, 0, -6 },
  { 103, 3, 8, 2, -1, -6 },
  { 106, 4, 5, 5, 0, -6 },
  { 109, 4, 3, 5, 1, -5 },
  { 111, 5, 5, 5, 0, -6 },
  { 115, 4, 8, 5, 1, -8 },
  { 119, 8, 10, 8, 0, -8 },
  { 129, 5, 8, 6, 0, -8 },
  { 134, 6, 8, 6, 0, -8 },
  { 140, 5, 8, 6, 1, -8 },
  { 145, 6, 8, 6, 0, -8 },
  { 151, 6, 8, 5, 0, -8 },
  { 157, 6, 8, 5, 0, -8 },
  { 163, 5, 8, 6, 1, -8 },
  { 168, 7, 8, 7, 0, -8 },
  { 175, 3, 8, 3, 0, -8 },
  { 178, 5, 8, 5, 0, -8 },
  { 183, 6, 8, 6, 0, -8 },
  { 189, 4, 8, 5, 0, -8 },
  { 193, 8, 8, 8, 0, -8 },
  { 201, 7, 8, 7, 0, -8 },
  { 208, 5, 8, 6, 1, -8 },
  { 213, 6, 8, 6, 0, -8 },
  { 219, 5, 9, 6, 1, -8 },
  { 225, 6, 8, 6, 0, -8 },
  { 231, 6, 8, 6, 0, -8 },
  { 237, 5, 8, 6, 1, -8 },
  { 242, 6, 8, 6, 0, -8 },
  { 248, 6, 8, 6, 1, -8 },
  { 254, 8, 8, 8, 1, -8 },
  { 262, 6, 8, 6, 0, -8 },
  { 268, 5, 8, 6, 1, -8 },
  { 273, 6, 8, 6, 0, -8 },
  { 279, 3, 11, 3, 0, -9 },
  { 284, 2, 9, 4, 1, -8 },
  { 287, 4, 11, 3, -1, -9 },
  { 293, 4, 4, 4, 0, -8 },
  { 295, 5, 1, 4, -1, 0 },
  { 296, 2, 2, 3, 1, -9 },
  { 297, 5, 6, 5, 0, -6 },
  { 301, 5, 9, 5, 0, -9 },
  { 307, 5, 6, 5, 0, -6 },
  { 311, 5, 9, 5, 0, -9 },
  { 317, 5, 6, 5, 0, -6 },
  { 321, 3, 9, 3, 1, -9 },
  { 325, 5, 8, 5, 0, -6 },
  { 330, 5, 9, 5, 0, -9 },
  { 336, 3, 8, 2, 0, -8 },
  { 339, 3, 10, 2, -1, -8 },
  { 343, 5, 9, 5, 0, -9 },
  { 349, 3, 9, 2, 0, -9 },
  { 353, 7, 6, 8, 0, -6 },
  { 359, 5, 6, 5, 0, -6 },
  { 363, 5, 6, 5, 0, -6 },
  { 367, 5, 8, 5, 0, -6 },
  { 372, 5, 8, 5, 0, -6 },
  { 377, 3, 6, 3, 0, -6 },
  { 380, 4, 6, 5, 0, -6 },
  { 383, 3, 7, 3, 0, -7 },
  { 386, 5, 6, 5, 0, -6 },
  { 390, 4, 6, 5, 1, -6 },
  { 393, 6, 6, 7, 1, -6 },
  { 398, 5, 6, 5, 0, -6 },
  { 402, 5, 8, 4, 0, -6 },
  { 407, 5, 6, 5, 0, -6 },
  { 411, 4, 11, 3, 0, -9 },
  { 417, 2, 9, 3, 0, -8 },
  { 420, 4, 11, 3, -1, -9 },
  { 426, 5, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_Italic11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_ITALIC11PT7B_H_
