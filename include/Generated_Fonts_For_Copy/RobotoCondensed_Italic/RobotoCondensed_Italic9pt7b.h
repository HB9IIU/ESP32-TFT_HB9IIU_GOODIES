#ifndef _ROBOTOCONDENSED_ITALIC9PT7B_H_
#define _ROBOTOCONDENSED_ITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x48, 0xF0, 0x29, 0x5E, 0xAF, 0x31, 0x80, 0x23, 0x54, 0x21,
  0x96, 0x40, 0xCD, 0xE4, 0x7B, 0x30, 0x35, 0x66, 0xB9, 0x70, 0xC0, 0x29,
  0x29, 0x22, 0x40, 0x55, 0x56, 0x80, 0x27, 0x66, 0x22, 0xF2, 0x40, 0x50,
  0xC0, 0x80, 0x12, 0x24, 0x48, 0x88, 0x35, 0x59, 0x99, 0x60, 0x75, 0x58,
  0x75, 0x12, 0x24, 0xF0, 0x75, 0x12, 0x19, 0x60, 0x13, 0x55, 0xF2, 0x20,
  0x34, 0x61, 0x19, 0x60, 0x34, 0x69, 0x99, 0x60, 0xE2, 0x24, 0x48, 0x80,
  0x35, 0x56, 0x99, 0x60, 0xF6, 0xDE, 0xA0, 0x40, 0x80, 0x40, 0xA0, 0x16,
  0x42, 0x70, 0x07, 0x42, 0x2C, 0xD4, 0xA8, 0x20, 0x3D, 0x15, 0xEB, 0xB6,
  0xF8, 0x1C, 0x13, 0x35, 0x79, 0x90, 0x72, 0x54, 0xE9, 0x4B, 0xC0, 0x32,
  0x50, 0x88, 0x49, 0xC0, 0x72, 0x52, 0x99, 0x4B, 0x80, 0x7A, 0x10, 0xE8,
  0x43, 0xC0, 0x72, 0x10, 0xE8, 0x42, 0x00, 0x32, 0x50, 0xB8, 0xC9, 0xC0,
  0x4A, 0x52, 0xF8, 0xC6, 0x40, 0x55, 0x68, 0x11, 0x11, 0x1A, 0xE0, 0x4A,
  0x98, 0xC6, 0x4A, 0x40, 0x44, 0x44, 0x88, 0xF0, 0x44, 0xC9, 0xB3, 0x6B,
  0x56, 0xA9, 0x00, 0x4B, 0x5A, 0xD9, 0xCE, 0x40, 0x32, 0x52, 0x98, 0xC9,
  0xC0, 0x72, 0x52, 0xE8, 0x42, 0x00, 0x32, 0x53, 0x18, 0xC9, 0xC2, 0x72,
  0x52, 0xE9, 0x4A, 0x40, 0x32, 0x50, 0x41, 0x49, 0x80, 0xF4, 0x44, 0x44,
  0x80, 0x4A, 0x52, 0x99, 0x49, 0x80, 0x99, 0xAA, 0xA4, 0x40, 0xA6, 0x9A,
  0xB6, 0xDA, 0x49, 0x00, 0x4A, 0x8C, 0x46, 0x2A, 0x40, 0x9A, 0xA4, 0x44,
  0x80, 0x78, 0x88, 0x44, 0x23, 0xC0, 0x69, 0x29, 0x24, 0xAA, 0xA5, 0x24,
  0x92, 0x92, 0x2E, 0x80, 0xE0, 0xC0, 0x61, 0x7A, 0xE0, 0x44, 0x75, 0x99,
  0xE0, 0x69, 0x89, 0x60, 0x11, 0x79, 0x99, 0x60, 0x69, 0xF8, 0x60, 0x29,
  0xA4, 0xA0, 0x79, 0x99, 0x62, 0xE0, 0x44, 0x75, 0x99, 0xA0, 0x45, 0xA8,
  0x20, 0x94, 0x92, 0xC0, 0x44, 0x56, 0x4A, 0xA0, 0x55, 0xA8, 0x7D, 0x59,
  0x65, 0xA4, 0x75, 0x99, 0xA0, 0x79, 0x99, 0x60, 0x79, 0x99, 0xE8, 0x80,
  0x79, 0x99, 0x62, 0x20, 0x6A, 0x48, 0x64, 0x6A, 0x60, 0x5D, 0x28, 0x80,
  0x55, 0x9A, 0x60, 0xBB, 0x48, 0xAF, 0xBD, 0x4A, 0x00, 0x56, 0x46, 0xA0,
  0x96, 0x64, 0x44, 0x80, 0x72, 0x44, 0xE0, 0x29, 0x28, 0x92, 0x40, 0x55,
  0xAA, 0x55, 0x5A, 0x80, 0x6C, 0x80,
};

const GFXglyph RobotoCondensed_Italic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 4, 9, 4, 0, -8 },
  { 14, 4, 7, 6, 1, -7 },
  { 18, 4, 7, 5, 0, -7 },
  { 22, 1, 2, 2, 1, -7 },
  { 23, 3, 9, 3, 0, -7 },
  { 27, 2, 9, 3, 0, -7 },
  { 30, 4, 4, 4, 0, -7 },
  { 32, 4, 5, 4, 0, -6 },
  { 35, 2, 2, 2, -1, -1 },
  { 36, 2, 1, 2, 0, -3 },
  { 37, 1, 1, 2, 0, -1 },
  { 38, 4, 8, 3, 0, -7 },
  { 42, 4, 7, 4, 0, -7 },
  { 46, 2, 7, 4, 1, -7 },
  { 48, 4, 7, 4, 0, -7 },
  { 52, 4, 7, 4, 0, -7 },
  { 56, 4, 7, 4, 0, -7 },
  { 60, 4, 7, 4, 0, -7 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 4, 7, 4, 1, -7 },
  { 72, 4, 7, 4, 0, -7 },
  { 76, 3, 7, 4, 1, -7 },
  { 79, 2, 5, 2, 0, -5 },
  { 81, 2, 6, 2, 0, -5 },
  { 83, 4, 4, 4, 0, -5 },
  { 85, 4, 4, 4, 0, -5 },
  { 87, 4, 4, 4, 0, -5 },
  { 89, 3, 7, 4, 1, -7 },
  { 92, 6, 8, 7, 0, -6 },
  { 98, 4, 7, 5, 0, -7 },
  { 102, 5, 7, 5, 0, -7 },
  { 107, 5, 7, 5, 0, -7 },
  { 112, 5, 7, 5, 0, -7 },
  { 117, 5, 7, 4, 0, -7 },
  { 122, 5, 7, 4, 0, -7 },
  { 127, 5, 7, 5, 0, -7 },
  { 132, 5, 7, 5, 0, -7 },
  { 137, 2, 7, 2, 0, -7 },
  { 139, 4, 7, 4, 0, -7 },
  { 143, 5, 7, 5, 0, -7 },
  { 148, 4, 7, 4, 0, -7 },
  { 152, 7, 7, 7, 0, -7 },
  { 159, 5, 7, 5, 0, -7 },
  { 164, 5, 7, 5, 0, -7 },
  { 169, 5, 7, 5, 0, -7 },
  { 174, 5, 8, 5, 0, -7 },
  { 179, 5, 7, 5, 0, -7 },
  { 184, 5, 7, 5, 0, -7 },
  { 189, 4, 7, 5, 1, -7 },
  { 193, 5, 7, 5, 0, -7 },
  { 198, 4, 7, 5, 1, -7 },
  { 202, 6, 7, 7, 1, -7 },
  { 208, 5, 7, 5, 0, -7 },
  { 213, 4, 7, 5, 1, -7 },
  { 217, 5, 7, 5, 0, -7 },
  { 222, 3, 8, 2, 0, -7 },
  { 225, 2, 8, 3, 1, -7 },
  { 227, 3, 8, 2, -1, -7 },
  { 230, 3, 3, 3, 0, -7 },
  { 232, 3, 1, 4, 0, 0 },
  { 233, 1, 2, 3, 1, -7 },
  { 234, 4, 5, 4, 0, -5 },
  { 237, 4, 7, 4, 0, -7 },
  { 241, 4, 5, 4, 0, -5 },
  { 244, 4, 7, 4, 0, -7 },
  { 248, 4, 5, 4, 0, -5 },
  { 251, 3, 7, 3, 0, -7 },
  { 254, 4, 7, 4, 0, -5 },
  { 258, 4, 7, 4, 0, -7 },
  { 262, 2, 7, 2, 0, -7 },
  { 264, 3, 9, 2, -1, -7 },
  { 268, 4, 7, 4, 0, -7 },
  { 272, 2, 7, 2, 0, -7 },
  { 274, 6, 5, 7, 0, -5 },
  { 278, 4, 5, 4, 0, -5 },
  { 281, 4, 5, 4, 0, -5 },
  { 284, 4, 7, 4, 0, -5 },
  { 288, 4, 7, 4, 0, -5 },
  { 292, 3, 5, 3, 0, -5 },
  { 294, 4, 5, 4, 0, -5 },
  { 297, 3, 6, 3, 0, -6 },
  { 300, 4, 5, 4, 0, -5 },
  { 303, 3, 5, 4, 1, -5 },
  { 305, 5, 5, 6, 1, -5 },
  { 309, 4, 5, 4, 0, -5 },
  { 312, 4, 7, 4, 0, -5 },
  { 316, 4, 5, 4, 0, -5 },
  { 319, 3, 9, 3, 0, -7 },
  { 323, 2, 8, 2, 0, -7 },
  { 325, 2, 9, 3, 0, -7 },
  { 328, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_Italic9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_ITALIC9PT7B_H_
