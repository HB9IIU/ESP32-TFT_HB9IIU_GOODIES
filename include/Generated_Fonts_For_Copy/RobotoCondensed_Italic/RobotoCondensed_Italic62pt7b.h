#ifndef _ROBOTOCONDENSED_ITALIC62PT7B_H_
#define _ROBOTOCONDENSED_ITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF0,
  0x02, 0x00, 0x00, 0x3E, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3,
  0xC7, 0x8F, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xC3,
  0x83, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0x81, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E,
  0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x3F, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3E, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x01, 0x8F,
  0x01, 0xE0, 0x1E, 0xF0, 0x1E, 0x03, 0xCF, 0x01, 0xE0, 0x78, 0xF0, 0x1E,
  0x0F, 0x8F, 0x01, 0xE0, 0xF0, 0xF0, 0x1E, 0x1E, 0x0F, 0x01, 0xE3, 0xE0,
  0xF0, 0x3C, 0x3C, 0x0F, 0x03, 0xC7, 0x80, 0xF0, 0x7C, 0xF8, 0x07, 0x8F,
  0x8F, 0x00, 0x7F, 0xF9, 0xE0, 0x03, 0xFF, 0x3E, 0x00, 0x1F, 0xC3, 0xC0,
  0x00, 0x20, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x04, 0x00, 0x03, 0xC3, 0xF8, 0x00, 0x7C, 0xFF, 0xC0, 0x07, 0x9F,
  0xFE, 0x00, 0xF1, 0xF1, 0xE0, 0x1F, 0x3E, 0x0F, 0x01, 0xE3, 0xC0, 0xF0,
  0x3C, 0x78, 0x0F, 0x07, 0xC7, 0x80, 0xF0, 0x78, 0x78, 0x0F, 0x0F, 0x07,
  0x80, 0xF1, 0xE0, 0x78, 0x0F, 0x1E, 0x07, 0x80, 0xF3, 0xC0, 0x78, 0x0F,
  0x78, 0x07, 0x81, 0xE7, 0x80, 0x78, 0x1E, 0x30, 0x07, 0x83, 0xE0, 0x00,
  0x3C, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x03, 0xE0,
  0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x0F, 0xC0,
  0x01, 0xF1, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x1F, 0x1F,
  0x8F, 0xC1, 0xF3, 0xF8, 0xFC, 0x1F, 0x3F, 0x07, 0xE1, 0xF7, 0xE0, 0x7E,
  0x3E, 0x7C, 0x03, 0xF3, 0xEF, 0xC0, 0x3F, 0x3E, 0xFC, 0x01, 0xFF, 0xCF,
  0x80, 0x1F, 0xFC, 0xF8, 0x00, 0xFF, 0x8F, 0x80, 0x0F, 0xF8, 0xFC, 0x00,
  0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xF0,
  0x7F, 0x03, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xEF, 0xC0, 0xFF,
  0xFC, 0x7C, 0x07, 0xFF, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x7C, 0xF9,
  0xE3, 0xC7, 0x9F, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x1E, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x20,
  0x1E, 0x01, 0x38, 0x1E, 0x0F, 0x7F, 0x1E, 0x3F, 0x7F, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xEF, 0x00, 0x07, 0xCF, 0x80, 0x0F,
  0xC7, 0x80, 0x1F, 0x87, 0xC0, 0x3F, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F,
  0xC7, 0xE1, 0xF0, 0xF8, 0x1C, 0x02, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x1F, 0xC3, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x0F,
  0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03,
  0xF7, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x9F, 0x80,
  0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0,
  0xFC, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xBE, 0x7E, 0x3E, 0x70, 0x3E, 0xC0, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x3E,
  0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x3E, 0x00,
  0x3F, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x1F,
  0x00, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x7E, 0x00, 0x0F, 0xBF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x1F,
  0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8,
  0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x1F, 0x7F, 0xE0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xFC, 0x0F, 0xC7, 0xF0,
  0x0F, 0x9F, 0xC0, 0x1F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xF9,
  0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0xC0, 0x3F, 0x0F,
  0x80, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E,
  0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x3F,
  0x07, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0x0F, 0xE1,
  0xF8, 0x1F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0xFD, 0xF8, 0x01, 0xF7, 0xC0,
  0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0x00,
  0xFE, 0x7E, 0x07, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x0F, 0xFD, 0xF0, 0x1F, 0xC7, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7C,
  0x01, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xE7, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0,
  0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80,
  0x00, 0x00, 0x70, 0x07, 0xC0, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0xF8, 0x01, 0xF8, 0x00, 0xE0, 0x3C, 0x01, 0xFF, 0x80, 0x38,
  0x1E, 0x00, 0xFF, 0xF0, 0x0E, 0x07, 0x80, 0x7F, 0xFE, 0x03, 0x83, 0xC0,
  0x3F, 0x07, 0x80, 0xE0, 0xF0, 0x0F, 0x81, 0xE0, 0x3C, 0x78, 0x07, 0xC0,
  0x78, 0x0F, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC7, 0x80, 0xF0, 0x0F, 0x00,
  0xF3, 0xC0, 0x7C, 0x03, 0xC0, 0x38, 0xF0, 0x1F, 0x00, 0xF0, 0x0E, 0x3C,
  0x07, 0x80, 0x7C, 0x03, 0x9F, 0x03, 0xE0, 0x1E, 0x00, 0xE7, 0x80, 0xF8,
  0x07, 0x80, 0x39, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x78, 0x0F, 0x00, 0xF8,
  0x07, 0x9E, 0x07, 0xC0, 0x3C, 0x01, 0xEF, 0x81, 0xF0, 0x0F, 0x00, 0x73,
  0xC0, 0x7C, 0x03, 0xC0, 0x1C, 0xF0, 0x1E, 0x01, 0xF0, 0x0F, 0x3C, 0x07,
  0x80, 0x78, 0x03, 0x8F, 0x01, 0xE0, 0x1E, 0x00, 0xE3, 0xC0, 0x78, 0x0F,
  0x80, 0x78, 0xF0, 0x1E, 0x03, 0xE0, 0x1C, 0x3C, 0x07, 0xC1, 0xF8, 0x0F,
  0x0F, 0x01, 0xF0, 0xFE, 0x07, 0x83, 0xC0, 0x7F, 0xFF, 0xC3, 0xC0, 0xF0,
  0x0F, 0xFC, 0xFF, 0xF0, 0x3C, 0x03, 0xFE, 0x3F, 0xF8, 0x0F, 0x00, 0x7F,
  0x07, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xE0,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x80,
  0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xE1, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xFC, 0x07, 0xC0, 0x07, 0xF0,
  0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFC, 0x7E, 0x00, 0xFF,
  0xF8, 0xF8, 0x03, 0xFF, 0xF1, 0xF0, 0x07, 0xFF, 0xE3, 0xE0, 0x0F, 0xFF,
  0x87, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC,
  0x07, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x03, 0xF8, 0x03, 0xE0,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0xC0,
  0x01, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0x3F, 0x80, 0x00,
  0x03, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFB,
  0xF0, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3E, 0xF8,
  0x00, 0x0F, 0xFC, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x00,
  0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x7C, 0xF8, 0x00, 0x3E,
  0x7C, 0x07, 0xCF, 0x80, 0x07, 0xEF, 0x80, 0x7C, 0x78, 0x00, 0x7C, 0xF8,
  0x07, 0xC7, 0x80, 0x0F, 0xCF, 0x80, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0xFC, 0x7C, 0x01, 0xF1, 0xF8, 0x0F, 0x87,
  0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xC0,
  0x7E, 0x1F, 0x00, 0xF8, 0x3C, 0x07, 0xC3, 0xF0, 0x1F, 0x83, 0xE0, 0xFC,
  0x3F, 0x01, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x1F, 0x83, 0xE1, 0xF8, 0x3E,
  0x01, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0x1F, 0x01, 0xE3, 0xF0, 0x3E, 0x01,
  0xF0, 0x1E, 0x3E, 0x07, 0xE0, 0x3F, 0x01, 0xE7, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x7C, 0x07, 0xC0, 0x3F, 0x01, 0xF7, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0xF0,
  0x0F, 0xC0, 0x7E, 0x00, 0xFF, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0x80, 0x7E, 0x00, 0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x1F, 0xE0, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xE0,
  0x00, 0x3E, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x00, 0x7E, 0x01,
  0xFF, 0x00, 0x07, 0xE0, 0x3F, 0xF8, 0x00, 0x7C, 0x03, 0xFF, 0x80, 0x07,
  0xC0, 0x3F, 0xF8, 0x00, 0x7C, 0x03, 0xE7, 0xC0, 0x07, 0xC0, 0x3E, 0x7C,
  0x00, 0xFC, 0x03, 0xE7, 0xC0, 0x0F, 0xC0, 0x7E, 0x3E, 0x00, 0xF8, 0x07,
  0xE3, 0xE0, 0x0F, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x1F,
  0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x0F,
  0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x80, 0x7C, 0x3E,
  0x01, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0x03,
  0xE3, 0xE0, 0x1F, 0x00, 0x1E, 0x7E, 0x01, 0xF0, 0x01, 0xF7, 0xE0, 0x3F,
  0x00, 0x1F, 0x7C, 0x03, 0xF0, 0x00, 0xF7, 0xC0, 0x3F, 0x00, 0x0F, 0xFC,
  0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x07, 0xFC, 0x03, 0xE0, 0x00,
  0x7F, 0xC0, 0x7E, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xF3, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0x9F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFC, 0x03,
  0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0x87, 0xE0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xC0, 0x07, 0xCF, 0xC0, 0x07, 0xF0, 0x01,
  0xF3, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFF, 0x00, 0x3E, 0x1F,
  0x00, 0x7F, 0xC0, 0x0F, 0x87, 0xC0, 0x1F, 0xF0, 0x07, 0xE1, 0xF0, 0x07,
  0xBC, 0x01, 0xF0, 0x7C, 0x03, 0xEF, 0x00, 0x7C, 0x1F, 0x00, 0xFB, 0xC0,
  0x3F, 0x07, 0xC0, 0x3C, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x3C, 0x03, 0xE0,
  0x7C, 0x07, 0x8F, 0x81, 0xF8, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x07, 0xC0,
  0xF8, 0xF8, 0x1F, 0x01, 0xF0, 0x3C, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x07,
  0x83, 0xE0, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x78, 0x7E,
  0x01, 0xF0, 0xF8, 0x1E, 0x1F, 0x00, 0x7C, 0x3C, 0x07, 0x87, 0xC0, 0x1F,
  0x1F, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x78, 0xF8, 0x01, 0xF1, 0xE0,
  0x1E, 0x3E, 0x00, 0x7C, 0xF8, 0x07, 0x9F, 0x00, 0x1F, 0x3C, 0x01, 0xE7,
  0xC0, 0x07, 0xDF, 0x00, 0x79, 0xF0, 0x01, 0xF7, 0xC0, 0x1E, 0x78, 0x00,
  0x7D, 0xE0, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x07, 0xC0,
  0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00,
  0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C,
  0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C,
  0x0F, 0x8F, 0x03, 0xE3, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x07, 0x8F,
  0x81, 0xE7, 0xC0, 0x79, 0xF0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0x7E,
  0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xE0, 0x7C,
  0x3F, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x03, 0xF8, 0xFC, 0x07, 0xF8, 0xFF, 0x3F, 0xF8, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x3F, 0xF9, 0xF8, 0x0F, 0xF1, 0xF8, 0x01, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x10, 0x00, 0x7E, 0x7F,
  0xC0, 0x1F, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xC3, 0xF8, 0x3F, 0xC0, 0x7E, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x01,
  0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0,
  0x03, 0xF1, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x9F, 0x80, 0x07, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7F, 0x00,
  0x7E, 0x1F, 0xE0, 0x3F, 0x87, 0xFC, 0x3F, 0xC3, 0xEF, 0xFF, 0xE0, 0xF9,
  0xFF, 0xF8, 0x3E, 0x3F, 0xF8, 0x0F, 0x87, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x7E, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x1F,
  0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8,
  0x7E, 0x01, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x02, 0x03, 0xE0,
  0x03, 0xFE, 0x1F, 0x00, 0x3F, 0xF8, 0xF8, 0x03, 0xFF, 0xE7, 0xC0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x01,
  0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0,
  0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7C, 0x00, 0x1F, 0xE3, 0xE0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x3E,
  0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x20,
  0x7C, 0x00, 0x70, 0x7E, 0x00, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0x00, 0x7F, 0xF1, 0xF0, 0x0F,
  0xFF, 0x9F, 0x01, 0xFF, 0xFD, 0xF0, 0x3F, 0xC3, 0xFF, 0x03, 0xF0, 0x0F,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC1, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8,
  0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x01, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xBE, 0x00, 0x1F, 0xE3, 0xE0, 0x00,
  0x30, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x02, 0x00, 0x0F, 0x80, 0x30, 0x01, 0xF8, 0x07,
  0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x02, 0x00, 0x1F, 0x9F, 0xE0, 0x0F, 0xBF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x1F, 0xC1, 0xFE, 0x03, 0xE0,
  0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00,
  0x7E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F,
  0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE0,
  0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x3E, 0x00, 0xFE,
  0x07, 0xC0, 0x3F, 0x80, 0xF8, 0x0F, 0xE0, 0x1F, 0x03, 0xF8, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x03, 0xE1, 0xF8, 0x00,
  0x7C, 0x7E, 0x00, 0x0F, 0x9F, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0xFC,
  0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0x80,
  0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x03, 0xE3, 0xFC, 0x03, 0xFC,
  0x01, 0xF7, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xC7, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF7, 0xFF, 0xF0, 0x3F, 0xC3, 0xFF, 0xC3, 0xF8, 0x3F, 0x80, 0xFF,
  0xC0, 0x7E, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0xC0, 0x1F,
  0x87, 0xC0, 0x0F, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x03, 0xE1, 0xF0,
  0x03, 0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x8F, 0xC0,
  0x0F, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x03, 0xE3,
  0xF0, 0x03, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE3, 0xFC, 0x01, 0xF7, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xE3, 0xF8, 0x3F, 0xC0, 0x7C, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x07, 0xE3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x01,
  0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x01, 0xFC, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7E,
  0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0x1F, 0xF0, 0x01, 0xF7, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xE1, 0xFE, 0x03,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00,
  0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0,
  0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE0, 0xF8,
  0x00, 0x7C, 0x1F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F,
  0xFF, 0xFE, 0x03, 0xE7, 0xFF, 0xC0, 0x3E, 0x3F, 0xF8, 0x03, 0xE1, 0xFF,
  0x00, 0x3E, 0x03, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xE1, 0xF0, 0x1F, 0xFE, 0x7C, 0x0F, 0xFF, 0x9F,
  0x07, 0xFF, 0xF7, 0xC3, 0xFC, 0x3F, 0xF1, 0xFC, 0x03, 0xF8, 0x7E, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF8, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03,
  0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F,
  0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC1, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xF8, 0x01, 0xFF,
  0x7E, 0x00, 0x0C, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x01, 0xF3,
  0xF0, 0x7D, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0x80,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xE0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00,
  0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x20,
  0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0x00, 0x1F, 0x00,
  0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03,
  0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80,
  0xFE, 0x0F, 0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F,
  0xF7, 0xC0, 0x1F, 0xF3, 0xE0, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F,
  0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x07, 0x81,
  0xF0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xCF, 0x00,
  0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xEF, 0x80, 0x3F,
  0x00, 0x3E, 0xF8, 0x03, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0x80, 0x7C, 0xF8,
  0x07, 0xF8, 0x0F, 0xC7, 0x80, 0x7F, 0x80, 0xF8, 0x78, 0x0F, 0xF8, 0x0F,
  0x87, 0x80, 0xFF, 0x81, 0xF0, 0x7C, 0x1F, 0x78, 0x1F, 0x07, 0xC1, 0xF7,
  0x81, 0xF0, 0x7C, 0x3E, 0x78, 0x3E, 0x07, 0xC3, 0xE7, 0x83, 0xE0, 0x7C,
  0x3C, 0x78, 0x7C, 0x07, 0xC7, 0xC7, 0x87, 0xC0, 0x7C, 0x78, 0x78, 0x78,
  0x07, 0xCF, 0x87, 0xCF, 0x80, 0x7C, 0xF8, 0x7C, 0xF8, 0x07, 0xDF, 0x07,
  0xCF, 0x00, 0x7D, 0xF0, 0x7D, 0xF0, 0x07, 0xDE, 0x03, 0xDE, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x07, 0xF0, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x01, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x00, 0xF8,
  0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x7D, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x3E,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00,
  0xFC, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x78, 0x7C,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xC7,
  0xFF, 0x80, 0x1E, 0x3F, 0xFE, 0x00, 0xF3, 0xFF, 0xF8, 0x0F, 0x9F, 0x0F,
  0xE0, 0x79, 0xF0, 0x3F, 0x87, 0xCF, 0x00, 0xFF, 0xFC, 0xF8, 0x03, 0xFF,
  0xE7, 0xC0, 0x0F, 0xFE, 0x3E, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_Italic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 13, 45, 15, 2, -44 },
  { 75, 15, 15, 19, 6, -47 },
  { 104, 31, 44, 33, 3, -44 },
  { 275, 26, 59, 30, 2, -52 },
  { 467, 28, 46, 38, 6, -45 },
  { 628, 28, 46, 33, 2, -45 },
  { 789, 7, 14, 11, 5, -47 },
  { 802, 19, 64, 19, 3, -50 },
  { 954, 19, 64, 19, -3, -50 },
  { 1106, 24, 26, 26, 3, -44 },
  { 1184, 25, 32, 30, 3, -36 },
  { 1284, 10, 15, 12, -3, -7 },
  { 1303, 13, 5, 15, 1, -21 },
  { 1312, 6, 7, 16, 2, -6 },
  { 1318, 28, 48, 22, -3, -44 },
  { 1486, 25, 46, 30, 3, -45 },
  { 1630, 16, 44, 30, 7, -44 },
  { 1718, 27, 45, 30, 1, -45 },
  { 1870, 26, 46, 30, 2, -45 },
  { 2020, 28, 44, 30, 0, -44 },
  { 2174, 27, 45, 30, 3, -44 },
  { 2326, 23, 45, 30, 3, -44 },
  { 2456, 27, 44, 30, 4, -44 },
  { 2605, 26, 46, 30, 2, -45 },
  { 2755, 22, 45, 30, 5, -45 },
  { 2879, 12, 34, 14, 1, -33 },
  { 2930, 15, 41, 13, -3, -33 },
  { 3007, 23, 27, 27, 2, -33 },
  { 3085, 24, 18, 29, 3, -30 },
  { 3139, 24, 27, 28, 2, -33 },
  { 3220, 21, 46, 25, 5, -45 },
  { 3341, 42, 57, 46, 2, -43 },
  { 3641, 32, 44, 35, -2, -44 },
  { 3817, 30, 44, 33, 1, -44 },
  { 3982, 31, 46, 34, 3, -45 },
  { 4161, 31, 44, 34, 1, -44 },
  { 4332, 31, 44, 30, 1, -44 },
  { 4503, 30, 44, 29, 1, -44 },
  { 4668, 31, 46, 36, 3, -45 },
  { 4847, 36, 44, 37, 1, -44 },
  { 5045, 13, 44, 15, 2, -44 },
  { 5117, 29, 45, 29, 0, -44 },
  { 5281, 35, 44, 33, 1, -44 },
  { 5474, 23, 44, 29, 1, -44 },
  { 5601, 44, 44, 45, 1, -44 },
  { 5843, 36, 44, 37, 1, -44 },
  { 6041, 31, 46, 36, 3, -45 },
  { 6220, 33, 44, 33, 1, -44 },
  { 6402, 31, 52, 36, 3, -45 },
  { 6604, 31, 44, 32, 1, -44 },
  { 6775, 30, 46, 31, 1, -45 },
  { 6948, 29, 44, 31, 5, -44 },
  { 7108, 32, 45, 34, 3, -44 },
  { 7288, 32, 44, 34, 5, -44 },
  { 7464, 42, 44, 46, 6, -44 },
  { 7695, 36, 44, 33, -1, -44 },
  { 7893, 29, 44, 32, 6, -44 },
  { 8053, 33, 44, 31, 0, -44 },
  { 8235, 19, 59, 15, 0, -50 },
  { 8376, 12, 48, 22, 6, -44 },
  { 8448, 19, 59, 15, -3, -50 },
  { 8589, 18, 22, 22, 3, -44 },
  { 8639, 24, 5, 24, -3, 0 },
  { 8654, 11, 9, 19, 6, -47 },
  { 8667, 24, 35, 29, 2, -34 },
  { 8772, 26, 48, 30, 1, -47 },
  { 8928, 24, 35, 28, 2, -34 },
  { 9033, 29, 48, 30, 2, -47 },
  { 9207, 24, 35, 28, 2, -34 },
  { 9312, 20, 48, 19, 3, -48 },
  { 9432, 28, 47, 30, 0, -34 },
  { 9597, 25, 47, 29, 1, -47 },
  { 9744, 13, 45, 14, 1, -45 },
  { 9818, 20, 59, 13, -6, -46 },
  { 9966, 27, 47, 27, 1, -47 },
  { 10125, 13, 47, 14, 1, -47 },
  { 10202, 41, 34, 45, 1, -34 },
  { 10377, 25, 34, 29, 1, -34 },
  { 10484, 26, 35, 30, 2, -34 },
  { 10598, 28, 47, 30, -1, -34 },
  { 10763, 26, 47, 30, 2, -34 },
  { 10916, 18, 34, 18, 1, -34 },
  { 10993, 24, 35, 27, 1, -34 },
  { 11098, 16, 42, 18, 2, -41 },
  { 11182, 25, 34, 29, 3, -33 },
  { 11289, 23, 33, 26, 4, -33 },
  { 11384, 36, 33, 39, 4, -33 },
  { 11533, 28, 33, 26, -1, -33 },
  { 11649, 30, 46, 25, -3, -33 },
  { 11822, 26, 33, 26, 0, -33 },
  { 11930, 19, 59, 18, 2, -48 },
  { 12071, 13, 52, 15, 1, -44 },
  { 12156, 20, 59, 18, -3, -48 },
  { 12304, 29, 12, 35, 3, -24 },
};

const GFXfont RobotoCondensed_Italic62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_ITALIC62PT7B_H_
