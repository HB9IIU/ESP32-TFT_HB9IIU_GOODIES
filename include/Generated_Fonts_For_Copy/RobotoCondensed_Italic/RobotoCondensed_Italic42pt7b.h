#ifndef _ROBOTOCONDENSED_ITALIC42PT7B_H_
#define _ROBOTOCONDENSED_ITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1E, 0x0F, 0x03, 0x80, 0x31,
  0xDC, 0x77, 0x1D, 0xC6, 0x73, 0x98, 0xE6, 0x39, 0x8C, 0xE3, 0x38, 0xC0,
  0x00, 0x1C, 0x30, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xC0, 0x07,
  0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x1C, 0x38, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x03, 0x87, 0x00, 0x1C, 0x30, 0x01, 0xC3,
  0x80, 0x0E, 0x1C, 0x00, 0x70, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x70, 0xE0,
  0x03, 0x87, 0x00, 0x1C, 0x30, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0x3E,
  0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0,
  0x1C, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E,
  0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE1, 0xE3,
  0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xEF, 0x00, 0x38,
  0xE0, 0x0E, 0x0C, 0x1D, 0xC1, 0x83, 0xB8, 0x30, 0xE7, 0x06, 0x38, 0xE1,
  0xC7, 0x1C, 0x39, 0xC3, 0x86, 0x70, 0x3B, 0xCC, 0x07, 0xF3, 0x80, 0x7C,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xCF, 0x80, 0x73, 0xF8, 0x0E,
  0xF7, 0x03, 0x9C, 0x70, 0xE7, 0x0E, 0x38, 0xE1, 0xC7, 0x1C, 0x39, 0xC3,
  0x07, 0x70, 0x60, 0xEE, 0x0C, 0x1D, 0x81, 0xC7, 0x00, 0x3D, 0xE0, 0x03,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x01,
  0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x3C, 0x07,
  0x07, 0x00, 0xE1, 0xE0, 0x1E, 0x78, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0xE7, 0xDE, 0x1D, 0xF1,
  0xE3, 0xBC, 0x3C, 0xF7, 0x03, 0xDD, 0xE0, 0x7B, 0xBC, 0x07, 0xE7, 0x80,
  0x7C, 0x70, 0x0F, 0x0F, 0x01, 0xE1, 0xF0, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF,
  0xBC, 0x0F, 0xC3, 0xC0, 0x77, 0x76, 0xEE, 0xEE, 0xCC, 0x00, 0x10, 0x01,
  0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x00, 0x08, 0x00, 0x01, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x01, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x03, 0x86, 0x19, 0xF7, 0x7D,
  0xFF, 0xFF, 0x1F, 0xFE, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xEF,
  0x01, 0xE3, 0x81, 0xE1, 0xE0, 0x60, 0x70, 0x10, 0x20, 0x00, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1E, 0x3C, 0x70,
  0xE3, 0xC7, 0x9E, 0x78, 0xE0, 0x80, 0xFF, 0x7F, 0xBF, 0xC0, 0x27, 0xBF,
  0xF7, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x01,
  0xFF, 0x01, 0xFF, 0xC1, 0xE1, 0xE1, 0xE0, 0x70, 0xF0, 0x3C, 0x70, 0x1E,
  0x78, 0x07, 0x38, 0x03, 0x9C, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80,
  0x7B, 0xC0, 0x3D, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x0F, 0x78, 0x07, 0xBC,
  0x03, 0xDE, 0x01, 0xEF, 0x00, 0xE7, 0x80, 0x73, 0xC0, 0x79, 0xE0, 0x38,
  0xF0, 0x3C, 0x38, 0x1E, 0x1E, 0x1E, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7C,
  0x00, 0x00, 0x60, 0x3C, 0x3F, 0x1F, 0xEF, 0xFD, 0xF7, 0xB8, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0x03, 0xE1, 0xE0, 0x78, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78,
  0x70, 0x0F, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xF0, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x3C, 0x70,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x38, 0xF0, 0x1E, 0x1E, 0x07, 0x87, 0xC7, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xDC, 0x00, 0x73,
  0x80, 0x1E, 0x70, 0x03, 0x9E, 0x00, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x0E,
  0x01, 0xC1, 0xC0, 0x78, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x3C,
  0x3C, 0x07, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xCF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xCF, 0x83, 0xC1,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x1E, 0x1C,
  0x0F, 0x07, 0xC7, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x7E, 0x01, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3D, 0xF0, 0x3B, 0xFC, 0x3F,
  0xFC, 0x7E, 0x1E, 0x7C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E, 0x70,
  0x1C, 0x78, 0x3C, 0x7C, 0x78, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x1F, 0x1E, 0x07, 0x83, 0xC3, 0xC0, 0xF0, 0xE0, 0x3C, 0x38,
  0x0F, 0x0E, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x38, 0x3C, 0x1E, 0x07, 0x0F,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1E, 0x1E, 0x0F, 0x03, 0x87,
  0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF1, 0xC0,
  0x3C, 0x70, 0x0E, 0x1E, 0x07, 0x87, 0xC3, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x1E, 0x3C, 0x3C,
  0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0,
  0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x3E, 0x7C,
  0xFE, 0x3F, 0xFC, 0x3F, 0xDC, 0x0F, 0xBC, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x80, 0x7E,
  0x00, 0x78, 0x00, 0x04, 0x1E, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0xF0, 0xF8,
  0xF0, 0x70, 0x01, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x08, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFC, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F,
  0x9F, 0x78, 0x3D, 0xE0, 0x77, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xF8,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0x80, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x30, 0x70, 0x1F, 0x01, 0x83,
  0x81, 0xFE, 0x0C, 0x38, 0x1F, 0xF8, 0x61, 0xC1, 0xC1, 0x83, 0x1C, 0x1E,
  0x1C, 0x18, 0xE0, 0xE0, 0xE0, 0xC7, 0x0E, 0x07, 0x06, 0x70, 0x70, 0x30,
  0x33, 0x83, 0x83, 0x81, 0x9C, 0x38, 0x1C, 0x0C, 0xE1, 0xC0, 0xE0, 0xE6,
  0x0E, 0x06, 0x07, 0x30, 0x70, 0x70, 0x33, 0x83, 0x83, 0x81, 0x9C, 0x1C,
  0x3C, 0x1C, 0xE0, 0xE1, 0xE0, 0xC7, 0x07, 0x1F, 0x0E, 0x38, 0x3F, 0xBD,
  0xE0, 0xC1, 0xFC, 0xFE, 0x06, 0x07, 0x83, 0xC0, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x60, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00,
  0x03, 0xB8, 0x00, 0x39, 0xC0, 0x01, 0xCF, 0x00, 0x1E, 0x38, 0x00, 0xE1,
  0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x83, 0x80, 0x38, 0x1C, 0x03,
  0xC0, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x78, 0x01, 0xC3, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0,
  0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1C,
  0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x70, 0x3E, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0,
  0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x07, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0xF8, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x03, 0xC3,
  0x80, 0x1C, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x07, 0x87, 0x00, 0xF8, 0x70, 0x1F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xC7, 0xC0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x01, 0xC3, 0xC0, 0x0F,
  0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x78, 0x00,
  0xE3, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x7C, 0x0F,
  0x87, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0E, 0x0F, 0xC0, 0xF0, 0x1E, 0x07,
  0x80, 0x78, 0x3C, 0x01, 0xC1, 0xE0, 0x0E, 0x0E, 0x00, 0x78, 0x70, 0x03,
  0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x70,
  0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C,
  0x70, 0x01, 0xC3, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x0F, 0x00,
  0x78, 0x78, 0x07, 0x83, 0x80, 0x7C, 0x1C, 0x0F, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0x87, 0xE0, 0xF8, 0x0F, 0x0F, 0x80, 0x38, 0x78, 0x01, 0xE3, 0x80, 0x0F,
  0x3C, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xFE, 0x70, 0x3F, 0xE3,
  0x81, 0xFF, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00,
  0xF1, 0xC0, 0x07, 0x8E, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xE0, 0x3E, 0x0F,
  0x87, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00,
  0x0E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0E, 0x00,
  0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3C, 0x00,
  0x38, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x78, 0x38, 0x00,
  0x78, 0x78, 0x00, 0x70, 0x78, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x00,
  0xE0, 0xF0, 0x01, 0xE0, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x7C, 0x03, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3C, 0x07,
  0x00, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x03, 0xE0, 0x0F,
  0x07, 0xC0, 0x0F, 0x0F, 0x80, 0x0E, 0x1F, 0x00, 0x0E, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x38, 0x00, 0x3E,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x70,
  0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x83, 0xB8, 0x01, 0xFC, 0x0E, 0xE0, 0x07, 0x70, 0x3B, 0x80, 0x3D,
  0xC1, 0xEE, 0x00, 0xEF, 0x07, 0xB8, 0x07, 0xBC, 0x1E, 0xF0, 0x1C, 0xF0,
  0x73, 0xC0, 0xF3, 0x81, 0xC7, 0x03, 0x8E, 0x0F, 0x1C, 0x1E, 0x78, 0x3C,
  0x70, 0x71, 0xE0, 0xF1, 0xC3, 0xC7, 0x83, 0xC7, 0x0E, 0x1E, 0x0E, 0x1C,
  0x38, 0x70, 0x38, 0x79, 0xC3, 0xC1, 0xE0, 0xE7, 0x0F, 0x07, 0x83, 0xB8,
  0x3C, 0x1E, 0x0E, 0xE0, 0xF0, 0x78, 0x3F, 0x03, 0x81, 0xC0, 0xFC, 0x0E,
  0x07, 0x03, 0xE0, 0x78, 0x3C, 0x07, 0x81, 0xE0, 0xF0, 0x1C, 0x07, 0x83,
  0xC0, 0x70, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0xC0,
  0x0F, 0x07, 0xC0, 0x0F, 0x0F, 0xC0, 0x0E, 0x0F, 0xE0, 0x1E, 0x0F, 0xE0,
  0x1E, 0x0F, 0xE0, 0x1E, 0x0E, 0xF0, 0x1E, 0x0E, 0x70, 0x1C, 0x1E, 0x70,
  0x1C, 0x1E, 0x78, 0x3C, 0x1E, 0x38, 0x3C, 0x1E, 0x38, 0x3C, 0x1C, 0x3C,
  0x3C, 0x3C, 0x1C, 0x38, 0x3C, 0x1C, 0x38, 0x3C, 0x1E, 0x78, 0x3C, 0x0E,
  0x78, 0x3C, 0x0E, 0x78, 0x38, 0x0F, 0x78, 0x78, 0x07, 0x70, 0x78, 0x07,
  0x70, 0x78, 0x07, 0xF0, 0x78, 0x03, 0xF0, 0x70, 0x03, 0xF0, 0x70, 0x03,
  0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xC7, 0xE0, 0xF8, 0x0F, 0x07,
  0x80, 0x38, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03,
  0xCE, 0x00, 0x1E, 0x70, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0,
  0x01, 0xEF, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x07, 0xBC, 0x00, 0x3D,
  0xE0, 0x01, 0xEF, 0x00, 0x0E, 0x78, 0x00, 0xF1, 0xC0, 0x07, 0x8E, 0x00,
  0x78, 0x78, 0x03, 0xC3, 0xE0, 0x3C, 0x0F, 0xC7, 0xC0, 0x3F, 0xFC, 0x00,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xC0, 0x7C, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x03,
  0x83, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x07, 0xC1, 0xC0, 0x3E, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xC7, 0xC0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x01, 0xC3, 0x80,
  0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00,
  0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xCF, 0x00, 0x0E, 0x78,
  0x00, 0xF3, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x7C,
  0x0F, 0x8F, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x80,
  0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0E, 0x07, 0xC0, 0xF0,
  0x0F, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xC1, 0xE0, 0x0E, 0x0E, 0x00, 0x70,
  0x70, 0x03, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x01,
  0xF0, 0x70, 0x3F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F,
  0x07, 0x80, 0x78, 0x3C, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x78, 0x07, 0x03, 0x80, 0x3C, 0x1C, 0x01, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7E, 0x3E, 0x0F, 0x81, 0xE0, 0xF0, 0x0F, 0x1E, 0x00,
  0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x87, 0x80, 0xF8,
  0x7E, 0x3F, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0xF0, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8E,
  0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x8F, 0x00, 0x3C, 0x70, 0x01, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0E, 0x3C, 0x00, 0x71,
  0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x78, 0x1F, 0x0F, 0xC0, 0x7F, 0xFC, 0x01,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00,
  0x3D, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xE1, 0xC0, 0x0F, 0x0E,
  0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0x81, 0xE0, 0x1C, 0x0F, 0x00, 0xE0, 0xF0, 0x07, 0x07, 0x80, 0x38,
  0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x79, 0xE0, 0x01, 0xCF, 0x00,
  0x0E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x07, 0x00, 0x7F, 0x80, 0x78, 0x03, 0xBC, 0x03, 0xC0, 0x3D, 0xE0,
  0x1E, 0x01, 0xEF, 0x01, 0xF0, 0x0E, 0x78, 0x0F, 0x80, 0xF3, 0xC0, 0xFC,
  0x07, 0x9E, 0x07, 0x60, 0x38, 0x70, 0x3B, 0x83, 0xC3, 0x83, 0xDC, 0x1C,
  0x1C, 0x1C, 0xE0, 0xE0, 0xE0, 0xE7, 0x0F, 0x07, 0x0E, 0x38, 0x70, 0x38,
  0x71, 0xC3, 0x81, 0xC7, 0x8E, 0x3C, 0x0E, 0x38, 0x71, 0xC0, 0x71, 0xC3,
  0x8E, 0x03, 0x9C, 0x1C, 0xF0, 0x1C, 0xE0, 0xE7, 0x00, 0xE7, 0x07, 0x38,
  0x07, 0x70, 0x3B, 0xC0, 0x3B, 0x81, 0xDC, 0x01, 0xFC, 0x06, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0x3C,
  0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x03, 0xC3, 0xE0, 0x01,
  0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x39, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3E, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x0E,
  0x00, 0x0F, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0xF0,
  0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0x87,
  0x80, 0xF8, 0x78, 0x0F, 0x03, 0x81, 0xE0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0,
  0x1C, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xE0, 0xF0, 0xF0, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x78, 0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0F, 0x0F, 0x07, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x38,
  0xE3, 0x87, 0x70, 0x7F, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x78, 0xF0, 0xF0, 0xE1, 0xE1, 0xC0, 0x01, 0xF8, 0x07, 0xFE, 0x0F,
  0xFE, 0x1F, 0x1F, 0x1E, 0x0F, 0x1C, 0x07, 0x3C, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x03, 0xFF, 0x0F, 0xFF, 0x3F, 0xFE, 0x7C, 0x0E, 0x78, 0x0E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xFD, 0xFC, 0x7F, 0xFC, 0x3F,
  0xDC, 0x1F, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF3, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xF1, 0xF1, 0xF0,
  0x3C, 0x78, 0x07, 0x1E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07,
  0x3C, 0x01, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x03, 0x8E,
  0x01, 0xE7, 0x80, 0x79, 0xF0, 0x3C, 0x7E, 0x1F, 0x1D, 0xFF, 0x87, 0x3F,
  0xC1, 0xC7, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xE1, 0xE1,
  0xE0, 0x71, 0xE0, 0x3C, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x1C, 0x70, 0x0E, 0x3C, 0x0F, 0x1F, 0x0F, 0x07, 0xFF, 0x01, 0xFF, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x03, 0xF3, 0xC0, 0x7F, 0xBC, 0x0F, 0xFF, 0xC1, 0xF1,
  0xF8, 0x3E, 0x07, 0x83, 0xC0, 0x78, 0x38, 0x07, 0x87, 0x80, 0x78, 0x78,
  0x07, 0x87, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x81, 0xE0,
  0x7C, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xF9, 0xC0, 0x01, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0x83, 0xE1, 0xE1, 0xE0, 0x71, 0xE0, 0x38, 0xE0,
  0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x06,
  0x1F, 0x0F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x07,
  0xF0, 0x3F, 0x81, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0xE0, 0x7F, 0x9C, 0x1F, 0xFF,
  0x87, 0xC3, 0xF1, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x00, 0x71, 0xE0, 0x1E,
  0x3C, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38,
  0xF0, 0x0F, 0x1E, 0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x07, 0x81, 0xE0,
  0xF8, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0x9E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC1, 0x80, 0xF0, 0x38, 0x3E, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF3, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x83, 0xF1, 0xE1, 0xF0, 0x38, 0x78, 0x0E, 0x1E, 0x03, 0x87, 0x80, 0xE1,
  0xC0, 0x38, 0x70, 0x0E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0,
  0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F,
  0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x07, 0x07, 0x81, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38,
  0x3C, 0x1E, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x0F, 0xE0, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x7C, 0x78, 0x3E,
  0x1C, 0x1F, 0x07, 0x0F, 0x83, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F,
  0x78, 0x03, 0xBC, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xDE,
  0x01, 0xE7, 0x80, 0x70, 0xF0, 0x1C, 0x3C, 0x0F, 0x07, 0x03, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x0F, 0x0E, 0x03, 0xC3, 0x80, 0x78, 0x07, 0x83, 0xC1,
  0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0,
  0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0,
  0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0x1E, 0x7C, 0x1F,
  0x83, 0xFF, 0xC7, 0xF8, 0x7F, 0xFD, 0xFF, 0x8F, 0x8F, 0xF9, 0xF1, 0xE0,
  0xFC, 0x1E, 0x78, 0x0F, 0x01, 0xCF, 0x01, 0xE0, 0x39, 0xE0, 0x3C, 0x07,
  0x38, 0x07, 0x00, 0xE7, 0x00, 0xE0, 0x3C, 0xE0, 0x3C, 0x07, 0xBC, 0x07,
  0x80, 0xF7, 0x80, 0xF0, 0x1E, 0xF0, 0x1C, 0x03, 0x9C, 0x03, 0x80, 0x73,
  0x80, 0x70, 0x1E, 0xF0, 0x1E, 0x03, 0xDE, 0x03, 0xC0, 0x7B, 0xC0, 0x78,
  0x0E, 0x78, 0x0E, 0x01, 0xCE, 0x01, 0xC0, 0x39, 0xC0, 0x38, 0x0F, 0x00,
  0x0F, 0x3E, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0x1E, 0x0F, 0x03, 0x87,
  0x80, 0xE1, 0xE0, 0x38, 0x78, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0,
  0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C,
  0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x38, 0x70, 0x0E, 0x1C,
  0x03, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x3C, 0x1E,
  0x07, 0x8F, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x0F, 0x78, 0x03, 0xDC, 0x00,
  0xF7, 0x00, 0x39, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x01, 0xEF, 0x00, 0x79,
  0xC0, 0x1C, 0x70, 0x0F, 0x1E, 0x07, 0x83, 0xC3, 0xE0, 0xFF, 0xF0, 0x1F,
  0xF8, 0x01, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0xEF, 0xF0, 0x1F, 0xFF, 0x03,
  0xF1, 0xF0, 0x78, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x38, 0x78, 0x07, 0x0E,
  0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C,
  0x03, 0xC7, 0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x03, 0xC7, 0xC0, 0xF0, 0xFC,
  0x3E, 0x1F, 0xFF, 0x83, 0x9F, 0xE0, 0x71, 0xF8, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF1, 0xC1, 0xFE, 0x70, 0xFF,
  0xFC, 0x7C, 0x3F, 0x3E, 0x07, 0x8F, 0x00, 0xE3, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0x9C, 0x01, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0xF0, 0x0F, 0x3C,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x38, 0x70, 0x0E, 0x1E, 0x07, 0x87, 0xC3,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xE7, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x0F, 0x78, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xF8,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1E,
  0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x07, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x1C, 0xF0, 0x1E,
  0xF0, 0x1C, 0xF0, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x1F, 0x87, 0xE0, 0xF8, 0x3C,
  0x07, 0x9E, 0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF3, 0xC0, 0x79,
  0xE0, 0x3C, 0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x3C, 0x07, 0x9E, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x3C, 0x78,
  0x3E, 0x3E, 0x3F, 0x0F, 0xFF, 0x07, 0xFB, 0x81, 0xF9, 0xC0, 0xE0, 0x1F,
  0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xCE, 0x07, 0x9E, 0x0F, 0x3C, 0x1C, 0x38,
  0x78, 0x70, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x38, 0x0E, 0x70,
  0x1D, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x78,
  0x0E, 0xE0, 0x7C, 0x1E, 0xE0, 0xFC, 0x1C, 0xE0, 0xFC, 0x1C, 0xE0, 0xFC,
  0x3C, 0xE1, 0xDC, 0x38, 0xF1, 0xDC, 0x78, 0xF3, 0x9C, 0x70, 0xF3, 0x9C,
  0x70, 0xF7, 0x9C, 0xE0, 0x77, 0x1C, 0xE0, 0x77, 0x1D, 0xE0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x01,
  0xE1, 0xE0, 0x78, 0x1C, 0x1F, 0x03, 0xC3, 0xC0, 0x38, 0xF0, 0x07, 0x1C,
  0x00, 0xF7, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xC0,
  0x0F, 0x3C, 0x03, 0xC3, 0x80, 0xF0, 0x70, 0x1E, 0x0F, 0x07, 0x81, 0xE1,
  0xF0, 0x1E, 0x00, 0x07, 0x00, 0xF0, 0x70, 0x1E, 0x07, 0x01, 0xE0, 0x70,
  0x1C, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07,
  0x87, 0x00, 0x38, 0xF0, 0x03, 0x8E, 0x00, 0x39, 0xE0, 0x03, 0x9C, 0x00,
  0x3B, 0xC0, 0x03, 0xB8, 0x00, 0x3B, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC7,
  0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00,
  0x08, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x81, 0xF8, 0x0F, 0x80, 0x7C, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x40, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x02, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x03, 0xE0, 0x1E, 0x00, 0xC0, 0x00, 0x0F,
  0x00, 0x01, 0xFC, 0x07, 0x3F, 0xE0, 0x77, 0x9F, 0x0E, 0x70, 0xF9, 0xEE,
  0x07, 0xFC, 0xE0, 0x3F, 0xC0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Italic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 30, 10, 1, -30 },
  { 35, 10, 10, 13, 4, -32 },
  { 48, 21, 30, 22, 2, -30 },
  { 127, 17, 38, 20, 2, -34 },
  { 208, 19, 30, 26, 4, -30 },
  { 280, 19, 30, 22, 1, -30 },
  { 352, 4, 10, 7, 4, -32 },
  { 357, 13, 44, 13, 2, -34 },
  { 429, 13, 44, 13, -2, -34 },
  { 501, 17, 17, 18, 2, -30 },
  { 538, 17, 22, 20, 2, -25 },
  { 585, 7, 10, 8, -2, -5 },
  { 594, 9, 3, 10, 1, -14 },
  { 598, 5, 5, 11, 1, -5 },
  { 602, 19, 33, 15, -2, -30 },
  { 681, 17, 30, 20, 2, -30 },
  { 745, 11, 30, 20, 5, -30 },
  { 787, 19, 30, 20, 0, -30 },
  { 859, 18, 30, 20, 1, -30 },
  { 927, 19, 30, 20, 0, -30 },
  { 999, 18, 30, 20, 2, -30 },
  { 1067, 16, 30, 20, 2, -30 },
  { 1127, 18, 30, 20, 3, -30 },
  { 1195, 18, 30, 20, 1, -30 },
  { 1263, 16, 30, 20, 3, -30 },
  { 1323, 8, 23, 10, 1, -23 },
  { 1346, 10, 28, 8, -2, -23 },
  { 1381, 16, 19, 18, 1, -23 },
  { 1419, 16, 12, 20, 2, -20 },
  { 1443, 17, 18, 19, 1, -22 },
  { 1482, 14, 30, 17, 3, -30 },
  { 1535, 29, 38, 31, 1, -29 },
  { 1673, 21, 30, 24, -1, -30 },
  { 1752, 20, 30, 22, 1, -30 },
  { 1827, 21, 30, 23, 2, -30 },
  { 1906, 21, 30, 23, 1, -30 },
  { 1985, 21, 30, 20, 1, -30 },
  { 2064, 20, 30, 20, 1, -30 },
  { 2139, 21, 30, 24, 2, -30 },
  { 2218, 24, 30, 25, 1, -30 },
  { 2308, 9, 30, 10, 1, -30 },
  { 2342, 20, 30, 20, 0, -30 },
  { 2417, 24, 30, 22, 1, -30 },
  { 2507, 16, 30, 19, 1, -30 },
  { 2567, 30, 30, 31, 1, -30 },
  { 2680, 24, 30, 25, 1, -30 },
  { 2770, 21, 30, 24, 2, -30 },
  { 2849, 22, 30, 23, 1, -30 },
  { 2932, 21, 35, 24, 2, -30 },
  { 3024, 21, 30, 22, 1, -30 },
  { 3103, 20, 30, 21, 1, -30 },
  { 3178, 19, 30, 21, 4, -30 },
  { 3250, 21, 30, 23, 2, -30 },
  { 3329, 21, 30, 23, 4, -30 },
  { 3408, 29, 30, 31, 4, -30 },
  { 3517, 25, 30, 22, -1, -30 },
  { 3611, 20, 30, 21, 4, -30 },
  { 3686, 22, 30, 21, 0, -30 },
  { 3769, 13, 40, 10, 0, -34 },
  { 3834, 8, 33, 15, 4, -30 },
  { 3867, 13, 40, 10, -2, -34 },
  { 3932, 12, 15, 15, 2, -30 },
  { 3955, 16, 3, 16, -2, 0 },
  { 3961, 7, 6, 13, 4, -31 },
  { 3967, 16, 22, 20, 1, -22 },
  { 4011, 18, 32, 20, 0, -32 },
  { 4083, 17, 22, 19, 1, -22 },
  { 4130, 20, 32, 20, 1, -32 },
  { 4210, 17, 22, 19, 1, -22 },
  { 4257, 14, 32, 13, 2, -32 },
  { 4313, 19, 31, 20, 0, -22 },
  { 4387, 18, 32, 20, 0, -32 },
  { 4459, 9, 30, 9, 1, -30 },
  { 4493, 13, 39, 9, -4, -30 },
  { 4557, 18, 32, 18, 1, -32 },
  { 4629, 9, 32, 9, 1, -32 },
  { 4665, 27, 22, 31, 1, -22 },
  { 4740, 18, 22, 20, 0, -22 },
  { 4790, 18, 22, 20, 1, -22 },
  { 4840, 19, 31, 20, -1, -22 },
  { 4914, 18, 31, 20, 1, -22 },
  { 4984, 13, 22, 12, 0, -22 },
  { 5020, 16, 22, 19, 1, -22 },
  { 5064, 10, 28, 12, 2, -28 },
  { 5099, 17, 22, 20, 2, -22 },
  { 5146, 15, 22, 17, 3, -22 },
  { 5188, 24, 22, 26, 3, -22 },
  { 5254, 19, 22, 18, -1, -22 },
  { 5307, 20, 31, 17, -2, -22 },
  { 5385, 18, 22, 18, 0, -22 },
  { 5435, 13, 40, 12, 1, -33 },
  { 5500, 8, 36, 10, 1, -30 },
  { 5536, 13, 41, 12, -2, -33 },
  { 5603, 20, 8, 24, 2, -16 },
};

const GFXfont RobotoCondensed_Italic42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_ITALIC42PT7B_H_
