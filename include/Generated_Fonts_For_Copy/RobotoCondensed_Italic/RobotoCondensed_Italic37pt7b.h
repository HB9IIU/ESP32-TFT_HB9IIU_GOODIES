#ifndef _ROBOTOCONDENSED_ITALIC37PT7B_H_
#define _ROBOTOCONDENSED_ITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60,
  0xF0, 0xF0, 0x60, 0x63, 0x63, 0x67, 0xE7, 0xE6, 0xC6, 0xC6, 0xC6, 0xCC,
  0x00, 0x71, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x03, 0x8E, 0x00, 0xC3, 0x00,
  0x31, 0xC0, 0x1C, 0x70, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF0, 0x30,
  0xC0, 0x0C, 0x70, 0x07, 0x1C, 0x01, 0x86, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x61, 0x80, 0x38, 0xE0, 0x0E,
  0x38, 0x03, 0x0C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x01, 0xF8, 0x03, 0xFC, 0x07,
  0xFE, 0x0F, 0x0E, 0x0E, 0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0x70,
  0x1C, 0x70, 0x3C, 0x78, 0x78, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1C, 0xE0, 0x0E,
  0x30, 0x26, 0x1C, 0x33, 0x0E, 0x3B, 0x86, 0x39, 0xC3, 0x18, 0x61, 0x98,
  0x39, 0xDC, 0x1F, 0xDC, 0x03, 0xCC, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x78, 0x06, 0x7E, 0x07, 0x73, 0x87, 0x30, 0xC3, 0x38, 0x63, 0x9C, 0x33,
  0x8E, 0x19, 0x87, 0x0D, 0x83, 0x8E, 0x00, 0xCE, 0x00, 0x7F, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xE3, 0xC0, 0xF0, 0xE0,
  0x70, 0x70, 0x38, 0x38, 0x1C, 0x38, 0x0E, 0x3C, 0x07, 0xBC, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0xFE, 0x1C, 0xF7, 0x0E, 0x71, 0xC7, 0x70,
  0xE7, 0x78, 0x3B, 0xB8, 0x1D, 0x9C, 0x07, 0xCE, 0x03, 0xC7, 0x80, 0xE1,
  0xC1, 0xF8, 0xFF, 0xFC, 0x3F, 0xEF, 0x07, 0xC3, 0x80, 0x77, 0x77, 0x66,
  0xEE, 0xE0, 0x00, 0x20, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x10, 0x00, 0x02, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x10,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x43, 0x85, 0xEE, 0xFF,
  0xFF, 0xCF, 0xFE, 0x07, 0x80, 0x3E, 0x01, 0xDC, 0x0E, 0x70, 0x78, 0xE1,
  0xC3, 0x82, 0x04, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x1C, 0x71, 0xCF, 0x39, 0xE7, 0x38, 0x40, 0xFF,
  0xFF, 0xF8, 0x6F, 0xF6, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xE3,
  0xC1, 0xC7, 0x01, 0xCE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x3D, 0xC0,
  0x73, 0x80, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x3D,
  0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x1C, 0x0E, 0x3C, 0x38, 0x3F,
  0xF0, 0x3F, 0xC0, 0x3E, 0x00, 0x00, 0xC0, 0xF1, 0xF9, 0xFE, 0x7B, 0x98,
  0xE8, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0F, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xE0, 0xE0, 0xE0,
  0x78, 0xF0, 0x3C, 0x70, 0x0E, 0x38, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x00, 0x01, 0xF0,
  0x07, 0xFC, 0x0F, 0xFC, 0x1E, 0x1E, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0xE0, 0x1C, 0xE0, 0x38, 0xF0, 0x38, 0x70, 0x70, 0x7F, 0xF0, 0x3F, 0xE0,
  0x1F, 0x80, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xDC, 0x01, 0xCE, 0x01, 0xE7, 0x00,
  0xE3, 0x80, 0xE3, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x70, 0x70, 0x70, 0x38,
  0x38, 0x3C, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3B, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3C, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78, 0x70, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0,
  0x1F, 0x80, 0x00, 0x78, 0x07, 0xE0, 0x3F, 0x81, 0xE0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xEF, 0x87, 0xFF, 0x1F, 0xFE, 0x7C,
  0x39, 0xE0, 0xEF, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xB8,
  0x0E, 0xE0, 0x39, 0xC1, 0xC7, 0x0F, 0x1F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00,
  0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFC,
  0x07, 0xFE, 0x0F, 0x0E, 0x0E, 0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x0F,
  0x1C, 0x0E, 0x1C, 0x0E, 0x0E, 0x1C, 0x0F, 0xFC, 0x07, 0xF0, 0x1F, 0xF0,
  0x3C, 0x38, 0x78, 0x3C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xE0, 0x1C,
  0xF0, 0x3C, 0x70, 0x38, 0x70, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80,
  0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x70, 0xF7, 0x03, 0xB8, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF8, 0x7D, 0xFF,
  0xCF, 0xFE, 0x1E, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0,
  0x3E, 0x1F, 0xE0, 0xFC, 0x07, 0x80, 0x00, 0x1C, 0x3C, 0x78, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xE3, 0xC7,
  0x00, 0x03, 0x83, 0xC1, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x07, 0x03, 0x83,
  0xC1, 0xC1, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0,
  0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x1E, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x06, 0x00, 0x08, 0x3F, 0xFC,
  0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x00, 0x10, 0x00, 0x60, 0x01, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1C, 0x03, 0xF0,
  0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x07, 0x80, 0x38, 0x00, 0x80, 0x00,
  0x0F, 0x81, 0xFE, 0x3F, 0xF7, 0x8F, 0x70, 0x7F, 0x07, 0xE0, 0x70, 0x07,
  0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x1F,
  0x00, 0x3C, 0x01, 0xC0, 0x3C, 0x00, 0x60, 0x18, 0x00, 0x18, 0x1C, 0x00,
  0x0C, 0x1C, 0x00, 0x07, 0x0C, 0x0F, 0x81, 0x8E, 0x0F, 0xE0, 0xC6, 0x0F,
  0x38, 0x67, 0x0E, 0x1C, 0x33, 0x06, 0x0C, 0x19, 0x87, 0x06, 0x0D, 0xC3,
  0x87, 0x06, 0xC1, 0x83, 0x83, 0x61, 0xC1, 0x83, 0xB0, 0xE0, 0xC1, 0xB8,
  0x70, 0xE0, 0xDC, 0x30, 0x70, 0x6E, 0x18, 0x30, 0x77, 0x0C, 0x38, 0x33,
  0x87, 0x1C, 0x39, 0xC3, 0xFF, 0x38, 0xE1, 0xF9, 0xF8, 0x70, 0x78, 0xF8,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x08, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1C, 0xC0, 0x03, 0x98, 0x00, 0xE3, 0x80,
  0x1C, 0x70, 0x07, 0x8E, 0x00, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x07, 0x01,
  0xE0, 0xE0, 0x38, 0x0E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0E,
  0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x7B, 0x80, 0x07, 0x70,
  0x00, 0xFC, 0x00, 0x1C, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x38,
  0x1E, 0x0E, 0x03, 0x87, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0E, 0x1C, 0x03,
  0x87, 0x01, 0xE1, 0xC0, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0x83,
  0x80, 0xE0, 0xE0, 0x3C, 0x38, 0x07, 0x1E, 0x01, 0xC7, 0x00, 0x71, 0xC0,
  0x3C, 0x70, 0x0F, 0x1C, 0x07, 0x8F, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3C, 0x1E,
  0x1E, 0x03, 0x87, 0x00, 0xF3, 0xC0, 0x1C, 0xE0, 0x07, 0x78, 0x01, 0xDC,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x3C,
  0xF0, 0x0E, 0x1C, 0x07, 0x87, 0x83, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03,
  0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x38, 0x1E, 0x0E,
  0x03, 0x87, 0x80, 0xF1, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x38,
  0xE0, 0x0E, 0x38, 0x03, 0x9E, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x70,
  0x0F, 0x1C, 0x07, 0x8F, 0x07, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x1E, 0x1E, 0x03, 0xCF, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x07, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x1F, 0xEF, 0x07, 0xFB, 0x81, 0xFE, 0xE0,
  0x07, 0xB8, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xF0, 0x07, 0x1C, 0x03,
  0xC7, 0x81, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0x00,
  0x38, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x0F,
  0x00, 0x38, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07,
  0x07, 0x00, 0x38, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xE0,
  0x07, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0x70,
  0xE0, 0x07, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1E, 0x00,
  0x70, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38,
  0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x3C,
  0x07, 0x1E, 0x03, 0x8F, 0x03, 0xC3, 0x81, 0xC1, 0xE1, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x70, 0x0F, 0x03, 0x80,
  0xF0, 0x1C, 0x0F, 0x00, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x03,
  0x87, 0x80, 0x1C, 0x78, 0x00, 0xE7, 0x80, 0x07, 0x78, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0x80, 0x07, 0x9E, 0x00, 0x38,
  0x70, 0x03, 0xC3, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x78, 0x07, 0x01, 0xC0,
  0x38, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x01, 0xC0, 0xE0, 0x0F, 0x07, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0,
  0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x77,
  0x00, 0xEE, 0x1D, 0xC0, 0x3B, 0x87, 0x70, 0x1D, 0xC1, 0xDC, 0x07, 0x70,
  0xF7, 0x03, 0x9C, 0x39, 0xC0, 0xE7, 0x0E, 0x30, 0x73, 0xC3, 0x8E, 0x1C,
  0xF0, 0xE3, 0x8E, 0x38, 0x38, 0xE3, 0x8E, 0x1E, 0x39, 0xC3, 0x87, 0x0E,
  0x70, 0xE1, 0xC3, 0xB8, 0x78, 0x70, 0x6E, 0x1C, 0x1C, 0x1F, 0x07, 0x0F,
  0x07, 0xC1, 0xC3, 0xC1, 0xE0, 0x70, 0xE0, 0x78, 0x3C, 0x38, 0x1C, 0x0F,
  0x00, 0x0F, 0x00, 0x38, 0x78, 0x01, 0xC3, 0xC0, 0x1E, 0x1F, 0x00, 0xF0,
  0xF8, 0x07, 0x0F, 0xC0, 0x38, 0x7F, 0x01, 0xC3, 0xB8, 0x0E, 0x1C, 0xC0,
  0xF0, 0xE7, 0x07, 0x07, 0x38, 0x38, 0x78, 0xC1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE0, 0xC7, 0x87, 0x07, 0x38, 0x38, 0x39, 0xC3, 0xC0, 0xCE,
  0x1C, 0x07, 0x70, 0xE0, 0x3F, 0x87, 0x00, 0xFC, 0x38, 0x07, 0xC3, 0xC0,
  0x3E, 0x1E, 0x00, 0xF0, 0xE0, 0x07, 0x87, 0x00, 0x3C, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x1E, 0x1E, 0x03, 0xC7, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x07, 0x78, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0,
  0x07, 0x70, 0x01, 0xDC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0E, 0xE0, 0x03,
  0xB8, 0x00, 0xEE, 0x00, 0x7B, 0x80, 0x1C, 0xF0, 0x0F, 0x1C, 0x03, 0x87,
  0x83, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0x01, 0xE0, 0xE0, 0x1C, 0x3C, 0x03, 0xC7,
  0x80, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x1E,
  0x01, 0xE3, 0xC0, 0x78, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3C, 0x1E, 0x1E, 0x03, 0x8F, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x07, 0x78, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D,
  0xC0, 0x07, 0x70, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x0E, 0xE0,
  0x03, 0xB8, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x1C, 0xF0, 0x0F, 0x1C, 0x07,
  0x87, 0x83, 0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x38, 0x1E, 0x0E, 0x03, 0xC7, 0x80, 0x71, 0xE0, 0x1C, 0x70,
  0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE1, 0xC0, 0x78, 0xF0, 0x3C, 0x3F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x1E, 0x0E, 0x07,
  0x03, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0x38, 0xE0, 0x0E, 0x38, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x3C, 0x1E, 0x1E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x3C, 0x70, 0x0F,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x3C, 0x07, 0x87, 0x83, 0xC0, 0xFF, 0xE0,
  0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x01, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x1E, 0x00, 0xE3, 0x80,
  0x1C, 0x70, 0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x1C, 0x78, 0x03, 0x8F, 0x00,
  0x71, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x3C, 0x01,
  0xC7, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x38, 0x70, 0x07,
  0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x3C, 0x0F, 0x03, 0xFF, 0xC0, 0x3F, 0xF0,
  0x01, 0xF8, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01,
  0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0xC0, 0x70, 0x78, 0x0E,
  0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x1E, 0x03, 0x83, 0x80, 0x70, 0xF0,
  0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x77, 0x00,
  0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x07, 0xF0, 0x1E, 0x03, 0xB8,
  0x0F, 0x01, 0xDC, 0x07, 0x81, 0xEE, 0x07, 0xC0, 0xE7, 0x03, 0xE0, 0x73,
  0x83, 0xF0, 0x79, 0xC1, 0xD8, 0x38, 0xE0, 0xCC, 0x1C, 0x70, 0xE6, 0x1E,
  0x38, 0x73, 0x0E, 0x1C, 0x31, 0x87, 0x0E, 0x38, 0xC7, 0x07, 0x18, 0x63,
  0x83, 0x9C, 0x31, 0xC1, 0xCE, 0x1D, 0xC0, 0xE6, 0x0E, 0xE0, 0x77, 0x07,
  0x70, 0x3B, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0,
  0x7C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x38, 0x0F, 0x00,
  0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x07, 0x07, 0x00, 0x1E, 0x3C, 0x00, 0x39,
  0xE0, 0x00, 0xE7, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0x78, 0x00, 0x78, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F,
  0x00, 0x78, 0x1C, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x03, 0x81,
  0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xDC, 0x01, 0xE7, 0x00, 0x79, 0xE0, 0x3C,
  0x38, 0x0E, 0x0E, 0x07, 0x83, 0x83, 0xC0, 0xE0, 0xE0, 0x1C, 0x78, 0x07,
  0x1C, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0xE3, 0x8E, 0x38,
  0xE3, 0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0xC3, 0x8E, 0x38, 0xE3, 0x8E,
  0x18, 0x71, 0xC7, 0x1C, 0x71, 0xC3, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x70,
  0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x03, 0x01, 0xE0, 0x78,
  0x3E, 0x0F, 0x87, 0x61, 0xD8, 0xE7, 0x39, 0xDC, 0x77, 0x1F, 0x83, 0xE0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xC3, 0x8E, 0x1C, 0x03,
  0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0x07, 0x3C, 0x1C, 0xE0, 0x70, 0x01, 0xC0,
  0x07, 0x07, 0xFC, 0x7F, 0xF3, 0xF3, 0x9E, 0x0E, 0xF0, 0x3B, 0x80, 0xEE,
  0x03, 0xB8, 0x1E, 0xF0, 0xF1, 0xFF, 0xC7, 0xFF, 0x0F, 0x9E, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x0F, 0x1E, 0x07,
  0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x7C, 0x3C,
  0x7F, 0xF8, 0x77, 0xF8, 0x63, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1,
  0xE0, 0xE3, 0x81, 0xCF, 0x01, 0xDC, 0x03, 0xB8, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x07, 0x38, 0x0E, 0x38, 0x1C,
  0x70, 0x70, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x07, 0xC7, 0x07, 0xF3, 0x87, 0xFF, 0x87, 0x83, 0xC3, 0x80, 0xE3,
  0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x1C, 0x38, 0x0E, 0x3C, 0x07,
  0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE3, 0xC0, 0xE0, 0xE0, 0x70, 0x70,
  0x78, 0x3F, 0xFC, 0x0F, 0xEE, 0x03, 0xE7, 0x00, 0x03, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF0, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x7F,
  0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x08, 0x78, 0x30, 0xFF, 0xF0, 0xFF, 0x80, 0x7C, 0x00, 0x01, 0xF0,
  0x3F, 0x07, 0xF0, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x7F, 0x8F,
  0xF8, 0xFF, 0x81, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x03, 0xE3, 0x83, 0xFD, 0xC3, 0xFF, 0xE3, 0xC1,
  0xE1, 0xC0, 0x71, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0F, 0x1C,
  0x07, 0x1E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x78,
  0x70, 0x38, 0x38, 0x3C, 0x1F, 0xFE, 0x07, 0xF7, 0x01, 0xF3, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x80, 0xF0, 0x60, 0xF0, 0x7F, 0xF0, 0x1F,
  0xF0, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0xF8, 0x1F, 0xF8, 0x7F,
  0xF8, 0xF8, 0x71, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x3C, 0x0E,
  0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xF3, 0x81, 0xC7, 0x03, 0x9E, 0x07, 0x38,
  0x0E, 0x70, 0x1C, 0xE0, 0x79, 0xC0, 0xE3, 0x81, 0xC0, 0x06, 0x1C, 0x38,
  0x70, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x78,
  0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x80, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x7C, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x0F, 0x07, 0x0F, 0x07,
  0x87, 0x83, 0x87, 0x81, 0xC7, 0x80, 0xE7, 0x80, 0x77, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xB8, 0x03, 0x8E, 0x01, 0xC7,
  0x01, 0xE3, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0E,
  0x07, 0x80, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70,
  0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x0E, 0xF8, 0x3E, 0x07, 0xFE, 0x7F,
  0x87, 0xFF, 0xFF, 0xC3, 0xC1, 0xF0, 0xF1, 0xC0, 0xF0, 0x38, 0xE0, 0x78,
  0x1C, 0x70, 0x3C, 0x0E, 0x38, 0x1C, 0x07, 0x3C, 0x0E, 0x03, 0x9C, 0x07,
  0x03, 0xCE, 0x03, 0x81, 0xC7, 0x03, 0xC0, 0xE3, 0x81, 0xC0, 0x71, 0xC0,
  0xE0, 0x39, 0xE0, 0x70, 0x1C, 0xE0, 0x38, 0x1E, 0x70, 0x1C, 0x0E, 0x38,
  0x1E, 0x07, 0x1C, 0x0E, 0x03, 0x8E, 0x07, 0x01, 0xC0, 0x0E, 0x78, 0x1F,
  0xF8, 0x7F, 0xF8, 0xF8, 0x71, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07,
  0x3C, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xF3, 0x81, 0xC7, 0x03, 0x9E,
  0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x79, 0xC0, 0xE3, 0x81, 0xC0, 0x03,
  0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xE0, 0xF3, 0x80, 0xE7, 0x01, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xBC, 0x07, 0x38, 0x1E, 0x78, 0x78, 0x7F, 0xE0, 0xFF, 0x80, 0x7C,
  0x00, 0x07, 0x7C, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xF0, 0xF0, 0xE0, 0x38,
  0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x1E, 0x03, 0x8E, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0x71, 0xC0, 0x70, 0xE0, 0x38, 0xF0, 0x1C, 0x78, 0x1E, 0x3C,
  0x1E, 0x1F, 0xFE, 0x0E, 0xFF, 0x07, 0x3E, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0xC7, 0x0F, 0xF7, 0x1F, 0xFE, 0x3C, 0x1E, 0x38, 0x0E, 0x78,
  0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xF0, 0x38, 0x70, 0x78, 0x7F,
  0xF8, 0x3F, 0xB8, 0x1F, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0xF0, 0xFF,
  0x1F, 0xE1, 0xF0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0F, 0x38, 0x1C,
  0xE0, 0x73, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x70, 0x01, 0xEE, 0x03, 0xB8, 0x1C, 0xF0, 0xF1, 0xFF, 0x83, 0xFE,
  0x07, 0xE0, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x7F, 0xDF, 0xFF, 0xF8, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x07, 0x81, 0xC0, 0x78, 0x1F, 0x83, 0xE0, 0x78, 0x38, 0x1C, 0x70, 0x39,
  0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x1C, 0xF0,
  0x39, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x1C,
  0x70, 0x78, 0xE1, 0xF1, 0xFF, 0xE1, 0xFF, 0x81, 0xF7, 0x00, 0xE0, 0x3F,
  0x80, 0xE7, 0x03, 0x9C, 0x1C, 0x70, 0x71, 0xC3, 0xC7, 0x0E, 0x1C, 0x38,
  0x71, 0xC1, 0xC7, 0x03, 0x38, 0x0C, 0xE0, 0x33, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0xE0, 0x30, 0x1D,
  0x81, 0xC0, 0xE7, 0x07, 0x83, 0x9C, 0x3E, 0x0E, 0x70, 0xF8, 0x71, 0xC3,
  0xE1, 0xC7, 0x1F, 0x8E, 0x1C, 0x6E, 0x38, 0x73, 0xB8, 0xE1, 0xCE, 0x67,
  0x07, 0x71, 0x9C, 0x1D, 0xC6, 0x60, 0x76, 0x1B, 0x81, 0xF8, 0x6E, 0x07,
  0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1E, 0x00, 0xE0, 0x78, 0x03, 0x81,
  0xE0, 0x0C, 0x07, 0x00, 0x0E, 0x07, 0x87, 0x07, 0x83, 0xC3, 0x80, 0xE3,
  0xC0, 0x71, 0xC0, 0x19, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x39, 0xC0,
  0x3C, 0xE0, 0x3C, 0x38, 0x1C, 0x1C, 0x1E, 0x0E, 0x1E, 0x07, 0x80, 0x0F,
  0x03, 0xC3, 0xC0, 0xE0, 0xF0, 0x78, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC3,
  0x80, 0x70, 0xE0, 0x1C, 0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80,
  0x1C, 0xE0, 0x03, 0x70, 0x00, 0xDC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xC0, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x20, 0x0F, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x40,
  0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x87,
  0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87,
  0x0E, 0x1C, 0x30, 0x00, 0x02, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x07, 0x01, 0xF0, 0x3C, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x04, 0x00, 0x1E, 0x01,
  0x9F, 0xC0, 0xDF, 0xF0, 0xFE, 0x3C, 0xEE, 0x1F, 0xF7, 0x07, 0xF0, 0x00,
  0xF0,
};

const GFXglyph RobotoCondensed_Italic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 26, 9, 1, -26 },
  { 27, 8, 9, 11, 4, -28 },
  { 36, 18, 26, 20, 2, -26 },
  { 95, 16, 33, 18, 1, -30 },
  { 161, 17, 26, 23, 3, -26 },
  { 217, 17, 26, 20, 1, -26 },
  { 273, 4, 9, 6, 3, -28 },
  { 278, 11, 38, 11, 2, -30 },
  { 331, 11, 39, 11, -2, -30 },
  { 385, 14, 15, 15, 2, -26 },
  { 412, 15, 19, 18, 2, -22 },
  { 448, 6, 9, 7, -2, -4 },
  { 455, 7, 3, 9, 1, -13 },
  { 458, 4, 4, 9, 1, -4 },
  { 460, 17, 28, 13, -2, -26 },
  { 520, 15, 26, 18, 2, -26 },
  { 569, 10, 26, 18, 4, -26 },
  { 602, 17, 26, 18, 0, -26 },
  { 658, 16, 26, 18, 1, -26 },
  { 710, 17, 26, 18, 0, -26 },
  { 766, 16, 26, 18, 2, -26 },
  { 818, 14, 26, 18, 2, -26 },
  { 864, 17, 26, 18, 2, -26 },
  { 920, 16, 26, 18, 1, -26 },
  { 972, 13, 26, 18, 3, -26 },
  { 1015, 7, 20, 9, 1, -20 },
  { 1033, 9, 25, 7, -2, -20 },
  { 1062, 14, 16, 16, 1, -20 },
  { 1090, 14, 11, 17, 2, -18 },
  { 1110, 14, 17, 17, 1, -20 },
  { 1140, 12, 26, 15, 3, -26 },
  { 1179, 25, 34, 28, 1, -26 },
  { 1286, 19, 26, 21, -1, -26 },
  { 1348, 18, 26, 20, 1, -26 },
  { 1407, 18, 26, 20, 2, -26 },
  { 1466, 18, 26, 20, 1, -26 },
  { 1525, 18, 26, 18, 1, -26 },
  { 1584, 18, 26, 17, 1, -26 },
  { 1643, 18, 26, 21, 2, -26 },
  { 1702, 21, 26, 22, 1, -26 },
  { 1771, 8, 26, 9, 1, -26 },
  { 1797, 17, 26, 17, 0, -26 },
  { 1853, 21, 26, 20, 1, -26 },
  { 1922, 14, 26, 17, 1, -26 },
  { 1968, 26, 26, 27, 1, -26 },
  { 2053, 21, 26, 22, 1, -26 },
  { 2122, 18, 26, 22, 2, -26 },
  { 2181, 19, 26, 20, 1, -26 },
  { 2243, 18, 30, 22, 2, -26 },
  { 2311, 18, 26, 19, 1, -26 },
  { 2370, 18, 26, 19, 1, -26 },
  { 2429, 17, 26, 19, 3, -26 },
  { 2485, 19, 26, 20, 2, -26 },
  { 2547, 19, 26, 20, 3, -26 },
  { 2609, 25, 26, 27, 4, -26 },
  { 2691, 22, 26, 20, -1, -26 },
  { 2763, 18, 26, 19, 3, -26 },
  { 2822, 20, 26, 19, 0, -26 },
  { 2887, 11, 36, 9, 0, -30 },
  { 2937, 6, 28, 13, 4, -26 },
  { 2958, 11, 36, 9, -2, -30 },
  { 3008, 10, 13, 13, 2, -26 },
  { 3025, 14, 3, 15, -2, 0 },
  { 3031, 6, 5, 11, 4, -27 },
  { 3035, 14, 20, 17, 1, -20 },
  { 3070, 16, 28, 18, 0, -28 },
  { 3126, 15, 20, 17, 1, -20 },
  { 3164, 17, 28, 18, 1, -28 },
  { 3224, 15, 20, 17, 1, -20 },
  { 3262, 12, 28, 11, 2, -28 },
  { 3304, 17, 28, 18, 0, -20 },
  { 3364, 15, 28, 17, 0, -28 },
  { 3417, 7, 27, 8, 1, -27 },
  { 3441, 12, 35, 8, -4, -27 },
  { 3494, 17, 28, 16, 0, -28 },
  { 3554, 8, 28, 8, 1, -28 },
  { 3582, 25, 20, 27, 0, -20 },
  { 3645, 15, 20, 17, 0, -20 },
  { 3683, 15, 20, 18, 1, -20 },
  { 3721, 17, 28, 18, -1, -20 },
  { 3781, 16, 28, 18, 1, -20 },
  { 3837, 12, 20, 11, 0, -20 },
  { 3867, 14, 20, 16, 1, -20 },
  { 3902, 10, 24, 11, 1, -24 },
  { 3932, 15, 20, 17, 2, -20 },
  { 3970, 14, 20, 15, 2, -20 },
  { 4005, 22, 20, 23, 2, -20 },
  { 4060, 17, 20, 16, -1, -20 },
  { 4103, 18, 28, 15, -2, -20 },
  { 4166, 16, 20, 16, 0, -20 },
  { 4206, 12, 36, 11, 1, -29 },
  { 4260, 7, 31, 9, 1, -26 },
  { 4288, 12, 36, 11, -2, -29 },
  { 4342, 17, 7, 21, 2, -14 },
};

const GFXfont RobotoCondensed_Italic37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_ITALIC37PT7B_H_
